    I_MXI1_I1010_MP4 (XI1_I1010_p1 XI1_I1010_An I1_b10_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1010_MP2 (VDD I1_dd20_b3_1 XI1_I1010_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1010_MP3 (XI1_I1010_p1 I1_qu22_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1010_MP0 (VDD I1_dd20_b3_1 XI1_I1010_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I215_MP1 (VDD I1_I976_G11_0n XI1_I976_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I215_MP5 (I1_p9_12 XI1_I976_I215_Bn XI1_I976_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I215_MP4 (XI1_I976_I215_p1 XI1_I976_I215_An I1_p9_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I976_I215_MP2 (VDD I1_I976_pn12 XI1_I976_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I976_I215_MP3 (XI1_I976_I215_p1 I1_I976_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I215_MP0 (VDD I1_I976_pn12 XI1_I976_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I948_MP1 (VDD I1_qu23_b3_0 XI1_I948_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I948_MP5 (I1_b9_4 XI1_I948_Bn XI1_I948_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I948_MP4 (XI1_I948_p1 XI1_I948_An I1_b9_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I948_MP2 (VDD I1_dd4_b3_1 XI1_I948_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I948_MP3 (XI1_I948_p1 I1_qu23_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I948_MP0 (VDD I1_dd4_b3_1 XI1_I948_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1474_MP1 (VDD I1_qu12_b3_4 XI1_I1474_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1474_MP5 (I1_b20_24 XI1_I1474_Bn XI1_I1474_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1474_MP4 (XI1_I1474_p1 XI1_I1474_An I1_b20_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1474_MP2 (VDD I1_dd24_b3_3 XI1_I1474_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1474_MP3 (XI1_I1474_p1 I1_qu12_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1474_MP0 (VDD I1_dd24_b3_3 XI1_I1474_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1465_MP1 (VDD I1_qu12_b3_2 XI1_I1465_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1465_MP5 (I1_b20_15 XI1_I1465_Bn XI1_I1465_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1465_MP4 (XI1_I1465_p1 XI1_I1465_An I1_b20_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1465_MP2 (VDD I1_dd15_b3_3 XI1_I1465_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1465_MP3 (XI1_I1465_p1 I1_qu12_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1465_MP0 (VDD I1_dd15_b3_3 XI1_I1465_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1452_MP1 (VDD I1_qu12_b3_0 XI1_I1452_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1452_MP5 (I1_b20_2 XI1_I1452_Bn XI1_I1452_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1452_MP4 (XI1_I1452_p1 XI1_I1452_An I1_b20_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1452_MP2 (VDD I1_dd2_b3_3 XI1_I1452_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1452_MP3 (XI1_I1452_p1 I1_qu12_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1452_MP0 (VDD I1_dd2_b3_3 XI1_I1452_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I213_MP1 (VDD I1_I1114_G9_0n XI1_I1114_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I213_MP5 (I1_p12_10 XI1_I1114_I213_Bn XI1_I1114_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I213_MP4 (XI1_I1114_I213_p1 XI1_I1114_I213_An I1_p12_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1114_I213_MP2 (VDD I1_I1114_pn10 XI1_I1114_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1114_I213_MP3 (XI1_I1114_I213_p1 I1_I1114_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I213_MP0 (VDD I1_I1114_pn10 XI1_I1114_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1095_MP1 (VDD I1_qu20_b3_2 XI1_I1095_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1095_MP5 (I1_b12_13 XI1_I1095_Bn XI1_I1095_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1095_MP4 (XI1_I1095_p1 XI1_I1095_An I1_b12_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1095_MP2 (VDD I1_dd13_b3_2 XI1_I1095_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1095_MP3 (XI1_I1095_p1 I1_qu20_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1095_MP0 (VDD I1_dd13_b3_2 XI1_I1095_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1096_MP1 (VDD I1_qu20_b3_2 XI1_I1096_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1096_MP5 (I1_b12_14 XI1_I1096_Bn XI1_I1096_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1096_MP4 (XI1_I1096_p1 XI1_I1096_An I1_b12_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1096_MP2 (VDD I1_dd14_b3_2 XI1_I1096_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1096_MP3 (XI1_I1096_p1 I1_qu20_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1096_MP0 (VDD I1_dd14_b3_2 XI1_I1096_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I216_MP1 (VDD I1_I1068_G12_0n XI1_I1068_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I216_MP5 (I1_p11_13 XI1_I1068_I216_Bn XI1_I1068_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I216_MP4 (XI1_I1068_I216_p1 XI1_I1068_I216_An I1_p11_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1068_I216_MP2 (VDD I1_I1068_pn13 XI1_I1068_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1068_I216_MP3 (XI1_I1068_I216_p1 I1_I1068_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I216_MP0 (VDD I1_I1068_pn13 XI1_I1068_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I215_MP1 (VDD I1_I1068_G11_0n XI1_I1068_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I215_MP5 (I1_p11_12 XI1_I1068_I215_Bn XI1_I1068_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I215_MP4 (XI1_I1068_I215_p1 XI1_I1068_I215_An I1_p11_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1068_I215_MP2 (VDD I1_I1068_pn12 XI1_I1068_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1068_I215_MP3 (XI1_I1068_I215_p1 I1_I1068_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I215_MP0 (VDD I1_I1068_pn12 XI1_I1068_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1053_MP1 (VDD I1_qu21_b3_2 XI1_I1053_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1053_MP5 (I1_b11_17 XI1_I1053_Bn XI1_I1053_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1053_MP4 (XI1_I1053_p1 XI1_I1053_An I1_b11_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1053_MP2 (VDD I1_dd17_b3_2 XI1_I1053_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1053_MP3 (XI1_I1053_p1 I1_qu21_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1053_MP0 (VDD I1_dd17_b3_2 XI1_I1053_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1024_MP1 (VDD I1_c10_o XI1_I1024_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1024_MP5 (I1_p10_32 XI1_I1024_Bn XI1_I1024_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1024_MP4 (XI1_I1024_p1 XI1_I1024_An I1_p10_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1024_MP2 (VDD I1_h10 XI1_I1024_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1024_MP3 (XI1_I1024_p1 I1_c10_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1024_MP0 (VDD I1_h10 XI1_I1024_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1009_MP1 (VDD I1_qu22_b3_3 XI1_I1009_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1009_MP5 (I1_b10_19 XI1_I1009_Bn XI1_I1009_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1009_MP4 (XI1_I1009_p1 XI1_I1009_An I1_b10_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1009_MP2 (VDD I1_dd19_b3_1 XI1_I1009_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1009_MP3 (XI1_I1009_p1 I1_qu22_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1009_MP0 (VDD I1_dd19_b3_1 XI1_I1009_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1008_MP1 (VDD I1_qu22_b3_3 XI1_I1008_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1008_MP5 (I1_b10_18 XI1_I1008_Bn XI1_I1008_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1008_MP4 (XI1_I1008_p1 XI1_I1008_An I1_b10_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1008_MP2 (VDD I1_dd18_b3_1 XI1_I1008_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1008_MP3 (XI1_I1008_p1 I1_qu22_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1008_MP0 (VDD I1_dd18_b3_1 XI1_I1008_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I218_MP1 (VDD I1_I976_G14_0n XI1_I976_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I218_MP5 (I1_p9_15 XI1_I976_I218_Bn XI1_I976_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I218_MP4 (XI1_I976_I218_p1 XI1_I976_I218_An I1_p9_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I976_I218_MP2 (VDD I1_I976_pn15 XI1_I976_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I976_I218_MP3 (XI1_I976_I218_p1 I1_I976_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I218_MP0 (VDD I1_I976_pn15 XI1_I976_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I207_MP1 (VDD I1_I976_G3_0n XI1_I976_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I207_MP5 (I1_p9_4 XI1_I976_I207_Bn XI1_I976_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I207_MP4 (XI1_I976_I207_p1 XI1_I976_I207_An I1_p9_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I976_I207_MP2 (VDD I1_I976_pn4 XI1_I976_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I976_I207_MP3 (XI1_I976_I207_p1 I1_I976_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I207_MP0 (VDD I1_I976_pn4 XI1_I976_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I947_MP1 (VDD I1_qu23_b3_0 XI1_I947_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I947_MP5 (I1_b9_3 XI1_I947_Bn XI1_I947_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I947_MP4 (XI1_I947_p1 XI1_I947_An I1_b9_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I947_MP2 (VDD I1_dd3_b3_1 XI1_I947_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I947_MP3 (XI1_I947_p1 I1_qu23_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I947_MP0 (VDD I1_dd3_b3_1 XI1_I947_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I577_MP1 (VDD I1_qu31_b3_0 XI1_I577_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I577_MP5 (I1_b1_1 XI1_I577_Bn XI1_I577_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I577_MP4 (XI1_I577_p1 XI1_I577_An I1_b1_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I577_MP2 (VDD I1_dd1_b3_0 XI1_I577_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I577_MP3 (XI1_I577_p1 I1_qu31_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I577_MP0 (VDD I1_dd1_b3_0 XI1_I577_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I207_MP1 (VDD I1_I608_G3_0n XI1_I608_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I207_MP5 (I1_p1_4 XI1_I608_I207_Bn XI1_I608_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I207_MP4 (XI1_I608_I207_p1 XI1_I608_I207_An I1_p1_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I608_I207_MP2 (VDD I1_I608_pn4 XI1_I608_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I608_I207_MP3 (XI1_I608_I207_p1 I1_I608_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I207_MP0 (VDD I1_I608_pn4 XI1_I608_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I213_MP1 (VDD I1_I608_G9_0n XI1_I608_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I213_MP5 (I1_p1_10 XI1_I608_I213_Bn XI1_I608_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I213_MP4 (XI1_I608_I213_p1 XI1_I608_I213_An I1_p1_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I608_I213_MP2 (VDD I1_I608_pn10 XI1_I608_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I608_I213_MP3 (XI1_I608_I213_p1 I1_I608_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I213_MP0 (VDD I1_I608_pn10 XI1_I608_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I215_MP1 (VDD I1_I608_G11_0n XI1_I608_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I215_MP5 (I1_p1_12 XI1_I608_I215_Bn XI1_I608_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I215_MP4 (XI1_I608_I215_p1 XI1_I608_I215_An I1_p1_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I608_I215_MP2 (VDD I1_I608_pn12 XI1_I608_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I608_I215_MP3 (XI1_I608_I215_p1 I1_I608_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I215_MP0 (VDD I1_I608_pn12 XI1_I608_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I217_MP1 (VDD I1_I608_G13_0n XI1_I608_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I217_MP5 (I1_p1_14 XI1_I608_I217_Bn XI1_I608_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I217_MP4 (XI1_I608_I217_p1 XI1_I608_I217_An I1_p1_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I608_I217_MP2 (VDD I1_I608_pn14 XI1_I608_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I608_I217_MP3 (XI1_I608_I217_p1 I1_I608_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I217_MP0 (VDD I1_I608_pn14 XI1_I608_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1483_MP1 (VDD I1_qu12_b3_5 XI1_I1483_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1483_MP5 (I1_h20 XI1_I1483_Bn XI1_I1483_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1483_MP4 (XI1_I1483_p1 XI1_I1483_An I1_h20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1483_MP2 (VDD I1_p19_31 XI1_I1483_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1483_MP3 (XI1_I1483_p1 I1_qu12_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1483_MP0 (VDD I1_p19_31 XI1_I1483_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1475_MP1 (VDD I1_qu12_b3_4 XI1_I1475_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1475_MP5 (I1_b20_25 XI1_I1475_Bn XI1_I1475_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1475_MP4 (XI1_I1475_p1 XI1_I1475_An I1_b20_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1475_MP2 (VDD I1_dd25_b3_3 XI1_I1475_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1475_MP3 (XI1_I1475_p1 I1_qu12_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1475_MP0 (VDD I1_dd25_b3_3 XI1_I1475_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1451_MP1 (VDD I1_qu12_b3_0 XI1_I1451_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1451_MP5 (I1_b20_1 XI1_I1451_Bn XI1_I1451_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1451_MP4 (XI1_I1451_p1 XI1_I1451_An I1_b20_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1451_MP2 (VDD I1_dd1_b3_3 XI1_I1451_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1451_MP3 (XI1_I1451_p1 I1_qu12_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1451_MP0 (VDD I1_dd1_b3_3 XI1_I1451_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1450_MP1 (VDD I1_qu12_b3_0 XI1_I1450_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1450_MP5 (I1_b20_0 XI1_I1450_Bn XI1_I1450_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1450_MP4 (XI1_I1450_p1 XI1_I1450_An I1_b20_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1450_MP2 (VDD I1_B_0_b3_3 XI1_I1450_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1450_MP3 (XI1_I1450_p1 I1_qu12_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1450_MP0 (VDD I1_B_0_b3_3 XI1_I1450_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1094_MP1 (VDD I1_qu20_b3_2 XI1_I1094_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1094_MP5 (I1_b12_12 XI1_I1094_Bn XI1_I1094_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1094_MP4 (XI1_I1094_p1 XI1_I1094_An I1_b12_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1094_MP2 (VDD I1_dd12_b3_2 XI1_I1094_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1094_MP3 (XI1_I1094_p1 I1_qu20_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1094_MP0 (VDD I1_dd12_b3_2 XI1_I1094_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I214_MP1 (VDD I1_I1068_G10_0n XI1_I1068_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I214_MP5 (I1_p11_11 XI1_I1068_I214_Bn XI1_I1068_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I214_MP4 (XI1_I1068_I214_p1 XI1_I1068_I214_An I1_p11_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1068_I214_MP2 (VDD I1_I1068_pn11 XI1_I1068_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1068_I214_MP3 (XI1_I1068_I214_p1 I1_I1068_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I214_MP0 (VDD I1_I1068_pn11 XI1_I1068_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1050_MP1 (VDD I1_qu21_b3_2 XI1_I1050_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1050_MP5 (I1_b11_14 XI1_I1050_Bn XI1_I1050_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1050_MP4 (XI1_I1050_p1 XI1_I1050_An I1_b11_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1050_MP2 (VDD I1_dd14_b3_2 XI1_I1050_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1050_MP3 (XI1_I1050_p1 I1_qu21_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1050_MP0 (VDD I1_dd14_b3_2 XI1_I1050_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1052_MP1 (VDD I1_qu21_b3_2 XI1_I1052_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1052_MP5 (I1_b11_16 XI1_I1052_Bn XI1_I1052_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1052_MP4 (XI1_I1052_p1 XI1_I1052_An I1_b11_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1052_MP2 (VDD I1_dd16_b3_2 XI1_I1052_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1052_MP3 (XI1_I1052_p1 I1_qu21_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1052_MP0 (VDD I1_dd16_b3_2 XI1_I1052_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1051_MP1 (VDD I1_qu21_b3_2 XI1_I1051_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1051_MP5 (I1_b11_15 XI1_I1051_Bn XI1_I1051_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1051_MP4 (XI1_I1051_p1 XI1_I1051_An I1_b11_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1051_MP2 (VDD I1_dd15_b3_2 XI1_I1051_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1051_MP3 (XI1_I1051_p1 I1_qu21_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1051_MP0 (VDD I1_dd15_b3_2 XI1_I1051_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I219_MP1 (VDD I1_I1022_G15_0n XI1_I1022_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I219_MP5 (I1_p10_16 XI1_I1022_I219_Bn XI1_I1022_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I219_MP4 (XI1_I1022_I219_p1 XI1_I1022_I219_An I1_p10_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1022_I219_MP2 (VDD I1_I1022_pn16 XI1_I1022_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1022_I219_MP3 (XI1_I1022_I219_p1 I1_I1022_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I219_MP0 (VDD I1_I1022_pn16 XI1_I1022_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1007_MP1 (VDD I1_qu22_b3_2 XI1_I1007_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1007_MP5 (I1_b10_17 XI1_I1007_Bn XI1_I1007_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1007_MP4 (XI1_I1007_p1 XI1_I1007_An I1_b10_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1007_MP2 (VDD I1_dd17_b3_1 XI1_I1007_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1007_MP3 (XI1_I1007_p1 I1_qu22_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1007_MP0 (VDD I1_dd17_b3_1 XI1_I1007_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I216_MP1 (VDD I1_I976_G12_0n XI1_I976_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I216_MP5 (I1_p9_13 XI1_I976_I216_Bn XI1_I976_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I216_MP4 (XI1_I976_I216_p1 XI1_I976_I216_An I1_p9_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I976_I216_MP2 (VDD I1_I976_pn13 XI1_I976_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I976_I216_MP3 (XI1_I976_I216_p1 I1_I976_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I216_MP0 (VDD I1_I976_pn13 XI1_I976_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I214_MP1 (VDD I1_I976_G10_0n XI1_I976_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I214_MP5 (I1_p9_11 XI1_I976_I214_Bn XI1_I976_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I214_MP4 (XI1_I976_I214_p1 XI1_I976_I214_An I1_p9_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I976_I214_MP2 (VDD I1_I976_pn11 XI1_I976_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I976_I214_MP3 (XI1_I976_I214_p1 I1_I976_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I214_MP0 (VDD I1_I976_pn11 XI1_I976_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I578_MP1 (VDD I1_qu31_b3_0 XI1_I578_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I578_MP5 (I1_b1_2 XI1_I578_Bn XI1_I578_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I578_MP4 (XI1_I578_p1 XI1_I578_An I1_b1_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I578_MP2 (VDD I1_dd2_b3_0 XI1_I578_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I578_MP3 (XI1_I578_p1 I1_qu31_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I578_MP0 (VDD I1_dd2_b3_0 XI1_I578_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I219_MP1 (VDD I1_I608_G15_0n XI1_I608_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I219_MP5 (I1_p1_16 XI1_I608_I219_Bn XI1_I608_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I219_MP4 (XI1_I608_I219_p1 XI1_I608_I219_An I1_p1_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I608_I219_MP2 (VDD I1_I608_pn16 XI1_I608_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I608_I219_MP3 (XI1_I608_I219_p1 I1_I608_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I219_MP0 (VDD I1_I608_pn16 XI1_I608_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I610_MP1 (VDD I1_c1_o XI1_I610_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I610_MP5 (I1_p1_32 XI1_I610_Bn XI1_I610_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I610_MP4 (XI1_I610_p1 XI1_I610_An I1_p1_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I610_MP2 (VDD I1_h1 XI1_I610_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I610_MP3 (XI1_I610_p1 I1_c1_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I610_MP0 (VDD I1_h1 XI1_I610_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I606_MP1 (VDD I1_qu31_b3_5 XI1_I606_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I606_MP5 (I1_b1_30 XI1_I606_Bn XI1_I606_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I606_MP4 (XI1_I606_p1 XI1_I606_An I1_b1_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I606_MP2 (VDD I1_dd30_b3_0 XI1_I606_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I606_MP3 (XI1_I606_p1 I1_qu31_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I606_MP0 (VDD I1_dd30_b3_0 XI1_I606_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1484_MP1 (VDD I1_c20_o XI1_I1484_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1484_MP5 (I1_p20_32 XI1_I1484_Bn XI1_I1484_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1484_MP4 (XI1_I1484_p1 XI1_I1484_An I1_p20_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1484_MP2 (VDD I1_h20 XI1_I1484_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1484_MP3 (XI1_I1484_p1 I1_c20_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1484_MP0 (VDD I1_h20 XI1_I1484_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I207_MP1 (VDD I1_I1482_G3_0n XI1_I1482_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I207_MP5 (I1_p20_4 XI1_I1482_I207_Bn XI1_I1482_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I207_MP4 (XI1_I1482_I207_p1 XI1_I1482_I207_An I1_p20_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1482_I207_MP2 (VDD I1_I1482_pn4 XI1_I1482_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1482_I207_MP3 (XI1_I1482_I207_p1 I1_I1482_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I207_MP0 (VDD I1_I1482_pn4 XI1_I1482_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1505_MP1 (VDD I1_qu11_b3_1 XI1_I1505_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1505_MP5 (I1_b21_9 XI1_I1505_Bn XI1_I1505_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1505_MP4 (XI1_I1505_p1 XI1_I1505_An I1_b21_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1505_MP2 (VDD I1_dd9_b3_3 XI1_I1505_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1505_MP3 (XI1_I1505_p1 I1_qu11_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1505_MP0 (VDD I1_dd9_b3_3 XI1_I1505_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I212_MP1 (VDD I1_I1114_G8_0n XI1_I1114_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I212_MP5 (I1_p12_9 XI1_I1114_I212_Bn XI1_I1114_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I212_MP4 (XI1_I1114_I212_p1 XI1_I1114_I212_An I1_p12_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1114_I212_MP2 (VDD I1_I1114_pn9 XI1_I1114_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1114_I212_MP3 (XI1_I1114_I212_p1 I1_I1114_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I212_MP0 (VDD I1_I1114_pn9 XI1_I1114_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I207_MP1 (VDD I1_I1114_G3_0n XI1_I1114_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I207_MP5 (I1_p12_4 XI1_I1114_I207_Bn XI1_I1114_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I207_MP4 (XI1_I1114_I207_p1 XI1_I1114_I207_An I1_p12_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1114_I207_MP2 (VDD I1_I1114_pn4 XI1_I1114_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1114_I207_MP3 (XI1_I1114_I207_p1 I1_I1114_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I207_MP0 (VDD I1_I1114_pn4 XI1_I1114_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I206_MP1 (VDD I1_I1114_G2_0n XI1_I1114_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I206_MP5 (I1_p12_3 XI1_I1114_I206_Bn XI1_I1114_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I206_MP4 (XI1_I1114_I206_p1 XI1_I1114_I206_An I1_p12_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1114_I206_MP2 (VDD I1_I1114_pn3 XI1_I1114_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1114_I206_MP3 (XI1_I1114_I206_p1 I1_I1114_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I206_MP0 (VDD I1_I1114_pn3 XI1_I1114_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I213_MP1 (VDD I1_I1068_G9_0n XI1_I1068_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I213_MP5 (I1_p11_10 XI1_I1068_I213_Bn XI1_I1068_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I213_MP4 (XI1_I1068_I213_p1 XI1_I1068_I213_An I1_p11_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1068_I213_MP2 (VDD I1_I1068_pn10 XI1_I1068_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1068_I213_MP3 (XI1_I1068_I213_p1 I1_I1068_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I213_MP0 (VDD I1_I1068_pn10 XI1_I1068_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1048_MP1 (VDD I1_qu21_b3_2 XI1_I1048_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1048_MP5 (I1_b11_12 XI1_I1048_Bn XI1_I1048_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1048_MP4 (XI1_I1048_p1 XI1_I1048_An I1_b11_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1048_MP2 (VDD I1_dd12_b3_2 XI1_I1048_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1048_MP3 (XI1_I1048_p1 I1_qu21_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1048_MP0 (VDD I1_dd12_b3_2 XI1_I1048_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1049_MP1 (VDD I1_qu21_b3_2 XI1_I1049_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1049_MP5 (I1_b11_13 XI1_I1049_Bn XI1_I1049_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1049_MP4 (XI1_I1049_p1 XI1_I1049_An I1_b11_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1049_MP2 (VDD I1_dd13_b3_2 XI1_I1049_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1049_MP3 (XI1_I1049_p1 I1_qu21_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1049_MP0 (VDD I1_dd13_b3_2 XI1_I1049_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I218_MP1 (VDD I1_I1022_G14_0n XI1_I1022_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I218_MP5 (I1_p10_15 XI1_I1022_I218_Bn XI1_I1022_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I218_MP4 (XI1_I1022_I218_p1 XI1_I1022_I218_An I1_p10_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1022_I218_MP2 (VDD I1_I1022_pn15 XI1_I1022_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1022_I218_MP3 (XI1_I1022_I218_p1 I1_I1022_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I218_MP0 (VDD I1_I1022_pn15 XI1_I1022_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I216_MP1 (VDD I1_I1022_G12_0n XI1_I1022_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I216_MP5 (I1_p10_13 XI1_I1022_I216_Bn XI1_I1022_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I216_MP4 (XI1_I1022_I216_p1 XI1_I1022_I216_An I1_p10_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1022_I216_MP2 (VDD I1_I1022_pn13 XI1_I1022_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1022_I216_MP3 (XI1_I1022_I216_p1 I1_I1022_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I216_MP0 (VDD I1_I1022_pn13 XI1_I1022_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I217_MP1 (VDD I1_I1022_G13_0n XI1_I1022_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I217_MP5 (I1_p10_14 XI1_I1022_I217_Bn XI1_I1022_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I217_MP4 (XI1_I1022_I217_p1 XI1_I1022_I217_An I1_p10_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1022_I217_MP2 (VDD I1_I1022_pn14 XI1_I1022_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1022_I217_MP3 (XI1_I1022_I217_p1 I1_I1022_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I217_MP0 (VDD I1_I1022_pn14 XI1_I1022_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1006_MP1 (VDD I1_qu22_b3_2 XI1_I1006_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1006_MP5 (I1_b10_16 XI1_I1006_Bn XI1_I1006_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1006_MP4 (XI1_I1006_p1 XI1_I1006_An I1_b10_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1006_MP2 (VDD I1_dd16_b3_1 XI1_I1006_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1006_MP3 (XI1_I1006_p1 I1_qu22_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1006_MP0 (VDD I1_dd16_b3_1 XI1_I1006_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1005_MP1 (VDD I1_qu22_b3_2 XI1_I1005_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1005_MP5 (I1_b10_15 XI1_I1005_Bn XI1_I1005_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1005_MP4 (XI1_I1005_p1 XI1_I1005_An I1_b10_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1005_MP2 (VDD I1_dd15_b3_1 XI1_I1005_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1005_MP3 (XI1_I1005_p1 I1_qu22_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1005_MP0 (VDD I1_dd15_b3_1 XI1_I1005_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1004_MP1 (VDD I1_qu22_b3_2 XI1_I1004_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1004_MP5 (I1_b10_14 XI1_I1004_Bn XI1_I1004_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1004_MP4 (XI1_I1004_p1 XI1_I1004_An I1_b10_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1004_MP2 (VDD I1_dd14_b3_1 XI1_I1004_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1004_MP3 (XI1_I1004_p1 I1_qu22_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1004_MP0 (VDD I1_dd14_b3_1 XI1_I1004_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1003_MP1 (VDD I1_qu22_b3_2 XI1_I1003_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1003_MP5 (I1_b10_13 XI1_I1003_Bn XI1_I1003_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1003_MP4 (XI1_I1003_p1 XI1_I1003_An I1_b10_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1003_MP2 (VDD I1_dd13_b3_1 XI1_I1003_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1003_MP3 (XI1_I1003_p1 I1_qu22_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1003_MP0 (VDD I1_dd13_b3_1 XI1_I1003_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I212_MP1 (VDD I1_I976_G8_0n XI1_I976_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I212_MP5 (I1_p9_9 XI1_I976_I212_Bn XI1_I976_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I212_MP4 (XI1_I976_I212_p1 XI1_I976_I212_An I1_p9_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I976_I212_MP2 (VDD I1_I976_pn9 XI1_I976_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I976_I212_MP3 (XI1_I976_I212_p1 I1_I976_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I212_MP0 (VDD I1_I976_pn9 XI1_I976_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I946_MP1 (VDD I1_qu23_b3_0 XI1_I946_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I946_MP5 (I1_b9_2 XI1_I946_Bn XI1_I946_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I946_MP4 (XI1_I946_p1 XI1_I946_An I1_b9_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I946_MP2 (VDD I1_dd2_b3_1 XI1_I946_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I946_MP3 (XI1_I946_p1 I1_qu23_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I946_MP0 (VDD I1_dd2_b3_1 XI1_I946_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I576_MP1 (VDD I1_qu31_b3_0 XI1_I576_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I576_MP5 (I1_b1_0 XI1_I576_Bn XI1_I576_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I576_MP4 (XI1_I576_p1 XI1_I576_An I1_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I576_MP2 (VDD I1_B_0_b3_0 XI1_I576_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I576_MP3 (XI1_I576_p1 I1_qu31_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I576_MP0 (VDD I1_B_0_b3_0 XI1_I576_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I579_MP1 (VDD I1_qu31_b3_0 XI1_I579_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I579_MP5 (I1_b1_3 XI1_I579_Bn XI1_I579_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I579_MP4 (XI1_I579_p1 XI1_I579_An I1_b1_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I579_MP2 (VDD I1_dd3_b3_0 XI1_I579_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I579_MP3 (XI1_I579_p1 I1_qu31_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I579_MP0 (VDD I1_dd3_b3_0 XI1_I579_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I580_MP1 (VDD I1_qu31_b3_0 XI1_I580_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I580_MP5 (I1_b1_4 XI1_I580_Bn XI1_I580_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I580_MP4 (XI1_I580_p1 XI1_I580_An I1_b1_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I580_MP2 (VDD I1_dd4_b3_0 XI1_I580_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I580_MP3 (XI1_I580_p1 I1_qu31_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I580_MP0 (VDD I1_dd4_b3_0 XI1_I580_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I607_MP1 (VDD I1_qu31_b3_5 XI1_I607_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I607_MP5 (I1_b1_31 XI1_I607_Bn XI1_I607_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I607_MP4 (XI1_I607_p1 XI1_I607_An I1_b1_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I607_MP2 (VDD I1_dd31_b3_0 XI1_I607_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I607_MP3 (XI1_I607_p1 I1_qu31_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I607_MP0 (VDD I1_dd31_b3_0 XI1_I607_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1476_MP1 (VDD I1_qu12_b3_4 XI1_I1476_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1476_MP5 (I1_b20_26 XI1_I1476_Bn XI1_I1476_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1476_MP4 (XI1_I1476_p1 XI1_I1476_An I1_b20_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1476_MP2 (VDD I1_dd26_b3_3 XI1_I1476_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1476_MP3 (XI1_I1476_p1 I1_qu12_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1476_MP0 (VDD I1_dd26_b3_3 XI1_I1476_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I219_MP1 (VDD I1_I1482_G15_0n XI1_I1482_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I219_MP5 (I1_p20_16 XI1_I1482_I219_Bn XI1_I1482_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I219_MP4 (XI1_I1482_I219_p1 XI1_I1482_I219_An I1_p20_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1482_I219_MP2 (VDD I1_I1482_pn16 XI1_I1482_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1482_I219_MP3 (XI1_I1482_I219_p1 I1_I1482_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I219_MP0 (VDD I1_I1482_pn16 XI1_I1482_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I217_MP1 (VDD I1_I1482_G13_0n XI1_I1482_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I217_MP5 (I1_p20_14 XI1_I1482_I217_Bn XI1_I1482_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I217_MP4 (XI1_I1482_I217_p1 XI1_I1482_I217_An I1_p20_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1482_I217_MP2 (VDD I1_I1482_pn14 XI1_I1482_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1482_I217_MP3 (XI1_I1482_I217_p1 I1_I1482_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I217_MP0 (VDD I1_I1482_pn14 XI1_I1482_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I215_MP1 (VDD I1_I1482_G11_0n XI1_I1482_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I215_MP5 (I1_p20_12 XI1_I1482_I215_Bn XI1_I1482_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I215_MP4 (XI1_I1482_I215_p1 XI1_I1482_I215_An I1_p20_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1482_I215_MP2 (VDD I1_I1482_pn12 XI1_I1482_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1482_I215_MP3 (XI1_I1482_I215_p1 I1_I1482_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I215_MP0 (VDD I1_I1482_pn12 XI1_I1482_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I213_MP1 (VDD I1_I1482_G9_0n XI1_I1482_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I213_MP5 (I1_p20_10 XI1_I1482_I213_Bn XI1_I1482_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I213_MP4 (XI1_I1482_I213_p1 XI1_I1482_I213_An I1_p20_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1482_I213_MP2 (VDD I1_I1482_pn10 XI1_I1482_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1482_I213_MP3 (XI1_I1482_I213_p1 I1_I1482_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I213_MP0 (VDD I1_I1482_pn10 XI1_I1482_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I206_MP1 (VDD I1_I1482_G2_0n XI1_I1482_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I206_MP5 (I1_p20_3 XI1_I1482_I206_Bn XI1_I1482_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I206_MP4 (XI1_I1482_I206_p1 XI1_I1482_I206_An I1_p20_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1482_I206_MP2 (VDD I1_I1482_pn3 XI1_I1482_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1482_I206_MP3 (XI1_I1482_I206_p1 I1_I1482_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I206_MP0 (VDD I1_I1482_pn3 XI1_I1482_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1506_MP1 (VDD I1_qu11_b3_1 XI1_I1506_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1506_MP5 (I1_b21_10 XI1_I1506_Bn XI1_I1506_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1506_MP4 (XI1_I1506_p1 XI1_I1506_An I1_b21_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1506_MP2 (VDD I1_dd10_b3_3 XI1_I1506_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1506_MP3 (XI1_I1506_p1 I1_qu11_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1506_MP0 (VDD I1_dd10_b3_3 XI1_I1506_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1502_MP1 (VDD I1_qu11_b3_1 XI1_I1502_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1502_MP5 (I1_b21_6 XI1_I1502_Bn XI1_I1502_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1502_MP4 (XI1_I1502_p1 XI1_I1502_An I1_b21_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1502_MP2 (VDD I1_dd6_b3_3 XI1_I1502_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1502_MP3 (XI1_I1502_p1 I1_qu11_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1502_MP0 (VDD I1_dd6_b3_3 XI1_I1502_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1503_MP1 (VDD I1_qu11_b3_1 XI1_I1503_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1503_MP5 (I1_b21_7 XI1_I1503_Bn XI1_I1503_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1503_MP4 (XI1_I1503_p1 XI1_I1503_An I1_b21_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1503_MP2 (VDD I1_dd7_b3_3 XI1_I1503_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1503_MP3 (XI1_I1503_p1 I1_qu11_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1503_MP0 (VDD I1_dd7_b3_3 XI1_I1503_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1093_MP1 (VDD I1_qu20_b3_1 XI1_I1093_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1093_MP5 (I1_b12_11 XI1_I1093_Bn XI1_I1093_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1093_MP4 (XI1_I1093_p1 XI1_I1093_An I1_b12_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1093_MP2 (VDD I1_dd11_b3_2 XI1_I1093_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1093_MP3 (XI1_I1093_p1 I1_qu20_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1093_MP0 (VDD I1_dd11_b3_2 XI1_I1093_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I212_MP1 (VDD I1_I1068_G8_0n XI1_I1068_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I212_MP5 (I1_p11_9 XI1_I1068_I212_Bn XI1_I1068_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I212_MP4 (XI1_I1068_I212_p1 XI1_I1068_I212_An I1_p11_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1068_I212_MP2 (VDD I1_I1068_pn9 XI1_I1068_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1068_I212_MP3 (XI1_I1068_I212_p1 I1_I1068_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I212_MP0 (VDD I1_I1068_pn9 XI1_I1068_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I214_MP1 (VDD I1_I1022_G10_0n XI1_I1022_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I214_MP5 (I1_p10_11 XI1_I1022_I214_Bn XI1_I1022_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I214_MP4 (XI1_I1022_I214_p1 XI1_I1022_I214_An I1_p10_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1022_I214_MP2 (VDD I1_I1022_pn11 XI1_I1022_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1022_I214_MP3 (XI1_I1022_I214_p1 I1_I1022_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I214_MP0 (VDD I1_I1022_pn11 XI1_I1022_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I215_MP1 (VDD I1_I1022_G11_0n XI1_I1022_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I215_MP5 (I1_p10_12 XI1_I1022_I215_Bn XI1_I1022_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I215_MP4 (XI1_I1022_I215_p1 XI1_I1022_I215_An I1_p10_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1022_I215_MP2 (VDD I1_I1022_pn12 XI1_I1022_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1022_I215_MP3 (XI1_I1022_I215_p1 I1_I1022_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I215_MP0 (VDD I1_I1022_pn12 XI1_I1022_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1002_MP1 (VDD I1_qu22_b3_2 XI1_I1002_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1002_MP5 (I1_b10_12 XI1_I1002_Bn XI1_I1002_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1002_MP4 (XI1_I1002_p1 XI1_I1002_An I1_b10_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1002_MP2 (VDD I1_dd12_b3_1 XI1_I1002_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1002_MP3 (XI1_I1002_p1 I1_qu22_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1002_MP0 (VDD I1_dd12_b3_1 XI1_I1002_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1001_MP1 (VDD I1_qu22_b3_1 XI1_I1001_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1001_MP5 (I1_b10_11 XI1_I1001_Bn XI1_I1001_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1001_MP4 (XI1_I1001_p1 XI1_I1001_An I1_b10_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1001_MP2 (VDD I1_dd11_b3_1 XI1_I1001_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1001_MP3 (XI1_I1001_p1 I1_qu22_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1001_MP0 (VDD I1_dd11_b3_1 XI1_I1001_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I206_MP1 (VDD I1_I976_G2_0n XI1_I976_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I206_MP5 (I1_p9_3 XI1_I976_I206_Bn XI1_I976_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I206_MP4 (XI1_I976_I206_p1 XI1_I976_I206_An I1_p9_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I976_I206_MP2 (VDD I1_I976_pn3 XI1_I976_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I976_I206_MP3 (XI1_I976_I206_p1 I1_I976_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I206_MP0 (VDD I1_I976_pn3 XI1_I976_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I945_MP1 (VDD I1_qu23_b3_0 XI1_I945_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I945_MP5 (I1_b9_1 XI1_I945_Bn XI1_I945_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I945_MP4 (XI1_I945_p1 XI1_I945_An I1_b9_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I945_MP2 (VDD I1_dd1_b3_1 XI1_I945_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I945_MP3 (XI1_I945_p1 I1_qu23_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I945_MP0 (VDD I1_dd1_b3_1 XI1_I945_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I531_MP1 (VDD VDD XI1_I531_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I531_MP5 (I1_b0_1 XI1_I531_Bn XI1_I531_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I531_MP4 (XI1_I531_p1 XI1_I531_An I1_b0_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I531_MP2 (VDD I1_dd1_b3_0 XI1_I531_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I531_MP3 (XI1_I531_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I531_MP0 (VDD I1_dd1_b3_0 XI1_I531_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I581_MP1 (VDD I1_qu31_b3_0 XI1_I581_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I581_MP5 (I1_b1_5 XI1_I581_Bn XI1_I581_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I581_MP4 (XI1_I581_p1 XI1_I581_An I1_b1_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I581_MP2 (VDD I1_dd5_b3_0 XI1_I581_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I581_MP3 (XI1_I581_p1 I1_qu31_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I581_MP0 (VDD I1_dd5_b3_0 XI1_I581_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I582_MP1 (VDD I1_qu31_b3_1 XI1_I582_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I582_MP5 (I1_b1_6 XI1_I582_Bn XI1_I582_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I582_MP4 (XI1_I582_p1 XI1_I582_An I1_b1_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I582_MP2 (VDD I1_dd6_b3_0 XI1_I582_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I582_MP3 (XI1_I582_p1 I1_qu31_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I582_MP0 (VDD I1_dd6_b3_0 XI1_I582_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I604_MP1 (VDD I1_qu31_b3_4 XI1_I604_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I604_MP5 (I1_b1_28 XI1_I604_Bn XI1_I604_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I604_MP4 (XI1_I604_p1 XI1_I604_An I1_b1_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I604_MP2 (VDD I1_dd28_b3_0 XI1_I604_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I604_MP3 (XI1_I604_p1 I1_qu31_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I604_MP0 (VDD I1_dd28_b3_0 XI1_I604_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I605_MP1 (VDD I1_qu31_b3_4 XI1_I605_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I605_MP5 (I1_b1_29 XI1_I605_Bn XI1_I605_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I605_MP4 (XI1_I605_p1 XI1_I605_An I1_b1_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I605_MP2 (VDD I1_dd29_b3_0 XI1_I605_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I605_MP3 (XI1_I605_p1 I1_qu31_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I605_MP0 (VDD I1_dd29_b3_0 XI1_I605_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1477_MP1 (VDD I1_qu12_b3_4 XI1_I1477_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1477_MP5 (I1_b20_27 XI1_I1477_Bn XI1_I1477_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1477_MP4 (XI1_I1477_p1 XI1_I1477_An I1_b20_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1477_MP2 (VDD I1_dd27_b3_3 XI1_I1477_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1477_MP3 (XI1_I1477_p1 I1_qu12_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1477_MP0 (VDD I1_dd27_b3_3 XI1_I1477_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1513_MP1 (VDD I1_qu11_b3_2 XI1_I1513_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1513_MP5 (I1_b21_17 XI1_I1513_Bn XI1_I1513_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1513_MP4 (XI1_I1513_p1 XI1_I1513_An I1_b21_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1513_MP2 (VDD I1_dd17_b3_3 XI1_I1513_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1513_MP3 (XI1_I1513_p1 I1_qu11_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1513_MP0 (VDD I1_dd17_b3_3 XI1_I1513_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I212_MP1 (VDD I1_I1482_G8_0n XI1_I1482_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I212_MP5 (I1_p20_9 XI1_I1482_I212_Bn XI1_I1482_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I212_MP4 (XI1_I1482_I212_p1 XI1_I1482_I212_An I1_p20_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1482_I212_MP2 (VDD I1_I1482_pn9 XI1_I1482_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1482_I212_MP3 (XI1_I1482_I212_p1 I1_I1482_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I212_MP0 (VDD I1_I1482_pn9 XI1_I1482_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1510_MP1 (VDD I1_qu11_b3_2 XI1_I1510_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1510_MP5 (I1_b21_14 XI1_I1510_Bn XI1_I1510_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1510_MP4 (XI1_I1510_p1 XI1_I1510_An I1_b21_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1510_MP2 (VDD I1_dd14_b3_3 XI1_I1510_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1510_MP3 (XI1_I1510_p1 I1_qu11_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1510_MP0 (VDD I1_dd14_b3_3 XI1_I1510_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1509_MP1 (VDD I1_qu11_b3_2 XI1_I1509_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1509_MP5 (I1_b21_13 XI1_I1509_Bn XI1_I1509_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1509_MP4 (XI1_I1509_p1 XI1_I1509_An I1_b21_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1509_MP2 (VDD I1_dd13_b3_3 XI1_I1509_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1509_MP3 (XI1_I1509_p1 I1_qu11_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1509_MP0 (VDD I1_dd13_b3_3 XI1_I1509_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1507_MP1 (VDD I1_qu11_b3_1 XI1_I1507_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1507_MP5 (I1_b21_11 XI1_I1507_Bn XI1_I1507_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1507_MP4 (XI1_I1507_p1 XI1_I1507_An I1_b21_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1507_MP2 (VDD I1_dd11_b3_3 XI1_I1507_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1507_MP3 (XI1_I1507_p1 I1_qu11_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1507_MP0 (VDD I1_dd11_b3_3 XI1_I1507_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1504_MP1 (VDD I1_qu11_b3_1 XI1_I1504_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1504_MP5 (I1_b21_8 XI1_I1504_Bn XI1_I1504_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1504_MP4 (XI1_I1504_p1 XI1_I1504_An I1_b21_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1504_MP2 (VDD I1_dd8_b3_3 XI1_I1504_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1504_MP3 (XI1_I1504_p1 I1_qu11_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1504_MP0 (VDD I1_dd8_b3_3 XI1_I1504_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1501_MP1 (VDD I1_qu11_b3_0 XI1_I1501_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1501_MP5 (I1_b21_5 XI1_I1501_Bn XI1_I1501_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1501_MP4 (XI1_I1501_p1 XI1_I1501_An I1_b21_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1501_MP2 (VDD I1_dd5_b3_3 XI1_I1501_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1501_MP3 (XI1_I1501_p1 I1_qu11_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1501_MP0 (VDD I1_dd5_b3_3 XI1_I1501_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1500_MP1 (VDD I1_qu11_b3_0 XI1_I1500_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1500_MP5 (I1_b21_4 XI1_I1500_Bn XI1_I1500_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1500_MP4 (XI1_I1500_p1 XI1_I1500_An I1_b21_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1500_MP2 (VDD I1_dd4_b3_3 XI1_I1500_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1500_MP3 (XI1_I1500_p1 I1_qu11_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1500_MP0 (VDD I1_dd4_b3_3 XI1_I1500_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1091_MP1 (VDD I1_qu20_b3_1 XI1_I1091_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1091_MP5 (I1_b12_9 XI1_I1091_Bn XI1_I1091_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1091_MP4 (XI1_I1091_p1 XI1_I1091_An I1_b12_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1091_MP2 (VDD I1_dd9_b3_2 XI1_I1091_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1091_MP3 (XI1_I1091_p1 I1_qu20_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1091_MP0 (VDD I1_dd9_b3_2 XI1_I1091_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1092_MP1 (VDD I1_qu20_b3_1 XI1_I1092_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1092_MP5 (I1_b12_10 XI1_I1092_Bn XI1_I1092_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1092_MP4 (XI1_I1092_p1 XI1_I1092_An I1_b12_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1092_MP2 (VDD I1_dd10_b3_2 XI1_I1092_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1092_MP3 (XI1_I1092_p1 I1_qu20_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1092_MP0 (VDD I1_dd10_b3_2 XI1_I1092_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1089_MP1 (VDD I1_qu20_b3_1 XI1_I1089_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1089_MP5 (I1_b12_7 XI1_I1089_Bn XI1_I1089_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1089_MP4 (XI1_I1089_p1 XI1_I1089_An I1_b12_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1089_MP2 (VDD I1_dd7_b3_2 XI1_I1089_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1089_MP3 (XI1_I1089_p1 I1_qu20_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1089_MP0 (VDD I1_dd7_b3_2 XI1_I1089_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1045_MP1 (VDD I1_qu21_b3_1 XI1_I1045_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1045_MP5 (I1_b11_9 XI1_I1045_Bn XI1_I1045_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1045_MP4 (XI1_I1045_p1 XI1_I1045_An I1_b11_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1045_MP2 (VDD I1_dd9_b3_2 XI1_I1045_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1045_MP3 (XI1_I1045_p1 I1_qu21_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1045_MP0 (VDD I1_dd9_b3_2 XI1_I1045_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1046_MP1 (VDD I1_qu21_b3_1 XI1_I1046_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1046_MP5 (I1_b11_10 XI1_I1046_Bn XI1_I1046_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1046_MP4 (XI1_I1046_p1 XI1_I1046_An I1_b11_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1046_MP2 (VDD I1_dd10_b3_2 XI1_I1046_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1046_MP3 (XI1_I1046_p1 I1_qu21_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1046_MP0 (VDD I1_dd10_b3_2 XI1_I1046_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1043_MP1 (VDD I1_qu21_b3_1 XI1_I1043_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1043_MP5 (I1_b11_7 XI1_I1043_Bn XI1_I1043_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1043_MP4 (XI1_I1043_p1 XI1_I1043_An I1_b11_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1043_MP2 (VDD I1_dd7_b3_2 XI1_I1043_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1043_MP3 (XI1_I1043_p1 I1_qu21_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1043_MP0 (VDD I1_dd7_b3_2 XI1_I1043_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1082_MP1 (VDD I1_qu20_b3_0 XI1_I1082_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1082_MP5 (I1_b12_0 XI1_I1082_Bn XI1_I1082_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1082_MP4 (XI1_I1082_p1 XI1_I1082_An I1_b12_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1082_MP2 (VDD I1_B_0_b3_2 XI1_I1082_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1082_MP3 (XI1_I1082_p1 I1_qu20_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1082_MP0 (VDD I1_B_0_b3_2 XI1_I1082_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1047_MP1 (VDD I1_qu21_b3_1 XI1_I1047_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1047_MP5 (I1_b11_11 XI1_I1047_Bn XI1_I1047_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1047_MP4 (XI1_I1047_p1 XI1_I1047_An I1_b11_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1047_MP2 (VDD I1_dd11_b3_2 XI1_I1047_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1047_MP3 (XI1_I1047_p1 I1_qu21_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1047_MP0 (VDD I1_dd11_b3_2 XI1_I1047_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I212_MP1 (VDD I1_I1022_G8_0n XI1_I1022_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I212_MP5 (I1_p10_9 XI1_I1022_I212_Bn XI1_I1022_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I212_MP4 (XI1_I1022_I212_p1 XI1_I1022_I212_An I1_p10_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1022_I212_MP2 (VDD I1_I1022_pn9 XI1_I1022_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1022_I212_MP3 (XI1_I1022_I212_p1 I1_I1022_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I212_MP0 (VDD I1_I1022_pn9 XI1_I1022_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I213_MP1 (VDD I1_I1022_G9_0n XI1_I1022_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I213_MP5 (I1_p10_10 XI1_I1022_I213_Bn XI1_I1022_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I213_MP4 (XI1_I1022_I213_p1 XI1_I1022_I213_An I1_p10_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1022_I213_MP2 (VDD I1_I1022_pn10 XI1_I1022_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1022_I213_MP3 (XI1_I1022_I213_p1 I1_I1022_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I213_MP0 (VDD I1_I1022_pn10 XI1_I1022_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I998_MP1 (VDD I1_qu22_b3_1 XI1_I998_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I998_MP5 (I1_b10_8 XI1_I998_Bn XI1_I998_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I998_MP4 (XI1_I998_p1 XI1_I998_An I1_b10_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I998_MP2 (VDD I1_dd8_b3_1 XI1_I998_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I998_MP3 (XI1_I998_p1 I1_qu22_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I998_MP0 (VDD I1_dd8_b3_1 XI1_I998_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1000_MP1 (VDD I1_qu22_b3_1 XI1_I1000_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1000_MP5 (I1_b10_10 XI1_I1000_Bn XI1_I1000_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1000_MP4 (XI1_I1000_p1 XI1_I1000_An I1_b10_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1000_MP2 (VDD I1_dd10_b3_1 XI1_I1000_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1000_MP3 (XI1_I1000_p1 I1_qu22_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1000_MP0 (VDD I1_dd10_b3_1 XI1_I1000_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I999_MP1 (VDD I1_qu22_b3_1 XI1_I999_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I999_MP5 (I1_b10_9 XI1_I999_Bn XI1_I999_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I999_MP4 (XI1_I999_p1 XI1_I999_An I1_b10_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I999_MP2 (VDD I1_dd9_b3_1 XI1_I999_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I999_MP3 (XI1_I999_p1 I1_qu22_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I999_MP0 (VDD I1_dd9_b3_1 XI1_I999_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I995_MP1 (VDD I1_qu22_b3_0 XI1_I995_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I995_MP5 (I1_b10_5 XI1_I995_Bn XI1_I995_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I995_MP4 (XI1_I995_p1 XI1_I995_An I1_b10_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I995_MP2 (VDD I1_dd5_b3_1 XI1_I995_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I995_MP3 (XI1_I995_p1 I1_qu22_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I995_MP0 (VDD I1_dd5_b3_1 XI1_I995_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I991_MP1 (VDD I1_qu22_b3_0 XI1_I991_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I991_MP5 (I1_b10_1 XI1_I991_Bn XI1_I991_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I991_MP4 (XI1_I991_p1 XI1_I991_An I1_b10_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I991_MP2 (VDD I1_dd1_b3_1 XI1_I991_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I991_MP3 (XI1_I991_p1 I1_qu22_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I991_MP0 (VDD I1_dd1_b3_1 XI1_I991_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I534_MP1 (VDD VDD XI1_I534_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I534_MP5 (I1_b0_4 XI1_I534_Bn XI1_I534_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I534_MP4 (XI1_I534_p1 XI1_I534_An I1_b0_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I534_MP2 (VDD I1_dd4_b3_0 XI1_I534_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I534_MP3 (XI1_I534_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I534_MP0 (VDD I1_dd4_b3_0 XI1_I534_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I535_MP1 (VDD VDD XI1_I535_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I535_MP5 (I1_b0_5 XI1_I535_Bn XI1_I535_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I535_MP4 (XI1_I535_p1 XI1_I535_An I1_b0_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I535_MP2 (VDD I1_dd5_b3_0 XI1_I535_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I535_MP3 (XI1_I535_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I535_MP0 (VDD I1_dd5_b3_0 XI1_I535_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I583_MP1 (VDD I1_qu31_b3_1 XI1_I583_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I583_MP5 (I1_b1_7 XI1_I583_Bn XI1_I583_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I583_MP4 (XI1_I583_p1 XI1_I583_An I1_b1_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I583_MP2 (VDD I1_dd7_b3_0 XI1_I583_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I583_MP3 (XI1_I583_p1 I1_qu31_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I583_MP0 (VDD I1_dd7_b3_0 XI1_I583_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I584_MP1 (VDD I1_qu31_b3_1 XI1_I584_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I584_MP5 (I1_b1_8 XI1_I584_Bn XI1_I584_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I584_MP4 (XI1_I584_p1 XI1_I584_An I1_b1_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I584_MP2 (VDD I1_dd8_b3_0 XI1_I584_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I584_MP3 (XI1_I584_p1 I1_qu31_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I584_MP0 (VDD I1_dd8_b3_0 XI1_I584_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I587_MP1 (VDD I1_qu31_b3_1 XI1_I587_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I587_MP5 (I1_b1_11 XI1_I587_Bn XI1_I587_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I587_MP4 (XI1_I587_p1 XI1_I587_An I1_b1_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I587_MP2 (VDD I1_dd11_b3_0 XI1_I587_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I587_MP3 (XI1_I587_p1 I1_qu31_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I587_MP0 (VDD I1_dd11_b3_0 XI1_I587_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I585_MP1 (VDD I1_qu31_b3_1 XI1_I585_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I585_MP5 (I1_b1_9 XI1_I585_Bn XI1_I585_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I585_MP4 (XI1_I585_p1 XI1_I585_An I1_b1_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I585_MP2 (VDD I1_dd9_b3_0 XI1_I585_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I585_MP3 (XI1_I585_p1 I1_qu31_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I585_MP0 (VDD I1_dd9_b3_0 XI1_I585_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I586_MP1 (VDD I1_qu31_b3_1 XI1_I586_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I586_MP5 (I1_b1_10 XI1_I586_Bn XI1_I586_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I586_MP4 (XI1_I586_p1 XI1_I586_An I1_b1_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I586_MP2 (VDD I1_dd10_b3_0 XI1_I586_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I586_MP3 (XI1_I586_p1 I1_qu31_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I586_MP0 (VDD I1_dd10_b3_0 XI1_I586_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I588_MP1 (VDD I1_qu31_b3_2 XI1_I588_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I588_MP5 (I1_b1_12 XI1_I588_Bn XI1_I588_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I588_MP4 (XI1_I588_p1 XI1_I588_An I1_b1_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I588_MP2 (VDD I1_dd12_b3_0 XI1_I588_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I588_MP3 (XI1_I588_p1 I1_qu31_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I588_MP0 (VDD I1_dd12_b3_0 XI1_I588_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I589_MP1 (VDD I1_qu31_b3_2 XI1_I589_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I589_MP5 (I1_b1_13 XI1_I589_Bn XI1_I589_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I589_MP4 (XI1_I589_p1 XI1_I589_An I1_b1_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I589_MP2 (VDD I1_dd13_b3_0 XI1_I589_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I589_MP3 (XI1_I589_p1 I1_qu31_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I589_MP0 (VDD I1_dd13_b3_0 XI1_I589_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I590_MP1 (VDD I1_qu31_b3_2 XI1_I590_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I590_MP5 (I1_b1_14 XI1_I590_Bn XI1_I590_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I590_MP4 (XI1_I590_p1 XI1_I590_An I1_b1_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I590_MP2 (VDD I1_dd14_b3_0 XI1_I590_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I590_MP3 (XI1_I590_p1 I1_qu31_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I590_MP0 (VDD I1_dd14_b3_0 XI1_I590_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I595_MP1 (VDD I1_qu31_b3_3 XI1_I595_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I595_MP5 (I1_b1_19 XI1_I595_Bn XI1_I595_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I595_MP4 (XI1_I595_p1 XI1_I595_An I1_b1_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I595_MP2 (VDD I1_dd19_b3_0 XI1_I595_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I595_MP3 (XI1_I595_p1 I1_qu31_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I595_MP0 (VDD I1_dd19_b3_0 XI1_I595_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I599_MP1 (VDD I1_qu31_b3_3 XI1_I599_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I599_MP5 (I1_b1_23 XI1_I599_Bn XI1_I599_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I599_MP4 (XI1_I599_p1 XI1_I599_An I1_b1_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I599_MP2 (VDD I1_dd23_b3_0 XI1_I599_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I599_MP3 (XI1_I599_p1 I1_qu31_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I599_MP0 (VDD I1_dd23_b3_0 XI1_I599_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I601_MP1 (VDD I1_qu31_b3_4 XI1_I601_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I601_MP5 (I1_b1_25 XI1_I601_Bn XI1_I601_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I601_MP4 (XI1_I601_p1 XI1_I601_An I1_b1_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I601_MP2 (VDD I1_dd25_b3_0 XI1_I601_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I601_MP3 (XI1_I601_p1 I1_qu31_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I601_MP0 (VDD I1_dd25_b3_0 XI1_I601_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I602_MP1 (VDD I1_qu31_b3_4 XI1_I602_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I602_MP5 (I1_b1_26 XI1_I602_Bn XI1_I602_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I602_MP4 (XI1_I602_p1 XI1_I602_An I1_b1_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I602_MP2 (VDD I1_dd26_b3_0 XI1_I602_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I602_MP3 (XI1_I602_p1 I1_qu31_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I602_MP0 (VDD I1_dd26_b3_0 XI1_I602_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I558_MP1 (VDD VDD XI1_I558_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I558_MP5 (I1_b0_28 XI1_I558_Bn XI1_I558_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I558_MP4 (XI1_I558_p1 XI1_I558_An I1_b0_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I558_MP2 (VDD I1_dd28_b3_0 XI1_I558_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I558_MP3 (XI1_I558_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I558_MP0 (VDD I1_dd28_b3_0 XI1_I558_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I603_MP1 (VDD I1_qu31_b3_4 XI1_I603_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I603_MP5 (I1_b1_27 XI1_I603_Bn XI1_I603_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I603_MP4 (XI1_I603_p1 XI1_I603_An I1_b1_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I603_MP2 (VDD I1_dd27_b3_0 XI1_I603_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I603_MP3 (XI1_I603_p1 I1_qu31_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I603_MP0 (VDD I1_dd27_b3_0 XI1_I603_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I561_MP1 (VDD VDD XI1_I561_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I561_MP5 (I1_b0_31 XI1_I561_Bn XI1_I561_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I561_MP4 (XI1_I561_p1 XI1_I561_An I1_b0_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I561_MP2 (VDD I1_dd31_b3_0 XI1_I561_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I561_MP3 (XI1_I561_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I561_MP0 (VDD I1_dd31_b3_0 XI1_I561_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1479_MP1 (VDD I1_qu12_b3_4 XI1_I1479_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1479_MP5 (I1_b20_29 XI1_I1479_Bn XI1_I1479_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1479_MP4 (XI1_I1479_p1 XI1_I1479_An I1_b20_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1479_MP2 (VDD I1_dd29_b3_3 XI1_I1479_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1479_MP3 (XI1_I1479_p1 I1_qu12_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1479_MP0 (VDD I1_dd29_b3_3 XI1_I1479_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1478_MP1 (VDD I1_qu12_b3_4 XI1_I1478_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1478_MP5 (I1_b20_28 XI1_I1478_Bn XI1_I1478_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1478_MP4 (XI1_I1478_p1 XI1_I1478_An I1_b20_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1478_MP2 (VDD I1_dd28_b3_3 XI1_I1478_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1478_MP3 (XI1_I1478_p1 I1_qu12_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1478_MP0 (VDD I1_dd28_b3_3 XI1_I1478_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I216_MP1 (VDD I1_I1482_G12_0n XI1_I1482_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I216_MP5 (I1_p20_13 XI1_I1482_I216_Bn XI1_I1482_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I216_MP4 (XI1_I1482_I216_p1 XI1_I1482_I216_An I1_p20_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1482_I216_MP2 (VDD I1_I1482_pn13 XI1_I1482_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1482_I216_MP3 (XI1_I1482_I216_p1 I1_I1482_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I216_MP0 (VDD I1_I1482_pn13 XI1_I1482_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I214_MP1 (VDD I1_I1482_G10_0n XI1_I1482_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I214_MP5 (I1_p20_11 XI1_I1482_I214_Bn XI1_I1482_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I214_MP4 (XI1_I1482_I214_p1 XI1_I1482_I214_An I1_p20_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1482_I214_MP2 (VDD I1_I1482_pn11 XI1_I1482_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1482_I214_MP3 (XI1_I1482_I214_p1 I1_I1482_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I214_MP0 (VDD I1_I1482_pn11 XI1_I1482_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1512_MP1 (VDD I1_qu11_b3_2 XI1_I1512_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1512_MP5 (I1_b21_16 XI1_I1512_Bn XI1_I1512_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1512_MP4 (XI1_I1512_p1 XI1_I1512_An I1_b21_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1512_MP2 (VDD I1_dd16_b3_3 XI1_I1512_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1512_MP3 (XI1_I1512_p1 I1_qu11_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1512_MP0 (VDD I1_dd16_b3_3 XI1_I1512_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1511_MP1 (VDD I1_qu11_b3_2 XI1_I1511_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1511_MP5 (I1_b21_15 XI1_I1511_Bn XI1_I1511_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1511_MP4 (XI1_I1511_p1 XI1_I1511_An I1_b21_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1511_MP2 (VDD I1_dd15_b3_3 XI1_I1511_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1511_MP3 (XI1_I1511_p1 I1_qu11_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1511_MP0 (VDD I1_dd15_b3_3 XI1_I1511_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1508_MP1 (VDD I1_qu11_b3_2 XI1_I1508_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1508_MP5 (I1_b21_12 XI1_I1508_Bn XI1_I1508_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1508_MP4 (XI1_I1508_p1 XI1_I1508_An I1_b21_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1508_MP2 (VDD I1_dd12_b3_3 XI1_I1508_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1508_MP3 (XI1_I1508_p1 I1_qu11_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1508_MP0 (VDD I1_dd12_b3_3 XI1_I1508_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1499_MP1 (VDD I1_qu11_b3_0 XI1_I1499_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1499_MP5 (I1_b21_3 XI1_I1499_Bn XI1_I1499_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1499_MP4 (XI1_I1499_p1 XI1_I1499_An I1_b21_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1499_MP2 (VDD I1_dd3_b3_3 XI1_I1499_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1499_MP3 (XI1_I1499_p1 I1_qu11_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1499_MP0 (VDD I1_dd3_b3_3 XI1_I1499_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1090_MP1 (VDD I1_qu20_b3_1 XI1_I1090_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1090_MP5 (I1_b12_8 XI1_I1090_Bn XI1_I1090_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1090_MP4 (XI1_I1090_p1 XI1_I1090_An I1_b12_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1090_MP2 (VDD I1_dd8_b3_2 XI1_I1090_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1090_MP3 (XI1_I1090_p1 I1_qu20_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1090_MP0 (VDD I1_dd8_b3_2 XI1_I1090_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1088_MP1 (VDD I1_qu20_b3_1 XI1_I1088_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1088_MP5 (I1_b12_6 XI1_I1088_Bn XI1_I1088_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1088_MP4 (XI1_I1088_p1 XI1_I1088_An I1_b12_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1088_MP2 (VDD I1_dd6_b3_2 XI1_I1088_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1088_MP3 (XI1_I1088_p1 I1_qu20_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1088_MP0 (VDD I1_dd6_b3_2 XI1_I1088_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1087_MP1 (VDD I1_qu20_b3_0 XI1_I1087_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1087_MP5 (I1_b12_5 XI1_I1087_Bn XI1_I1087_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1087_MP4 (XI1_I1087_p1 XI1_I1087_An I1_b12_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1087_MP2 (VDD I1_dd5_b3_2 XI1_I1087_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1087_MP3 (XI1_I1087_p1 I1_qu20_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1087_MP0 (VDD I1_dd5_b3_2 XI1_I1087_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1084_MP1 (VDD I1_qu20_b3_0 XI1_I1084_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1084_MP5 (I1_b12_2 XI1_I1084_Bn XI1_I1084_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1084_MP4 (XI1_I1084_p1 XI1_I1084_An I1_b12_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1084_MP2 (VDD I1_dd2_b3_2 XI1_I1084_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1084_MP3 (XI1_I1084_p1 I1_qu20_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1084_MP0 (VDD I1_dd2_b3_2 XI1_I1084_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1083_MP1 (VDD I1_qu20_b3_0 XI1_I1083_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1083_MP5 (I1_b12_1 XI1_I1083_Bn XI1_I1083_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1083_MP4 (XI1_I1083_p1 XI1_I1083_An I1_b12_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1083_MP2 (VDD I1_dd1_b3_2 XI1_I1083_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1083_MP3 (XI1_I1083_p1 I1_qu20_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1083_MP0 (VDD I1_dd1_b3_2 XI1_I1083_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I207_MP1 (VDD I1_I1068_G3_0n XI1_I1068_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I207_MP5 (I1_p11_4 XI1_I1068_I207_Bn XI1_I1068_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I207_MP4 (XI1_I1068_I207_p1 XI1_I1068_I207_An I1_p11_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1068_I207_MP2 (VDD I1_I1068_pn4 XI1_I1068_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1068_I207_MP3 (XI1_I1068_I207_p1 I1_I1068_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I207_MP0 (VDD I1_I1068_pn4 XI1_I1068_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1044_MP1 (VDD I1_qu21_b3_1 XI1_I1044_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1044_MP5 (I1_b11_8 XI1_I1044_Bn XI1_I1044_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1044_MP4 (XI1_I1044_p1 XI1_I1044_An I1_b11_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1044_MP2 (VDD I1_dd8_b3_2 XI1_I1044_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1044_MP3 (XI1_I1044_p1 I1_qu21_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1044_MP0 (VDD I1_dd8_b3_2 XI1_I1044_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1042_MP1 (VDD I1_qu21_b3_1 XI1_I1042_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1042_MP5 (I1_b11_6 XI1_I1042_Bn XI1_I1042_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1042_MP4 (XI1_I1042_p1 XI1_I1042_An I1_b11_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1042_MP2 (VDD I1_dd6_b3_2 XI1_I1042_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1042_MP3 (XI1_I1042_p1 I1_qu21_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1042_MP0 (VDD I1_dd6_b3_2 XI1_I1042_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I996_MP1 (VDD I1_qu22_b3_1 XI1_I996_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I996_MP5 (I1_b10_6 XI1_I996_Bn XI1_I996_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I996_MP4 (XI1_I996_p1 XI1_I996_An I1_b10_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I996_MP2 (VDD I1_dd6_b3_1 XI1_I996_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I996_MP3 (XI1_I996_p1 I1_qu22_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I996_MP0 (VDD I1_dd6_b3_1 XI1_I996_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I997_MP1 (VDD I1_qu22_b3_1 XI1_I997_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I997_MP5 (I1_b10_7 XI1_I997_Bn XI1_I997_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I997_MP4 (XI1_I997_p1 XI1_I997_An I1_b10_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I997_MP2 (VDD I1_dd7_b3_1 XI1_I997_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I997_MP3 (XI1_I997_p1 I1_qu22_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I997_MP0 (VDD I1_dd7_b3_1 XI1_I997_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I993_MP1 (VDD I1_qu22_b3_0 XI1_I993_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I993_MP5 (I1_b10_3 XI1_I993_Bn XI1_I993_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I993_MP4 (XI1_I993_p1 XI1_I993_An I1_b10_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I993_MP2 (VDD I1_dd3_b3_1 XI1_I993_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I993_MP3 (XI1_I993_p1 I1_qu22_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I993_MP0 (VDD I1_dd3_b3_1 XI1_I993_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I944_MP1 (VDD I1_qu23_b3_0 XI1_I944_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I944_MP5 (I1_b9_0 XI1_I944_Bn XI1_I944_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I944_MP4 (XI1_I944_p1 XI1_I944_An I1_b9_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I944_MP2 (VDD I1_B_0_b3_1 XI1_I944_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I944_MP3 (XI1_I944_p1 I1_qu23_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I944_MP0 (VDD I1_B_0_b3_1 XI1_I944_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I992_MP1 (VDD I1_qu22_b3_0 XI1_I992_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I992_MP5 (I1_b10_2 XI1_I992_Bn XI1_I992_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I992_MP4 (XI1_I992_p1 XI1_I992_An I1_b10_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I992_MP2 (VDD I1_dd2_b3_1 XI1_I992_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I992_MP3 (XI1_I992_p1 I1_qu22_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I992_MP0 (VDD I1_dd2_b3_1 XI1_I992_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I994_MP1 (VDD I1_qu22_b3_0 XI1_I994_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I994_MP5 (I1_b10_4 XI1_I994_Bn XI1_I994_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I994_MP4 (XI1_I994_p1 XI1_I994_An I1_b10_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I994_MP2 (VDD I1_dd4_b3_1 XI1_I994_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I994_MP3 (XI1_I994_p1 I1_qu22_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I994_MP0 (VDD I1_dd4_b3_1 XI1_I994_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I532_MP1 (VDD VDD XI1_I532_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I532_MP5 (I1_b0_2 XI1_I532_Bn XI1_I532_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I532_MP4 (XI1_I532_p1 XI1_I532_An I1_b0_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I532_MP2 (VDD I1_dd2_b3_0 XI1_I532_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I532_MP3 (XI1_I532_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I532_MP0 (VDD I1_dd2_b3_0 XI1_I532_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I533_MP1 (VDD VDD XI1_I533_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I533_MP5 (I1_b0_3 XI1_I533_Bn XI1_I533_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I533_MP4 (XI1_I533_p1 XI1_I533_An I1_b0_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I533_MP2 (VDD I1_dd3_b3_0 XI1_I533_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I533_MP3 (XI1_I533_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I533_MP0 (VDD I1_dd3_b3_0 XI1_I533_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I536_MP1 (VDD VDD XI1_I536_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I536_MP5 (I1_b0_6 XI1_I536_Bn XI1_I536_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I536_MP4 (XI1_I536_p1 XI1_I536_An I1_b0_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I536_MP2 (VDD I1_dd6_b3_0 XI1_I536_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I536_MP3 (XI1_I536_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I536_MP0 (VDD I1_dd6_b3_0 XI1_I536_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I537_MP1 (VDD VDD XI1_I537_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I537_MP5 (I1_b0_7 XI1_I537_Bn XI1_I537_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I537_MP4 (XI1_I537_p1 XI1_I537_An I1_b0_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I537_MP2 (VDD I1_dd7_b3_0 XI1_I537_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I537_MP3 (XI1_I537_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I537_MP0 (VDD I1_dd7_b3_0 XI1_I537_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I538_MP1 (VDD VDD XI1_I538_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I538_MP5 (I1_b0_8 XI1_I538_Bn XI1_I538_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I538_MP4 (XI1_I538_p1 XI1_I538_An I1_b0_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I538_MP2 (VDD I1_dd8_b3_0 XI1_I538_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I538_MP3 (XI1_I538_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I538_MP0 (VDD I1_dd8_b3_0 XI1_I538_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I539_MP1 (VDD VDD XI1_I539_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I539_MP5 (I1_b0_9 XI1_I539_Bn XI1_I539_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I539_MP4 (XI1_I539_p1 XI1_I539_An I1_b0_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I539_MP2 (VDD I1_dd9_b3_0 XI1_I539_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I539_MP3 (XI1_I539_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I539_MP0 (VDD I1_dd9_b3_0 XI1_I539_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I540_MP1 (VDD VDD XI1_I540_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I540_MP5 (I1_b0_10 XI1_I540_Bn XI1_I540_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I540_MP4 (XI1_I540_p1 XI1_I540_An I1_b0_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I540_MP2 (VDD I1_dd10_b3_0 XI1_I540_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I540_MP3 (XI1_I540_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I540_MP0 (VDD I1_dd10_b3_0 XI1_I540_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I541_MP1 (VDD VDD XI1_I541_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I541_MP5 (I1_b0_11 XI1_I541_Bn XI1_I541_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I541_MP4 (XI1_I541_p1 XI1_I541_An I1_b0_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I541_MP2 (VDD I1_dd11_b3_0 XI1_I541_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I541_MP3 (XI1_I541_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I541_MP0 (VDD I1_dd11_b3_0 XI1_I541_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I542_MP1 (VDD VDD XI1_I542_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I542_MP5 (I1_b0_12 XI1_I542_Bn XI1_I542_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I542_MP4 (XI1_I542_p1 XI1_I542_An I1_b0_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I542_MP2 (VDD I1_dd12_b3_0 XI1_I542_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I542_MP3 (XI1_I542_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I542_MP0 (VDD I1_dd12_b3_0 XI1_I542_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I543_MP1 (VDD VDD XI1_I543_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I543_MP5 (I1_b0_13 XI1_I543_Bn XI1_I543_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I543_MP4 (XI1_I543_p1 XI1_I543_An I1_b0_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I543_MP2 (VDD I1_dd13_b3_0 XI1_I543_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I543_MP3 (XI1_I543_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I543_MP0 (VDD I1_dd13_b3_0 XI1_I543_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I544_MP1 (VDD VDD XI1_I544_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I544_MP5 (I1_b0_14 XI1_I544_Bn XI1_I544_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I544_MP4 (XI1_I544_p1 XI1_I544_An I1_b0_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I544_MP2 (VDD I1_dd14_b3_0 XI1_I544_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I544_MP3 (XI1_I544_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I544_MP0 (VDD I1_dd14_b3_0 XI1_I544_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I591_MP1 (VDD I1_qu31_b3_2 XI1_I591_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I591_MP5 (I1_b1_15 XI1_I591_Bn XI1_I591_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I591_MP4 (XI1_I591_p1 XI1_I591_An I1_b1_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I591_MP2 (VDD I1_dd15_b3_0 XI1_I591_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I591_MP3 (XI1_I591_p1 I1_qu31_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I591_MP0 (VDD I1_dd15_b3_0 XI1_I591_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I593_MP1 (VDD I1_qu31_b3_2 XI1_I593_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I593_MP5 (I1_b1_17 XI1_I593_Bn XI1_I593_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I593_MP4 (XI1_I593_p1 XI1_I593_An I1_b1_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I593_MP2 (VDD I1_dd17_b3_0 XI1_I593_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I593_MP3 (XI1_I593_p1 I1_qu31_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I593_MP0 (VDD I1_dd17_b3_0 XI1_I593_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I592_MP1 (VDD I1_qu31_b3_2 XI1_I592_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I592_MP5 (I1_b1_16 XI1_I592_Bn XI1_I592_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I592_MP4 (XI1_I592_p1 XI1_I592_An I1_b1_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I592_MP2 (VDD I1_dd16_b3_0 XI1_I592_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I592_MP3 (XI1_I592_p1 I1_qu31_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I592_MP0 (VDD I1_dd16_b3_0 XI1_I592_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I594_MP1 (VDD I1_qu31_b3_3 XI1_I594_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I594_MP5 (I1_b1_18 XI1_I594_Bn XI1_I594_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I594_MP4 (XI1_I594_p1 XI1_I594_An I1_b1_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I594_MP2 (VDD I1_dd18_b3_0 XI1_I594_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I594_MP3 (XI1_I594_p1 I1_qu31_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I594_MP0 (VDD I1_dd18_b3_0 XI1_I594_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I548_MP1 (VDD VDD XI1_I548_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I548_MP5 (I1_b0_18 XI1_I548_Bn XI1_I548_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I548_MP4 (XI1_I548_p1 XI1_I548_An I1_b0_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I548_MP2 (VDD I1_dd18_b3_0 XI1_I548_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I548_MP3 (XI1_I548_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I548_MP0 (VDD I1_dd18_b3_0 XI1_I548_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I549_MP1 (VDD VDD XI1_I549_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I549_MP5 (I1_b0_19 XI1_I549_Bn XI1_I549_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I549_MP4 (XI1_I549_p1 XI1_I549_An I1_b0_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I549_MP2 (VDD I1_dd19_b3_0 XI1_I549_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I549_MP3 (XI1_I549_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I549_MP0 (VDD I1_dd19_b3_0 XI1_I549_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I596_MP1 (VDD I1_qu31_b3_3 XI1_I596_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I596_MP5 (I1_b1_20 XI1_I596_Bn XI1_I596_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I596_MP4 (XI1_I596_p1 XI1_I596_An I1_b1_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I596_MP2 (VDD I1_dd20_b3_0 XI1_I596_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I596_MP3 (XI1_I596_p1 I1_qu31_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I596_MP0 (VDD I1_dd20_b3_0 XI1_I596_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I597_MP1 (VDD I1_qu31_b3_3 XI1_I597_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I597_MP5 (I1_b1_21 XI1_I597_Bn XI1_I597_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I597_MP4 (XI1_I597_p1 XI1_I597_An I1_b1_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I597_MP2 (VDD I1_dd21_b3_0 XI1_I597_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I597_MP3 (XI1_I597_p1 I1_qu31_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I597_MP0 (VDD I1_dd21_b3_0 XI1_I597_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I598_MP1 (VDD I1_qu31_b3_3 XI1_I598_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I598_MP5 (I1_b1_22 XI1_I598_Bn XI1_I598_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I598_MP4 (XI1_I598_p1 XI1_I598_An I1_b1_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I598_MP2 (VDD I1_dd22_b3_0 XI1_I598_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I598_MP3 (XI1_I598_p1 I1_qu31_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I598_MP0 (VDD I1_dd22_b3_0 XI1_I598_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I551_MP1 (VDD VDD XI1_I551_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I551_MP5 (I1_b0_21 XI1_I551_Bn XI1_I551_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I551_MP4 (XI1_I551_p1 XI1_I551_An I1_b0_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I551_MP2 (VDD I1_dd21_b3_0 XI1_I551_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I551_MP3 (XI1_I551_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I551_MP0 (VDD I1_dd21_b3_0 XI1_I551_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I600_MP1 (VDD I1_qu31_b3_4 XI1_I600_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I600_MP5 (I1_b1_24 XI1_I600_Bn XI1_I600_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I600_MP4 (XI1_I600_p1 XI1_I600_An I1_b1_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I600_MP2 (VDD I1_dd24_b3_0 XI1_I600_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I600_MP3 (XI1_I600_p1 I1_qu31_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I600_MP0 (VDD I1_dd24_b3_0 XI1_I600_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I609_MP1 (VDD I1_qu31_b3_5 XI1_I609_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I609_MP5 (I1_h1 XI1_I609_Bn XI1_I609_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I609_MP4 (XI1_I609_p1 XI1_I609_An I1_h1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I609_MP2 (VDD I1_p0_31 XI1_I609_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I609_MP3 (XI1_I609_p1 I1_qu31_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I609_MP0 (VDD I1_p0_31 XI1_I609_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I556_MP1 (VDD VDD XI1_I556_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I556_MP5 (I1_b0_26 XI1_I556_Bn XI1_I556_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I556_MP4 (XI1_I556_p1 XI1_I556_An I1_b0_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I556_MP2 (VDD I1_dd26_b3_0 XI1_I556_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I556_MP3 (XI1_I556_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I556_MP0 (VDD I1_dd26_b3_0 XI1_I556_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I557_MP1 (VDD VDD XI1_I557_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I557_MP5 (I1_b0_27 XI1_I557_Bn XI1_I557_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I557_MP4 (XI1_I557_p1 XI1_I557_An I1_b0_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I557_MP2 (VDD I1_dd27_b3_0 XI1_I557_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I557_MP3 (XI1_I557_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I557_MP0 (VDD I1_dd27_b3_0 XI1_I557_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I560_MP1 (VDD VDD XI1_I560_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I560_MP5 (I1_b0_30 XI1_I560_Bn XI1_I560_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I560_MP4 (XI1_I560_p1 XI1_I560_An I1_b0_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I560_MP2 (VDD I1_dd30_b3_0 XI1_I560_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I560_MP3 (XI1_I560_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I560_MP0 (VDD I1_dd30_b3_0 XI1_I560_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I218_MP1 (VDD I1_I1482_G14_0n XI1_I1482_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I218_MP5 (I1_p20_15 XI1_I1482_I218_Bn XI1_I1482_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I218_MP4 (XI1_I1482_I218_p1 XI1_I1482_I218_An I1_p20_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1482_I218_MP2 (VDD I1_I1482_pn15 XI1_I1482_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1482_I218_MP3 (XI1_I1482_I218_p1 I1_I1482_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I218_MP0 (VDD I1_I1482_pn15 XI1_I1482_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1516_MP1 (VDD I1_qu11_b3_3 XI1_I1516_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1516_MP5 (I1_b21_20 XI1_I1516_Bn XI1_I1516_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1516_MP4 (XI1_I1516_p1 XI1_I1516_An I1_b21_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1516_MP2 (VDD I1_dd20_b3_3 XI1_I1516_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1516_MP3 (XI1_I1516_p1 I1_qu11_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1516_MP0 (VDD I1_dd20_b3_3 XI1_I1516_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1515_MP1 (VDD I1_qu11_b3_3 XI1_I1515_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1515_MP5 (I1_b21_19 XI1_I1515_Bn XI1_I1515_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1515_MP4 (XI1_I1515_p1 XI1_I1515_An I1_b21_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1515_MP2 (VDD I1_dd19_b3_3 XI1_I1515_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1515_MP3 (XI1_I1515_p1 I1_qu11_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1515_MP0 (VDD I1_dd19_b3_3 XI1_I1515_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1514_MP1 (VDD I1_qu11_b3_3 XI1_I1514_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1514_MP5 (I1_b21_18 XI1_I1514_Bn XI1_I1514_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1514_MP4 (XI1_I1514_p1 XI1_I1514_An I1_b21_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1514_MP2 (VDD I1_dd18_b3_3 XI1_I1514_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1514_MP3 (XI1_I1514_p1 I1_qu11_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1514_MP0 (VDD I1_dd18_b3_3 XI1_I1514_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1498_MP1 (VDD I1_qu11_b3_0 XI1_I1498_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1498_MP5 (I1_b21_2 XI1_I1498_Bn XI1_I1498_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1498_MP4 (XI1_I1498_p1 XI1_I1498_An I1_b21_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1498_MP2 (VDD I1_dd2_b3_3 XI1_I1498_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1498_MP3 (XI1_I1498_p1 I1_qu11_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1498_MP0 (VDD I1_dd2_b3_3 XI1_I1498_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1086_MP1 (VDD I1_qu20_b3_0 XI1_I1086_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1086_MP5 (I1_b12_4 XI1_I1086_Bn XI1_I1086_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1086_MP4 (XI1_I1086_p1 XI1_I1086_An I1_b12_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1086_MP2 (VDD I1_dd4_b3_2 XI1_I1086_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1086_MP3 (XI1_I1086_p1 I1_qu20_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1086_MP0 (VDD I1_dd4_b3_2 XI1_I1086_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1085_MP1 (VDD I1_qu20_b3_0 XI1_I1085_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1085_MP5 (I1_b12_3 XI1_I1085_Bn XI1_I1085_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1085_MP4 (XI1_I1085_p1 XI1_I1085_An I1_b12_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1085_MP2 (VDD I1_dd3_b3_2 XI1_I1085_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1085_MP3 (XI1_I1085_p1 I1_qu20_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1085_MP0 (VDD I1_dd3_b3_2 XI1_I1085_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I206_MP1 (VDD I1_I1068_G2_0n XI1_I1068_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I206_MP5 (I1_p11_3 XI1_I1068_I206_Bn XI1_I1068_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I206_MP4 (XI1_I1068_I206_p1 XI1_I1068_I206_An I1_p11_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1068_I206_MP2 (VDD I1_I1068_pn3 XI1_I1068_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1068_I206_MP3 (XI1_I1068_I206_p1 I1_I1068_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I206_MP0 (VDD I1_I1068_pn3 XI1_I1068_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1037_MP1 (VDD I1_qu21_b3_0 XI1_I1037_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1037_MP5 (I1_b11_1 XI1_I1037_Bn XI1_I1037_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1037_MP4 (XI1_I1037_p1 XI1_I1037_An I1_b11_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1037_MP2 (VDD I1_dd1_b3_2 XI1_I1037_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1037_MP3 (XI1_I1037_p1 I1_qu21_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1037_MP0 (VDD I1_dd1_b3_2 XI1_I1037_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1038_MP1 (VDD I1_qu21_b3_0 XI1_I1038_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1038_MP5 (I1_b11_2 XI1_I1038_Bn XI1_I1038_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1038_MP4 (XI1_I1038_p1 XI1_I1038_An I1_b11_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1038_MP2 (VDD I1_dd2_b3_2 XI1_I1038_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1038_MP3 (XI1_I1038_p1 I1_qu21_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1038_MP0 (VDD I1_dd2_b3_2 XI1_I1038_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1039_MP1 (VDD I1_qu21_b3_0 XI1_I1039_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1039_MP5 (I1_b11_3 XI1_I1039_Bn XI1_I1039_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1039_MP4 (XI1_I1039_p1 XI1_I1039_An I1_b11_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1039_MP2 (VDD I1_dd3_b3_2 XI1_I1039_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1039_MP3 (XI1_I1039_p1 I1_qu21_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1039_MP0 (VDD I1_dd3_b3_2 XI1_I1039_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1040_MP1 (VDD I1_qu21_b3_0 XI1_I1040_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1040_MP5 (I1_b11_4 XI1_I1040_Bn XI1_I1040_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1040_MP4 (XI1_I1040_p1 XI1_I1040_An I1_b11_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1040_MP2 (VDD I1_dd4_b3_2 XI1_I1040_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1040_MP3 (XI1_I1040_p1 I1_qu21_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1040_MP0 (VDD I1_dd4_b3_2 XI1_I1040_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1041_MP1 (VDD I1_qu21_b3_0 XI1_I1041_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1041_MP5 (I1_b11_5 XI1_I1041_Bn XI1_I1041_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1041_MP4 (XI1_I1041_p1 XI1_I1041_An I1_b11_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1041_MP2 (VDD I1_dd5_b3_2 XI1_I1041_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1041_MP3 (XI1_I1041_p1 I1_qu21_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1041_MP0 (VDD I1_dd5_b3_2 XI1_I1041_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1036_MP1 (VDD I1_qu21_b3_0 XI1_I1036_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1036_MP5 (I1_b11_0 XI1_I1036_Bn XI1_I1036_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1036_MP4 (XI1_I1036_p1 XI1_I1036_An I1_b11_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1036_MP2 (VDD I1_B_0_b3_2 XI1_I1036_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1036_MP3 (XI1_I1036_p1 I1_qu21_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1036_MP0 (VDD I1_B_0_b3_2 XI1_I1036_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I206_MP1 (VDD I1_I1022_G2_0n XI1_I1022_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I206_MP5 (I1_p10_3 XI1_I1022_I206_Bn XI1_I1022_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I206_MP4 (XI1_I1022_I206_p1 XI1_I1022_I206_An I1_p10_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1022_I206_MP2 (VDD I1_I1022_pn3 XI1_I1022_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1022_I206_MP3 (XI1_I1022_I206_p1 I1_I1022_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I206_MP0 (VDD I1_I1022_pn3 XI1_I1022_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I207_MP1 (VDD I1_I1022_G3_0n XI1_I1022_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I207_MP5 (I1_p10_4 XI1_I1022_I207_Bn XI1_I1022_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I207_MP4 (XI1_I1022_I207_p1 XI1_I1022_I207_An I1_p10_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1022_I207_MP2 (VDD I1_I1022_pn4 XI1_I1022_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1022_I207_MP3 (XI1_I1022_I207_p1 I1_I1022_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I207_MP0 (VDD I1_I1022_pn4 XI1_I1022_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I990_MP1 (VDD I1_qu22_b3_0 XI1_I990_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I990_MP5 (I1_b10_0 XI1_I990_Bn XI1_I990_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I990_MP4 (XI1_I990_p1 XI1_I990_An I1_b10_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I990_MP2 (VDD I1_B_0_b3_1 XI1_I990_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I990_MP3 (XI1_I990_p1 I1_qu22_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I990_MP0 (VDD I1_B_0_b3_1 XI1_I990_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I530_MP1 (VDD VDD XI1_I530_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I530_MP5 (I1_b0_0 XI1_I530_Bn XI1_I530_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I530_MP4 (XI1_I530_p1 XI1_I530_An I1_b0_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I530_MP2 (VDD I1_B_0_b3_0 XI1_I530_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I530_MP3 (XI1_I530_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I530_MP0 (VDD I1_B_0_b3_0 XI1_I530_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I206_MP1 (VDD I1_I562_G2_0n XI1_I562_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I206_MP5 (I1_p0_3 XI1_I562_I206_Bn XI1_I562_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I206_MP4 (XI1_I562_I206_p1 XI1_I562_I206_An I1_p0_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I206_MP2 (VDD I1_I562_pn3 XI1_I562_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I206_MP3 (XI1_I562_I206_p1 I1_I562_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I206_MP0 (VDD I1_I562_pn3 XI1_I562_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I212_MP1 (VDD I1_I562_G8_0n XI1_I562_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I212_MP5 (I1_p0_9 XI1_I562_I212_Bn XI1_I562_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I212_MP4 (XI1_I562_I212_p1 XI1_I562_I212_An I1_p0_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I212_MP2 (VDD I1_I562_pn9 XI1_I562_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I212_MP3 (XI1_I562_I212_p1 I1_I562_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I212_MP0 (VDD I1_I562_pn9 XI1_I562_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I214_MP1 (VDD I1_I562_G10_0n XI1_I562_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I214_MP5 (I1_p0_11 XI1_I562_I214_Bn XI1_I562_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I214_MP4 (XI1_I562_I214_p1 XI1_I562_I214_An I1_p0_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I214_MP2 (VDD I1_I562_pn11 XI1_I562_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I214_MP3 (XI1_I562_I214_p1 I1_I562_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I214_MP0 (VDD I1_I562_pn11 XI1_I562_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I216_MP1 (VDD I1_I562_G12_0n XI1_I562_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I216_MP5 (I1_p0_13 XI1_I562_I216_Bn XI1_I562_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I216_MP4 (XI1_I562_I216_p1 XI1_I562_I216_An I1_p0_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I216_MP2 (VDD I1_I562_pn13 XI1_I562_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I216_MP3 (XI1_I562_I216_p1 I1_I562_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I216_MP0 (VDD I1_I562_pn13 XI1_I562_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I545_MP1 (VDD VDD XI1_I545_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I545_MP5 (I1_b0_15 XI1_I545_Bn XI1_I545_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I545_MP4 (XI1_I545_p1 XI1_I545_An I1_b0_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I545_MP2 (VDD I1_dd15_b3_0 XI1_I545_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I545_MP3 (XI1_I545_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I545_MP0 (VDD I1_dd15_b3_0 XI1_I545_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I546_MP1 (VDD VDD XI1_I546_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I546_MP5 (I1_b0_16 XI1_I546_Bn XI1_I546_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I546_MP4 (XI1_I546_p1 XI1_I546_An I1_b0_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I546_MP2 (VDD I1_dd16_b3_0 XI1_I546_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I546_MP3 (XI1_I546_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I546_MP0 (VDD I1_dd16_b3_0 XI1_I546_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I547_MP1 (VDD VDD XI1_I547_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I547_MP5 (I1_b0_17 XI1_I547_Bn XI1_I547_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I547_MP4 (XI1_I547_p1 XI1_I547_An I1_b0_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I547_MP2 (VDD I1_dd17_b3_0 XI1_I547_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I547_MP3 (XI1_I547_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I547_MP0 (VDD I1_dd17_b3_0 XI1_I547_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I550_MP1 (VDD VDD XI1_I550_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I550_MP5 (I1_b0_20 XI1_I550_Bn XI1_I550_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I550_MP4 (XI1_I550_p1 XI1_I550_An I1_b0_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I550_MP2 (VDD I1_dd20_b3_0 XI1_I550_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I550_MP3 (XI1_I550_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I550_MP0 (VDD I1_dd20_b3_0 XI1_I550_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I552_MP1 (VDD VDD XI1_I552_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I552_MP5 (I1_b0_22 XI1_I552_Bn XI1_I552_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I552_MP4 (XI1_I552_p1 XI1_I552_An I1_b0_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I552_MP2 (VDD I1_dd22_b3_0 XI1_I552_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I552_MP3 (XI1_I552_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I552_MP0 (VDD I1_dd22_b3_0 XI1_I552_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I553_MP1 (VDD VDD XI1_I553_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I553_MP5 (I1_b0_23 XI1_I553_Bn XI1_I553_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I553_MP4 (XI1_I553_p1 XI1_I553_An I1_b0_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I553_MP2 (VDD I1_dd23_b3_0 XI1_I553_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I553_MP3 (XI1_I553_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I553_MP0 (VDD I1_dd23_b3_0 XI1_I553_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I554_MP1 (VDD VDD XI1_I554_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I554_MP5 (I1_b0_24 XI1_I554_Bn XI1_I554_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I554_MP4 (XI1_I554_p1 XI1_I554_An I1_b0_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I554_MP2 (VDD I1_dd24_b3_0 XI1_I554_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I554_MP3 (XI1_I554_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I554_MP0 (VDD I1_dd24_b3_0 XI1_I554_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I555_MP1 (VDD VDD XI1_I555_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I555_MP5 (I1_b0_25 XI1_I555_Bn XI1_I555_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I555_MP4 (XI1_I555_p1 XI1_I555_An I1_b0_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I555_MP2 (VDD I1_dd25_b3_0 XI1_I555_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I555_MP3 (XI1_I555_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I555_MP0 (VDD I1_dd25_b3_0 XI1_I555_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I559_MP1 (VDD VDD XI1_I559_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I559_MP5 (I1_b0_29 XI1_I559_Bn XI1_I559_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I559_MP4 (XI1_I559_p1 XI1_I559_An I1_b0_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I559_MP2 (VDD I1_dd29_b3_0 XI1_I559_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I559_MP3 (XI1_I559_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I559_MP0 (VDD I1_dd29_b3_0 XI1_I559_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1521_MP1 (VDD I1_qu11_b3_4 XI1_I1521_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1521_MP5 (I1_b21_25 XI1_I1521_Bn XI1_I1521_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1521_MP4 (XI1_I1521_p1 XI1_I1521_An I1_b21_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1521_MP2 (VDD I1_dd25_b3_3 XI1_I1521_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1521_MP3 (XI1_I1521_p1 I1_qu11_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1521_MP0 (VDD I1_dd25_b3_3 XI1_I1521_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1520_MP1 (VDD I1_qu11_b3_4 XI1_I1520_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1520_MP5 (I1_b21_24 XI1_I1520_Bn XI1_I1520_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1520_MP4 (XI1_I1520_p1 XI1_I1520_An I1_b21_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1520_MP2 (VDD I1_dd24_b3_3 XI1_I1520_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1520_MP3 (XI1_I1520_p1 I1_qu11_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1520_MP0 (VDD I1_dd24_b3_3 XI1_I1520_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1519_MP1 (VDD I1_qu11_b3_3 XI1_I1519_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1519_MP5 (I1_b21_23 XI1_I1519_Bn XI1_I1519_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1519_MP4 (XI1_I1519_p1 XI1_I1519_An I1_b21_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1519_MP2 (VDD I1_dd23_b3_3 XI1_I1519_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1519_MP3 (XI1_I1519_p1 I1_qu11_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1519_MP0 (VDD I1_dd23_b3_3 XI1_I1519_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1518_MP1 (VDD I1_qu11_b3_3 XI1_I1518_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1518_MP5 (I1_b21_22 XI1_I1518_Bn XI1_I1518_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1518_MP4 (XI1_I1518_p1 XI1_I1518_An I1_b21_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1518_MP2 (VDD I1_dd22_b3_3 XI1_I1518_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1518_MP3 (XI1_I1518_p1 I1_qu11_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1518_MP0 (VDD I1_dd22_b3_3 XI1_I1518_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1517_MP1 (VDD I1_qu11_b3_3 XI1_I1517_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1517_MP5 (I1_b21_21 XI1_I1517_Bn XI1_I1517_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1517_MP4 (XI1_I1517_p1 XI1_I1517_An I1_b21_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1517_MP2 (VDD I1_dd21_b3_3 XI1_I1517_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1517_MP3 (XI1_I1517_p1 I1_qu11_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1517_MP0 (VDD I1_dd21_b3_3 XI1_I1517_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1497_MP1 (VDD I1_qu11_b3_0 XI1_I1497_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1497_MP5 (I1_b21_1 XI1_I1497_Bn XI1_I1497_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1497_MP4 (XI1_I1497_p1 XI1_I1497_An I1_b21_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1497_MP2 (VDD I1_dd1_b3_3 XI1_I1497_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1497_MP3 (XI1_I1497_p1 I1_qu11_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1497_MP0 (VDD I1_dd1_b3_3 XI1_I1497_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1496_MP1 (VDD I1_qu11_b3_0 XI1_I1496_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1496_MP5 (I1_b21_0 XI1_I1496_Bn XI1_I1496_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1496_MP4 (XI1_I1496_p1 XI1_I1496_An I1_b21_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1496_MP2 (VDD I1_B_0_b3_3 XI1_I1496_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1496_MP3 (XI1_I1496_p1 I1_qu11_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1496_MP0 (VDD I1_B_0_b3_3 XI1_I1496_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I218_MP1 (VDD I1_I562_G14_0n XI1_I562_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I218_MP5 (I1_p0_15 XI1_I562_I218_Bn XI1_I562_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I218_MP4 (XI1_I562_I218_p1 XI1_I562_I218_An I1_p0_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I218_MP2 (VDD I1_I562_pn15 XI1_I562_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I218_MP3 (XI1_I562_I218_p1 I1_I562_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I218_MP0 (VDD I1_I562_pn15 XI1_I562_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1480_MP1 (VDD I1_qu12_b3_5 XI1_I1480_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1480_MP5 (I1_b20_30 XI1_I1480_Bn XI1_I1480_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1480_MP4 (XI1_I1480_p1 XI1_I1480_An I1_b20_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1480_MP2 (VDD I1_dd30_b3_3 XI1_I1480_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1480_MP3 (XI1_I1480_p1 I1_qu12_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1480_MP0 (VDD I1_dd30_b3_3 XI1_I1480_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1481_MP1 (VDD I1_qu12_b3_5 XI1_I1481_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1481_MP5 (I1_b20_31 XI1_I1481_Bn XI1_I1481_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1481_MP4 (XI1_I1481_p1 XI1_I1481_An I1_b20_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1481_MP2 (VDD I1_dd31_b3_3 XI1_I1481_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1481_MP3 (XI1_I1481_p1 I1_qu12_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1481_MP0 (VDD I1_dd31_b3_3 XI1_I1481_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1526_MP1 (VDD I1_qu11_b3_5 XI1_I1526_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1526_MP5 (I1_b21_30 XI1_I1526_Bn XI1_I1526_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1526_MP4 (XI1_I1526_p1 XI1_I1526_An I1_b21_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1526_MP2 (VDD I1_dd30_b3_3 XI1_I1526_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1526_MP3 (XI1_I1526_p1 I1_qu11_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1526_MP0 (VDD I1_dd30_b3_3 XI1_I1526_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1525_MP1 (VDD I1_qu11_b3_4 XI1_I1525_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1525_MP5 (I1_b21_29 XI1_I1525_Bn XI1_I1525_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1525_MP4 (XI1_I1525_p1 XI1_I1525_An I1_b21_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1525_MP2 (VDD I1_dd29_b3_3 XI1_I1525_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1525_MP3 (XI1_I1525_p1 I1_qu11_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1525_MP0 (VDD I1_dd29_b3_3 XI1_I1525_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1524_MP1 (VDD I1_qu11_b3_4 XI1_I1524_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1524_MP5 (I1_b21_28 XI1_I1524_Bn XI1_I1524_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1524_MP4 (XI1_I1524_p1 XI1_I1524_An I1_b21_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1524_MP2 (VDD I1_dd28_b3_3 XI1_I1524_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1524_MP3 (XI1_I1524_p1 I1_qu11_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1524_MP0 (VDD I1_dd28_b3_3 XI1_I1524_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1523_MP1 (VDD I1_qu11_b3_4 XI1_I1523_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1523_MP5 (I1_b21_27 XI1_I1523_Bn XI1_I1523_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1523_MP4 (XI1_I1523_p1 XI1_I1523_An I1_b21_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1523_MP2 (VDD I1_dd27_b3_3 XI1_I1523_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1523_MP3 (XI1_I1523_p1 I1_qu11_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1523_MP0 (VDD I1_dd27_b3_3 XI1_I1523_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1522_MP1 (VDD I1_qu11_b3_4 XI1_I1522_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1522_MP5 (I1_b21_26 XI1_I1522_Bn XI1_I1522_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1522_MP4 (XI1_I1522_p1 XI1_I1522_An I1_b21_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1522_MP2 (VDD I1_dd26_b3_3 XI1_I1522_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1522_MP3 (XI1_I1522_p1 I1_qu11_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1522_MP0 (VDD I1_dd26_b3_3 XI1_I1522_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I214_MP1 (VDD I1_I1528_G10_0n XI1_I1528_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I214_MP5 (I1_p21_11 XI1_I1528_I214_Bn XI1_I1528_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I214_MP4 (XI1_I1528_I214_p1 XI1_I1528_I214_An I1_p21_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1528_I214_MP2 (VDD I1_I1528_pn11 XI1_I1528_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1528_I214_MP3 (XI1_I1528_I214_p1 I1_I1528_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I214_MP0 (VDD I1_I1528_pn11 XI1_I1528_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I212_MP1 (VDD I1_I1528_G8_0n XI1_I1528_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I212_MP5 (I1_p21_9 XI1_I1528_I212_Bn XI1_I1528_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I212_MP4 (XI1_I1528_I212_p1 XI1_I1528_I212_An I1_p21_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1528_I212_MP2 (VDD I1_I1528_pn9 XI1_I1528_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1528_I212_MP3 (XI1_I1528_I212_p1 I1_I1528_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I212_MP0 (VDD I1_I1528_pn9 XI1_I1528_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I206_MP1 (VDD I1_I1528_G2_0n XI1_I1528_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I206_MP5 (I1_p21_3 XI1_I1528_I206_Bn XI1_I1528_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I206_MP4 (XI1_I1528_I206_p1 XI1_I1528_I206_An I1_p21_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1528_I206_MP2 (VDD I1_I1528_pn3 XI1_I1528_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1528_I206_MP3 (XI1_I1528_I206_p1 I1_I1528_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I206_MP0 (VDD I1_I1528_pn3 XI1_I1528_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2067_MP1 (VDD I1_B_31_b3_5 XI1_I2067_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2067_MP5 (I1_sq XI1_I2067_Bn XI1_I2067_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2067_MP4 (XI1_I2067_p1 XI1_I2067_An I1_sq VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I2067_MP2 (VDD I1_A_31_b3_5 XI1_I2067_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I2067_MP3 (XI1_I2067_p1 I1_B_31_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2067_MP0 (VDD I1_A_31_b3_5 XI1_I2067_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1527_MP1 (VDD I1_qu11_b3_5 XI1_I1527_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1527_MP5 (I1_b21_31 XI1_I1527_Bn XI1_I1527_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1527_MP4 (XI1_I1527_p1 XI1_I1527_An I1_b21_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1527_MP2 (VDD I1_dd31_b3_3 XI1_I1527_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1527_MP3 (XI1_I1527_p1 I1_qu11_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1527_MP0 (VDD I1_dd31_b3_3 XI1_I1527_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I218_MP1 (VDD I1_I1528_G14_0n XI1_I1528_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I218_MP5 (I1_p21_15 XI1_I1528_I218_Bn XI1_I1528_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I218_MP4 (XI1_I1528_I218_p1 XI1_I1528_I218_An I1_p21_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1528_I218_MP2 (VDD I1_I1528_pn15 XI1_I1528_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1528_I218_MP3 (XI1_I1528_I218_p1 I1_I1528_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I218_MP0 (VDD I1_I1528_pn15 XI1_I1528_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I216_MP1 (VDD I1_I1528_G12_0n XI1_I1528_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I216_MP5 (I1_p21_13 XI1_I1528_I216_Bn XI1_I1528_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I216_MP4 (XI1_I1528_I216_p1 XI1_I1528_I216_An I1_p21_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1528_I216_MP2 (VDD I1_I1528_pn13 XI1_I1528_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1528_I216_MP3 (XI1_I1528_I216_p1 I1_I1528_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I216_MP0 (VDD I1_I1528_pn13 XI1_I1528_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I213_MP1 (VDD I1_I1528_G9_0n XI1_I1528_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I213_MP5 (I1_p21_10 XI1_I1528_I213_Bn XI1_I1528_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I213_MP4 (XI1_I1528_I213_p1 XI1_I1528_I213_An I1_p21_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1528_I213_MP2 (VDD I1_I1528_pn10 XI1_I1528_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1528_I213_MP3 (XI1_I1528_I213_p1 I1_I1528_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I213_MP0 (VDD I1_I1528_pn10 XI1_I1528_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I207_MP1 (VDD I1_I1528_G3_0n XI1_I1528_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I207_MP5 (I1_p21_4 XI1_I1528_I207_Bn XI1_I1528_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I207_MP4 (XI1_I1528_I207_p1 XI1_I1528_I207_An I1_p21_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1528_I207_MP2 (VDD I1_I1528_pn4 XI1_I1528_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1528_I207_MP3 (XI1_I1528_I207_p1 I1_I1528_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I207_MP0 (VDD I1_I1528_pn4 XI1_I1528_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I118_MP1 (VDD B_19 XI2_I2_I118_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I118_MP5 (I2_XOR_19 XI2_I2_I118_Bn XI2_I2_I118_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I118_MP4 (XI2_I2_I118_p1 XI2_I2_I118_An I2_XOR_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I118_MP2 (VDD A_19 XI2_I2_I118_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I118_MP3 (XI2_I2_I118_p1 B_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I118_MP0 (VDD A_19 XI2_I2_I118_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I112_MP1 (VDD B_18 XI2_I2_I112_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I112_MP5 (I2_XOR_18 XI2_I2_I112_Bn XI2_I2_I112_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I112_MP4 (XI2_I2_I112_p1 XI2_I2_I112_An I2_XOR_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I112_MP2 (VDD A_18 XI2_I2_I112_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I112_MP3 (XI2_I2_I112_p1 B_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I112_MP0 (VDD A_18 XI2_I2_I112_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I124_MP1 (VDD B_20 XI2_I2_I124_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I124_MP5 (I2_XOR_20 XI2_I2_I124_Bn XI2_I2_I124_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I124_MP4 (XI2_I2_I124_p1 XI2_I2_I124_An I2_XOR_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I124_MP2 (VDD A_20 XI2_I2_I124_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I124_MP3 (XI2_I2_I124_p1 B_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I124_MP0 (VDD A_20 XI2_I2_I124_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I142_MP1 (VDD B_23 XI2_I2_I142_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I142_MP5 (I2_XOR_23 XI2_I2_I142_Bn XI2_I2_I142_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I142_MP4 (XI2_I2_I142_p1 XI2_I2_I142_An I2_XOR_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I142_MP2 (VDD A_23 XI2_I2_I142_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I142_MP3 (XI2_I2_I142_p1 B_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I142_MP0 (VDD A_23 XI2_I2_I142_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I207_MP1 (VDD I1_I562_G3_0n XI1_I562_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I207_MP5 (I1_p0_4 XI1_I562_I207_Bn XI1_I562_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I207_MP4 (XI1_I562_I207_p1 XI1_I562_I207_An I1_p0_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I207_MP2 (VDD I1_I562_pn4 XI1_I562_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I207_MP3 (XI1_I562_I207_p1 I1_I562_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I207_MP0 (VDD I1_I562_pn4 XI1_I562_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1529_MP1 (VDD I1_qu11_b3_5 XI1_I1529_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1529_MP5 (I1_h21 XI1_I1529_Bn XI1_I1529_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1529_MP4 (XI1_I1529_p1 XI1_I1529_An I1_h21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1529_MP2 (VDD I1_p20_31 XI1_I1529_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1529_MP3 (XI1_I1529_p1 I1_qu11_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1529_MP0 (VDD I1_p20_31 XI1_I1529_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I26_MP1 (VDD I2_I1_SUB_b3_2 XI2_I1_I26_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I26_MP5 (I2_I1_bx16 XI2_I1_I26_Bn XI2_I1_I26_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I26_MP4 (XI2_I1_I26_p1 XI2_I1_I26_An I2_I1_bx16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I26_MP2 (VDD B_16 XI2_I1_I26_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I26_MP3 (XI2_I1_I26_p1 I2_I1_SUB_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I26_MP0 (VDD B_16 XI2_I1_I26_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I27_MP1 (VDD I2_I1_SUB_b3_3 XI2_I1_I27_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I27_MP5 (I2_I1_bx17 XI2_I1_I27_Bn XI2_I1_I27_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I27_MP4 (XI2_I1_I27_p1 XI2_I1_I27_An I2_I1_bx17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I27_MP2 (VDD B_17 XI2_I1_I27_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I27_MP3 (XI2_I1_I27_p1 I2_I1_SUB_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I27_MP0 (VDD B_17 XI2_I1_I27_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I28_MP1 (VDD I2_I1_SUB_b3_3 XI2_I1_I28_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I28_MP5 (I2_I1_bx18 XI2_I1_I28_Bn XI2_I1_I28_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I28_MP4 (XI2_I1_I28_p1 XI2_I1_I28_An I2_I1_bx18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I28_MP2 (VDD B_18 XI2_I1_I28_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I28_MP3 (XI2_I1_I28_p1 I2_I1_SUB_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I28_MP0 (VDD B_18 XI2_I1_I28_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I29_MP1 (VDD I2_I1_SUB_b3_3 XI2_I1_I29_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I29_MP5 (I2_I1_bx19 XI2_I1_I29_Bn XI2_I1_I29_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I29_MP4 (XI2_I1_I29_p1 XI2_I1_I29_An I2_I1_bx19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I29_MP2 (VDD B_19 XI2_I1_I29_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I29_MP3 (XI2_I1_I29_p1 I2_I1_SUB_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I29_MP0 (VDD B_19 XI2_I1_I29_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I30_MP1 (VDD I2_I1_SUB_b3_3 XI2_I1_I30_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I30_MP5 (I2_I1_bx20 XI2_I1_I30_Bn XI2_I1_I30_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I30_MP4 (XI2_I1_I30_p1 XI2_I1_I30_An I2_I1_bx20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I30_MP2 (VDD B_20 XI2_I1_I30_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I30_MP3 (XI2_I1_I30_p1 I2_I1_SUB_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I30_MP0 (VDD B_20 XI2_I1_I30_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I130_MP1 (VDD B_21 XI2_I2_I130_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I130_MP5 (I2_XOR_21 XI2_I2_I130_Bn XI2_I2_I130_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I130_MP4 (XI2_I2_I130_p1 XI2_I2_I130_An I2_XOR_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I130_MP2 (VDD A_21 XI2_I2_I130_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I130_MP3 (XI2_I2_I130_p1 B_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I130_MP0 (VDD A_21 XI2_I2_I130_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I100_MP1 (VDD B_16 XI2_I2_I100_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I100_MP5 (I2_XOR_16 XI2_I2_I100_Bn XI2_I2_I100_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I100_MP4 (XI2_I2_I100_p1 XI2_I2_I100_An I2_XOR_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I100_MP2 (VDD A_16 XI2_I2_I100_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I100_MP3 (XI2_I2_I100_p1 B_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I100_MP0 (VDD A_16 XI2_I2_I100_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I136_MP1 (VDD B_22 XI2_I2_I136_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I136_MP5 (I2_XOR_22 XI2_I2_I136_Bn XI2_I2_I136_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I136_MP4 (XI2_I2_I136_p1 XI2_I2_I136_An I2_XOR_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I136_MP2 (VDD A_22 XI2_I2_I136_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I136_MP3 (XI2_I2_I136_p1 B_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I136_MP0 (VDD A_22 XI2_I2_I136_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I213_MP1 (VDD I1_I562_G9_0n XI1_I562_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I213_MP5 (I1_p0_10 XI1_I562_I213_Bn XI1_I562_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I213_MP4 (XI1_I562_I213_p1 XI1_I562_I213_An I1_p0_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I213_MP2 (VDD I1_I562_pn10 XI1_I562_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I213_MP3 (XI1_I562_I213_p1 I1_I562_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I213_MP0 (VDD I1_I562_pn10 XI1_I562_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I215_MP1 (VDD I1_I562_G11_0n XI1_I562_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I215_MP5 (I1_p0_12 XI1_I562_I215_Bn XI1_I562_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I215_MP4 (XI1_I562_I215_p1 XI1_I562_I215_An I1_p0_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I215_MP2 (VDD I1_I562_pn12 XI1_I562_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I215_MP3 (XI1_I562_I215_p1 I1_I562_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I215_MP0 (VDD I1_I562_pn12 XI1_I562_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I217_MP1 (VDD I1_I562_G13_0n XI1_I562_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I217_MP5 (I1_p0_14 XI1_I562_I217_Bn XI1_I562_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I217_MP4 (XI1_I562_I217_p1 XI1_I562_I217_An I1_p0_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I217_MP2 (VDD I1_I562_pn14 XI1_I562_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I217_MP3 (XI1_I562_I217_p1 I1_I562_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I217_MP0 (VDD I1_I562_pn14 XI1_I562_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I215_MP1 (VDD I1_I1528_G11_0n XI1_I1528_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I215_MP5 (I1_p21_12 XI1_I1528_I215_Bn XI1_I1528_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I215_MP4 (XI1_I1528_I215_p1 XI1_I1528_I215_An I1_p21_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1528_I215_MP2 (VDD I1_I1528_pn12 XI1_I1528_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1528_I215_MP3 (XI1_I1528_I215_p1 I1_I1528_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I215_MP0 (VDD I1_I1528_pn12 XI1_I1528_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I215_MP1 (VDD I1_I1574_G11_0n XI1_I1574_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I215_MP5 (I1_p22_12 XI1_I1574_I215_Bn XI1_I1574_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I215_MP4 (XI1_I1574_I215_p1 XI1_I1574_I215_An I1_p22_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I215_MP2 (VDD I1_I1574_pn12 XI1_I1574_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I215_MP3 (XI1_I1574_I215_p1 I1_I1574_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I215_MP0 (VDD I1_I1574_pn12 XI1_I1574_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I23_MP1 (VDD I2_I1_SUB_b3_2 XI2_I1_I23_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I23_MP5 (I2_I1_bx13 XI2_I1_I23_Bn XI2_I1_I23_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I23_MP4 (XI2_I1_I23_p1 XI2_I1_I23_An I2_I1_bx13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I23_MP2 (VDD B_13 XI2_I1_I23_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I23_MP3 (XI2_I1_I23_p1 I2_I1_SUB_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I23_MP0 (VDD B_13 XI2_I1_I23_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I25_MP1 (VDD I2_I1_SUB_b3_2 XI2_I1_I25_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I25_MP5 (I2_I1_bx15 XI2_I1_I25_Bn XI2_I1_I25_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I25_MP4 (XI2_I1_I25_p1 XI2_I1_I25_An I2_I1_bx15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I25_MP2 (VDD B_15 XI2_I1_I25_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I25_MP3 (XI2_I1_I25_p1 I2_I1_SUB_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I25_MP0 (VDD B_15 XI2_I1_I25_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I24_MP1 (VDD I2_I1_SUB_b3_2 XI2_I1_I24_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I24_MP5 (I2_I1_bx14 XI2_I1_I24_Bn XI2_I1_I24_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I24_MP4 (XI2_I1_I24_p1 XI2_I1_I24_An I2_I1_bx14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I24_MP2 (VDD B_14 XI2_I1_I24_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I24_MP3 (XI2_I1_I24_p1 I2_I1_SUB_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I24_MP0 (VDD B_14 XI2_I1_I24_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I31_MP1 (VDD I2_I1_SUB_b3_3 XI2_I1_I31_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I31_MP5 (I2_I1_bx21 XI2_I1_I31_Bn XI2_I1_I31_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I31_MP4 (XI2_I1_I31_p1 XI2_I1_I31_An I2_I1_bx21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I31_MP2 (VDD B_21 XI2_I1_I31_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I31_MP3 (XI2_I1_I31_p1 I2_I1_SUB_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I31_MP0 (VDD B_21 XI2_I1_I31_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I32_MP1 (VDD I2_I1_SUB_b3_4 XI2_I1_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I32_MP5 (I2_I1_bx22 XI2_I1_I32_Bn XI2_I1_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I32_MP4 (XI2_I1_I32_p1 XI2_I1_I32_An I2_I1_bx22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I32_MP2 (VDD B_22 XI2_I1_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I32_MP3 (XI2_I1_I32_p1 I2_I1_SUB_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I32_MP0 (VDD B_22 XI2_I1_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I33_MP1 (VDD I2_I1_SUB_b3_4 XI2_I1_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I33_MP5 (I2_I1_bx23 XI2_I1_I33_Bn XI2_I1_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I33_MP4 (XI2_I1_I33_p1 XI2_I1_I33_An I2_I1_bx23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I33_MP2 (VDD B_23 XI2_I1_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I33_MP3 (XI2_I1_I33_p1 I2_I1_SUB_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I33_MP0 (VDD B_23 XI2_I1_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I106_MP1 (VDD B_17 XI2_I2_I106_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I106_MP5 (I2_XOR_17 XI2_I2_I106_Bn XI2_I2_I106_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I106_MP4 (XI2_I2_I106_p1 XI2_I2_I106_An I2_XOR_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I106_MP2 (VDD A_17 XI2_I2_I106_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I106_MP3 (XI2_I2_I106_p1 B_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I106_MP0 (VDD A_17 XI2_I2_I106_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I219_MP1 (VDD I1_I562_G15_0n XI1_I562_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I219_MP5 (I1_p0_16 XI1_I562_I219_Bn XI1_I562_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I219_MP4 (XI1_I562_I219_p1 XI1_I562_I219_An I1_p0_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I219_MP2 (VDD I1_I562_pn16 XI1_I562_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I219_MP3 (XI1_I562_I219_p1 I1_I562_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I219_MP0 (VDD I1_I562_pn16 XI1_I562_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1530_MP1 (VDD I1_c21_o XI1_I1530_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1530_MP5 (I1_p21_32 XI1_I1530_Bn XI1_I1530_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1530_MP4 (XI1_I1530_p1 XI1_I1530_An I1_p21_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1530_MP2 (VDD I1_h21 XI1_I1530_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1530_MP3 (XI1_I1530_p1 I1_c21_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1530_MP0 (VDD I1_h21 XI1_I1530_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I219_MP1 (VDD I1_I1528_G15_0n XI1_I1528_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I219_MP5 (I1_p21_16 XI1_I1528_I219_Bn XI1_I1528_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I219_MP4 (XI1_I1528_I219_p1 XI1_I1528_I219_An I1_p21_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1528_I219_MP2 (VDD I1_I1528_pn16 XI1_I1528_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1528_I219_MP3 (XI1_I1528_I219_p1 I1_I1528_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I219_MP0 (VDD I1_I1528_pn16 XI1_I1528_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1575_MP1 (VDD I1_qu10_b3_5 XI1_I1575_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1575_MP5 (I1_h22 XI1_I1575_Bn XI1_I1575_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1575_MP4 (XI1_I1575_p1 XI1_I1575_An I1_h22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1575_MP2 (VDD I1_p21_31 XI1_I1575_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1575_MP3 (XI1_I1575_p1 I1_qu10_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1575_MP0 (VDD I1_p21_31 XI1_I1575_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I217_MP1 (VDD I1_I1528_G13_0n XI1_I1528_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I217_MP5 (I1_p21_14 XI1_I1528_I217_Bn XI1_I1528_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I217_MP4 (XI1_I1528_I217_p1 XI1_I1528_I217_An I1_p21_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1528_I217_MP2 (VDD I1_I1528_pn14 XI1_I1528_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1528_I217_MP3 (XI1_I1528_I217_p1 I1_I1528_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I217_MP0 (VDD I1_I1528_pn14 XI1_I1528_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1576_MP1 (VDD I1_c22_o XI1_I1576_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1576_MP5 (I1_p22_32 XI1_I1576_Bn XI1_I1576_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1576_MP4 (XI1_I1576_p1 XI1_I1576_An I1_p22_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1576_MP2 (VDD I1_h22 XI1_I1576_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1576_MP3 (XI1_I1576_p1 I1_c22_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1576_MP0 (VDD I1_h22 XI1_I1576_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I82_MP1 (VDD B_13 XI2_I2_I82_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I82_MP5 (I2_XOR_13 XI2_I2_I82_Bn XI2_I2_I82_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I82_MP4 (XI2_I2_I82_p1 XI2_I2_I82_An I2_XOR_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I82_MP2 (VDD A_13 XI2_I2_I82_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I82_MP3 (XI2_I2_I82_p1 B_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I82_MP0 (VDD A_13 XI2_I2_I82_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I94_MP1 (VDD B_15 XI2_I2_I94_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I94_MP5 (I2_XOR_15 XI2_I2_I94_Bn XI2_I2_I94_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I94_MP4 (XI2_I2_I94_p1 XI2_I2_I94_An I2_XOR_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I94_MP2 (VDD A_15 XI2_I2_I94_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I94_MP3 (XI2_I2_I94_p1 B_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I94_MP0 (VDD A_15 XI2_I2_I94_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I21_MP1 (VDD I2_I1_SUB_b3_2 XI2_I1_I21_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I21_MP5 (I2_I1_bx11 XI2_I1_I21_Bn XI2_I1_I21_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I21_MP4 (XI2_I1_I21_p1 XI2_I1_I21_An I2_I1_bx11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I21_MP2 (VDD B_11 XI2_I1_I21_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I21_MP3 (XI2_I1_I21_p1 I2_I1_SUB_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I21_MP0 (VDD B_11 XI2_I1_I21_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I34_MP1 (VDD I2_I1_SUB_b3_4 XI2_I1_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I34_MP5 (I2_I1_bx24 XI2_I1_I34_Bn XI2_I1_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I34_MP4 (XI2_I1_I34_p1 XI2_I1_I34_An I2_I1_bx24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I34_MP2 (VDD B_24 XI2_I1_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I34_MP3 (XI2_I1_I34_p1 I2_I1_SUB_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I34_MP0 (VDD B_24 XI2_I1_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I35_MP1 (VDD I2_I1_SUB_b3_4 XI2_I1_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I35_MP5 (I2_I1_bx25 XI2_I1_I35_Bn XI2_I1_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I35_MP4 (XI2_I1_I35_p1 XI2_I1_I35_An I2_I1_bx25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I35_MP2 (VDD B_25 XI2_I1_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I35_MP3 (XI2_I1_I35_p1 I2_I1_SUB_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I35_MP0 (VDD B_25 XI2_I1_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I36_MP1 (VDD I2_I1_SUB_b3_4 XI2_I1_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I36_MP5 (I2_I1_bx26 XI2_I1_I36_Bn XI2_I1_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I36_MP4 (XI2_I1_I36_p1 XI2_I1_I36_An I2_I1_bx26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I36_MP2 (VDD B_26 XI2_I1_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I36_MP3 (XI2_I1_I36_p1 I2_I1_SUB_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I36_MP0 (VDD B_26 XI2_I1_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I37_MP1 (VDD I2_I1_SUB_b3_4 XI2_I1_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I37_MP5 (I2_I1_bx27 XI2_I1_I37_Bn XI2_I1_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I37_MP4 (XI2_I1_I37_p1 XI2_I1_I37_An I2_I1_bx27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I37_MP2 (VDD B_27 XI2_I1_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I37_MP3 (XI2_I1_I37_p1 I2_I1_SUB_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I37_MP0 (VDD B_27 XI2_I1_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I154_MP1 (VDD B_25 XI2_I2_I154_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I154_MP5 (I2_XOR_25 XI2_I2_I154_Bn XI2_I2_I154_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I154_MP4 (XI2_I2_I154_p1 XI2_I2_I154_An I2_XOR_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I154_MP2 (VDD A_25 XI2_I2_I154_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I154_MP3 (XI2_I2_I154_p1 B_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I154_MP0 (VDD A_25 XI2_I2_I154_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I166_MP1 (VDD B_27 XI2_I2_I166_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I166_MP5 (I2_XOR_27 XI2_I2_I166_Bn XI2_I2_I166_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I166_MP4 (XI2_I2_I166_p1 XI2_I2_I166_An I2_XOR_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I166_MP2 (VDD A_27 XI2_I2_I166_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I166_MP3 (XI2_I2_I166_p1 B_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I166_MP0 (VDD A_27 XI2_I2_I166_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I178_MP1 (VDD B_29 XI2_I2_I178_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I178_MP5 (I2_XOR_29 XI2_I2_I178_Bn XI2_I2_I178_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I178_MP4 (XI2_I2_I178_p1 XI2_I2_I178_An I2_XOR_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I178_MP2 (VDD A_29 XI2_I2_I178_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I178_MP3 (XI2_I2_I178_p1 B_29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I178_MP0 (VDD A_29 XI2_I2_I178_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I207_MP1 (VDD I1_I1712_G3_0n XI1_I1712_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I207_MP5 (I1_p25_4 XI1_I1712_I207_Bn XI1_I1712_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I207_MP4 (XI1_I1712_I207_p1 XI1_I1712_I207_An I1_p25_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I207_MP2 (VDD I1_I1712_pn4 XI1_I1712_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I207_MP3 (XI1_I1712_I207_p1 I1_I1712_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I207_MP0 (VDD I1_I1712_pn4 XI1_I1712_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I217_MP1 (VDD I1_I1574_G13_0n XI1_I1574_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I217_MP5 (I1_p22_14 XI1_I1574_I217_Bn XI1_I1574_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I217_MP4 (XI1_I1574_I217_p1 XI1_I1574_I217_An I1_p22_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I217_MP2 (VDD I1_I1574_pn14 XI1_I1574_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I217_MP3 (XI1_I1574_I217_p1 I1_I1574_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I217_MP0 (VDD I1_I1574_pn14 XI1_I1574_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I213_MP1 (VDD I1_I1574_G9_0n XI1_I1574_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I213_MP5 (I1_p22_10 XI1_I1574_I213_Bn XI1_I1574_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I213_MP4 (XI1_I1574_I213_p1 XI1_I1574_I213_An I1_p22_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I213_MP2 (VDD I1_I1574_pn10 XI1_I1574_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I213_MP3 (XI1_I1574_I213_p1 I1_I1574_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I213_MP0 (VDD I1_I1574_pn10 XI1_I1574_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I207_MP1 (VDD I1_I1574_G3_0n XI1_I1574_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I207_MP5 (I1_p22_4 XI1_I1574_I207_Bn XI1_I1574_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I207_MP4 (XI1_I1574_I207_p1 XI1_I1574_I207_An I1_p22_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I207_MP2 (VDD I1_I1574_pn4 XI1_I1574_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I207_MP3 (XI1_I1574_I207_p1 I1_I1574_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I207_MP0 (VDD I1_I1574_pn4 XI1_I1574_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I88_MP1 (VDD B_14 XI2_I2_I88_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I88_MP5 (I2_XOR_14 XI2_I2_I88_Bn XI2_I2_I88_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I88_MP4 (XI2_I2_I88_p1 XI2_I2_I88_An I2_XOR_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I88_MP2 (VDD A_14 XI2_I2_I88_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I88_MP3 (XI2_I2_I88_p1 B_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I88_MP0 (VDD A_14 XI2_I2_I88_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I22_MP1 (VDD I2_I1_SUB_b3_2 XI2_I1_I22_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I22_MP5 (I2_I1_bx12 XI2_I1_I22_Bn XI2_I1_I22_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I22_MP4 (XI2_I1_I22_p1 XI2_I1_I22_An I2_I1_bx12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I22_MP2 (VDD B_12 XI2_I1_I22_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I22_MP3 (XI2_I1_I22_p1 I2_I1_SUB_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I22_MP0 (VDD B_12 XI2_I1_I22_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I216_MP1 (VDD I2_I1_I42_G12_0n XI2_I1_I42_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I216_MP5 (I2_S_13 XI2_I1_I42_I216_Bn XI2_I1_I42_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I216_MP4 (XI2_I1_I42_I216_p1 XI2_I1_I42_I216_An I2_S_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I216_MP2 (VDD I2_I1_I42_pn13 XI2_I1_I42_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I216_MP3 (XI2_I1_I42_I216_p1 I2_I1_I42_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I216_MP0 (VDD I2_I1_I42_pn13 XI2_I1_I42_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I219_MP1 (VDD I2_I1_I42_G15_0n XI2_I1_I42_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I219_MP5 (I2_S_16 XI2_I1_I42_I219_Bn XI2_I1_I42_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I219_MP4 (XI2_I1_I42_I219_p1 XI2_I1_I42_I219_An I2_S_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I219_MP2 (VDD I2_I1_I42_pn16 XI2_I1_I42_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I219_MP3 (XI2_I1_I42_I219_p1 I2_I1_I42_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I219_MP0 (VDD I2_I1_I42_pn16 XI2_I1_I42_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I148_MP1 (VDD B_24 XI2_I2_I148_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I148_MP5 (I2_XOR_24 XI2_I2_I148_Bn XI2_I2_I148_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I148_MP4 (XI2_I2_I148_p1 XI2_I2_I148_An I2_XOR_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I148_MP2 (VDD A_24 XI2_I2_I148_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I148_MP3 (XI2_I2_I148_p1 B_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I148_MP0 (VDD A_24 XI2_I2_I148_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I160_MP1 (VDD B_26 XI2_I2_I160_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I160_MP5 (I2_XOR_26 XI2_I2_I160_Bn XI2_I2_I160_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I160_MP4 (XI2_I2_I160_p1 XI2_I2_I160_An I2_XOR_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I160_MP2 (VDD A_26 XI2_I2_I160_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I160_MP3 (XI2_I2_I160_p1 B_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I160_MP0 (VDD A_26 XI2_I2_I160_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I172_MP1 (VDD B_28 XI2_I2_I172_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I172_MP5 (I2_XOR_28 XI2_I2_I172_Bn XI2_I2_I172_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I172_MP4 (XI2_I2_I172_p1 XI2_I2_I172_An I2_XOR_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I172_MP2 (VDD A_28 XI2_I2_I172_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I172_MP3 (XI2_I2_I172_p1 B_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I172_MP0 (VDD A_28 XI2_I2_I172_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I213_MP1 (VDD I1_I1712_G9_0n XI1_I1712_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I213_MP5 (I1_p25_10 XI1_I1712_I213_Bn XI1_I1712_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I213_MP4 (XI1_I1712_I213_p1 XI1_I1712_I213_An I1_p25_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I213_MP2 (VDD I1_I1712_pn10 XI1_I1712_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I213_MP3 (XI1_I1712_I213_p1 I1_I1712_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I213_MP0 (VDD I1_I1712_pn10 XI1_I1712_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1684_MP1 (VDD I1_qu7_b3_0 XI1_I1684_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1684_MP5 (I1_b25_4 XI1_I1684_Bn XI1_I1684_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1684_MP4 (XI1_I1684_p1 XI1_I1684_An I1_b25_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1684_MP2 (VDD I1_dd4_b3_4 XI1_I1684_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1684_MP3 (XI1_I1684_p1 I1_qu7_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1684_MP0 (VDD I1_dd4_b3_4 XI1_I1684_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1683_MP1 (VDD I1_qu7_b3_0 XI1_I1683_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1683_MP5 (I1_b25_3 XI1_I1683_Bn XI1_I1683_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1683_MP4 (XI1_I1683_p1 XI1_I1683_An I1_b25_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1683_MP2 (VDD I1_dd3_b3_4 XI1_I1683_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1683_MP3 (XI1_I1683_p1 I1_qu7_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1683_MP0 (VDD I1_dd3_b3_4 XI1_I1683_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1573_MP1 (VDD I1_qu10_b3_5 XI1_I1573_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1573_MP5 (I1_b22_31 XI1_I1573_Bn XI1_I1573_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1573_MP4 (XI1_I1573_p1 XI1_I1573_An I1_b22_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1573_MP2 (VDD I1_dd31_b3_4 XI1_I1573_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1573_MP3 (XI1_I1573_p1 I1_qu10_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1573_MP0 (VDD I1_dd31_b3_4 XI1_I1573_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I219_MP1 (VDD I1_I1574_G15_0n XI1_I1574_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I219_MP5 (I1_p22_16 XI1_I1574_I219_Bn XI1_I1574_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I219_MP4 (XI1_I1574_I219_p1 XI1_I1574_I219_An I1_p22_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I219_MP2 (VDD I1_I1574_pn16 XI1_I1574_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I219_MP3 (XI1_I1574_I219_p1 I1_I1574_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I219_MP0 (VDD I1_I1574_pn16 XI1_I1574_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I216_MP1 (VDD I1_I1574_G12_0n XI1_I1574_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I216_MP5 (I1_p22_13 XI1_I1574_I216_Bn XI1_I1574_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I216_MP4 (XI1_I1574_I216_p1 XI1_I1574_I216_An I1_p22_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I216_MP2 (VDD I1_I1574_pn13 XI1_I1574_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I216_MP3 (XI1_I1574_I216_p1 I1_I1574_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I216_MP0 (VDD I1_I1574_pn13 XI1_I1574_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1547_MP1 (VDD I1_qu10_b3_0 XI1_I1547_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1547_MP5 (I1_b22_5 XI1_I1547_Bn XI1_I1547_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1547_MP4 (XI1_I1547_p1 XI1_I1547_An I1_b22_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1547_MP2 (VDD I1_dd5_b3_4 XI1_I1547_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1547_MP3 (XI1_I1547_p1 I1_qu10_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1547_MP0 (VDD I1_dd5_b3_4 XI1_I1547_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1546_MP1 (VDD I1_qu10_b3_0 XI1_I1546_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1546_MP5 (I1_b22_4 XI1_I1546_Bn XI1_I1546_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1546_MP4 (XI1_I1546_p1 XI1_I1546_An I1_b22_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1546_MP2 (VDD I1_dd4_b3_4 XI1_I1546_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1546_MP3 (XI1_I1546_p1 I1_qu10_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1546_MP0 (VDD I1_dd4_b3_4 XI1_I1546_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1545_MP1 (VDD I1_qu10_b3_0 XI1_I1545_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1545_MP5 (I1_b22_3 XI1_I1545_Bn XI1_I1545_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1545_MP4 (XI1_I1545_p1 XI1_I1545_An I1_b22_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1545_MP2 (VDD I1_dd3_b3_4 XI1_I1545_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1545_MP3 (XI1_I1545_p1 I1_qu10_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1545_MP0 (VDD I1_dd3_b3_4 XI1_I1545_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I218_MP1 (VDD I2_I1_I42_G14_0n XI2_I1_I42_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I218_MP5 (I2_S_15 XI2_I1_I42_I218_Bn XI2_I1_I42_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I218_MP4 (XI2_I1_I42_I218_p1 XI2_I1_I42_I218_An I2_S_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I218_MP2 (VDD I2_I1_I42_pn15 XI2_I1_I42_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I218_MP3 (XI2_I1_I42_I218_p1 I2_I1_I42_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I218_MP0 (VDD I2_I1_I42_pn15 XI2_I1_I42_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I38_MP1 (VDD I2_I1_SUB_b3_5 XI2_I1_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I38_MP5 (I2_I1_bx28 XI2_I1_I38_Bn XI2_I1_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I38_MP4 (XI2_I1_I38_p1 XI2_I1_I38_An I2_I1_bx28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I38_MP2 (VDD B_28 XI2_I1_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I38_MP3 (XI2_I1_I38_p1 I2_I1_SUB_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I38_MP0 (VDD B_28 XI2_I1_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I39_MP1 (VDD I2_I1_SUB_b3_5 XI2_I1_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I39_MP5 (I2_I1_bx29 XI2_I1_I39_Bn XI2_I1_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I39_MP4 (XI2_I1_I39_p1 XI2_I1_I39_An I2_I1_bx29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I39_MP2 (VDD B_29 XI2_I1_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I39_MP3 (XI2_I1_I39_p1 I2_I1_SUB_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I39_MP0 (VDD B_29 XI2_I1_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I184_MP1 (VDD B_30 XI2_I2_I184_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I184_MP5 (I2_XOR_30 XI2_I2_I184_Bn XI2_I2_I184_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I184_MP4 (XI2_I2_I184_p1 XI2_I2_I184_An I2_XOR_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I184_MP2 (VDD A_30 XI2_I2_I184_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I184_MP3 (XI2_I2_I184_p1 B_30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I184_MP0 (VDD A_30 XI2_I2_I184_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I564_MP1 (VDD I1_c0_o XI1_I564_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I564_MP5 (I1_p0_32 XI1_I564_Bn XI1_I564_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I564_MP4 (XI1_I564_p1 XI1_I564_An I1_p0_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I564_MP2 (VDD I1_h0 XI1_I564_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I564_MP3 (XI1_I564_p1 I1_c0_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I564_MP0 (VDD I1_h0 XI1_I564_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I563_MP1 (VDD VDD XI1_I563_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I563_MP5 (I1_h0 XI1_I563_Bn XI1_I563_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I563_MP4 (XI1_I563_p1 XI1_I563_An I1_h0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I563_MP2 (VDD VSS XI1_I563_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I563_MP3 (XI1_I563_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I563_MP0 (VDD VSS XI1_I563_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1685_MP1 (VDD I1_qu7_b3_0 XI1_I1685_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1685_MP5 (I1_b25_5 XI1_I1685_Bn XI1_I1685_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1685_MP4 (XI1_I1685_p1 XI1_I1685_An I1_b25_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1685_MP2 (VDD I1_dd5_b3_4 XI1_I1685_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1685_MP3 (XI1_I1685_p1 I1_qu7_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1685_MP0 (VDD I1_dd5_b3_4 XI1_I1685_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1572_MP1 (VDD I1_qu10_b3_5 XI1_I1572_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1572_MP5 (I1_b22_30 XI1_I1572_Bn XI1_I1572_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1572_MP4 (XI1_I1572_p1 XI1_I1572_An I1_b22_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1572_MP2 (VDD I1_dd30_b3_4 XI1_I1572_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1572_MP3 (XI1_I1572_p1 I1_qu10_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1572_MP0 (VDD I1_dd30_b3_4 XI1_I1572_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1571_MP1 (VDD I1_qu10_b3_4 XI1_I1571_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1571_MP5 (I1_b22_29 XI1_I1571_Bn XI1_I1571_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1571_MP4 (XI1_I1571_p1 XI1_I1571_An I1_b22_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1571_MP2 (VDD I1_dd29_b3_4 XI1_I1571_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1571_MP3 (XI1_I1571_p1 I1_qu10_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1571_MP0 (VDD I1_dd29_b3_4 XI1_I1571_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1544_MP1 (VDD I1_qu10_b3_0 XI1_I1544_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1544_MP5 (I1_b22_2 XI1_I1544_Bn XI1_I1544_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1544_MP4 (XI1_I1544_p1 XI1_I1544_An I1_b22_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1544_MP2 (VDD I1_dd2_b3_4 XI1_I1544_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1544_MP3 (XI1_I1544_p1 I1_qu10_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1544_MP0 (VDD I1_dd2_b3_4 XI1_I1544_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I76_MP1 (VDD B_12 XI2_I2_I76_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I76_MP5 (I2_XOR_12 XI2_I2_I76_Bn XI2_I2_I76_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I76_MP4 (XI2_I2_I76_p1 XI2_I2_I76_An I2_XOR_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I76_MP2 (VDD A_12 XI2_I2_I76_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I76_MP3 (XI2_I2_I76_p1 B_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I76_MP0 (VDD A_12 XI2_I2_I76_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I70_MP1 (VDD B_11 XI2_I2_I70_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I70_MP5 (I2_XOR_11 XI2_I2_I70_Bn XI2_I2_I70_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I70_MP4 (XI2_I2_I70_p1 XI2_I2_I70_An I2_XOR_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I70_MP2 (VDD A_11 XI2_I2_I70_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I70_MP3 (XI2_I2_I70_p1 B_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I70_MP0 (VDD A_11 XI2_I2_I70_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I215_MP1 (VDD I2_I1_I42_G11_0n XI2_I1_I42_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I215_MP5 (I2_S_12 XI2_I1_I42_I215_Bn XI2_I1_I42_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I215_MP4 (XI2_I1_I42_I215_p1 XI2_I1_I42_I215_An I2_S_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I215_MP2 (VDD I2_I1_I42_pn12 XI2_I1_I42_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I215_MP3 (XI2_I1_I42_I215_p1 I2_I1_I42_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I215_MP0 (VDD I2_I1_I42_pn12 XI2_I1_I42_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I217_MP1 (VDD I2_I1_I42_G13_0n XI2_I1_I42_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I217_MP5 (I2_S_14 XI2_I1_I42_I217_Bn XI2_I1_I42_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I217_MP4 (XI2_I1_I42_I217_p1 XI2_I1_I42_I217_An I2_S_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I217_MP2 (VDD I2_I1_I42_pn14 XI2_I1_I42_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I217_MP3 (XI2_I1_I42_I217_p1 I2_I1_I42_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I217_MP0 (VDD I2_I1_I42_pn14 XI2_I1_I42_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I41_MP1 (VDD I2_I1_SUB_b3_5 XI2_I1_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I41_MP5 (I2_I1_bx31 XI2_I1_I41_Bn XI2_I1_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I41_MP4 (XI2_I1_I41_p1 XI2_I1_I41_An I2_I1_bx31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I41_MP2 (VDD B_31 XI2_I1_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I41_MP3 (XI2_I1_I41_p1 I2_I1_SUB_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I41_MP0 (VDD B_31 XI2_I1_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I40_MP1 (VDD I2_I1_SUB_b3_5 XI2_I1_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I40_MP5 (I2_I1_bx30 XI2_I1_I40_Bn XI2_I1_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I40_MP4 (XI2_I1_I40_p1 XI2_I1_I40_An I2_I1_bx30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I40_MP2 (VDD B_30 XI2_I1_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I40_MP3 (XI2_I1_I40_p1 I2_I1_SUB_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I40_MP0 (VDD B_30 XI2_I1_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I4_I66_MP1 (VDD I2_CO XI2_I4_I66_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I4_I66_MP5 (I2_I4_ovf XI2_I4_I66_Bn XI2_I4_I66_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I66_MP4 (XI2_I4_I66_p1 XI2_I4_I66_An I2_I4_ovf VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I4_I66_MP2 (VDD I2_CM XI2_I4_I66_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I4_I66_MP3 (XI2_I4_I66_p1 I2_CO VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I66_MP0 (VDD I2_CM XI2_I4_I66_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I190_MP1 (VDD B_31 XI2_I2_I190_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I190_MP5 (I2_XOR_31 XI2_I2_I190_Bn XI2_I2_I190_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I190_MP4 (XI2_I2_I190_p1 XI2_I2_I190_An I2_XOR_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I190_MP2 (VDD A_31 XI2_I2_I190_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I190_MP3 (XI2_I2_I190_p1 B_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I190_MP0 (VDD A_31 XI2_I2_I190_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1709_MP1 (VDD I1_qu7_b3_4 XI1_I1709_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1709_MP5 (I1_b25_29 XI1_I1709_Bn XI1_I1709_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1709_MP4 (XI1_I1709_p1 XI1_I1709_An I1_b25_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1709_MP2 (VDD I1_dd29_b3_4 XI1_I1709_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1709_MP3 (XI1_I1709_p1 I1_qu7_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1709_MP0 (VDD I1_dd29_b3_4 XI1_I1709_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1707_MP1 (VDD I1_qu7_b3_4 XI1_I1707_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1707_MP5 (I1_b25_27 XI1_I1707_Bn XI1_I1707_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1707_MP4 (XI1_I1707_p1 XI1_I1707_An I1_b25_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1707_MP2 (VDD I1_dd27_b3_4 XI1_I1707_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1707_MP3 (XI1_I1707_p1 I1_qu7_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1707_MP0 (VDD I1_dd27_b3_4 XI1_I1707_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I206_MP1 (VDD I1_I1712_G2_0n XI1_I1712_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I206_MP5 (I1_p25_3 XI1_I1712_I206_Bn XI1_I1712_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I206_MP4 (XI1_I1712_I206_p1 XI1_I1712_I206_An I1_p25_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I206_MP2 (VDD I1_I1712_pn3 XI1_I1712_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I206_MP3 (XI1_I1712_I206_p1 I1_I1712_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I206_MP0 (VDD I1_I1712_pn3 XI1_I1712_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1682_MP1 (VDD I1_qu7_b3_0 XI1_I1682_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1682_MP5 (I1_b25_2 XI1_I1682_Bn XI1_I1682_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1682_MP4 (XI1_I1682_p1 XI1_I1682_An I1_b25_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1682_MP2 (VDD I1_dd2_b3_4 XI1_I1682_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1682_MP3 (XI1_I1682_p1 I1_qu7_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1682_MP0 (VDD I1_dd2_b3_4 XI1_I1682_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1681_MP1 (VDD I1_qu7_b3_0 XI1_I1681_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1681_MP5 (I1_b25_1 XI1_I1681_Bn XI1_I1681_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1681_MP4 (XI1_I1681_p1 XI1_I1681_An I1_b25_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1681_MP2 (VDD I1_dd1_b3_4 XI1_I1681_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1681_MP3 (XI1_I1681_p1 I1_qu7_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1681_MP0 (VDD I1_dd1_b3_4 XI1_I1681_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1569_MP1 (VDD I1_qu10_b3_4 XI1_I1569_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1569_MP5 (I1_b22_27 XI1_I1569_Bn XI1_I1569_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1569_MP4 (XI1_I1569_p1 XI1_I1569_An I1_b22_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1569_MP2 (VDD I1_dd27_b3_4 XI1_I1569_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1569_MP3 (XI1_I1569_p1 I1_qu10_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1569_MP0 (VDD I1_dd27_b3_4 XI1_I1569_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1570_MP1 (VDD I1_qu10_b3_4 XI1_I1570_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1570_MP5 (I1_b22_28 XI1_I1570_Bn XI1_I1570_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1570_MP4 (XI1_I1570_p1 XI1_I1570_An I1_b22_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1570_MP2 (VDD I1_dd28_b3_4 XI1_I1570_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1570_MP3 (XI1_I1570_p1 I1_qu10_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1570_MP0 (VDD I1_dd28_b3_4 XI1_I1570_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1568_MP1 (VDD I1_qu10_b3_4 XI1_I1568_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1568_MP5 (I1_b22_26 XI1_I1568_Bn XI1_I1568_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1568_MP4 (XI1_I1568_p1 XI1_I1568_An I1_b22_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1568_MP2 (VDD I1_dd26_b3_4 XI1_I1568_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1568_MP3 (XI1_I1568_p1 I1_qu10_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1568_MP0 (VDD I1_dd26_b3_4 XI1_I1568_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I212_MP1 (VDD I1_I1574_G8_0n XI1_I1574_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I212_MP5 (I1_p22_9 XI1_I1574_I212_Bn XI1_I1574_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I212_MP4 (XI1_I1574_I212_p1 XI1_I1574_I212_An I1_p22_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I212_MP2 (VDD I1_I1574_pn9 XI1_I1574_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I212_MP3 (XI1_I1574_I212_p1 I1_I1574_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I212_MP0 (VDD I1_I1574_pn9 XI1_I1574_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1543_MP1 (VDD I1_qu10_b3_0 XI1_I1543_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1543_MP5 (I1_b22_1 XI1_I1543_Bn XI1_I1543_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1543_MP4 (XI1_I1543_p1 XI1_I1543_An I1_b22_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1543_MP2 (VDD I1_dd1_b3_4 XI1_I1543_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1543_MP3 (XI1_I1543_p1 I1_qu10_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1543_MP0 (VDD I1_dd1_b3_4 XI1_I1543_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I214_MP1 (VDD I2_I1_I42_G10_0n XI2_I1_I42_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I214_MP5 (I2_S_11 XI2_I1_I42_I214_Bn XI2_I1_I42_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I214_MP4 (XI2_I1_I42_I214_p1 XI2_I1_I42_I214_An I2_S_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I214_MP2 (VDD I2_I1_I42_pn11 XI2_I1_I42_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I214_MP3 (XI2_I1_I42_I214_p1 I2_I1_I42_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I214_MP0 (VDD I2_I1_I42_pn11 XI2_I1_I42_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1708_MP1 (VDD I1_qu7_b3_4 XI1_I1708_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1708_MP5 (I1_b25_28 XI1_I1708_Bn XI1_I1708_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1708_MP4 (XI1_I1708_p1 XI1_I1708_An I1_b25_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1708_MP2 (VDD I1_dd28_b3_4 XI1_I1708_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1708_MP3 (XI1_I1708_p1 I1_qu7_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1708_MP0 (VDD I1_dd28_b3_4 XI1_I1708_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1704_MP1 (VDD I1_qu7_b3_4 XI1_I1704_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1704_MP5 (I1_b25_24 XI1_I1704_Bn XI1_I1704_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1704_MP4 (XI1_I1704_p1 XI1_I1704_An I1_b25_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1704_MP2 (VDD I1_dd24_b3_4 XI1_I1704_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1704_MP3 (XI1_I1704_p1 I1_qu7_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1704_MP0 (VDD I1_dd24_b3_4 XI1_I1704_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I212_MP1 (VDD I1_I1712_G8_0n XI1_I1712_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I212_MP5 (I1_p25_9 XI1_I1712_I212_Bn XI1_I1712_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I212_MP4 (XI1_I1712_I212_p1 XI1_I1712_I212_An I1_p25_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I212_MP2 (VDD I1_I1712_pn9 XI1_I1712_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I212_MP3 (XI1_I1712_I212_p1 I1_I1712_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I212_MP0 (VDD I1_I1712_pn9 XI1_I1712_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1680_MP1 (VDD I1_qu7_b3_0 XI1_I1680_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1680_MP5 (I1_b25_0 XI1_I1680_Bn XI1_I1680_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1680_MP4 (XI1_I1680_p1 XI1_I1680_An I1_b25_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1680_MP2 (VDD I1_B_0_b3_4 XI1_I1680_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1680_MP3 (XI1_I1680_p1 I1_qu7_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1680_MP0 (VDD I1_B_0_b3_4 XI1_I1680_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1634_MP1 (VDD I1_qu8_b3_0 XI1_I1634_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1634_MP5 (I1_b24_0 XI1_I1634_Bn XI1_I1634_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1634_MP4 (XI1_I1634_p1 XI1_I1634_An I1_b24_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1634_MP2 (VDD I1_B_0_b3_4 XI1_I1634_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1634_MP3 (XI1_I1634_p1 I1_qu8_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1634_MP0 (VDD I1_B_0_b3_4 XI1_I1634_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1635_MP1 (VDD I1_qu8_b3_0 XI1_I1635_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1635_MP5 (I1_b24_1 XI1_I1635_Bn XI1_I1635_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1635_MP4 (XI1_I1635_p1 XI1_I1635_An I1_b24_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1635_MP2 (VDD I1_dd1_b3_4 XI1_I1635_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1635_MP3 (XI1_I1635_p1 I1_qu8_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1635_MP0 (VDD I1_dd1_b3_4 XI1_I1635_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1636_MP1 (VDD I1_qu8_b3_0 XI1_I1636_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1636_MP5 (I1_b24_2 XI1_I1636_Bn XI1_I1636_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1636_MP4 (XI1_I1636_p1 XI1_I1636_An I1_b24_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1636_MP2 (VDD I1_dd2_b3_4 XI1_I1636_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1636_MP3 (XI1_I1636_p1 I1_qu8_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1636_MP0 (VDD I1_dd2_b3_4 XI1_I1636_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1567_MP1 (VDD I1_qu10_b3_4 XI1_I1567_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1567_MP5 (I1_b22_25 XI1_I1567_Bn XI1_I1567_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1567_MP4 (XI1_I1567_p1 XI1_I1567_An I1_b22_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1567_MP2 (VDD I1_dd25_b3_4 XI1_I1567_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1567_MP3 (XI1_I1567_p1 I1_qu10_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1567_MP0 (VDD I1_dd25_b3_4 XI1_I1567_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1566_MP1 (VDD I1_qu10_b3_4 XI1_I1566_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1566_MP5 (I1_b22_24 XI1_I1566_Bn XI1_I1566_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1566_MP4 (XI1_I1566_p1 XI1_I1566_An I1_b22_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1566_MP2 (VDD I1_dd24_b3_4 XI1_I1566_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1566_MP3 (XI1_I1566_p1 I1_qu10_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1566_MP0 (VDD I1_dd24_b3_4 XI1_I1566_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I206_MP1 (VDD I1_I1574_G2_0n XI1_I1574_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I206_MP5 (I1_p22_3 XI1_I1574_I206_Bn XI1_I1574_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I206_MP4 (XI1_I1574_I206_p1 XI1_I1574_I206_An I1_p22_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I206_MP2 (VDD I1_I1574_pn3 XI1_I1574_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I206_MP3 (XI1_I1574_I206_p1 I1_I1574_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I206_MP0 (VDD I1_I1574_pn3 XI1_I1574_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1542_MP1 (VDD I1_qu10_b3_0 XI1_I1542_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1542_MP5 (I1_b22_0 XI1_I1542_Bn XI1_I1542_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1542_MP4 (XI1_I1542_p1 XI1_I1542_An I1_b22_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1542_MP2 (VDD I1_B_0_b3_3 XI1_I1542_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1542_MP3 (XI1_I1542_p1 I1_qu10_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1542_MP0 (VDD I1_B_0_b3_3 XI1_I1542_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I20_MP1 (VDD I2_I1_SUB_b3_1 XI2_I1_I20_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I20_MP5 (I2_I1_bx10 XI2_I1_I20_Bn XI2_I1_I20_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I20_MP4 (XI2_I1_I20_p1 XI2_I1_I20_An I2_I1_bx10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I20_MP2 (VDD B_10 XI2_I1_I20_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I20_MP3 (XI2_I1_I20_p1 I2_I1_SUB_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I20_MP0 (VDD B_10 XI2_I1_I20_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I213_MP1 (VDD I2_I1_I42_G9_0n XI2_I1_I42_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I213_MP5 (I2_S_10 XI2_I1_I42_I213_Bn XI2_I1_I42_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I213_MP4 (XI2_I1_I42_I213_p1 XI2_I1_I42_I213_An I2_S_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I213_MP2 (VDD I2_I1_I42_pn10 XI2_I1_I42_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I213_MP3 (XI2_I1_I42_I213_p1 I2_I1_I42_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I213_MP0 (VDD I2_I1_I42_pn10 XI2_I1_I42_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1710_MP1 (VDD I1_qu7_b3_5 XI1_I1710_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1710_MP5 (I1_b25_30 XI1_I1710_Bn XI1_I1710_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1710_MP4 (XI1_I1710_p1 XI1_I1710_An I1_b25_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1710_MP2 (VDD I1_dd30_b3_4 XI1_I1710_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1710_MP3 (XI1_I1710_p1 I1_qu7_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1710_MP0 (VDD I1_dd30_b3_4 XI1_I1710_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1706_MP1 (VDD I1_qu7_b3_4 XI1_I1706_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1706_MP5 (I1_b25_26 XI1_I1706_Bn XI1_I1706_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1706_MP4 (XI1_I1706_p1 XI1_I1706_An I1_b25_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1706_MP2 (VDD I1_dd26_b3_4 XI1_I1706_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1706_MP3 (XI1_I1706_p1 I1_qu7_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1706_MP0 (VDD I1_dd26_b3_4 XI1_I1706_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I215_MP1 (VDD I1_I1712_G11_0n XI1_I1712_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I215_MP5 (I1_p25_12 XI1_I1712_I215_Bn XI1_I1712_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I215_MP4 (XI1_I1712_I215_p1 XI1_I1712_I215_An I1_p25_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I215_MP2 (VDD I1_I1712_pn12 XI1_I1712_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I215_MP3 (XI1_I1712_I215_p1 I1_I1712_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I215_MP0 (VDD I1_I1712_pn12 XI1_I1712_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I214_MP1 (VDD I1_I1712_G10_0n XI1_I1712_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I214_MP5 (I1_p25_11 XI1_I1712_I214_Bn XI1_I1712_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I214_MP4 (XI1_I1712_I214_p1 XI1_I1712_I214_An I1_p25_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I214_MP2 (VDD I1_I1712_pn11 XI1_I1712_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I214_MP3 (XI1_I1712_I214_p1 I1_I1712_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I214_MP0 (VDD I1_I1712_pn11 XI1_I1712_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1690_MP1 (VDD I1_qu7_b3_1 XI1_I1690_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1690_MP5 (I1_b25_10 XI1_I1690_Bn XI1_I1690_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1690_MP4 (XI1_I1690_p1 XI1_I1690_An I1_b25_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1690_MP2 (VDD I1_dd10_b3_4 XI1_I1690_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1690_MP3 (XI1_I1690_p1 I1_qu7_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1690_MP0 (VDD I1_dd10_b3_4 XI1_I1690_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1687_MP1 (VDD I1_qu7_b3_1 XI1_I1687_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1687_MP5 (I1_b25_7 XI1_I1687_Bn XI1_I1687_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1687_MP4 (XI1_I1687_p1 XI1_I1687_An I1_b25_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1687_MP2 (VDD I1_dd7_b3_4 XI1_I1687_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1687_MP3 (XI1_I1687_p1 I1_qu7_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1687_MP0 (VDD I1_dd7_b3_4 XI1_I1687_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1686_MP1 (VDD I1_qu7_b3_1 XI1_I1686_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1686_MP5 (I1_b25_6 XI1_I1686_Bn XI1_I1686_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1686_MP4 (XI1_I1686_p1 XI1_I1686_An I1_b25_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1686_MP2 (VDD I1_dd6_b3_4 XI1_I1686_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1686_MP3 (XI1_I1686_p1 I1_qu7_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1686_MP0 (VDD I1_dd6_b3_4 XI1_I1686_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I206_MP1 (VDD I1_I1666_G2_0n XI1_I1666_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I206_MP5 (I1_p24_3 XI1_I1666_I206_Bn XI1_I1666_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I206_MP4 (XI1_I1666_I206_p1 XI1_I1666_I206_An I1_p24_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I206_MP2 (VDD I1_I1666_pn3 XI1_I1666_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I206_MP3 (XI1_I1666_I206_p1 I1_I1666_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I206_MP0 (VDD I1_I1666_pn3 XI1_I1666_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1637_MP1 (VDD I1_qu8_b3_0 XI1_I1637_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1637_MP5 (I1_b24_3 XI1_I1637_Bn XI1_I1637_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1637_MP4 (XI1_I1637_p1 XI1_I1637_An I1_b24_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1637_MP2 (VDD I1_dd3_b3_4 XI1_I1637_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1637_MP3 (XI1_I1637_p1 I1_qu8_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1637_MP0 (VDD I1_dd3_b3_4 XI1_I1637_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1565_MP1 (VDD I1_qu10_b3_3 XI1_I1565_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1565_MP5 (I1_b22_23 XI1_I1565_Bn XI1_I1565_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1565_MP4 (XI1_I1565_p1 XI1_I1565_An I1_b22_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1565_MP2 (VDD I1_dd23_b3_4 XI1_I1565_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1565_MP3 (XI1_I1565_p1 I1_qu10_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1565_MP0 (VDD I1_dd23_b3_4 XI1_I1565_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1564_MP1 (VDD I1_qu10_b3_3 XI1_I1564_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1564_MP5 (I1_b22_22 XI1_I1564_Bn XI1_I1564_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1564_MP4 (XI1_I1564_p1 XI1_I1564_An I1_b22_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1564_MP2 (VDD I1_dd22_b3_4 XI1_I1564_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1564_MP3 (XI1_I1564_p1 I1_qu10_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1564_MP0 (VDD I1_dd22_b3_4 XI1_I1564_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I214_MP1 (VDD I1_I1574_G10_0n XI1_I1574_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I214_MP5 (I1_p22_11 XI1_I1574_I214_Bn XI1_I1574_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I214_MP4 (XI1_I1574_I214_p1 XI1_I1574_I214_An I1_p22_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I214_MP2 (VDD I1_I1574_pn11 XI1_I1574_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I214_MP3 (XI1_I1574_I214_p1 I1_I1574_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I214_MP0 (VDD I1_I1574_pn11 XI1_I1574_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1552_MP1 (VDD I1_qu10_b3_1 XI1_I1552_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1552_MP5 (I1_b22_10 XI1_I1552_Bn XI1_I1552_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1552_MP4 (XI1_I1552_p1 XI1_I1552_An I1_b22_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1552_MP2 (VDD I1_dd10_b3_4 XI1_I1552_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1552_MP3 (XI1_I1552_p1 I1_qu10_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1552_MP0 (VDD I1_dd10_b3_4 XI1_I1552_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1550_MP1 (VDD I1_qu10_b3_1 XI1_I1550_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1550_MP5 (I1_b22_8 XI1_I1550_Bn XI1_I1550_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1550_MP4 (XI1_I1550_p1 XI1_I1550_An I1_b22_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1550_MP2 (VDD I1_dd8_b3_4 XI1_I1550_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1550_MP3 (XI1_I1550_p1 I1_qu10_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1550_MP0 (VDD I1_dd8_b3_4 XI1_I1550_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1549_MP1 (VDD I1_qu10_b3_1 XI1_I1549_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1549_MP5 (I1_b22_7 XI1_I1549_Bn XI1_I1549_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1549_MP4 (XI1_I1549_p1 XI1_I1549_An I1_b22_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1549_MP2 (VDD I1_dd7_b3_4 XI1_I1549_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1549_MP3 (XI1_I1549_p1 I1_qu10_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1549_MP0 (VDD I1_dd7_b3_4 XI1_I1549_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1548_MP1 (VDD I1_qu10_b3_1 XI1_I1548_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1548_MP5 (I1_b22_6 XI1_I1548_Bn XI1_I1548_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1548_MP4 (XI1_I1548_p1 XI1_I1548_An I1_b22_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1548_MP2 (VDD I1_dd6_b3_4 XI1_I1548_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1548_MP3 (XI1_I1548_p1 I1_qu10_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1548_MP0 (VDD I1_dd6_b3_4 XI1_I1548_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1592_MP1 (VDD I1_qu9_b3_0 XI1_I1592_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1592_MP5 (I1_b23_4 XI1_I1592_Bn XI1_I1592_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1592_MP4 (XI1_I1592_p1 XI1_I1592_An I1_b23_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1592_MP2 (VDD I1_dd4_b3_4 XI1_I1592_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1592_MP3 (XI1_I1592_p1 I1_qu9_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1592_MP0 (VDD I1_dd4_b3_4 XI1_I1592_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1591_MP1 (VDD I1_qu9_b3_0 XI1_I1591_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1591_MP5 (I1_b23_3 XI1_I1591_Bn XI1_I1591_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1591_MP4 (XI1_I1591_p1 XI1_I1591_An I1_b23_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1591_MP2 (VDD I1_dd3_b3_4 XI1_I1591_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1591_MP3 (XI1_I1591_p1 I1_qu9_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1591_MP0 (VDD I1_dd3_b3_4 XI1_I1591_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I18_MP1 (VDD I2_I1_SUB_b3_1 XI2_I1_I18_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I18_MP5 (I2_I1_bx8 XI2_I1_I18_Bn XI2_I1_I18_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I18_MP4 (XI2_I1_I18_p1 XI2_I1_I18_An I2_I1_bx8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I18_MP2 (VDD B_8 XI2_I1_I18_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I18_MP3 (XI2_I1_I18_p1 I2_I1_SUB_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I18_MP0 (VDD B_8 XI2_I1_I18_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I19_MP1 (VDD I2_I1_SUB_b3_1 XI2_I1_I19_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I19_MP5 (I2_I1_bx9 XI2_I1_I19_Bn XI2_I1_I19_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I19_MP4 (XI2_I1_I19_p1 XI2_I1_I19_An I2_I1_bx9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I19_MP2 (VDD B_9 XI2_I1_I19_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I19_MP3 (XI2_I1_I19_p1 I2_I1_SUB_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I19_MP0 (VDD B_9 XI2_I1_I19_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I212_MP1 (VDD I2_I1_I42_G8_0n XI2_I1_I42_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I212_MP5 (I2_S_9 XI2_I1_I42_I212_Bn XI2_I1_I42_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I212_MP4 (XI2_I1_I42_I212_p1 XI2_I1_I42_I212_An I2_S_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I212_MP2 (VDD I2_I1_I42_pn9 XI2_I1_I42_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I212_MP3 (XI2_I1_I42_I212_p1 I2_I1_I42_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I212_MP0 (VDD I2_I1_I42_pn9 XI2_I1_I42_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1754_MP1 (VDD I1_qu6_b3_4 XI1_I1754_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1754_MP5 (I1_b26_28 XI1_I1754_Bn XI1_I1754_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1754_MP4 (XI1_I1754_p1 XI1_I1754_An I1_b26_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1754_MP2 (VDD I1_dd28_b3_4 XI1_I1754_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1754_MP3 (XI1_I1754_p1 I1_qu6_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1754_MP0 (VDD I1_dd28_b3_4 XI1_I1754_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1711_MP1 (VDD I1_qu7_b3_5 XI1_I1711_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1711_MP5 (I1_b25_31 XI1_I1711_Bn XI1_I1711_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1711_MP4 (XI1_I1711_p1 XI1_I1711_An I1_b25_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1711_MP2 (VDD I1_dd31_b3_4 XI1_I1711_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1711_MP3 (XI1_I1711_p1 I1_qu7_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1711_MP0 (VDD I1_dd31_b3_4 XI1_I1711_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1705_MP1 (VDD I1_qu7_b3_4 XI1_I1705_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1705_MP5 (I1_b25_25 XI1_I1705_Bn XI1_I1705_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1705_MP4 (XI1_I1705_p1 XI1_I1705_An I1_b25_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1705_MP2 (VDD I1_dd25_b3_4 XI1_I1705_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1705_MP3 (XI1_I1705_p1 I1_qu7_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1705_MP0 (VDD I1_dd25_b3_4 XI1_I1705_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1702_MP1 (VDD I1_qu7_b3_3 XI1_I1702_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1702_MP5 (I1_b25_22 XI1_I1702_Bn XI1_I1702_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1702_MP4 (XI1_I1702_p1 XI1_I1702_An I1_b25_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1702_MP2 (VDD I1_dd22_b3_4 XI1_I1702_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1702_MP3 (XI1_I1702_p1 I1_qu7_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1702_MP0 (VDD I1_dd22_b3_4 XI1_I1702_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I217_MP1 (VDD I1_I1712_G13_0n XI1_I1712_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I217_MP5 (I1_p25_14 XI1_I1712_I217_Bn XI1_I1712_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I217_MP4 (XI1_I1712_I217_p1 XI1_I1712_I217_An I1_p25_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I217_MP2 (VDD I1_I1712_pn14 XI1_I1712_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I217_MP3 (XI1_I1712_I217_p1 I1_I1712_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I217_MP0 (VDD I1_I1712_pn14 XI1_I1712_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1689_MP1 (VDD I1_qu7_b3_1 XI1_I1689_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1689_MP5 (I1_b25_9 XI1_I1689_Bn XI1_I1689_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1689_MP4 (XI1_I1689_p1 XI1_I1689_An I1_b25_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1689_MP2 (VDD I1_dd9_b3_4 XI1_I1689_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1689_MP3 (XI1_I1689_p1 I1_qu7_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1689_MP0 (VDD I1_dd9_b3_4 XI1_I1689_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1691_MP1 (VDD I1_qu7_b3_1 XI1_I1691_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1691_MP5 (I1_b25_11 XI1_I1691_Bn XI1_I1691_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1691_MP4 (XI1_I1691_p1 XI1_I1691_An I1_b25_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1691_MP2 (VDD I1_dd11_b3_4 XI1_I1691_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1691_MP3 (XI1_I1691_p1 I1_qu7_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1691_MP0 (VDD I1_dd11_b3_4 XI1_I1691_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1688_MP1 (VDD I1_qu7_b3_1 XI1_I1688_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1688_MP5 (I1_b25_8 XI1_I1688_Bn XI1_I1688_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1688_MP4 (XI1_I1688_p1 XI1_I1688_An I1_b25_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1688_MP2 (VDD I1_dd8_b3_4 XI1_I1688_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1688_MP3 (XI1_I1688_p1 I1_qu7_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1688_MP0 (VDD I1_dd8_b3_4 XI1_I1688_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I207_MP1 (VDD I1_I1666_G3_0n XI1_I1666_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I207_MP5 (I1_p24_4 XI1_I1666_I207_Bn XI1_I1666_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I207_MP4 (XI1_I1666_I207_p1 XI1_I1666_I207_An I1_p24_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I207_MP2 (VDD I1_I1666_pn4 XI1_I1666_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I207_MP3 (XI1_I1666_I207_p1 I1_I1666_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I207_MP0 (VDD I1_I1666_pn4 XI1_I1666_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1638_MP1 (VDD I1_qu8_b3_0 XI1_I1638_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1638_MP5 (I1_b24_4 XI1_I1638_Bn XI1_I1638_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1638_MP4 (XI1_I1638_p1 XI1_I1638_An I1_b24_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1638_MP2 (VDD I1_dd4_b3_4 XI1_I1638_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1638_MP3 (XI1_I1638_p1 I1_qu8_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1638_MP0 (VDD I1_dd4_b3_4 XI1_I1638_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1563_MP1 (VDD I1_qu10_b3_3 XI1_I1563_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1563_MP5 (I1_b22_21 XI1_I1563_Bn XI1_I1563_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1563_MP4 (XI1_I1563_p1 XI1_I1563_An I1_b22_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1563_MP2 (VDD I1_dd21_b3_4 XI1_I1563_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1563_MP3 (XI1_I1563_p1 I1_qu10_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1563_MP0 (VDD I1_dd21_b3_4 XI1_I1563_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1639_MP1 (VDD I1_qu8_b3_0 XI1_I1639_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1639_MP5 (I1_b24_5 XI1_I1639_Bn XI1_I1639_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1639_MP4 (XI1_I1639_p1 XI1_I1639_An I1_b24_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1639_MP2 (VDD I1_dd5_b3_4 XI1_I1639_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1639_MP3 (XI1_I1639_p1 I1_qu8_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1639_MP0 (VDD I1_dd5_b3_4 XI1_I1639_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1560_MP1 (VDD I1_qu10_b3_3 XI1_I1560_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1560_MP5 (I1_b22_18 XI1_I1560_Bn XI1_I1560_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1560_MP4 (XI1_I1560_p1 XI1_I1560_An I1_b22_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1560_MP2 (VDD I1_dd18_b3_4 XI1_I1560_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1560_MP3 (XI1_I1560_p1 I1_qu10_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1560_MP0 (VDD I1_dd18_b3_4 XI1_I1560_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1561_MP1 (VDD I1_qu10_b3_3 XI1_I1561_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1561_MP5 (I1_b22_19 XI1_I1561_Bn XI1_I1561_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1561_MP4 (XI1_I1561_p1 XI1_I1561_An I1_b22_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1561_MP2 (VDD I1_dd19_b3_4 XI1_I1561_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1561_MP3 (XI1_I1561_p1 I1_qu10_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1561_MP0 (VDD I1_dd19_b3_4 XI1_I1561_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1562_MP1 (VDD I1_qu10_b3_3 XI1_I1562_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1562_MP5 (I1_b22_20 XI1_I1562_Bn XI1_I1562_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1562_MP4 (XI1_I1562_p1 XI1_I1562_An I1_b22_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1562_MP2 (VDD I1_dd20_b3_4 XI1_I1562_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1562_MP3 (XI1_I1562_p1 I1_qu10_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1562_MP0 (VDD I1_dd20_b3_4 XI1_I1562_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1559_MP1 (VDD I1_qu10_b3_2 XI1_I1559_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1559_MP5 (I1_b22_17 XI1_I1559_Bn XI1_I1559_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1559_MP4 (XI1_I1559_p1 XI1_I1559_An I1_b22_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1559_MP2 (VDD I1_dd17_b3_4 XI1_I1559_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1559_MP3 (XI1_I1559_p1 I1_qu10_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1559_MP0 (VDD I1_dd17_b3_4 XI1_I1559_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1558_MP1 (VDD I1_qu10_b3_2 XI1_I1558_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1558_MP5 (I1_b22_16 XI1_I1558_Bn XI1_I1558_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1558_MP4 (XI1_I1558_p1 XI1_I1558_An I1_b22_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1558_MP2 (VDD I1_dd16_b3_4 XI1_I1558_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1558_MP3 (XI1_I1558_p1 I1_qu10_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1558_MP0 (VDD I1_dd16_b3_4 XI1_I1558_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1557_MP1 (VDD I1_qu10_b3_2 XI1_I1557_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1557_MP5 (I1_b22_15 XI1_I1557_Bn XI1_I1557_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1557_MP4 (XI1_I1557_p1 XI1_I1557_An I1_b22_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1557_MP2 (VDD I1_dd15_b3_4 XI1_I1557_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1557_MP3 (XI1_I1557_p1 I1_qu10_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1557_MP0 (VDD I1_dd15_b3_4 XI1_I1557_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1554_MP1 (VDD I1_qu10_b3_2 XI1_I1554_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1554_MP5 (I1_b22_12 XI1_I1554_Bn XI1_I1554_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1554_MP4 (XI1_I1554_p1 XI1_I1554_An I1_b22_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1554_MP2 (VDD I1_dd12_b3_4 XI1_I1554_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1554_MP3 (XI1_I1554_p1 I1_qu10_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1554_MP0 (VDD I1_dd12_b3_4 XI1_I1554_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1556_MP1 (VDD I1_qu10_b3_2 XI1_I1556_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1556_MP5 (I1_b22_14 XI1_I1556_Bn XI1_I1556_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1556_MP4 (XI1_I1556_p1 XI1_I1556_An I1_b22_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1556_MP2 (VDD I1_dd14_b3_4 XI1_I1556_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1556_MP3 (XI1_I1556_p1 I1_qu10_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1556_MP0 (VDD I1_dd14_b3_4 XI1_I1556_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I218_MP1 (VDD I1_I1574_G14_0n XI1_I1574_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I218_MP5 (I1_p22_15 XI1_I1574_I218_Bn XI1_I1574_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I218_MP4 (XI1_I1574_I218_p1 XI1_I1574_I218_An I1_p22_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I218_MP2 (VDD I1_I1574_pn15 XI1_I1574_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I218_MP3 (XI1_I1574_I218_p1 I1_I1574_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I218_MP0 (VDD I1_I1574_pn15 XI1_I1574_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1553_MP1 (VDD I1_qu10_b3_1 XI1_I1553_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1553_MP5 (I1_b22_11 XI1_I1553_Bn XI1_I1553_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1553_MP4 (XI1_I1553_p1 XI1_I1553_An I1_b22_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1553_MP2 (VDD I1_dd11_b3_4 XI1_I1553_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1553_MP3 (XI1_I1553_p1 I1_qu10_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1553_MP0 (VDD I1_dd11_b3_4 XI1_I1553_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1551_MP1 (VDD I1_qu10_b3_1 XI1_I1551_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1551_MP5 (I1_b22_9 XI1_I1551_Bn XI1_I1551_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1551_MP4 (XI1_I1551_p1 XI1_I1551_An I1_b22_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1551_MP2 (VDD I1_dd9_b3_4 XI1_I1551_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1551_MP3 (XI1_I1551_p1 I1_qu10_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1551_MP0 (VDD I1_dd9_b3_4 XI1_I1551_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1597_MP1 (VDD I1_qu9_b3_1 XI1_I1597_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1597_MP5 (I1_b23_9 XI1_I1597_Bn XI1_I1597_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1597_MP4 (XI1_I1597_p1 XI1_I1597_An I1_b23_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1597_MP2 (VDD I1_dd9_b3_4 XI1_I1597_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1597_MP3 (XI1_I1597_p1 I1_qu9_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1597_MP0 (VDD I1_dd9_b3_4 XI1_I1597_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1596_MP1 (VDD I1_qu9_b3_1 XI1_I1596_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1596_MP5 (I1_b23_8 XI1_I1596_Bn XI1_I1596_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1596_MP4 (XI1_I1596_p1 XI1_I1596_An I1_b23_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1596_MP2 (VDD I1_dd8_b3_4 XI1_I1596_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1596_MP3 (XI1_I1596_p1 I1_qu9_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1596_MP0 (VDD I1_dd8_b3_4 XI1_I1596_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1593_MP1 (VDD I1_qu9_b3_0 XI1_I1593_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1593_MP5 (I1_b23_5 XI1_I1593_Bn XI1_I1593_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1593_MP4 (XI1_I1593_p1 XI1_I1593_An I1_b23_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1593_MP2 (VDD I1_dd5_b3_4 XI1_I1593_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1593_MP3 (XI1_I1593_p1 I1_qu9_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1593_MP0 (VDD I1_dd5_b3_4 XI1_I1593_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1589_MP1 (VDD I1_qu9_b3_0 XI1_I1589_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1589_MP5 (I1_b23_1 XI1_I1589_Bn XI1_I1589_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1589_MP4 (XI1_I1589_p1 XI1_I1589_An I1_b23_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1589_MP2 (VDD I1_dd1_b3_4 XI1_I1589_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1589_MP3 (XI1_I1589_p1 I1_qu9_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1589_MP0 (VDD I1_dd1_b3_4 XI1_I1589_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I17_MP1 (VDD I2_I1_SUB_b3_1 XI2_I1_I17_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I17_MP5 (I2_I1_bx7 XI2_I1_I17_Bn XI2_I1_I17_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I17_MP4 (XI2_I1_I17_p1 XI2_I1_I17_An I2_I1_bx7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I17_MP2 (VDD B_7 XI2_I1_I17_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I17_MP3 (XI2_I1_I17_p1 I2_I1_SUB_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I17_MP0 (VDD B_7 XI2_I1_I17_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1753_MP1 (VDD I1_qu6_b3_4 XI1_I1753_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1753_MP5 (I1_b26_27 XI1_I1753_Bn XI1_I1753_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1753_MP4 (XI1_I1753_p1 XI1_I1753_An I1_b26_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1753_MP2 (VDD I1_dd27_b3_4 XI1_I1753_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1753_MP3 (XI1_I1753_p1 I1_qu6_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1753_MP0 (VDD I1_dd27_b3_4 XI1_I1753_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1751_MP1 (VDD I1_qu6_b3_4 XI1_I1751_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1751_MP5 (I1_b26_25 XI1_I1751_Bn XI1_I1751_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1751_MP4 (XI1_I1751_p1 XI1_I1751_An I1_b26_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1751_MP2 (VDD I1_dd25_b3_4 XI1_I1751_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1751_MP3 (XI1_I1751_p1 I1_qu6_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1751_MP0 (VDD I1_dd25_b3_4 XI1_I1751_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1750_MP1 (VDD I1_qu6_b3_4 XI1_I1750_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1750_MP5 (I1_b26_24 XI1_I1750_Bn XI1_I1750_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1750_MP4 (XI1_I1750_p1 XI1_I1750_An I1_b26_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1750_MP2 (VDD I1_dd24_b3_4 XI1_I1750_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1750_MP3 (XI1_I1750_p1 I1_qu6_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1750_MP0 (VDD I1_dd24_b3_4 XI1_I1750_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1701_MP1 (VDD I1_qu7_b3_3 XI1_I1701_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1701_MP5 (I1_b25_21 XI1_I1701_Bn XI1_I1701_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1701_MP4 (XI1_I1701_p1 XI1_I1701_An I1_b25_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1701_MP2 (VDD I1_dd21_b3_4 XI1_I1701_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1701_MP3 (XI1_I1701_p1 I1_qu7_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1701_MP0 (VDD I1_dd21_b3_4 XI1_I1701_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1700_MP1 (VDD I1_qu7_b3_3 XI1_I1700_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1700_MP5 (I1_b25_20 XI1_I1700_Bn XI1_I1700_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1700_MP4 (XI1_I1700_p1 XI1_I1700_An I1_b25_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1700_MP2 (VDD I1_dd20_b3_4 XI1_I1700_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1700_MP3 (XI1_I1700_p1 I1_qu7_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1700_MP0 (VDD I1_dd20_b3_4 XI1_I1700_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1698_MP1 (VDD I1_qu7_b3_3 XI1_I1698_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1698_MP5 (I1_b25_18 XI1_I1698_Bn XI1_I1698_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1698_MP4 (XI1_I1698_p1 XI1_I1698_An I1_b25_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1698_MP2 (VDD I1_dd18_b3_4 XI1_I1698_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1698_MP3 (XI1_I1698_p1 I1_qu7_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1698_MP0 (VDD I1_dd18_b3_4 XI1_I1698_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I218_MP1 (VDD I1_I1712_G14_0n XI1_I1712_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I218_MP5 (I1_p25_15 XI1_I1712_I218_Bn XI1_I1712_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I218_MP4 (XI1_I1712_I218_p1 XI1_I1712_I218_An I1_p25_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I218_MP2 (VDD I1_I1712_pn15 XI1_I1712_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I218_MP3 (XI1_I1712_I218_p1 I1_I1712_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I218_MP0 (VDD I1_I1712_pn15 XI1_I1712_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I219_MP1 (VDD I1_I1712_G15_0n XI1_I1712_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I219_MP5 (I1_p25_16 XI1_I1712_I219_Bn XI1_I1712_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I219_MP4 (XI1_I1712_I219_p1 XI1_I1712_I219_An I1_p25_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I219_MP2 (VDD I1_I1712_pn16 XI1_I1712_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I219_MP3 (XI1_I1712_I219_p1 I1_I1712_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I219_MP0 (VDD I1_I1712_pn16 XI1_I1712_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I216_MP1 (VDD I1_I1712_G12_0n XI1_I1712_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I216_MP5 (I1_p25_13 XI1_I1712_I216_Bn XI1_I1712_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I216_MP4 (XI1_I1712_I216_p1 XI1_I1712_I216_An I1_p25_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I216_MP2 (VDD I1_I1712_pn13 XI1_I1712_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I216_MP3 (XI1_I1712_I216_p1 I1_I1712_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I216_MP0 (VDD I1_I1712_pn13 XI1_I1712_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1695_MP1 (VDD I1_qu7_b3_2 XI1_I1695_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1695_MP5 (I1_b25_15 XI1_I1695_Bn XI1_I1695_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1695_MP4 (XI1_I1695_p1 XI1_I1695_An I1_b25_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1695_MP2 (VDD I1_dd15_b3_4 XI1_I1695_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1695_MP3 (XI1_I1695_p1 I1_qu7_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1695_MP0 (VDD I1_dd15_b3_4 XI1_I1695_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1696_MP1 (VDD I1_qu7_b3_2 XI1_I1696_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1696_MP5 (I1_b25_16 XI1_I1696_Bn XI1_I1696_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1696_MP4 (XI1_I1696_p1 XI1_I1696_An I1_b25_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1696_MP2 (VDD I1_dd16_b3_4 XI1_I1696_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1696_MP3 (XI1_I1696_p1 I1_qu7_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1696_MP0 (VDD I1_dd16_b3_4 XI1_I1696_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1692_MP1 (VDD I1_qu7_b3_2 XI1_I1692_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1692_MP5 (I1_b25_12 XI1_I1692_Bn XI1_I1692_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1692_MP4 (XI1_I1692_p1 XI1_I1692_An I1_b25_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1692_MP2 (VDD I1_dd12_b3_4 XI1_I1692_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1692_MP3 (XI1_I1692_p1 I1_qu7_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1692_MP0 (VDD I1_dd12_b3_4 XI1_I1692_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I213_MP1 (VDD I1_I1666_G9_0n XI1_I1666_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I213_MP5 (I1_p24_10 XI1_I1666_I213_Bn XI1_I1666_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I213_MP4 (XI1_I1666_I213_p1 XI1_I1666_I213_An I1_p24_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I213_MP2 (VDD I1_I1666_pn10 XI1_I1666_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I213_MP3 (XI1_I1666_I213_p1 I1_I1666_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I213_MP0 (VDD I1_I1666_pn10 XI1_I1666_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1640_MP1 (VDD I1_qu8_b3_1 XI1_I1640_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1640_MP5 (I1_b24_6 XI1_I1640_Bn XI1_I1640_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1640_MP4 (XI1_I1640_p1 XI1_I1640_An I1_b24_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1640_MP2 (VDD I1_dd6_b3_4 XI1_I1640_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1640_MP3 (XI1_I1640_p1 I1_qu8_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1640_MP0 (VDD I1_dd6_b3_4 XI1_I1640_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1643_MP1 (VDD I1_qu8_b3_1 XI1_I1643_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1643_MP5 (I1_b24_9 XI1_I1643_Bn XI1_I1643_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1643_MP4 (XI1_I1643_p1 XI1_I1643_An I1_b24_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1643_MP2 (VDD I1_dd9_b3_4 XI1_I1643_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1643_MP3 (XI1_I1643_p1 I1_qu8_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1643_MP0 (VDD I1_dd9_b3_4 XI1_I1643_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1642_MP1 (VDD I1_qu8_b3_1 XI1_I1642_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1642_MP5 (I1_b24_8 XI1_I1642_Bn XI1_I1642_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1642_MP4 (XI1_I1642_p1 XI1_I1642_An I1_b24_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1642_MP2 (VDD I1_dd8_b3_4 XI1_I1642_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1642_MP3 (XI1_I1642_p1 I1_qu8_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1642_MP0 (VDD I1_dd8_b3_4 XI1_I1642_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1621_MP1 (VDD I1_qu9_b3_5 XI1_I1621_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1621_MP5 (I1_h23 XI1_I1621_Bn XI1_I1621_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1621_MP4 (XI1_I1621_p1 XI1_I1621_An I1_h23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1621_MP2 (VDD I1_p22_31 XI1_I1621_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1621_MP3 (XI1_I1621_p1 I1_qu9_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1621_MP0 (VDD I1_p22_31 XI1_I1621_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1555_MP1 (VDD I1_qu10_b3_2 XI1_I1555_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1555_MP5 (I1_b22_13 XI1_I1555_Bn XI1_I1555_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1555_MP4 (XI1_I1555_p1 XI1_I1555_An I1_b22_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1555_MP2 (VDD I1_dd13_b3_4 XI1_I1555_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1555_MP3 (XI1_I1555_p1 I1_qu10_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1555_MP0 (VDD I1_dd13_b3_4 XI1_I1555_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1599_MP1 (VDD I1_qu9_b3_1 XI1_I1599_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1599_MP5 (I1_b23_11 XI1_I1599_Bn XI1_I1599_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1599_MP4 (XI1_I1599_p1 XI1_I1599_An I1_b23_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1599_MP2 (VDD I1_dd11_b3_4 XI1_I1599_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1599_MP3 (XI1_I1599_p1 I1_qu9_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1599_MP0 (VDD I1_dd11_b3_4 XI1_I1599_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1598_MP1 (VDD I1_qu9_b3_1 XI1_I1598_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1598_MP5 (I1_b23_10 XI1_I1598_Bn XI1_I1598_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1598_MP4 (XI1_I1598_p1 XI1_I1598_An I1_b23_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1598_MP2 (VDD I1_dd10_b3_4 XI1_I1598_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1598_MP3 (XI1_I1598_p1 I1_qu9_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1598_MP0 (VDD I1_dd10_b3_4 XI1_I1598_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1594_MP1 (VDD I1_qu9_b3_1 XI1_I1594_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1594_MP5 (I1_b23_6 XI1_I1594_Bn XI1_I1594_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1594_MP4 (XI1_I1594_p1 XI1_I1594_An I1_b23_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1594_MP2 (VDD I1_dd6_b3_4 XI1_I1594_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1594_MP3 (XI1_I1594_p1 I1_qu9_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1594_MP0 (VDD I1_dd6_b3_4 XI1_I1594_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1595_MP1 (VDD I1_qu9_b3_1 XI1_I1595_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1595_MP5 (I1_b23_7 XI1_I1595_Bn XI1_I1595_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1595_MP4 (XI1_I1595_p1 XI1_I1595_An I1_b23_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1595_MP2 (VDD I1_dd7_b3_4 XI1_I1595_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1595_MP3 (XI1_I1595_p1 I1_qu9_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1595_MP0 (VDD I1_dd7_b3_4 XI1_I1595_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I206_MP1 (VDD I1_I1620_G2_0n XI1_I1620_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I206_MP5 (I1_p23_3 XI1_I1620_I206_Bn XI1_I1620_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I206_MP4 (XI1_I1620_I206_p1 XI1_I1620_I206_An I1_p23_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I206_MP2 (VDD I1_I1620_pn3 XI1_I1620_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I206_MP3 (XI1_I1620_I206_p1 I1_I1620_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I206_MP0 (VDD I1_I1620_pn3 XI1_I1620_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1590_MP1 (VDD I1_qu9_b3_0 XI1_I1590_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1590_MP5 (I1_b23_2 XI1_I1590_Bn XI1_I1590_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1590_MP4 (XI1_I1590_p1 XI1_I1590_An I1_b23_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1590_MP2 (VDD I1_dd2_b3_4 XI1_I1590_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1590_MP3 (XI1_I1590_p1 I1_qu9_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1590_MP0 (VDD I1_dd2_b3_4 XI1_I1590_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1588_MP1 (VDD I1_qu9_b3_0 XI1_I1588_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1588_MP5 (I1_b23_0 XI1_I1588_Bn XI1_I1588_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1588_MP4 (XI1_I1588_p1 XI1_I1588_An I1_b23_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1588_MP2 (VDD I1_B_0_b3_4 XI1_I1588_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1588_MP3 (XI1_I1588_p1 I1_qu9_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1588_MP0 (VDD I1_B_0_b3_4 XI1_I1588_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I16_MP1 (VDD I2_I1_SUB_b3_1 XI2_I1_I16_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I16_MP5 (I2_I1_bx6 XI2_I1_I16_Bn XI2_I1_I16_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I16_MP4 (XI2_I1_I16_p1 XI2_I1_I16_An I2_I1_bx6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I16_MP2 (VDD B_6 XI2_I1_I16_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I16_MP3 (XI2_I1_I16_p1 I2_I1_SUB_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I16_MP0 (VDD B_6 XI2_I1_I16_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1755_MP1 (VDD I1_qu6_b3_4 XI1_I1755_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1755_MP5 (I1_b26_29 XI1_I1755_Bn XI1_I1755_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1755_MP4 (XI1_I1755_p1 XI1_I1755_An I1_b26_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1755_MP2 (VDD I1_dd29_b3_4 XI1_I1755_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1755_MP3 (XI1_I1755_p1 I1_qu6_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1755_MP0 (VDD I1_dd29_b3_4 XI1_I1755_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1759_MP1 (VDD I1_qu6_b3_5 XI1_I1759_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1759_MP5 (I1_h26 XI1_I1759_Bn XI1_I1759_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1759_MP4 (XI1_I1759_p1 XI1_I1759_An I1_h26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1759_MP2 (VDD I1_p25_31 XI1_I1759_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1759_MP3 (XI1_I1759_p1 I1_qu6_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1759_MP0 (VDD I1_p25_31 XI1_I1759_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1752_MP1 (VDD I1_qu6_b3_4 XI1_I1752_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1752_MP5 (I1_b26_26 XI1_I1752_Bn XI1_I1752_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1752_MP4 (XI1_I1752_p1 XI1_I1752_An I1_b26_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1752_MP2 (VDD I1_dd26_b3_4 XI1_I1752_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1752_MP3 (XI1_I1752_p1 I1_qu6_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1752_MP0 (VDD I1_dd26_b3_4 XI1_I1752_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1747_MP1 (VDD I1_qu6_b3_3 XI1_I1747_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1747_MP5 (I1_b26_21 XI1_I1747_Bn XI1_I1747_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1747_MP4 (XI1_I1747_p1 XI1_I1747_An I1_b26_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1747_MP2 (VDD I1_dd21_b3_4 XI1_I1747_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1747_MP3 (XI1_I1747_p1 I1_qu6_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1747_MP0 (VDD I1_dd21_b3_4 XI1_I1747_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1703_MP1 (VDD I1_qu7_b3_3 XI1_I1703_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1703_MP5 (I1_b25_23 XI1_I1703_Bn XI1_I1703_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1703_MP4 (XI1_I1703_p1 XI1_I1703_An I1_b25_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1703_MP2 (VDD I1_dd23_b3_4 XI1_I1703_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1703_MP3 (XI1_I1703_p1 I1_qu7_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1703_MP0 (VDD I1_dd23_b3_4 XI1_I1703_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1699_MP1 (VDD I1_qu7_b3_3 XI1_I1699_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1699_MP5 (I1_b25_19 XI1_I1699_Bn XI1_I1699_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1699_MP4 (XI1_I1699_p1 XI1_I1699_An I1_b25_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1699_MP2 (VDD I1_dd19_b3_4 XI1_I1699_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1699_MP3 (XI1_I1699_p1 I1_qu7_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1699_MP0 (VDD I1_dd19_b3_4 XI1_I1699_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1744_MP1 (VDD I1_qu6_b3_3 XI1_I1744_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1744_MP5 (I1_b26_18 XI1_I1744_Bn XI1_I1744_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1744_MP4 (XI1_I1744_p1 XI1_I1744_An I1_b26_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1744_MP2 (VDD I1_dd18_b3_4 XI1_I1744_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1744_MP3 (XI1_I1744_p1 I1_qu6_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1744_MP0 (VDD I1_dd18_b3_4 XI1_I1744_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1714_MP1 (VDD I1_c25_o XI1_I1714_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1714_MP5 (I1_p25_32 XI1_I1714_Bn XI1_I1714_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1714_MP4 (XI1_I1714_p1 XI1_I1714_An I1_p25_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1714_MP2 (VDD I1_h25 XI1_I1714_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1714_MP3 (XI1_I1714_p1 I1_c25_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1714_MP0 (VDD I1_h25 XI1_I1714_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1697_MP1 (VDD I1_qu7_b3_2 XI1_I1697_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1697_MP5 (I1_b25_17 XI1_I1697_Bn XI1_I1697_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1697_MP4 (XI1_I1697_p1 XI1_I1697_An I1_b25_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1697_MP2 (VDD I1_dd17_b3_4 XI1_I1697_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1697_MP3 (XI1_I1697_p1 I1_qu7_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1697_MP0 (VDD I1_dd17_b3_4 XI1_I1697_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1741_MP1 (VDD I1_qu6_b3_2 XI1_I1741_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1741_MP5 (I1_b26_15 XI1_I1741_Bn XI1_I1741_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1741_MP4 (XI1_I1741_p1 XI1_I1741_An I1_b26_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1741_MP2 (VDD I1_dd15_b3_4 XI1_I1741_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1741_MP3 (XI1_I1741_p1 I1_qu6_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1741_MP0 (VDD I1_dd15_b3_4 XI1_I1741_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1694_MP1 (VDD I1_qu7_b3_2 XI1_I1694_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1694_MP5 (I1_b25_14 XI1_I1694_Bn XI1_I1694_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1694_MP4 (XI1_I1694_p1 XI1_I1694_An I1_b25_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1694_MP2 (VDD I1_dd14_b3_4 XI1_I1694_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1694_MP3 (XI1_I1694_p1 I1_qu7_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1694_MP0 (VDD I1_dd14_b3_4 XI1_I1694_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1713_MP1 (VDD I1_qu7_b3_5 XI1_I1713_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1713_MP5 (I1_h25 XI1_I1713_Bn XI1_I1713_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1713_MP4 (XI1_I1713_p1 XI1_I1713_An I1_h25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1713_MP2 (VDD I1_p24_31 XI1_I1713_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1713_MP3 (XI1_I1713_p1 I1_qu7_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1713_MP0 (VDD I1_p24_31 XI1_I1713_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1693_MP1 (VDD I1_qu7_b3_2 XI1_I1693_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1693_MP5 (I1_b25_13 XI1_I1693_Bn XI1_I1693_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1693_MP4 (XI1_I1693_p1 XI1_I1693_An I1_b25_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1693_MP2 (VDD I1_dd13_b3_4 XI1_I1693_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1693_MP3 (XI1_I1693_p1 I1_qu7_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1693_MP0 (VDD I1_dd13_b3_4 XI1_I1693_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I214_MP1 (VDD I1_I1666_G10_0n XI1_I1666_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I214_MP5 (I1_p24_11 XI1_I1666_I214_Bn XI1_I1666_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I214_MP4 (XI1_I1666_I214_p1 XI1_I1666_I214_An I1_p24_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I214_MP2 (VDD I1_I1666_pn11 XI1_I1666_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I214_MP3 (XI1_I1666_I214_p1 I1_I1666_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I214_MP0 (VDD I1_I1666_pn11 XI1_I1666_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I212_MP1 (VDD I1_I1666_G8_0n XI1_I1666_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I212_MP5 (I1_p24_9 XI1_I1666_I212_Bn XI1_I1666_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I212_MP4 (XI1_I1666_I212_p1 XI1_I1666_I212_An I1_p24_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I212_MP2 (VDD I1_I1666_pn9 XI1_I1666_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I212_MP3 (XI1_I1666_I212_p1 I1_I1666_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I212_MP0 (VDD I1_I1666_pn9 XI1_I1666_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1644_MP1 (VDD I1_qu8_b3_1 XI1_I1644_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1644_MP5 (I1_b24_10 XI1_I1644_Bn XI1_I1644_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1644_MP4 (XI1_I1644_p1 XI1_I1644_An I1_b24_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1644_MP2 (VDD I1_dd10_b3_4 XI1_I1644_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1644_MP3 (XI1_I1644_p1 I1_qu8_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1644_MP0 (VDD I1_dd10_b3_4 XI1_I1644_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1641_MP1 (VDD I1_qu8_b3_1 XI1_I1641_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1641_MP5 (I1_b24_7 XI1_I1641_Bn XI1_I1641_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1641_MP4 (XI1_I1641_p1 XI1_I1641_An I1_b24_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1641_MP2 (VDD I1_dd7_b3_4 XI1_I1641_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1641_MP3 (XI1_I1641_p1 I1_qu8_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1641_MP0 (VDD I1_dd7_b3_4 XI1_I1641_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1602_MP1 (VDD I1_qu9_b3_2 XI1_I1602_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1602_MP5 (I1_b23_14 XI1_I1602_Bn XI1_I1602_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1602_MP4 (XI1_I1602_p1 XI1_I1602_An I1_b23_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1602_MP2 (VDD I1_dd14_b3_4 XI1_I1602_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1602_MP3 (XI1_I1602_p1 I1_qu9_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1602_MP0 (VDD I1_dd14_b3_4 XI1_I1602_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1600_MP1 (VDD I1_qu9_b3_2 XI1_I1600_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1600_MP5 (I1_b23_12 XI1_I1600_Bn XI1_I1600_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1600_MP4 (XI1_I1600_p1 XI1_I1600_An I1_b23_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1600_MP2 (VDD I1_dd12_b3_4 XI1_I1600_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1600_MP3 (XI1_I1600_p1 I1_qu9_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1600_MP0 (VDD I1_dd12_b3_4 XI1_I1600_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1601_MP1 (VDD I1_qu9_b3_2 XI1_I1601_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1601_MP5 (I1_b23_13 XI1_I1601_Bn XI1_I1601_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1601_MP4 (XI1_I1601_p1 XI1_I1601_An I1_b23_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1601_MP2 (VDD I1_dd13_b3_4 XI1_I1601_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1601_MP3 (XI1_I1601_p1 I1_qu9_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1601_MP0 (VDD I1_dd13_b3_4 XI1_I1601_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I207_MP1 (VDD I1_I1620_G3_0n XI1_I1620_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I207_MP5 (I1_p23_4 XI1_I1620_I207_Bn XI1_I1620_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I207_MP4 (XI1_I1620_I207_p1 XI1_I1620_I207_An I1_p23_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I207_MP2 (VDD I1_I1620_pn4 XI1_I1620_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I207_MP3 (XI1_I1620_I207_p1 I1_I1620_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I207_MP0 (VDD I1_I1620_pn4 XI1_I1620_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I15_MP1 (VDD I2_I1_SUB_b3_0 XI2_I1_I15_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I15_MP5 (I2_I1_bx5 XI2_I1_I15_Bn XI2_I1_I15_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I15_MP4 (XI2_I1_I15_p1 XI2_I1_I15_An I2_I1_bx5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I15_MP2 (VDD B_5 XI2_I1_I15_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I15_MP3 (XI2_I1_I15_p1 I2_I1_SUB_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I15_MP0 (VDD B_5 XI2_I1_I15_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I207_MP1 (VDD I2_I1_I42_G3_0n XI2_I1_I42_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I207_MP5 (I2_S_4 XI2_I1_I42_I207_Bn XI2_I1_I42_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I207_MP4 (XI2_I1_I42_I207_p1 XI2_I1_I42_I207_An I2_S_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I207_MP2 (VDD I2_I1_I42_pn4 XI2_I1_I42_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I207_MP3 (XI2_I1_I42_I207_p1 I2_I1_I42_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I207_MP0 (VDD I2_I1_I42_pn4 XI2_I1_I42_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1757_MP1 (VDD I1_qu6_b3_5 XI1_I1757_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1757_MP5 (I1_b26_31 XI1_I1757_Bn XI1_I1757_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1757_MP4 (XI1_I1757_p1 XI1_I1757_An I1_b26_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1757_MP2 (VDD I1_dd31_b3_4 XI1_I1757_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1757_MP3 (XI1_I1757_p1 I1_qu6_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1757_MP0 (VDD I1_dd31_b3_4 XI1_I1757_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1749_MP1 (VDD I1_qu6_b3_3 XI1_I1749_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1749_MP5 (I1_b26_23 XI1_I1749_Bn XI1_I1749_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1749_MP4 (XI1_I1749_p1 XI1_I1749_An I1_b26_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1749_MP2 (VDD I1_dd23_b3_4 XI1_I1749_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1749_MP3 (XI1_I1749_p1 I1_qu6_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1749_MP0 (VDD I1_dd23_b3_4 XI1_I1749_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1748_MP1 (VDD I1_qu6_b3_3 XI1_I1748_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1748_MP5 (I1_b26_22 XI1_I1748_Bn XI1_I1748_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1748_MP4 (XI1_I1748_p1 XI1_I1748_An I1_b26_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1748_MP2 (VDD I1_dd22_b3_4 XI1_I1748_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1748_MP3 (XI1_I1748_p1 I1_qu6_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1748_MP0 (VDD I1_dd22_b3_4 XI1_I1748_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1746_MP1 (VDD I1_qu6_b3_3 XI1_I1746_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1746_MP5 (I1_b26_20 XI1_I1746_Bn XI1_I1746_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1746_MP4 (XI1_I1746_p1 XI1_I1746_An I1_b26_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1746_MP2 (VDD I1_dd20_b3_4 XI1_I1746_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1746_MP3 (XI1_I1746_p1 I1_qu6_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1746_MP0 (VDD I1_dd20_b3_4 XI1_I1746_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1745_MP1 (VDD I1_qu6_b3_3 XI1_I1745_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1745_MP5 (I1_b26_19 XI1_I1745_Bn XI1_I1745_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1745_MP4 (XI1_I1745_p1 XI1_I1745_An I1_b26_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1745_MP2 (VDD I1_dd19_b3_4 XI1_I1745_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1745_MP3 (XI1_I1745_p1 I1_qu6_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1745_MP0 (VDD I1_dd19_b3_4 XI1_I1745_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1739_MP1 (VDD I1_qu6_b3_2 XI1_I1739_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1739_MP5 (I1_b26_13 XI1_I1739_Bn XI1_I1739_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1739_MP4 (XI1_I1739_p1 XI1_I1739_An I1_b26_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1739_MP2 (VDD I1_dd13_b3_4 XI1_I1739_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1739_MP3 (XI1_I1739_p1 I1_qu6_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1739_MP0 (VDD I1_dd13_b3_4 XI1_I1739_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1743_MP1 (VDD I1_qu6_b3_2 XI1_I1743_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1743_MP5 (I1_b26_17 XI1_I1743_Bn XI1_I1743_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1743_MP4 (XI1_I1743_p1 XI1_I1743_An I1_b26_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1743_MP2 (VDD I1_dd17_b3_4 XI1_I1743_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1743_MP3 (XI1_I1743_p1 I1_qu6_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1743_MP0 (VDD I1_dd17_b3_4 XI1_I1743_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1742_MP1 (VDD I1_qu6_b3_2 XI1_I1742_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1742_MP5 (I1_b26_16 XI1_I1742_Bn XI1_I1742_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1742_MP4 (XI1_I1742_p1 XI1_I1742_An I1_b26_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1742_MP2 (VDD I1_dd16_b3_4 XI1_I1742_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1742_MP3 (XI1_I1742_p1 I1_qu6_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1742_MP0 (VDD I1_dd16_b3_4 XI1_I1742_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1738_MP1 (VDD I1_qu6_b3_2 XI1_I1738_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1738_MP5 (I1_b26_12 XI1_I1738_Bn XI1_I1738_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1738_MP4 (XI1_I1738_p1 XI1_I1738_An I1_b26_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1738_MP2 (VDD I1_dd12_b3_4 XI1_I1738_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1738_MP3 (XI1_I1738_p1 I1_qu6_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1738_MP0 (VDD I1_dd12_b3_4 XI1_I1738_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I216_MP1 (VDD I1_I1666_G12_0n XI1_I1666_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I216_MP5 (I1_p24_13 XI1_I1666_I216_Bn XI1_I1666_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I216_MP4 (XI1_I1666_I216_p1 XI1_I1666_I216_An I1_p24_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I216_MP2 (VDD I1_I1666_pn13 XI1_I1666_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I216_MP3 (XI1_I1666_I216_p1 I1_I1666_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I216_MP0 (VDD I1_I1666_pn13 XI1_I1666_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I215_MP1 (VDD I1_I1666_G11_0n XI1_I1666_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I215_MP5 (I1_p24_12 XI1_I1666_I215_Bn XI1_I1666_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I215_MP4 (XI1_I1666_I215_p1 XI1_I1666_I215_An I1_p24_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I215_MP2 (VDD I1_I1666_pn12 XI1_I1666_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I215_MP3 (XI1_I1666_I215_p1 I1_I1666_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I215_MP0 (VDD I1_I1666_pn12 XI1_I1666_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1645_MP1 (VDD I1_qu8_b3_1 XI1_I1645_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1645_MP5 (I1_b24_11 XI1_I1645_Bn XI1_I1645_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1645_MP4 (XI1_I1645_p1 XI1_I1645_An I1_b24_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1645_MP2 (VDD I1_dd11_b3_4 XI1_I1645_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1645_MP3 (XI1_I1645_p1 I1_qu8_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1645_MP0 (VDD I1_dd11_b3_4 XI1_I1645_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1646_MP1 (VDD I1_qu8_b3_2 XI1_I1646_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1646_MP5 (I1_b24_12 XI1_I1646_Bn XI1_I1646_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1646_MP4 (XI1_I1646_p1 XI1_I1646_An I1_b24_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1646_MP2 (VDD I1_dd12_b3_4 XI1_I1646_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1646_MP3 (XI1_I1646_p1 I1_qu8_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1646_MP0 (VDD I1_dd12_b3_4 XI1_I1646_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1647_MP1 (VDD I1_qu8_b3_2 XI1_I1647_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1647_MP5 (I1_b24_13 XI1_I1647_Bn XI1_I1647_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1647_MP4 (XI1_I1647_p1 XI1_I1647_An I1_b24_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1647_MP2 (VDD I1_dd13_b3_4 XI1_I1647_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1647_MP3 (XI1_I1647_p1 I1_qu8_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1647_MP0 (VDD I1_dd13_b3_4 XI1_I1647_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1603_MP1 (VDD I1_qu9_b3_2 XI1_I1603_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1603_MP5 (I1_b23_15 XI1_I1603_Bn XI1_I1603_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1603_MP4 (XI1_I1603_p1 XI1_I1603_An I1_b23_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1603_MP2 (VDD I1_dd15_b3_4 XI1_I1603_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1603_MP3 (XI1_I1603_p1 I1_qu9_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1603_MP0 (VDD I1_dd15_b3_4 XI1_I1603_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1604_MP1 (VDD I1_qu9_b3_2 XI1_I1604_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1604_MP5 (I1_b23_16 XI1_I1604_Bn XI1_I1604_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1604_MP4 (XI1_I1604_p1 XI1_I1604_An I1_b23_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1604_MP2 (VDD I1_dd16_b3_4 XI1_I1604_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1604_MP3 (XI1_I1604_p1 I1_qu9_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1604_MP0 (VDD I1_dd16_b3_4 XI1_I1604_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I212_MP1 (VDD I1_I1620_G8_0n XI1_I1620_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I212_MP5 (I1_p23_9 XI1_I1620_I212_Bn XI1_I1620_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I212_MP4 (XI1_I1620_I212_p1 XI1_I1620_I212_An I1_p23_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I212_MP2 (VDD I1_I1620_pn9 XI1_I1620_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I212_MP3 (XI1_I1620_I212_p1 I1_I1620_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I212_MP0 (VDD I1_I1620_pn9 XI1_I1620_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I213_MP1 (VDD I1_I1620_G9_0n XI1_I1620_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I213_MP5 (I1_p23_10 XI1_I1620_I213_Bn XI1_I1620_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I213_MP4 (XI1_I1620_I213_p1 XI1_I1620_I213_An I1_p23_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I213_MP2 (VDD I1_I1620_pn10 XI1_I1620_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I213_MP3 (XI1_I1620_I213_p1 I1_I1620_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I213_MP0 (VDD I1_I1620_pn10 XI1_I1620_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I14_MP1 (VDD I2_I1_SUB_b3_0 XI2_I1_I14_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I14_MP5 (I2_I1_bx4 XI2_I1_I14_Bn XI2_I1_I14_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I14_MP4 (XI2_I1_I14_p1 XI2_I1_I14_An I2_I1_bx4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I14_MP2 (VDD B_4 XI2_I1_I14_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I14_MP3 (XI2_I1_I14_p1 I2_I1_SUB_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I14_MP0 (VDD B_4 XI2_I1_I14_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I206_MP1 (VDD I2_I1_I42_G2_0n XI2_I1_I42_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I206_MP5 (I2_S_3 XI2_I1_I42_I206_Bn XI2_I1_I42_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I206_MP4 (XI2_I1_I42_I206_p1 XI2_I1_I42_I206_An I2_S_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I206_MP2 (VDD I2_I1_I42_pn3 XI2_I1_I42_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I206_MP3 (XI2_I1_I42_I206_p1 I2_I1_I42_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I206_MP0 (VDD I2_I1_I42_pn3 XI2_I1_I42_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1756_MP1 (VDD I1_qu6_b3_5 XI1_I1756_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1756_MP5 (I1_b26_30 XI1_I1756_Bn XI1_I1756_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1756_MP4 (XI1_I1756_p1 XI1_I1756_An I1_b26_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1756_MP2 (VDD I1_dd30_b3_4 XI1_I1756_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1756_MP3 (XI1_I1756_p1 I1_qu6_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1756_MP0 (VDD I1_dd30_b3_4 XI1_I1756_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1740_MP1 (VDD I1_qu6_b3_2 XI1_I1740_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1740_MP5 (I1_b26_14 XI1_I1740_Bn XI1_I1740_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1740_MP4 (XI1_I1740_p1 XI1_I1740_An I1_b26_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1740_MP2 (VDD I1_dd14_b3_4 XI1_I1740_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1740_MP3 (XI1_I1740_p1 I1_qu6_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1740_MP0 (VDD I1_dd14_b3_4 XI1_I1740_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1785_MP1 (VDD I1_qu5_b3_2 XI1_I1785_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1785_MP5 (I1_b27_13 XI1_I1785_Bn XI1_I1785_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1785_MP4 (XI1_I1785_p1 XI1_I1785_An I1_b27_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1785_MP2 (VDD I1_dd13_b3_4 XI1_I1785_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1785_MP3 (XI1_I1785_p1 I1_qu5_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1785_MP0 (VDD I1_dd13_b3_4 XI1_I1785_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1786_MP1 (VDD I1_qu5_b3_2 XI1_I1786_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1786_MP5 (I1_b27_14 XI1_I1786_Bn XI1_I1786_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1786_MP4 (XI1_I1786_p1 XI1_I1786_An I1_b27_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1786_MP2 (VDD I1_dd14_b3_4 XI1_I1786_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1786_MP3 (XI1_I1786_p1 I1_qu5_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1786_MP0 (VDD I1_dd14_b3_4 XI1_I1786_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1784_MP1 (VDD I1_qu5_b3_2 XI1_I1784_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1784_MP5 (I1_b27_12 XI1_I1784_Bn XI1_I1784_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1784_MP4 (XI1_I1784_p1 XI1_I1784_An I1_b27_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1784_MP2 (VDD I1_dd12_b3_4 XI1_I1784_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1784_MP3 (XI1_I1784_p1 I1_qu5_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1784_MP0 (VDD I1_dd12_b3_4 XI1_I1784_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1736_MP1 (VDD I1_qu6_b3_1 XI1_I1736_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1736_MP5 (I1_b26_10 XI1_I1736_Bn XI1_I1736_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1736_MP4 (XI1_I1736_p1 XI1_I1736_An I1_b26_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1736_MP2 (VDD I1_dd10_b3_4 XI1_I1736_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1736_MP3 (XI1_I1736_p1 I1_qu6_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1736_MP0 (VDD I1_dd10_b3_4 XI1_I1736_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1737_MP1 (VDD I1_qu6_b3_1 XI1_I1737_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1737_MP5 (I1_b26_11 XI1_I1737_Bn XI1_I1737_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1737_MP4 (XI1_I1737_p1 XI1_I1737_An I1_b26_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1737_MP2 (VDD I1_dd11_b3_4 XI1_I1737_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1737_MP3 (XI1_I1737_p1 I1_qu6_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1737_MP0 (VDD I1_dd11_b3_4 XI1_I1737_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I217_MP1 (VDD I1_I1666_G13_0n XI1_I1666_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I217_MP5 (I1_p24_14 XI1_I1666_I217_Bn XI1_I1666_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I217_MP4 (XI1_I1666_I217_p1 XI1_I1666_I217_An I1_p24_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I217_MP2 (VDD I1_I1666_pn14 XI1_I1666_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I217_MP3 (XI1_I1666_I217_p1 I1_I1666_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I217_MP0 (VDD I1_I1666_pn14 XI1_I1666_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1648_MP1 (VDD I1_qu8_b3_2 XI1_I1648_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1648_MP5 (I1_b24_14 XI1_I1648_Bn XI1_I1648_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1648_MP4 (XI1_I1648_p1 XI1_I1648_An I1_b24_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1648_MP2 (VDD I1_dd14_b3_4 XI1_I1648_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1648_MP3 (XI1_I1648_p1 I1_qu8_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1648_MP0 (VDD I1_dd14_b3_4 XI1_I1648_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1605_MP1 (VDD I1_qu9_b3_2 XI1_I1605_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1605_MP5 (I1_b23_17 XI1_I1605_Bn XI1_I1605_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1605_MP4 (XI1_I1605_p1 XI1_I1605_An I1_b23_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1605_MP2 (VDD I1_dd17_b3_4 XI1_I1605_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1605_MP3 (XI1_I1605_p1 I1_qu9_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1605_MP0 (VDD I1_dd17_b3_4 XI1_I1605_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I214_MP1 (VDD I1_I1620_G10_0n XI1_I1620_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I214_MP5 (I1_p23_11 XI1_I1620_I214_Bn XI1_I1620_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I214_MP4 (XI1_I1620_I214_p1 XI1_I1620_I214_An I1_p23_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I214_MP2 (VDD I1_I1620_pn11 XI1_I1620_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I214_MP3 (XI1_I1620_I214_p1 I1_I1620_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I214_MP0 (VDD I1_I1620_pn11 XI1_I1620_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I216_MP1 (VDD I1_I1620_G12_0n XI1_I1620_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I216_MP5 (I1_p23_13 XI1_I1620_I216_Bn XI1_I1620_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I216_MP4 (XI1_I1620_I216_p1 XI1_I1620_I216_An I1_p23_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I216_MP2 (VDD I1_I1620_pn13 XI1_I1620_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I216_MP3 (XI1_I1620_I216_p1 I1_I1620_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I216_MP0 (VDD I1_I1620_pn13 XI1_I1620_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I215_MP1 (VDD I1_I1620_G11_0n XI1_I1620_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I215_MP5 (I1_p23_12 XI1_I1620_I215_Bn XI1_I1620_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I215_MP4 (XI1_I1620_I215_p1 XI1_I1620_I215_An I1_p23_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I215_MP2 (VDD I1_I1620_pn12 XI1_I1620_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I215_MP3 (XI1_I1620_I215_p1 I1_I1620_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I215_MP0 (VDD I1_I1620_pn12 XI1_I1620_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I13_MP1 (VDD I2_I1_SUB_b3_0 XI2_I1_I13_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I13_MP5 (I2_I1_bx3 XI2_I1_I13_Bn XI2_I1_I13_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I13_MP4 (XI2_I1_I13_p1 XI2_I1_I13_An I2_I1_bx3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I13_MP2 (VDD B_3 XI2_I1_I13_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I13_MP3 (XI2_I1_I13_p1 I2_I1_SUB_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I13_MP0 (VDD B_3 XI2_I1_I13_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I12_MP1 (VDD I2_I1_SUB_b3_0 XI2_I1_I12_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I12_MP5 (I2_I1_bx2 XI2_I1_I12_Bn XI2_I1_I12_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I12_MP4 (XI2_I1_I12_p1 XI2_I1_I12_An I2_I1_bx2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I12_MP2 (VDD B_2 XI2_I1_I12_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I12_MP3 (XI2_I1_I12_p1 I2_I1_SUB_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I12_MP0 (VDD B_2 XI2_I1_I12_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1788_MP1 (VDD I1_qu5_b3_2 XI1_I1788_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1788_MP5 (I1_b27_16 XI1_I1788_Bn XI1_I1788_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1788_MP4 (XI1_I1788_p1 XI1_I1788_An I1_b27_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1788_MP2 (VDD I1_dd16_b3_4 XI1_I1788_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1788_MP3 (XI1_I1788_p1 I1_qu5_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1788_MP0 (VDD I1_dd16_b3_4 XI1_I1788_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1787_MP1 (VDD I1_qu5_b3_2 XI1_I1787_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1787_MP5 (I1_b27_15 XI1_I1787_Bn XI1_I1787_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1787_MP4 (XI1_I1787_p1 XI1_I1787_An I1_b27_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1787_MP2 (VDD I1_dd15_b3_4 XI1_I1787_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1787_MP3 (XI1_I1787_p1 I1_qu5_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1787_MP0 (VDD I1_dd15_b3_4 XI1_I1787_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1734_MP1 (VDD I1_qu6_b3_1 XI1_I1734_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1734_MP5 (I1_b26_8 XI1_I1734_Bn XI1_I1734_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1734_MP4 (XI1_I1734_p1 XI1_I1734_An I1_b26_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1734_MP2 (VDD I1_dd8_b3_4 XI1_I1734_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1734_MP3 (XI1_I1734_p1 I1_qu6_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1734_MP0 (VDD I1_dd8_b3_4 XI1_I1734_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1735_MP1 (VDD I1_qu6_b3_1 XI1_I1735_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1735_MP5 (I1_b26_9 XI1_I1735_Bn XI1_I1735_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1735_MP4 (XI1_I1735_p1 XI1_I1735_An I1_b26_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1735_MP2 (VDD I1_dd9_b3_4 XI1_I1735_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1735_MP3 (XI1_I1735_p1 I1_qu6_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1735_MP0 (VDD I1_dd9_b3_4 XI1_I1735_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I218_MP1 (VDD I1_I1666_G14_0n XI1_I1666_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I218_MP5 (I1_p24_15 XI1_I1666_I218_Bn XI1_I1666_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I218_MP4 (XI1_I1666_I218_p1 XI1_I1666_I218_An I1_p24_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I218_MP2 (VDD I1_I1666_pn15 XI1_I1666_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I218_MP3 (XI1_I1666_I218_p1 I1_I1666_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I218_MP0 (VDD I1_I1666_pn15 XI1_I1666_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I219_MP1 (VDD I1_I1666_G15_0n XI1_I1666_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I219_MP5 (I1_p24_16 XI1_I1666_I219_Bn XI1_I1666_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I219_MP4 (XI1_I1666_I219_p1 XI1_I1666_I219_An I1_p24_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I219_MP2 (VDD I1_I1666_pn16 XI1_I1666_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I219_MP3 (XI1_I1666_I219_p1 I1_I1666_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I219_MP0 (VDD I1_I1666_pn16 XI1_I1666_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1650_MP1 (VDD I1_qu8_b3_2 XI1_I1650_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1650_MP5 (I1_b24_16 XI1_I1650_Bn XI1_I1650_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1650_MP4 (XI1_I1650_p1 XI1_I1650_An I1_b24_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1650_MP2 (VDD I1_dd16_b3_4 XI1_I1650_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1650_MP3 (XI1_I1650_p1 I1_qu8_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1650_MP0 (VDD I1_dd16_b3_4 XI1_I1650_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1649_MP1 (VDD I1_qu8_b3_2 XI1_I1649_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1649_MP5 (I1_b24_15 XI1_I1649_Bn XI1_I1649_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1649_MP4 (XI1_I1649_p1 XI1_I1649_An I1_b24_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1649_MP2 (VDD I1_dd15_b3_4 XI1_I1649_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1649_MP3 (XI1_I1649_p1 I1_qu8_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1649_MP0 (VDD I1_dd15_b3_4 XI1_I1649_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I218_MP1 (VDD I1_I1620_G14_0n XI1_I1620_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I218_MP5 (I1_p23_15 XI1_I1620_I218_Bn XI1_I1620_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I218_MP4 (XI1_I1620_I218_p1 XI1_I1620_I218_An I1_p23_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I218_MP2 (VDD I1_I1620_pn15 XI1_I1620_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I218_MP3 (XI1_I1620_I218_p1 I1_I1620_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I218_MP0 (VDD I1_I1620_pn15 XI1_I1620_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1622_MP1 (VDD I1_c23_o XI1_I1622_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1622_MP5 (I1_p23_32 XI1_I1622_Bn XI1_I1622_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1622_MP4 (XI1_I1622_p1 XI1_I1622_An I1_p23_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1622_MP2 (VDD I1_h23 XI1_I1622_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1622_MP3 (XI1_I1622_p1 I1_c23_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1622_MP0 (VDD I1_h23 XI1_I1622_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I217_MP1 (VDD I1_I1620_G13_0n XI1_I1620_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I217_MP5 (I1_p23_14 XI1_I1620_I217_Bn XI1_I1620_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I217_MP4 (XI1_I1620_I217_p1 XI1_I1620_I217_An I1_p23_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I217_MP2 (VDD I1_I1620_pn14 XI1_I1620_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I217_MP3 (XI1_I1620_I217_p1 I1_I1620_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I217_MP0 (VDD I1_I1620_pn14 XI1_I1620_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I64_MP1 (VDD B_10 XI2_I2_I64_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I64_MP5 (I2_XOR_10 XI2_I2_I64_Bn XI2_I2_I64_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I64_MP4 (XI2_I2_I64_p1 XI2_I2_I64_An I2_XOR_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I64_MP2 (VDD A_10 XI2_I2_I64_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I64_MP3 (XI2_I2_I64_p1 B_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I64_MP0 (VDD A_10 XI2_I2_I64_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I40_MP1 (VDD B_6 XI2_I2_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I40_MP5 (I2_XOR_6 XI2_I2_I40_Bn XI2_I2_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I40_MP4 (XI2_I2_I40_p1 XI2_I2_I40_An I2_XOR_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I40_MP2 (VDD A_6 XI2_I2_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I2_I40_MP3 (XI2_I2_I40_p1 B_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I40_MP0 (VDD A_6 XI2_I2_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I10_MP1 (VDD I2_I1_SUB_b3_0 XI2_I1_I10_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I10_MP5 (I2_I1_bx0 XI2_I1_I10_Bn XI2_I1_I10_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I10_MP4 (XI2_I1_I10_p1 XI2_I1_I10_An I2_I1_bx0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I10_MP2 (VDD B_0 XI2_I1_I10_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I10_MP3 (XI2_I1_I10_p1 I2_I1_SUB_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I10_MP0 (VDD B_0 XI2_I1_I10_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I11_MP1 (VDD I2_I1_SUB_b3_0 XI2_I1_I11_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I11_MP5 (I2_I1_bx1 XI2_I1_I11_Bn XI2_I1_I11_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I11_MP4 (XI2_I1_I11_p1 XI2_I1_I11_An I2_I1_bx1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I11_MP2 (VDD B_1 XI2_I1_I11_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I11_MP3 (XI2_I1_I11_p1 I2_I1_SUB_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I11_MP0 (VDD B_1 XI2_I1_I11_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1789_MP1 (VDD I1_qu5_b3_2 XI1_I1789_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1789_MP5 (I1_b27_17 XI1_I1789_Bn XI1_I1789_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1789_MP4 (XI1_I1789_p1 XI1_I1789_An I1_b27_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
