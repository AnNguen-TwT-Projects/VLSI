    I_MXI1_I562_I147_XG_MN0 (I1_I562_G22_15 I1_I562_P22_19n XI1_I562_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I147_XG_MN1 (XI1_I562_I147_XG_n1 I1_I562_G18_15n I1_I562_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I151_XG_MN2 (XI1_I562_I151_XG_n1 I1_I562_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I151_XG_MN0 (I1_I562_G26_19 I1_I562_P26_23n XI1_I562_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I151_XG_MN1 (XI1_I562_I151_XG_n1 I1_I562_G22_19n I1_I562_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I153_XG_MN2 (XI1_I562_I153_XG_n1 I1_I562_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I153_XG_MN0 (I1_I562_G28_21 I1_I562_P28_25n XI1_I562_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I153_XG_MN1 (XI1_I562_I153_XG_n1 I1_I562_G24_21n I1_I562_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I155_XG_MN2 (XI1_I562_I155_XG_n1 I1_I562_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I155_XG_MN0 (I1_I562_G30_23 I1_I562_P30_27n XI1_I562_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I155_XG_MN1 (XI1_I562_I155_XG_n1 I1_I562_G26_23n I1_I562_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I97_XG_MN2 (XI1_I562_I97_XG_n1 I1_I562_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I97_XG_MN0 (I1_I562_G31_30 I1_I562_pn31 XI1_I562_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I97_XG_MN1 (XI1_I562_I97_XG_n1 I1_I562_gn30 I1_I562_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I96_XG_MN2 (XI1_I562_I96_XG_n1 I1_I562_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I96_XG_MN0 (I1_I562_G30_29 I1_I562_pn30 XI1_I562_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I96_XG_MN1 (XI1_I562_I96_XG_n1 I1_I562_gn29 I1_I562_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I96_XG_MN2 (XI1_I1528_I96_XG_n1 I1_I1528_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I96_XG_MN0 (I1_I1528_G30_29 I1_I1528_pn30 XI1_I1528_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I96_XG_MN1 (XI1_I1528_I96_XG_n1 I1_I1528_gn29 I1_I1528_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I92_XG_MN2 (XI1_I1528_I92_XG_n1 I1_I1528_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I92_XG_MN0 (I1_I1528_G26_25 I1_I1528_pn26 XI1_I1528_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I92_XG_MN1 (XI1_I1528_I92_XG_n1 I1_I1528_gn25 I1_I1528_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I91_XG_MN2 (XI1_I1528_I91_XG_n1 I1_I1528_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I91_XG_MN0 (I1_I1528_G25_24 I1_I1528_pn25 XI1_I1528_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I91_XG_MN1 (XI1_I1528_I91_XG_n1 I1_I1528_gn24 I1_I1528_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I155_XG_MN2 (XI1_I1528_I155_XG_n1 I1_I1528_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I155_XG_MN0 (I1_I1528_G30_23 I1_I1528_P30_27n XI1_I1528_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I155_XG_MN1 (XI1_I1528_I155_XG_n1 I1_I1528_G26_23n I1_I1528_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I201_XG_MN2 (XI1_I1528_I201_XG_n1 I1_I1528_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I201_XG_MN0 (I1_c21_m I1_I1528_P30_15n XI1_I1528_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I201_XG_MN1 (XI1_I1528_I201_XG_n1 I1_I1528_G14_0n I1_c21_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I199_XG_MN2 (XI1_I1528_I199_XG_n1 I1_I1528_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I199_XG_MN0 (I1_I1528_G28_0 I1_I1528_P28_13n XI1_I1528_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I199_XG_MN1 (XI1_I1528_I199_XG_n1 I1_I1528_G12_0n I1_I1528_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I78_XG_MN2 (XI1_I1574_I78_XG_n1 I1_I1574_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I78_XG_MN0 (I1_I1574_G12_11 I1_I1574_pn12 XI1_I1574_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I78_XG_MN1 (XI1_I1574_I78_XG_n1 I1_I1574_gn11 I1_I1574_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I77_XG_MN2 (XI1_I1574_I77_XG_n1 I1_I1574_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I77_XG_MN0 (I1_I1574_G11_10 I1_I1574_pn11 XI1_I1574_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I77_XG_MN1 (XI1_I1574_I77_XG_n1 I1_I1574_gn10 I1_I1574_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I76_XG_MN2 (XI1_I1574_I76_XG_n1 I1_I1574_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I76_XG_MN0 (I1_I1574_G10_9 I1_I1574_pn10 XI1_I1574_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I76_XG_MN1 (XI1_I1574_I76_XG_n1 I1_I1574_gn9 I1_I1574_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I75_XG_MN2 (XI1_I1574_I75_XG_n1 I1_I1574_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I75_XG_MN0 (I1_I1574_G9_8 I1_I1574_pn9 XI1_I1574_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I75_XG_MN1 (XI1_I1574_I75_XG_n1 I1_I1574_gn8 I1_I1574_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I73_XG_MN2 (XI1_I562_I73_XG_n1 I1_I562_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I73_XG_MN0 (I1_I562_G7_6 I1_I562_pn7 XI1_I562_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I73_XG_MN1 (XI1_I562_I73_XG_n1 I1_I562_gn6 I1_I562_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I77_XG_MN2 (XI1_I562_I77_XG_n1 I1_I562_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I77_XG_MN0 (I1_I562_G11_10 I1_I562_pn11 XI1_I562_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I77_XG_MN1 (XI1_I562_I77_XG_n1 I1_I562_gn10 I1_I562_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I78_XG_MN2 (XI1_I562_I78_XG_n1 I1_I562_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I78_XG_MN0 (I1_I562_G12_11 I1_I562_pn12 XI1_I562_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I78_XG_MN1 (XI1_I562_I78_XG_n1 I1_I562_gn11 I1_I562_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I79_XG_MN2 (XI1_I562_I79_XG_n1 I1_I562_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I79_XG_MN0 (I1_I562_G13_12 I1_I562_pn13 XI1_I562_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I79_XG_MN1 (XI1_I562_I79_XG_n1 I1_I562_gn12 I1_I562_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I80_XG_MN2 (XI1_I562_I80_XG_n1 I1_I562_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I80_XG_MN0 (I1_I562_G14_13 I1_I562_pn14 XI1_I562_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I80_XG_MN1 (XI1_I562_I80_XG_n1 I1_I562_gn13 I1_I562_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I82_XG_MN2 (XI1_I562_I82_XG_n1 I1_I562_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I82_XG_MN0 (I1_I562_G16_15 I1_I562_pn16 XI1_I562_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I82_XG_MN1 (XI1_I562_I82_XG_n1 I1_I562_gn15 I1_I562_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I86_XG_MN2 (XI1_I562_I86_XG_n1 I1_I562_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I86_XG_MN0 (I1_I562_G20_19 I1_I562_pn20 XI1_I562_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I86_XG_MN1 (XI1_I562_I86_XG_n1 I1_I562_gn19 I1_I562_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I198_XG_MN2 (XI1_I1712_I198_XG_n1 I1_I1712_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I198_XG_MN0 (I1_I1712_G27_0 I1_I1712_P27_12n XI1_I1712_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I198_XG_MN1 (XI1_I1712_I198_XG_n1 I1_I1712_G11_0n I1_I1712_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I97_XG_MN2 (XI1_I1528_I97_XG_n1 I1_I1528_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I97_XG_MN0 (I1_I1528_G31_30 I1_I1528_pn31 XI1_I1528_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I97_XG_MN1 (XI1_I1528_I97_XG_n1 I1_I1528_gn30 I1_I1528_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I194_XG_MN2 (XI1_I1712_I194_XG_n1 I1_I1712_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I194_XG_MN0 (I1_I1712_G23_0 I1_I1712_P23_8n XI1_I1712_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I194_XG_MN1 (XI1_I1712_I194_XG_n1 I1_I1712_G7_0n I1_I1712_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I95_XG_MN2 (XI1_I1528_I95_XG_n1 I1_I1528_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I95_XG_MN0 (I1_I1528_G29_28 I1_I1528_pn29 XI1_I1528_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I95_XG_MN1 (XI1_I1528_I95_XG_n1 I1_I1528_gn28 I1_I1528_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I154_XG_MN2 (XI1_I1528_I154_XG_n1 I1_I1528_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I154_XG_MN0 (I1_I1528_G29_22 I1_I1528_P29_26n XI1_I1528_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I154_XG_MN1 (XI1_I1528_I154_XG_n1 I1_I1528_G25_22n I1_I1528_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I148_XG_MN2 (XI1_I1528_I148_XG_n1 I1_I1528_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I148_XG_MN0 (I1_I1528_G23_16 I1_I1528_P23_20n XI1_I1528_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I148_XG_MN1 (XI1_I1528_I148_XG_n1 I1_I1528_G19_16n I1_I1528_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I150_XG_MN2 (XI1_I1528_I150_XG_n1 I1_I1528_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I150_XG_MN0 (I1_I1528_G25_18 I1_I1528_P25_22n XI1_I1528_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I150_XG_MN1 (XI1_I1528_I150_XG_n1 I1_I1528_G21_18n I1_I1528_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I146_XG_MN2 (XI1_I1528_I146_XG_n1 I1_I1528_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I146_XG_MN0 (I1_I1528_G21_14 I1_I1528_P21_18n XI1_I1528_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I146_XG_MN1 (XI1_I1528_I146_XG_n1 I1_I1528_G17_14n I1_I1528_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I142_XG_MN2 (XI1_I1528_I142_XG_n1 I1_I1528_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I142_XG_MN0 (I1_I1528_G17_10 I1_I1528_P17_14n XI1_I1528_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I142_XG_MN1 (XI1_I1528_I142_XG_n1 I1_I1528_G13_10n I1_I1528_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I196_XG_MN2 (XI1_I1528_I196_XG_n1 I1_I1528_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I196_XG_MN0 (I1_I1528_G25_0 I1_I1528_P25_10n XI1_I1528_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I196_XG_MN1 (XI1_I1528_I196_XG_n1 I1_I1528_G9_0n I1_I1528_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I138_XG_MN2 (XI1_I1528_I138_XG_n1 I1_I1528_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I138_XG_MN0 (I1_I1528_G13_6 I1_I1528_P13_10n XI1_I1528_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I138_XG_MN1 (XI1_I1528_I138_XG_n1 I1_I1528_G9_6n I1_I1528_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I132_XG_MN2 (XI1_I1528_I132_XG_n1 I1_I1528_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I132_XG_MN0 (I1_I1528_G7_0 I1_I1528_P7_4n XI1_I1528_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I132_XG_MN1 (XI1_I1528_I132_XG_n1 I1_I1528_G3_0n I1_I1528_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I134_XG_MN2 (XI1_I1528_I134_XG_n1 I1_I1528_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I134_XG_MN0 (I1_I1528_G9_2 I1_I1528_P9_6n XI1_I1528_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I134_XG_MN1 (XI1_I1528_I134_XG_n1 I1_I1528_G5_2n I1_I1528_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I130_XG_MN2 (XI1_I1528_I130_XG_n1 I1_I1528_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I130_XG_MN0 (I1_I1528_G5_0 I1_I1528_P5_2n XI1_I1528_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I130_XG_MN1 (XI1_I1528_I130_XG_n1 I1_I1528_G1_0n I1_I1528_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I140_XG_MN2 (XI1_I1574_I140_XG_n1 I1_I1574_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I140_XG_MN0 (I1_I1574_G15_8 I1_I1574_P15_12n XI1_I1574_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I140_XG_MN1 (XI1_I1574_I140_XG_n1 I1_I1574_G11_8n I1_I1574_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I186_XG_MN2 (XI1_I1574_I186_XG_n1 I1_I1574_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I186_XG_MN0 (I1_I1574_G19_0 I1_I1574_P19_4n XI1_I1574_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I186_XG_MN1 (XI1_I1574_I186_XG_n1 I1_I1574_G3_0n I1_I1574_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I136_XG_MN2 (XI1_I1574_I136_XG_n1 I1_I1574_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I136_XG_MN0 (I1_I1574_G11_4 I1_I1574_P11_8n XI1_I1574_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I136_XG_MN1 (XI1_I1574_I136_XG_n1 I1_I1574_G7_4n I1_I1574_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I79_XG_MN2 (XI1_I1574_I79_XG_n1 I1_I1574_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I79_XG_MN0 (I1_I1574_G13_12 I1_I1574_pn13 XI1_I1574_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I79_XG_MN1 (XI1_I1574_I79_XG_n1 I1_I1574_gn12 I1_I1574_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I74_XG_MN2 (XI1_I1574_I74_XG_n1 I1_I1574_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I74_XG_MN0 (I1_I1574_G8_7 I1_I1574_pn8 XI1_I1574_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I74_XG_MN1 (XI1_I1574_I74_XG_n1 I1_I1574_gn7 I1_I1574_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I73_XG_MN2 (XI1_I1574_I73_XG_n1 I1_I1574_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I73_XG_MN0 (I1_I1574_G7_6 I1_I1574_pn7 XI1_I1574_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I73_XG_MN1 (XI1_I1574_I73_XG_n1 I1_I1574_gn6 I1_I1574_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I81_XG_MN2 (XI1_I562_I81_XG_n1 I1_I562_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I81_XG_MN0 (I1_I562_G15_14 I1_I562_pn15 XI1_I562_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I81_XG_MN1 (XI1_I562_I81_XG_n1 I1_I562_gn14 I1_I562_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I85_XG_MN2 (XI1_I562_I85_XG_n1 I1_I562_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I85_XG_MN0 (I1_I562_G19_18 I1_I562_pn19 XI1_I562_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I85_XG_MN1 (XI1_I562_I85_XG_n1 I1_I562_gn18 I1_I562_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I87_XG_MN2 (XI1_I562_I87_XG_n1 I1_I562_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I87_XG_MN0 (I1_I562_G21_20 I1_I562_pn21 XI1_I562_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I87_XG_MN1 (XI1_I562_I87_XG_n1 I1_I562_gn20 I1_I562_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I88_XG_MN2 (XI1_I562_I88_XG_n1 I1_I562_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I88_XG_MN0 (I1_I562_G22_21 I1_I562_pn22 XI1_I562_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I88_XG_MN1 (XI1_I562_I88_XG_n1 I1_I562_gn21 I1_I562_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I94_XG_MN2 (XI1_I562_I94_XG_n1 I1_I562_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I94_XG_MN0 (I1_I562_G28_27 I1_I562_pn28 XI1_I562_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I94_XG_MN1 (XI1_I562_I94_XG_n1 I1_I562_gn27 I1_I562_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I95_XG_MN2 (XI1_I562_I95_XG_n1 I1_I562_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I95_XG_MN0 (I1_I562_G29_28 I1_I562_pn29 XI1_I562_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I95_XG_MN1 (XI1_I562_I95_XG_n1 I1_I562_gn28 I1_I562_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I156_XG_MN2 (XI1_I1712_I156_XG_n1 I1_I1712_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I156_XG_MN0 (I1_I1712_G31_24 I1_I1712_P31_28n XI1_I1712_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I156_XG_MN1 (XI1_I1712_I156_XG_n1 I1_I1712_G27_24n I1_I1712_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I152_XG_MN2 (XI1_I1712_I152_XG_n1 I1_I1712_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I152_XG_MN0 (I1_I1712_G27_20 I1_I1712_P27_24n XI1_I1712_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I152_XG_MN1 (XI1_I1712_I152_XG_n1 I1_I1712_G23_20n I1_I1712_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I148_XG_MN2 (XI1_I1712_I148_XG_n1 I1_I1712_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I148_XG_MN0 (I1_I1712_G23_16 I1_I1712_P23_20n XI1_I1712_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I148_XG_MN1 (XI1_I1712_I148_XG_n1 I1_I1712_G19_16n I1_I1712_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I202_XG_MN2 (XI1_I1712_I202_XG_n1 I1_I1712_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I202_XG_MN0 (I1_c25_o I1_I1712_P31_16n XI1_I1712_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I202_XG_MN1 (XI1_I1712_I202_XG_n1 I1_I1712_G15_0n I1_c25_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I156_XG_MN2 (XI1_I1528_I156_XG_n1 I1_I1528_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I156_XG_MN0 (I1_I1528_G31_24 I1_I1528_P31_28n XI1_I1528_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I156_XG_MN1 (XI1_I1528_I156_XG_n1 I1_I1528_G27_24n I1_I1528_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I152_XG_MN2 (XI1_I1528_I152_XG_n1 I1_I1528_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I152_XG_MN0 (I1_I1528_G27_20 I1_I1528_P27_24n XI1_I1528_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I152_XG_MN1 (XI1_I1528_I152_XG_n1 I1_I1528_G23_20n I1_I1528_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I144_XG_MN2 (XI1_I1528_I144_XG_n1 I1_I1528_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I144_XG_MN0 (I1_I1528_G19_12 I1_I1528_P19_16n XI1_I1528_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I144_XG_MN1 (XI1_I1528_I144_XG_n1 I1_I1528_G15_12n I1_I1528_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I140_XG_MN2 (XI1_I1528_I140_XG_n1 I1_I1528_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I140_XG_MN0 (I1_I1528_G15_8 I1_I1528_P15_12n XI1_I1528_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I140_XG_MN1 (XI1_I1528_I140_XG_n1 I1_I1528_G11_8n I1_I1528_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I136_XG_MN2 (XI1_I1528_I136_XG_n1 I1_I1528_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I136_XG_MN0 (I1_I1528_G11_4 I1_I1528_P11_8n XI1_I1528_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I136_XG_MN1 (XI1_I1528_I136_XG_n1 I1_I1528_G7_4n I1_I1528_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I184_XG_MN2 (XI1_I1528_I184_XG_n1 I1_I1528_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I184_XG_MN0 (I1_I1528_G17_0 I1_I1528_P17_2n XI1_I1528_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I184_XG_MN1 (XI1_I1528_I184_XG_n1 I1_I1528_G1_0n I1_I1528_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I198_XG_MN2 (XI1_I1574_I198_XG_n1 I1_I1574_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I198_XG_MN0 (I1_I1574_G27_0 I1_I1574_P27_12n XI1_I1574_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I198_XG_MN1 (XI1_I1574_I198_XG_n1 I1_I1574_G11_0n I1_I1574_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I144_XG_MN2 (XI1_I1574_I144_XG_n1 I1_I1574_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I144_XG_MN0 (I1_I1574_G19_12 I1_I1574_P19_16n XI1_I1574_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I144_XG_MN1 (XI1_I1574_I144_XG_n1 I1_I1574_G15_12n I1_I1574_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I194_XG_MN2 (XI1_I1574_I194_XG_n1 I1_I1574_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I194_XG_MN0 (I1_I1574_G23_0 I1_I1574_P23_8n XI1_I1574_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I194_XG_MN1 (XI1_I1574_I194_XG_n1 I1_I1574_G7_0n I1_I1574_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I132_XG_MN2 (XI1_I1574_I132_XG_n1 I1_I1574_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I132_XG_MN0 (I1_I1574_G7_0 I1_I1574_P7_4n XI1_I1574_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I132_XG_MN1 (XI1_I1574_I132_XG_n1 I1_I1574_G3_0n I1_I1574_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I72_XG_MN2 (XI1_I1574_I72_XG_n1 I1_I1574_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I72_XG_MN0 (I1_I1574_G6_5 I1_I1574_pn6 XI1_I1574_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I72_XG_MN1 (XI1_I1574_I72_XG_n1 I1_I1574_gn5 I1_I1574_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I71_XG_MN2 (XI1_I1574_I71_XG_n1 I1_I1574_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I71_XG_MN0 (I1_I1574_G5_4 I1_I1574_pn5 XI1_I1574_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I71_XG_MN1 (XI1_I1574_I71_XG_n1 I1_I1574_gn4 I1_I1574_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I82_XG_MN2 (XI2_I1_I42_I82_XG_n1 I2_I1_I42_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I82_XG_MN0 (I2_I1_I42_G16_15 I2_I1_I42_pn16 XI2_I1_I42_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I82_XG_MN1 (XI2_I1_I42_I82_XG_n1 I2_I1_I42_gn15 I2_I1_I42_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I83_XG_MN2 (XI2_I1_I42_I83_XG_n1 I2_I1_I42_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I83_XG_MN0 (I2_I1_I42_G17_16 I2_I1_I42_pn17 XI2_I1_I42_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I83_XG_MN1 (XI2_I1_I42_I83_XG_n1 I2_I1_I42_gn16 I2_I1_I42_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I130_XG_MN2 (XI1_I562_I130_XG_n1 I1_I562_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I130_XG_MN0 (I1_I562_G5_0 I1_I562_P5_2n XI1_I562_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I130_XG_MN1 (XI1_I562_I130_XG_n1 I1_I562_G1_0n I1_I562_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I134_XG_MN2 (XI1_I562_I134_XG_n1 I1_I562_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I134_XG_MN0 (I1_I562_G9_2 I1_I562_P9_6n XI1_I562_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I134_XG_MN1 (XI1_I562_I134_XG_n1 I1_I562_G5_2n I1_I562_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I184_XG_MN2 (XI1_I562_I184_XG_n1 I1_I562_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I184_XG_MN0 (I1_I562_G17_0 I1_I562_P17_2n XI1_I562_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I184_XG_MN1 (XI1_I562_I184_XG_n1 I1_I562_G1_0n I1_I562_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I138_XG_MN2 (XI1_I562_I138_XG_n1 I1_I562_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I138_XG_MN0 (I1_I562_G13_6 I1_I562_P13_10n XI1_I562_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I138_XG_MN1 (XI1_I562_I138_XG_n1 I1_I562_G9_6n I1_I562_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I142_XG_MN2 (XI1_I562_I142_XG_n1 I1_I562_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I142_XG_MN0 (I1_I562_G17_10 I1_I562_P17_14n XI1_I562_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I142_XG_MN1 (XI1_I562_I142_XG_n1 I1_I562_G13_10n I1_I562_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I196_XG_MN2 (XI1_I562_I196_XG_n1 I1_I562_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I196_XG_MN0 (I1_I562_G25_0 I1_I562_P25_10n XI1_I562_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I196_XG_MN1 (XI1_I562_I196_XG_n1 I1_I562_G9_0n I1_I562_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I190_XG_MN2 (XI1_I562_I190_XG_n1 I1_I562_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I190_XG_MN0 (I1_I562_G21_0 I1_I562_P21_6n XI1_I562_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I190_XG_MN1 (XI1_I562_I190_XG_n1 I1_I562_G5_0n I1_I562_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I146_XG_MN2 (XI1_I562_I146_XG_n1 I1_I562_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I146_XG_MN0 (I1_I562_G21_14 I1_I562_P21_18n XI1_I562_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I146_XG_MN1 (XI1_I562_I146_XG_n1 I1_I562_G17_14n I1_I562_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I200_XG_MN2 (XI1_I562_I200_XG_n1 I1_I562_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I200_XG_MN0 (I1_I562_G29_0 I1_I562_P29_14n XI1_I562_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I200_XG_MN1 (XI1_I562_I200_XG_n1 I1_I562_G13_0n I1_I562_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I89_XG_MN2 (XI1_I562_I89_XG_n1 I1_I562_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I89_XG_MN0 (I1_I562_G23_22 I1_I562_pn23 XI1_I562_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I89_XG_MN1 (XI1_I562_I89_XG_n1 I1_I562_gn22 I1_I562_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I90_XG_MN2 (XI1_I562_I90_XG_n1 I1_I562_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I90_XG_MN0 (I1_I562_G24_23 I1_I562_pn24 XI1_I562_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I90_XG_MN1 (XI1_I562_I90_XG_n1 I1_I562_gn23 I1_I562_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I92_XG_MN2 (XI1_I562_I92_XG_n1 I1_I562_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I92_XG_MN0 (I1_I562_G26_25 I1_I562_pn26 XI1_I562_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I92_XG_MN1 (XI1_I562_I92_XG_n1 I1_I562_gn25 I1_I562_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I93_XG_MN2 (XI1_I562_I93_XG_n1 I1_I562_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I93_XG_MN0 (I1_I562_G27_26 I1_I562_pn27 XI1_I562_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I93_XG_MN1 (XI1_I562_I93_XG_n1 I1_I562_gn26 I1_I562_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I154_XG_MN2 (XI1_I1712_I154_XG_n1 I1_I1712_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I154_XG_MN0 (I1_I1712_G29_22 I1_I1712_P29_26n XI1_I1712_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I154_XG_MN1 (XI1_I1712_I154_XG_n1 I1_I1712_G25_22n I1_I1712_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I150_XG_MN2 (XI1_I1712_I150_XG_n1 I1_I1712_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I150_XG_MN0 (I1_I1712_G25_18 I1_I1712_P25_22n XI1_I1712_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I150_XG_MN1 (XI1_I1712_I150_XG_n1 I1_I1712_G21_18n I1_I1712_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I144_XG_MN2 (XI1_I1712_I144_XG_n1 I1_I1712_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I144_XG_MN0 (I1_I1712_G19_12 I1_I1712_P19_16n XI1_I1712_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I144_XG_MN1 (XI1_I1712_I144_XG_n1 I1_I1712_G15_12n I1_I1712_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I140_XG_MN2 (XI1_I1712_I140_XG_n1 I1_I1712_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I140_XG_MN0 (I1_I1712_G15_8 I1_I1712_P15_12n XI1_I1712_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I140_XG_MN1 (XI1_I1712_I140_XG_n1 I1_I1712_G11_8n I1_I1712_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I186_XG_MN2 (XI1_I1712_I186_XG_n1 I1_I1712_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I186_XG_MN0 (I1_I1712_G19_0 I1_I1712_P19_4n XI1_I1712_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I186_XG_MN1 (XI1_I1712_I186_XG_n1 I1_I1712_G3_0n I1_I1712_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I136_XG_MN2 (XI1_I1712_I136_XG_n1 I1_I1712_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I136_XG_MN0 (I1_I1712_G11_4 I1_I1712_P11_8n XI1_I1712_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I136_XG_MN1 (XI1_I1712_I136_XG_n1 I1_I1712_G7_4n I1_I1712_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I132_XG_MN2 (XI1_I1712_I132_XG_n1 I1_I1712_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I132_XG_MN0 (I1_I1712_G7_0 I1_I1712_P7_4n XI1_I1712_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I132_XG_MN1 (XI1_I1712_I132_XG_n1 I1_I1712_G3_0n I1_I1712_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I202_XG_MN2 (XI1_I1528_I202_XG_n1 I1_I1528_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I202_XG_MN0 (I1_c21_o I1_I1528_P31_16n XI1_I1528_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I202_XG_MN1 (XI1_I1528_I202_XG_n1 I1_I1528_G15_0n I1_c21_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I194_XG_MN2 (XI1_I1528_I194_XG_n1 I1_I1528_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I194_XG_MN0 (I1_I1528_G23_0 I1_I1528_P23_8n XI1_I1528_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I194_XG_MN1 (XI1_I1528_I194_XG_n1 I1_I1528_G7_0n I1_I1528_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I190_XG_MN2 (XI1_I1528_I190_XG_n1 I1_I1528_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I190_XG_MN0 (I1_I1528_G21_0 I1_I1528_P21_6n XI1_I1528_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I190_XG_MN1 (XI1_I1528_I190_XG_n1 I1_I1528_G5_0n I1_I1528_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I186_XG_MN2 (XI1_I1528_I186_XG_n1 I1_I1528_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I186_XG_MN0 (I1_I1528_G19_0 I1_I1528_P19_4n XI1_I1528_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I186_XG_MN1 (XI1_I1528_I186_XG_n1 I1_I1528_G3_0n I1_I1528_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I156_XG_MN2 (XI1_I1574_I156_XG_n1 I1_I1574_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I156_XG_MN0 (I1_I1574_G31_24 I1_I1574_P31_28n XI1_I1574_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I156_XG_MN1 (XI1_I1574_I156_XG_n1 I1_I1574_G27_24n I1_I1574_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I202_XG_MN2 (XI1_I1574_I202_XG_n1 I1_I1574_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I202_XG_MN0 (I1_c22_o I1_I1574_P31_16n XI1_I1574_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I202_XG_MN1 (XI1_I1574_I202_XG_n1 I1_I1574_G15_0n I1_c22_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I152_XG_MN2 (XI1_I1574_I152_XG_n1 I1_I1574_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I152_XG_MN0 (I1_I1574_G27_20 I1_I1574_P27_24n XI1_I1574_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I152_XG_MN1 (XI1_I1574_I152_XG_n1 I1_I1574_G23_20n I1_I1574_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I148_XG_MN2 (XI1_I1574_I148_XG_n1 I1_I1574_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I148_XG_MN0 (I1_I1574_G23_16 I1_I1574_P23_20n XI1_I1574_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I148_XG_MN1 (XI1_I1574_I148_XG_n1 I1_I1574_G19_16n I1_I1574_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I146_XG_MN2 (XI1_I1574_I146_XG_n1 I1_I1574_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I146_XG_MN0 (I1_I1574_G21_14 I1_I1574_P21_18n XI1_I1574_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I146_XG_MN1 (XI1_I1574_I146_XG_n1 I1_I1574_G17_14n I1_I1574_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I81_XG_MN2 (XI1_I1574_I81_XG_n1 I1_I1574_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I81_XG_MN0 (I1_I1574_G15_14 I1_I1574_pn15 XI1_I1574_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I81_XG_MN1 (XI1_I1574_I81_XG_n1 I1_I1574_gn14 I1_I1574_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I80_XG_MN2 (XI1_I1574_I80_XG_n1 I1_I1574_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I80_XG_MN0 (I1_I1574_G14_13 I1_I1574_pn14 XI1_I1574_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I80_XG_MN1 (XI1_I1574_I80_XG_n1 I1_I1574_gn13 I1_I1574_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I142_XG_MN2 (XI1_I1574_I142_XG_n1 I1_I1574_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I142_XG_MN0 (I1_I1574_G17_10 I1_I1574_P17_14n XI1_I1574_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I142_XG_MN1 (XI1_I1574_I142_XG_n1 I1_I1574_G13_10n I1_I1574_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I138_XG_MN2 (XI1_I1574_I138_XG_n1 I1_I1574_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I138_XG_MN0 (I1_I1574_G13_6 I1_I1574_P13_10n XI1_I1574_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I138_XG_MN1 (XI1_I1574_I138_XG_n1 I1_I1574_G9_6n I1_I1574_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I134_XG_MN2 (XI1_I1574_I134_XG_n1 I1_I1574_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I134_XG_MN0 (I1_I1574_G9_2 I1_I1574_P9_6n XI1_I1574_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I134_XG_MN1 (XI1_I1574_I134_XG_n1 I1_I1574_G5_2n I1_I1574_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I130_XG_MN2 (XI1_I1574_I130_XG_n1 I1_I1574_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I130_XG_MN0 (I1_I1574_G5_0 I1_I1574_P5_2n XI1_I1574_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I130_XG_MN1 (XI1_I1574_I130_XG_n1 I1_I1574_G1_0n I1_I1574_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I70_XG_MN2 (XI1_I1574_I70_XG_n1 I1_I1574_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I70_XG_MN0 (I1_I1574_G4_3 I1_I1574_pn4 XI1_I1574_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I70_XG_MN1 (XI1_I1574_I70_XG_n1 I1_I1574_gn3 I1_I1574_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I80_XG_MN2 (XI2_I1_I42_I80_XG_n1 I2_I1_I42_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I80_XG_MN0 (I2_I1_I42_G14_13 I2_I1_I42_pn14 XI2_I1_I42_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I80_XG_MN1 (XI2_I1_I42_I80_XG_n1 I2_I1_I42_gn13 I2_I1_I42_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I188_XG_MN2 (XI2_I1_I42_I188_XG_n1 I2_I1_I42_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I188_XG_MN0 (I2_I1_I42_G20_0 I2_I1_I42_P20_5n XI2_I1_I42_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I188_XG_MN1 (XI2_I1_I42_I188_XG_n1 I2_I1_I42_G4_0n I2_I1_I42_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I81_XG_MN2 (XI2_I1_I42_I81_XG_n1 I2_I1_I42_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I81_XG_MN0 (I2_I1_I42_G15_14 I2_I1_I42_pn15 XI2_I1_I42_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I81_XG_MN1 (XI2_I1_I42_I81_XG_n1 I2_I1_I42_gn14 I2_I1_I42_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I145_XG_MN2 (XI2_I1_I42_I145_XG_n1 I2_I1_I42_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I145_XG_MN0 (I2_I1_I42_G20_13 I2_I1_I42_P20_17n XI2_I1_I42_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I145_XG_MN1 (XI2_I1_I42_I145_XG_n1 I2_I1_I42_G16_13n I2_I1_I42_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I84_XG_MN2 (XI2_I1_I42_I84_XG_n1 I2_I1_I42_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I84_XG_MN0 (I2_I1_I42_G18_17 I2_I1_I42_pn18 XI2_I1_I42_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I84_XG_MN1 (XI2_I1_I42_I84_XG_n1 I2_I1_I42_gn17 I2_I1_I42_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I87_XG_MN2 (XI2_I1_I42_I87_XG_n1 I2_I1_I42_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I87_XG_MN0 (I2_I1_I42_G21_20 I2_I1_I42_pn21 XI2_I1_I42_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I87_XG_MN1 (XI2_I1_I42_I87_XG_n1 I2_I1_I42_gn20 I2_I1_I42_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I88_XG_MN2 (XI2_I1_I42_I88_XG_n1 I2_I1_I42_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I88_XG_MN0 (I2_I1_I42_G22_21 I2_I1_I42_pn22 XI2_I1_I42_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I88_XG_MN1 (XI2_I1_I42_I88_XG_n1 I2_I1_I42_gn21 I2_I1_I42_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I89_XG_MN2 (XI2_I1_I42_I89_XG_n1 I2_I1_I42_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I89_XG_MN0 (I2_I1_I42_G23_22 I2_I1_I42_pn23 XI2_I1_I42_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I89_XG_MN1 (XI2_I1_I42_I89_XG_n1 I2_I1_I42_gn22 I2_I1_I42_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I132_XG_MN2 (XI1_I562_I132_XG_n1 I1_I562_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I132_XG_MN0 (I1_I562_G7_0 I1_I562_P7_4n XI1_I562_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I132_XG_MN1 (XI1_I562_I132_XG_n1 I1_I562_G3_0n I1_I562_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I136_XG_MN2 (XI1_I562_I136_XG_n1 I1_I562_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I136_XG_MN0 (I1_I562_G11_4 I1_I562_P11_8n XI1_I562_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I136_XG_MN1 (XI1_I562_I136_XG_n1 I1_I562_G7_4n I1_I562_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I186_XG_MN2 (XI1_I562_I186_XG_n1 I1_I562_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I186_XG_MN0 (I1_I562_G19_0 I1_I562_P19_4n XI1_I562_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I186_XG_MN1 (XI1_I562_I186_XG_n1 I1_I562_G3_0n I1_I562_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I140_XG_MN2 (XI1_I562_I140_XG_n1 I1_I562_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I140_XG_MN0 (I1_I562_G15_8 I1_I562_P15_12n XI1_I562_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I140_XG_MN1 (XI1_I562_I140_XG_n1 I1_I562_G11_8n I1_I562_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I198_XG_MN2 (XI1_I562_I198_XG_n1 I1_I562_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I198_XG_MN0 (I1_I562_G27_0 I1_I562_P27_12n XI1_I562_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I198_XG_MN1 (XI1_I562_I198_XG_n1 I1_I562_G11_0n I1_I562_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I150_XG_MN2 (XI1_I562_I150_XG_n1 I1_I562_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I150_XG_MN0 (I1_I562_G25_18 I1_I562_P25_22n XI1_I562_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I150_XG_MN1 (XI1_I562_I150_XG_n1 I1_I562_G21_18n I1_I562_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I154_XG_MN2 (XI1_I562_I154_XG_n1 I1_I562_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I154_XG_MN0 (I1_I562_G29_22 I1_I562_P29_26n XI1_I562_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I154_XG_MN1 (XI1_I562_I154_XG_n1 I1_I562_G25_22n I1_I562_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I91_XG_MN2 (XI1_I562_I91_XG_n1 I1_I562_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I91_XG_MN0 (I1_I562_G25_24 I1_I562_pn25 XI1_I562_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I91_XG_MN1 (XI1_I562_I91_XG_n1 I1_I562_gn24 I1_I562_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I95_XG_MN2 (XI1_I1712_I95_XG_n1 I1_I1712_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I95_XG_MN0 (I1_I1712_G29_28 I1_I1712_pn29 XI1_I1712_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I95_XG_MN1 (XI1_I1712_I95_XG_n1 I1_I1712_gn28 I1_I1712_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I200_XG_MN2 (XI1_I1712_I200_XG_n1 I1_I1712_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I200_XG_MN0 (I1_I1712_G29_0 I1_I1712_P29_14n XI1_I1712_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I200_XG_MN1 (XI1_I1712_I200_XG_n1 I1_I1712_G13_0n I1_I1712_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I196_XG_MN2 (XI1_I1712_I196_XG_n1 I1_I1712_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I196_XG_MN0 (I1_I1712_G25_0 I1_I1712_P25_10n XI1_I1712_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I196_XG_MN1 (XI1_I1712_I196_XG_n1 I1_I1712_G9_0n I1_I1712_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I146_XG_MN2 (XI1_I1712_I146_XG_n1 I1_I1712_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I146_XG_MN0 (I1_I1712_G21_14 I1_I1712_P21_18n XI1_I1712_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I146_XG_MN1 (XI1_I1712_I146_XG_n1 I1_I1712_G17_14n I1_I1712_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I190_XG_MN2 (XI1_I1712_I190_XG_n1 I1_I1712_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I190_XG_MN0 (I1_I1712_G21_0 I1_I1712_P21_6n XI1_I1712_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I190_XG_MN1 (XI1_I1712_I190_XG_n1 I1_I1712_G5_0n I1_I1712_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I142_XG_MN2 (XI1_I1712_I142_XG_n1 I1_I1712_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I142_XG_MN0 (I1_I1712_G17_10 I1_I1712_P17_14n XI1_I1712_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I142_XG_MN1 (XI1_I1712_I142_XG_n1 I1_I1712_G13_10n I1_I1712_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I138_XG_MN2 (XI1_I1712_I138_XG_n1 I1_I1712_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I138_XG_MN0 (I1_I1712_G13_6 I1_I1712_P13_10n XI1_I1712_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I138_XG_MN1 (XI1_I1712_I138_XG_n1 I1_I1712_G9_6n I1_I1712_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I184_XG_MN2 (XI1_I1712_I184_XG_n1 I1_I1712_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I184_XG_MN0 (I1_I1712_G17_0 I1_I1712_P17_2n XI1_I1712_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I184_XG_MN1 (XI1_I1712_I184_XG_n1 I1_I1712_G1_0n I1_I1712_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I134_XG_MN2 (XI1_I1712_I134_XG_n1 I1_I1712_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I134_XG_MN0 (I1_I1712_G9_2 I1_I1712_P9_6n XI1_I1712_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I134_XG_MN1 (XI1_I1712_I134_XG_n1 I1_I1712_G5_2n I1_I1712_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I130_XG_MN2 (XI1_I1712_I130_XG_n1 I1_I1712_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I130_XG_MN0 (I1_I1712_G5_0 I1_I1712_P5_2n XI1_I1712_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I130_XG_MN1 (XI1_I1712_I130_XG_n1 I1_I1712_G1_0n I1_I1712_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I69_XG_MN2 (XI1_I1712_I69_XG_n1 I1_I1712_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I69_XG_MN0 (I1_I1712_G3_2 I1_I1712_pn3 XI1_I1712_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I69_XG_MN1 (XI1_I1712_I69_XG_n1 I1_I1712_gn2 I1_I1712_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I97_XG_MN2 (XI1_I1574_I97_XG_n1 I1_I1574_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I97_XG_MN0 (I1_I1574_G31_30 I1_I1574_pn31 XI1_I1574_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I97_XG_MN1 (XI1_I1574_I97_XG_n1 I1_I1574_gn30 I1_I1574_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I96_XG_MN2 (XI1_I1574_I96_XG_n1 I1_I1574_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I96_XG_MN0 (I1_I1574_G30_29 I1_I1574_pn30 XI1_I1574_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I96_XG_MN1 (XI1_I1574_I96_XG_n1 I1_I1574_gn29 I1_I1574_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I95_XG_MN2 (XI1_I1574_I95_XG_n1 I1_I1574_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I95_XG_MN0 (I1_I1574_G29_28 I1_I1574_pn29 XI1_I1574_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I95_XG_MN1 (XI1_I1574_I95_XG_n1 I1_I1574_gn28 I1_I1574_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I154_XG_MN2 (XI1_I1574_I154_XG_n1 I1_I1574_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I154_XG_MN0 (I1_I1574_G29_22 I1_I1574_P29_26n XI1_I1574_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I154_XG_MN1 (XI1_I1574_I154_XG_n1 I1_I1574_G25_22n I1_I1574_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I200_XG_MN2 (XI1_I1574_I200_XG_n1 I1_I1574_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I200_XG_MN0 (I1_I1574_G29_0 I1_I1574_P29_14n XI1_I1574_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I200_XG_MN1 (XI1_I1574_I200_XG_n1 I1_I1574_G13_0n I1_I1574_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I150_XG_MN2 (XI1_I1574_I150_XG_n1 I1_I1574_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I150_XG_MN0 (I1_I1574_G25_18 I1_I1574_P25_22n XI1_I1574_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I150_XG_MN1 (XI1_I1574_I150_XG_n1 I1_I1574_G21_18n I1_I1574_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I82_XG_MN2 (XI1_I1574_I82_XG_n1 I1_I1574_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I82_XG_MN0 (I1_I1574_G16_15 I1_I1574_pn16 XI1_I1574_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I82_XG_MN1 (XI1_I1574_I82_XG_n1 I1_I1574_gn15 I1_I1574_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I190_XG_MN2 (XI1_I1574_I190_XG_n1 I1_I1574_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I190_XG_MN0 (I1_I1574_G21_0 I1_I1574_P21_6n XI1_I1574_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I190_XG_MN1 (XI1_I1574_I190_XG_n1 I1_I1574_G5_0n I1_I1574_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I196_XG_MN2 (XI1_I1574_I196_XG_n1 I1_I1574_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I196_XG_MN0 (I1_I1574_G25_0 I1_I1574_P25_10n XI1_I1574_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I196_XG_MN1 (XI1_I1574_I196_XG_n1 I1_I1574_G9_0n I1_I1574_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I184_XG_MN2 (XI1_I1574_I184_XG_n1 I1_I1574_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I184_XG_MN0 (I1_I1574_G17_0 I1_I1574_P17_2n XI1_I1574_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I184_XG_MN1 (XI1_I1574_I184_XG_n1 I1_I1574_G1_0n I1_I1574_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I69_XG_MN2 (XI1_I1574_I69_XG_n1 I1_I1574_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I69_XG_MN0 (I1_I1574_G3_2 I1_I1574_pn3 XI1_I1574_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I69_XG_MN1 (XI1_I1574_I69_XG_n1 I1_I1574_gn2 I1_I1574_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I149_XG_MN2 (XI2_I1_I42_I149_XG_n1 I2_I1_I42_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I149_XG_MN0 (I2_I1_I42_G24_17 I2_I1_I42_P24_21n XI2_I1_I42_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I149_XG_MN1 (XI2_I1_I42_I149_XG_n1 I2_I1_I42_G20_17n I2_I1_I42_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I192_XG_MN2 (XI2_I1_I42_I192_XG_n1 I2_I1_I42_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I192_XG_MN0 (I2_I1_I42_G22_0 I2_I1_I42_P22_7n XI2_I1_I42_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I192_XG_MN1 (XI2_I1_I42_I192_XG_n1 I2_I1_I42_G6_0n I2_I1_I42_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I199_XG_MN2 (XI2_I1_I42_I199_XG_n1 I2_I1_I42_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I199_XG_MN0 (I2_I1_I42_G28_0 I2_I1_I42_P28_13n XI2_I1_I42_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I199_XG_MN1 (XI2_I1_I42_I199_XG_n1 I2_I1_I42_G12_0n I2_I1_I42_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I147_XG_MN2 (XI2_I1_I42_I147_XG_n1 I2_I1_I42_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I147_XG_MN0 (I2_I1_I42_G22_15 I2_I1_I42_P22_19n XI2_I1_I42_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I147_XG_MN1 (XI2_I1_I42_I147_XG_n1 I2_I1_I42_G18_15n I2_I1_I42_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I151_XG_MN2 (XI2_I1_I42_I151_XG_n1 I2_I1_I42_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I151_XG_MN0 (I2_I1_I42_G26_19 I2_I1_I42_P26_23n XI2_I1_I42_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I151_XG_MN1 (XI2_I1_I42_I151_XG_n1 I2_I1_I42_G22_19n I2_I1_I42_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I153_XG_MN2 (XI2_I1_I42_I153_XG_n1 I2_I1_I42_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I153_XG_MN0 (I2_I1_I42_G28_21 I2_I1_I42_P28_25n XI2_I1_I42_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I153_XG_MN1 (XI2_I1_I42_I153_XG_n1 I2_I1_I42_G24_21n I2_I1_I42_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I90_XG_MN2 (XI2_I1_I42_I90_XG_n1 I2_I1_I42_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I90_XG_MN0 (I2_I1_I42_G24_23 I2_I1_I42_pn24 XI2_I1_I42_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I90_XG_MN1 (XI2_I1_I42_I90_XG_n1 I2_I1_I42_gn23 I2_I1_I42_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I91_XG_MN2 (XI2_I1_I42_I91_XG_n1 I2_I1_I42_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I91_XG_MN0 (I2_I1_I42_G25_24 I2_I1_I42_pn25 XI2_I1_I42_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I91_XG_MN1 (XI2_I1_I42_I91_XG_n1 I2_I1_I42_gn24 I2_I1_I42_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I92_XG_MN2 (XI2_I1_I42_I92_XG_n1 I2_I1_I42_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I92_XG_MN0 (I2_I1_I42_G26_25 I2_I1_I42_pn26 XI2_I1_I42_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I92_XG_MN1 (XI2_I1_I42_I92_XG_n1 I2_I1_I42_gn25 I2_I1_I42_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I93_XG_MN2 (XI2_I1_I42_I93_XG_n1 I2_I1_I42_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I93_XG_MN0 (I2_I1_I42_G27_26 I2_I1_I42_pn27 XI2_I1_I42_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I93_XG_MN1 (XI2_I1_I42_I93_XG_n1 I2_I1_I42_gn26 I2_I1_I42_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I144_XG_MN2 (XI1_I562_I144_XG_n1 I1_I562_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I144_XG_MN0 (I1_I562_G19_12 I1_I562_P19_16n XI1_I562_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I144_XG_MN1 (XI1_I562_I144_XG_n1 I1_I562_G15_12n I1_I562_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I148_XG_MN2 (XI1_I562_I148_XG_n1 I1_I562_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I148_XG_MN0 (I1_I562_G23_16 I1_I562_P23_20n XI1_I562_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I148_XG_MN1 (XI1_I562_I148_XG_n1 I1_I562_G19_16n I1_I562_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I152_XG_MN2 (XI1_I562_I152_XG_n1 I1_I562_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I152_XG_MN0 (I1_I562_G27_20 I1_I562_P27_24n XI1_I562_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I152_XG_MN1 (XI1_I562_I152_XG_n1 I1_I562_G23_20n I1_I562_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I156_XG_MN2 (XI1_I562_I156_XG_n1 I1_I562_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I156_XG_MN0 (I1_I562_G31_24 I1_I562_P31_28n XI1_I562_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I156_XG_MN1 (XI1_I562_I156_XG_n1 I1_I562_G27_24n I1_I562_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I94_XG_MN2 (XI1_I1712_I94_XG_n1 I1_I1712_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I94_XG_MN0 (I1_I1712_G28_27 I1_I1712_pn28 XI1_I1712_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I94_XG_MN1 (XI1_I1712_I94_XG_n1 I1_I1712_gn27 I1_I1712_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I93_XG_MN2 (XI1_I1712_I93_XG_n1 I1_I1712_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I93_XG_MN0 (I1_I1712_G27_26 I1_I1712_pn27 XI1_I1712_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I93_XG_MN1 (XI1_I1712_I93_XG_n1 I1_I1712_gn26 I1_I1712_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I153_XG_MN2 (XI1_I1712_I153_XG_n1 I1_I1712_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I153_XG_MN0 (I1_I1712_G28_21 I1_I1712_P28_25n XI1_I1712_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I153_XG_MN1 (XI1_I1712_I153_XG_n1 I1_I1712_G24_21n I1_I1712_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I199_XG_MN2 (XI1_I1712_I199_XG_n1 I1_I1712_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I199_XG_MN0 (I1_I1712_G28_0 I1_I1712_P28_13n XI1_I1712_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I199_XG_MN1 (XI1_I1712_I199_XG_n1 I1_I1712_G12_0n I1_I1712_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I188_XG_MN2 (XI1_I1712_I188_XG_n1 I1_I1712_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I188_XG_MN0 (I1_I1712_G20_0 I1_I1712_P20_5n XI1_I1712_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I188_XG_MN1 (XI1_I1712_I188_XG_n1 I1_I1712_G4_0n I1_I1712_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I137_XG_MN2 (XI1_I1712_I137_XG_n1 I1_I1712_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I137_XG_MN0 (I1_I1712_G12_5 I1_I1712_P12_9n XI1_I1712_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I137_XG_MN1 (XI1_I1712_I137_XG_n1 I1_I1712_G8_5n I1_I1712_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I128_XG_MN2 (XI1_I1712_I128_XG_n1 I1_I1712_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I128_XG_MN0 (I1_I1712_G4_0 I1_I1712_P4_1n XI1_I1712_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I128_XG_MN1 (XI1_I1712_I128_XG_n1 I1_I1712_G0_0n I1_I1712_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I71_XG_MN2 (XI1_I1712_I71_XG_n1 I1_I1712_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I71_XG_MN0 (I1_I1712_G5_4 I1_I1712_pn5 XI1_I1712_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I71_XG_MN1 (XI1_I1712_I71_XG_n1 I1_I1712_gn4 I1_I1712_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I70_XG_MN2 (XI1_I1712_I70_XG_n1 I1_I1712_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I70_XG_MN0 (I1_I1712_G4_3 I1_I1712_pn4 XI1_I1712_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I70_XG_MN1 (XI1_I1712_I70_XG_n1 I1_I1712_gn3 I1_I1712_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I94_XG_MN2 (XI1_I1574_I94_XG_n1 I1_I1574_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I94_XG_MN0 (I1_I1574_G28_27 I1_I1574_pn28 XI1_I1574_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I94_XG_MN1 (XI1_I1574_I94_XG_n1 I1_I1574_gn27 I1_I1574_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I93_XG_MN2 (XI1_I1574_I93_XG_n1 I1_I1574_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I93_XG_MN0 (I1_I1574_G27_26 I1_I1574_pn27 XI1_I1574_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I93_XG_MN1 (XI1_I1574_I93_XG_n1 I1_I1574_gn26 I1_I1574_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I83_XG_MN2 (XI1_I1574_I83_XG_n1 I1_I1574_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I83_XG_MN0 (I1_I1574_G17_16 I1_I1574_pn17 XI1_I1574_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I83_XG_MN1 (XI1_I1574_I83_XG_n1 I1_I1574_gn16 I1_I1574_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I141_XG_MN2 (XI1_I1574_I141_XG_n1 I1_I1574_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I141_XG_MN0 (I1_I1574_G16_9 I1_I1574_P16_13n XI1_I1574_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I141_XG_MN1 (XI1_I1574_I141_XG_n1 I1_I1574_G12_9n I1_I1574_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I78_XG_MN2 (XI2_I1_I42_I78_XG_n1 I2_I1_I42_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I78_XG_MN0 (I2_I1_I42_G12_11 I2_I1_I42_pn12 XI2_I1_I42_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I78_XG_MN1 (XI2_I1_I42_I78_XG_n1 I2_I1_I42_gn11 I2_I1_I42_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I79_XG_MN2 (XI2_I1_I42_I79_XG_n1 I2_I1_I42_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I79_XG_MN0 (I2_I1_I42_G13_12 I2_I1_I42_pn13 XI2_I1_I42_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I79_XG_MN1 (XI2_I1_I42_I79_XG_n1 I2_I1_I42_gn12 I2_I1_I42_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I139_XG_MN2 (XI2_I1_I42_I139_XG_n1 I2_I1_I42_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I139_XG_MN0 (I2_I1_I42_G14_7 I2_I1_I42_P14_11n XI2_I1_I42_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I139_XG_MN1 (XI2_I1_I42_I139_XG_n1 I2_I1_I42_G10_7n I2_I1_I42_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I143_XG_MN2 (XI2_I1_I42_I143_XG_n1 I2_I1_I42_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I143_XG_MN0 (I2_I1_I42_G18_11 I2_I1_I42_P18_15n XI2_I1_I42_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I143_XG_MN1 (XI2_I1_I42_I143_XG_n1 I2_I1_I42_G14_11n I2_I1_I42_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I197_XG_MN2 (XI2_I1_I42_I197_XG_n1 I2_I1_I42_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I197_XG_MN0 (I2_I1_I42_G26_0 I2_I1_I42_P26_11n XI2_I1_I42_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I197_XG_MN1 (XI2_I1_I42_I197_XG_n1 I2_I1_I42_G10_0n I2_I1_I42_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I201_XG_MN2 (XI2_I1_I42_I201_XG_n1 I2_I1_I42_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I201_XG_MN0 (I2_CM I2_I1_I42_P30_15n XI2_I1_I42_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I201_XG_MN1 (XI2_I1_I42_I201_XG_n1 I2_I1_I42_G14_0n I2_CM VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I155_XG_MN2 (XI2_I1_I42_I155_XG_n1 I2_I1_I42_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I155_XG_MN0 (I2_I1_I42_G30_23 I2_I1_I42_P30_27n XI2_I1_I42_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I155_XG_MN1 (XI2_I1_I42_I155_XG_n1 I2_I1_I42_G26_23n I2_I1_I42_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I94_XG_MN2 (XI2_I1_I42_I94_XG_n1 I2_I1_I42_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I94_XG_MN0 (I2_I1_I42_G28_27 I2_I1_I42_pn28 XI2_I1_I42_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I94_XG_MN1 (XI2_I1_I42_I94_XG_n1 I2_I1_I42_gn27 I2_I1_I42_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I194_XG_MN2 (XI1_I562_I194_XG_n1 I1_I562_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I194_XG_MN0 (I1_I562_G23_0 I1_I562_P23_8n XI1_I562_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I194_XG_MN1 (XI1_I562_I194_XG_n1 I1_I562_G7_0n I1_I562_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I202_XG_MN2 (XI1_I562_I202_XG_n1 I1_I562_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I202_XG_MN0 (I1_c0_o I1_I562_P31_16n XI1_I562_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I202_XG_MN1 (XI1_I562_I202_XG_n1 I1_I562_G15_0n I1_c0_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I96_XG_MN2 (XI1_I1712_I96_XG_n1 I1_I1712_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I96_XG_MN0 (I1_I1712_G30_29 I1_I1712_pn30 XI1_I1712_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I96_XG_MN1 (XI1_I1712_I96_XG_n1 I1_I1712_gn29 I1_I1712_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I92_XG_MN2 (XI1_I1712_I92_XG_n1 I1_I1712_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I92_XG_MN0 (I1_I1712_G26_25 I1_I1712_pn26 XI1_I1712_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I92_XG_MN1 (XI1_I1712_I92_XG_n1 I1_I1712_gn25 I1_I1712_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I155_XG_MN2 (XI1_I1712_I155_XG_n1 I1_I1712_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I155_XG_MN0 (I1_I1712_G30_23 I1_I1712_P30_27n XI1_I1712_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I155_XG_MN1 (XI1_I1712_I155_XG_n1 I1_I1712_G26_23n I1_I1712_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I195_XG_MN2 (XI1_I1712_I195_XG_n1 I1_I1712_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I195_XG_MN0 (I1_I1712_G24_0 I1_I1712_P24_9n XI1_I1712_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I195_XG_MN1 (XI1_I1712_I195_XG_n1 I1_I1712_G8_0n I1_I1712_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I141_XG_MN2 (XI1_I1712_I141_XG_n1 I1_I1712_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I141_XG_MN0 (I1_I1712_G16_9 I1_I1712_P16_13n XI1_I1712_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I141_XG_MN1 (XI1_I1712_I141_XG_n1 I1_I1712_G12_9n I1_I1712_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I183_XG_MN2 (XI1_I1712_I183_XG_n1 I1_I1712_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I183_XG_MN0 (I1_I1712_G16_0 I1_I1712_P16_1n XI1_I1712_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I183_XG_MN1 (XI1_I1712_I183_XG_n1 I1_I1712_G0_0n I1_I1712_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I133_XG_MN2 (XI1_I1712_I133_XG_n1 I1_I1712_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I133_XG_MN0 (I1_I1712_G8_1 I1_I1712_P8_5n XI1_I1712_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I133_XG_MN1 (XI1_I1712_I133_XG_n1 I1_I1712_G4_1n I1_I1712_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I67_XG_MN2 (XI1_I1712_I67_XG_n1 I1_I1712_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I67_XG_MN0 (I1_I1712_G1_0 I1_I1712_pn1 XI1_I1712_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I67_XG_MN1 (XI1_I1712_I67_XG_n1 I1_I1712_G0_0n I1_I1712_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I68_XG_MN2 (XI1_I1712_I68_XG_n1 I1_I1712_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I68_XG_MN0 (I1_I1712_G2_1 I1_I1712_pn2 XI1_I1712_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I68_XG_MN1 (XI1_I1712_I68_XG_n1 I1_I1712_gn1 I1_I1712_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I92_XG_MN2 (XI1_I1574_I92_XG_n1 I1_I1574_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I92_XG_MN0 (I1_I1574_G26_25 I1_I1574_pn26 XI1_I1574_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I92_XG_MN1 (XI1_I1574_I92_XG_n1 I1_I1574_gn25 I1_I1574_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I91_XG_MN2 (XI1_I1574_I91_XG_n1 I1_I1574_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I91_XG_MN0 (I1_I1574_G25_24 I1_I1574_pn25 XI1_I1574_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I91_XG_MN1 (XI1_I1574_I91_XG_n1 I1_I1574_gn24 I1_I1574_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I153_XG_MN2 (XI1_I1574_I153_XG_n1 I1_I1574_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I153_XG_MN0 (I1_I1574_G28_21 I1_I1574_P28_25n XI1_I1574_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I153_XG_MN1 (XI1_I1574_I153_XG_n1 I1_I1574_G24_21n I1_I1574_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I199_XG_MN2 (XI1_I1574_I199_XG_n1 I1_I1574_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I199_XG_MN0 (I1_I1574_G28_0 I1_I1574_P28_13n XI1_I1574_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I199_XG_MN1 (XI1_I1574_I199_XG_n1 I1_I1574_G12_0n I1_I1574_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I145_XG_MN2 (XI1_I1574_I145_XG_n1 I1_I1574_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I145_XG_MN0 (I1_I1574_G20_13 I1_I1574_P20_17n XI1_I1574_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I145_XG_MN1 (XI1_I1574_I145_XG_n1 I1_I1574_G16_13n I1_I1574_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I137_XG_MN2 (XI1_I1574_I137_XG_n1 I1_I1574_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I137_XG_MN0 (I1_I1574_G12_5 I1_I1574_P12_9n XI1_I1574_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I137_XG_MN1 (XI1_I1574_I137_XG_n1 I1_I1574_G8_5n I1_I1574_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I133_XG_MN2 (XI1_I1574_I133_XG_n1 I1_I1574_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I133_XG_MN0 (I1_I1574_G8_1 I1_I1574_P8_5n XI1_I1574_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I133_XG_MN1 (XI1_I1574_I133_XG_n1 I1_I1574_G4_1n I1_I1574_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I128_XG_MN2 (XI1_I1574_I128_XG_n1 I1_I1574_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I128_XG_MN0 (I1_I1574_G4_0 I1_I1574_P4_1n XI1_I1574_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I128_XG_MN1 (XI1_I1574_I128_XG_n1 I1_I1574_G0_0n I1_I1574_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I68_XG_MN2 (XI1_I1574_I68_XG_n1 I1_I1574_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I68_XG_MN0 (I1_I1574_G2_1 I1_I1574_pn2 XI1_I1574_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I68_XG_MN1 (XI1_I1574_I68_XG_n1 I1_I1574_gn1 I1_I1574_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I67_XG_MN2 (XI1_I1574_I67_XG_n1 I1_I1574_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I67_XG_MN0 (I1_I1574_G1_0 I1_I1574_pn1 XI1_I1574_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I67_XG_MN1 (XI1_I1574_I67_XG_n1 I1_I1574_G0_0n I1_I1574_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I137_XG_MN2 (XI2_I1_I42_I137_XG_n1 I2_I1_I42_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I137_XG_MN0 (I2_I1_I42_G12_5 I2_I1_I42_P12_9n XI2_I1_I42_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I137_XG_MN1 (XI2_I1_I42_I137_XG_n1 I2_I1_I42_G8_5n I2_I1_I42_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I141_XG_MN2 (XI2_I1_I42_I141_XG_n1 I2_I1_I42_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I141_XG_MN0 (I2_I1_I42_G16_9 I2_I1_I42_P16_13n XI2_I1_I42_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I141_XG_MN1 (XI2_I1_I42_I141_XG_n1 I2_I1_I42_G12_9n I2_I1_I42_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I195_XG_MN2 (XI2_I1_I42_I195_XG_n1 I2_I1_I42_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I195_XG_MN0 (I2_I1_I42_G24_0 I2_I1_I42_P24_9n XI2_I1_I42_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I195_XG_MN1 (XI2_I1_I42_I195_XG_n1 I2_I1_I42_G8_0n I2_I1_I42_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I140_XG_MN2 (XI2_I1_I42_I140_XG_n1 I2_I1_I42_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I140_XG_MN0 (I2_I1_I42_G15_8 I2_I1_I42_P15_12n XI2_I1_I42_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I140_XG_MN1 (XI2_I1_I42_I140_XG_n1 I2_I1_I42_G11_8n I2_I1_I42_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I144_XG_MN2 (XI2_I1_I42_I144_XG_n1 I2_I1_I42_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I144_XG_MN0 (I2_I1_I42_G19_12 I2_I1_I42_P19_16n XI2_I1_I42_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I144_XG_MN1 (XI2_I1_I42_I144_XG_n1 I2_I1_I42_G15_12n I2_I1_I42_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I198_XG_MN2 (XI2_I1_I42_I198_XG_n1 I2_I1_I42_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I198_XG_MN0 (I2_I1_I42_G27_0 I2_I1_I42_P27_12n XI2_I1_I42_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I198_XG_MN1 (XI2_I1_I42_I198_XG_n1 I2_I1_I42_G11_0n I2_I1_I42_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I202_XG_MN2 (XI2_I1_I42_I202_XG_n1 I2_I1_I42_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I202_XG_MN0 (I2_CO I2_I1_I42_P31_16n XI2_I1_I42_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I202_XG_MN1 (XI2_I1_I42_I202_XG_n1 I2_I1_I42_G15_0n I2_CO VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I154_XG_MN2 (XI2_I1_I42_I154_XG_n1 I2_I1_I42_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I154_XG_MN0 (I2_I1_I42_G29_22 I2_I1_I42_P29_26n XI2_I1_I42_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I154_XG_MN1 (XI2_I1_I42_I154_XG_n1 I2_I1_I42_G25_22n I2_I1_I42_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I95_XG_MN2 (XI2_I1_I42_I95_XG_n1 I2_I1_I42_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I95_XG_MN0 (I2_I1_I42_G29_28 I2_I1_I42_pn29 XI2_I1_I42_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I95_XG_MN1 (XI2_I1_I42_I95_XG_n1 I2_I1_I42_gn28 I2_I1_I42_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I96_XG_MN2 (XI2_I1_I42_I96_XG_n1 I2_I1_I42_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I96_XG_MN0 (I2_I1_I42_G30_29 I2_I1_I42_pn30 XI2_I1_I42_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I96_XG_MN1 (XI2_I1_I42_I96_XG_n1 I2_I1_I42_gn29 I2_I1_I42_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I91_XG_MN2 (XI1_I1712_I91_XG_n1 I1_I1712_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I91_XG_MN0 (I1_I1712_G25_24 I1_I1712_pn25 XI1_I1712_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I91_XG_MN1 (XI1_I1712_I91_XG_n1 I1_I1712_gn24 I1_I1712_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I90_XG_MN2 (XI1_I1712_I90_XG_n1 I1_I1712_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I90_XG_MN0 (I1_I1712_G24_23 I1_I1712_pn24 XI1_I1712_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I90_XG_MN1 (XI1_I1712_I90_XG_n1 I1_I1712_gn23 I1_I1712_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I151_XG_MN2 (XI1_I1712_I151_XG_n1 I1_I1712_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I151_XG_MN0 (I1_I1712_G26_19 I1_I1712_P26_23n XI1_I1712_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I151_XG_MN1 (XI1_I1712_I151_XG_n1 I1_I1712_G22_19n I1_I1712_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I147_XG_MN2 (XI1_I1712_I147_XG_n1 I1_I1712_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I147_XG_MN0 (I1_I1712_G22_15 I1_I1712_P22_19n XI1_I1712_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I147_XG_MN1 (XI1_I1712_I147_XG_n1 I1_I1712_G18_15n I1_I1712_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I197_XG_MN2 (XI1_I1712_I197_XG_n1 I1_I1712_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I197_XG_MN0 (I1_I1712_G26_0 I1_I1712_P26_11n XI1_I1712_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I197_XG_MN1 (XI1_I1712_I197_XG_n1 I1_I1712_G10_0n I1_I1712_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I185_XG_MN2 (XI1_I1712_I185_XG_n1 I1_I1712_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I185_XG_MN0 (I1_I1712_G18_0 I1_I1712_P18_3n XI1_I1712_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I185_XG_MN1 (XI1_I1712_I185_XG_n1 I1_I1712_G2_0n I1_I1712_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I139_XG_MN2 (XI1_I1712_I139_XG_n1 I1_I1712_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I139_XG_MN0 (I1_I1712_G14_7 I1_I1712_P14_11n XI1_I1712_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I139_XG_MN1 (XI1_I1712_I139_XG_n1 I1_I1712_G10_7n I1_I1712_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I135_XG_MN2 (XI1_I1712_I135_XG_n1 I1_I1712_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I135_XG_MN0 (I1_I1712_G10_3 I1_I1712_P10_7n XI1_I1712_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I135_XG_MN1 (XI1_I1712_I135_XG_n1 I1_I1712_G6_3n I1_I1712_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I131_XG_MN2 (XI1_I1712_I131_XG_n1 I1_I1712_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I131_XG_MN0 (I1_I1712_G6_0 I1_I1712_P6_3n XI1_I1712_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I131_XG_MN1 (XI1_I1712_I131_XG_n1 I1_I1712_G2_0n I1_I1712_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I74_XG_MN2 (XI1_I1712_I74_XG_n1 I1_I1712_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I74_XG_MN0 (I1_I1712_G8_7 I1_I1712_pn8 XI1_I1712_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I74_XG_MN1 (XI1_I1712_I74_XG_n1 I1_I1712_gn7 I1_I1712_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I73_XG_MN2 (XI1_I1712_I73_XG_n1 I1_I1712_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I73_XG_MN0 (I1_I1712_G7_6 I1_I1712_pn7 XI1_I1712_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I73_XG_MN1 (XI1_I1712_I73_XG_n1 I1_I1712_gn6 I1_I1712_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I72_XG_MN2 (XI1_I1712_I72_XG_n1 I1_I1712_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I72_XG_MN0 (I1_I1712_G6_5 I1_I1712_pn6 XI1_I1712_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I72_XG_MN1 (XI1_I1712_I72_XG_n1 I1_I1712_gn5 I1_I1712_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I65_XG_MN2 (XI1_I1666_I65_XG_n1 I1_I1666_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I65_XG_MN0 (I1_I1666_G0_0 I1_I1666_pn0 XI1_I1666_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I65_XG_MN1 (XI1_I1666_I65_XG_n1 I1_I1666_cinn I1_I1666_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I90_XG_MN2 (XI1_I1574_I90_XG_n1 I1_I1574_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I90_XG_MN0 (I1_I1574_G24_23 I1_I1574_pn24 XI1_I1574_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I90_XG_MN1 (XI1_I1574_I90_XG_n1 I1_I1574_gn23 I1_I1574_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I89_XG_MN2 (XI1_I1574_I89_XG_n1 I1_I1574_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I89_XG_MN0 (I1_I1574_G23_22 I1_I1574_pn23 XI1_I1574_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I89_XG_MN1 (XI1_I1574_I89_XG_n1 I1_I1574_gn22 I1_I1574_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I88_XG_MN2 (XI1_I1574_I88_XG_n1 I1_I1574_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I88_XG_MN0 (I1_I1574_G22_21 I1_I1574_pn22 XI1_I1574_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I88_XG_MN1 (XI1_I1574_I88_XG_n1 I1_I1574_gn21 I1_I1574_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I155_XG_MN2 (XI1_I1574_I155_XG_n1 I1_I1574_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I155_XG_MN0 (I1_I1574_G30_23 I1_I1574_P30_27n XI1_I1574_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I155_XG_MN1 (XI1_I1574_I155_XG_n1 I1_I1574_G26_23n I1_I1574_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I149_XG_MN2 (XI1_I1574_I149_XG_n1 I1_I1574_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I149_XG_MN0 (I1_I1574_G24_17 I1_I1574_P24_21n XI1_I1574_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I149_XG_MN1 (XI1_I1574_I149_XG_n1 I1_I1574_G20_17n I1_I1574_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I188_XG_MN2 (XI1_I1574_I188_XG_n1 I1_I1574_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I188_XG_MN0 (I1_I1574_G20_0 I1_I1574_P20_5n XI1_I1574_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I188_XG_MN1 (XI1_I1574_I188_XG_n1 I1_I1574_G4_0n I1_I1574_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I183_XG_MN2 (XI1_I1574_I183_XG_n1 I1_I1574_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I183_XG_MN0 (I1_I1574_G16_0 I1_I1574_P16_1n XI1_I1574_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I183_XG_MN1 (XI1_I1574_I183_XG_n1 I1_I1574_G0_0n I1_I1574_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I131_XG_MN2 (XI1_I1574_I131_XG_n1 I1_I1574_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I131_XG_MN0 (I1_I1574_G6_0 I1_I1574_P6_3n XI1_I1574_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I131_XG_MN1 (XI1_I1574_I131_XG_n1 I1_I1574_G2_0n I1_I1574_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I76_XG_MN2 (XI2_I1_I42_I76_XG_n1 I2_I1_I42_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I76_XG_MN0 (I2_I1_I42_G10_9 I2_I1_I42_pn10 XI2_I1_I42_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I76_XG_MN1 (XI2_I1_I42_I76_XG_n1 I2_I1_I42_gn9 I2_I1_I42_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I77_XG_MN2 (XI2_I1_I42_I77_XG_n1 I2_I1_I42_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I77_XG_MN0 (I2_I1_I42_G11_10 I2_I1_I42_pn11 XI2_I1_I42_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I77_XG_MN1 (XI2_I1_I42_I77_XG_n1 I2_I1_I42_gn10 I2_I1_I42_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I135_XG_MN2 (XI2_I1_I42_I135_XG_n1 I2_I1_I42_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I135_XG_MN0 (I2_I1_I42_G10_3 I2_I1_I42_P10_7n XI2_I1_I42_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I135_XG_MN1 (XI2_I1_I42_I135_XG_n1 I2_I1_I42_G6_3n I2_I1_I42_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I185_XG_MN2 (XI2_I1_I42_I185_XG_n1 I2_I1_I42_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I185_XG_MN0 (I2_I1_I42_G18_0 I2_I1_I42_P18_3n XI2_I1_I42_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I185_XG_MN1 (XI2_I1_I42_I185_XG_n1 I2_I1_I42_G2_0n I2_I1_I42_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I138_XG_MN2 (XI2_I1_I42_I138_XG_n1 I2_I1_I42_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I138_XG_MN0 (I2_I1_I42_G13_6 I2_I1_I42_P13_10n XI2_I1_I42_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I138_XG_MN1 (XI2_I1_I42_I138_XG_n1 I2_I1_I42_G9_6n I2_I1_I42_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I142_XG_MN2 (XI2_I1_I42_I142_XG_n1 I2_I1_I42_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I142_XG_MN0 (I2_I1_I42_G17_10 I2_I1_I42_P17_14n XI2_I1_I42_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I142_XG_MN1 (XI2_I1_I42_I142_XG_n1 I2_I1_I42_G13_10n I2_I1_I42_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I190_XG_MN2 (XI2_I1_I42_I190_XG_n1 I2_I1_I42_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I190_XG_MN0 (I2_I1_I42_G21_0 I2_I1_I42_P21_6n XI2_I1_I42_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I190_XG_MN1 (XI2_I1_I42_I190_XG_n1 I2_I1_I42_G5_0n I2_I1_I42_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I146_XG_MN2 (XI2_I1_I42_I146_XG_n1 I2_I1_I42_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I146_XG_MN0 (I2_I1_I42_G21_14 I2_I1_I42_P21_18n XI2_I1_I42_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I146_XG_MN1 (XI2_I1_I42_I146_XG_n1 I2_I1_I42_G17_14n I2_I1_I42_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I150_XG_MN2 (XI2_I1_I42_I150_XG_n1 I2_I1_I42_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I150_XG_MN0 (I2_I1_I42_G25_18 I2_I1_I42_P25_22n XI2_I1_I42_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I150_XG_MN1 (XI2_I1_I42_I150_XG_n1 I2_I1_I42_G21_18n I2_I1_I42_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I194_XG_MN2 (XI2_I1_I42_I194_XG_n1 I2_I1_I42_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I194_XG_MN0 (I2_I1_I42_G23_0 I2_I1_I42_P23_8n XI2_I1_I42_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I194_XG_MN1 (XI2_I1_I42_I194_XG_n1 I2_I1_I42_G7_0n I2_I1_I42_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I200_XG_MN2 (XI2_I1_I42_I200_XG_n1 I2_I1_I42_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I200_XG_MN0 (I2_I1_I42_G29_0 I2_I1_I42_P29_14n XI2_I1_I42_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I200_XG_MN1 (XI2_I1_I42_I200_XG_n1 I2_I1_I42_G13_0n I2_I1_I42_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I156_XG_MN2 (XI2_I1_I42_I156_XG_n1 I2_I1_I42_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I156_XG_MN0 (I2_I1_I42_G31_24 I2_I1_I42_P31_28n XI2_I1_I42_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I156_XG_MN1 (XI2_I1_I42_I156_XG_n1 I2_I1_I42_G27_24n I2_I1_I42_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I97_XG_MN2 (XI2_I1_I42_I97_XG_n1 I2_I1_I42_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I97_XG_MN0 (I2_I1_I42_G31_30 I2_I1_I42_pn31 XI2_I1_I42_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I97_XG_MN1 (XI2_I1_I42_I97_XG_n1 I2_I1_I42_gn30 I2_I1_I42_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I97_XG_MN2 (XI1_I1712_I97_XG_n1 I1_I1712_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I97_XG_MN0 (I1_I1712_G31_30 I1_I1712_pn31 XI1_I1712_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I97_XG_MN1 (XI1_I1712_I97_XG_n1 I1_I1712_gn30 I1_I1712_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I89_XG_MN2 (XI1_I1712_I89_XG_n1 I1_I1712_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I89_XG_MN0 (I1_I1712_G23_22 I1_I1712_pn23 XI1_I1712_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I89_XG_MN1 (XI1_I1712_I89_XG_n1 I1_I1712_gn22 I1_I1712_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I88_XG_MN2 (XI1_I1712_I88_XG_n1 I1_I1712_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I88_XG_MN0 (I1_I1712_G22_21 I1_I1712_pn22 XI1_I1712_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I88_XG_MN1 (XI1_I1712_I88_XG_n1 I1_I1712_gn21 I1_I1712_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I201_XG_MN2 (XI1_I1712_I201_XG_n1 I1_I1712_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I201_XG_MN0 (I1_c25_m I1_I1712_P30_15n XI1_I1712_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I201_XG_MN1 (XI1_I1712_I201_XG_n1 I1_I1712_G14_0n I1_c25_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I192_XG_MN2 (XI1_I1712_I192_XG_n1 I1_I1712_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I192_XG_MN0 (I1_I1712_G22_0 I1_I1712_P22_7n XI1_I1712_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I192_XG_MN1 (XI1_I1712_I192_XG_n1 I1_I1712_G6_0n I1_I1712_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I143_XG_MN2 (XI1_I1712_I143_XG_n1 I1_I1712_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I143_XG_MN0 (I1_I1712_G18_11 I1_I1712_P18_15n XI1_I1712_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I143_XG_MN1 (XI1_I1712_I143_XG_n1 I1_I1712_G14_11n I1_I1712_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I76_XG_MN2 (XI1_I1712_I76_XG_n1 I1_I1712_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I76_XG_MN0 (I1_I1712_G10_9 I1_I1712_pn10 XI1_I1712_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I76_XG_MN1 (XI1_I1712_I76_XG_n1 I1_I1712_gn9 I1_I1712_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I75_XG_MN2 (XI1_I1712_I75_XG_n1 I1_I1712_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I75_XG_MN0 (I1_I1712_G9_8 I1_I1712_pn9 XI1_I1712_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I75_XG_MN1 (XI1_I1712_I75_XG_n1 I1_I1712_gn8 I1_I1712_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I65_XG_MN2 (XI1_I1712_I65_XG_n1 I1_I1712_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I65_XG_MN0 (I1_I1712_G0_0 I1_I1712_pn0 XI1_I1712_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I65_XG_MN1 (XI1_I1712_I65_XG_n1 I1_I1712_cinn I1_I1712_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I87_XG_MN2 (XI1_I1574_I87_XG_n1 I1_I1574_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I87_XG_MN0 (I1_I1574_G21_20 I1_I1574_pn21 XI1_I1574_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I87_XG_MN1 (XI1_I1574_I87_XG_n1 I1_I1574_gn20 I1_I1574_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I86_XG_MN2 (XI1_I1574_I86_XG_n1 I1_I1574_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I86_XG_MN0 (I1_I1574_G20_19 I1_I1574_pn20 XI1_I1574_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I86_XG_MN1 (XI1_I1574_I86_XG_n1 I1_I1574_gn19 I1_I1574_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I151_XG_MN2 (XI1_I1574_I151_XG_n1 I1_I1574_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I151_XG_MN0 (I1_I1574_G26_19 I1_I1574_P26_23n XI1_I1574_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I151_XG_MN1 (XI1_I1574_I151_XG_n1 I1_I1574_G22_19n I1_I1574_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I147_XG_MN2 (XI1_I1574_I147_XG_n1 I1_I1574_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I147_XG_MN0 (I1_I1574_G22_15 I1_I1574_P22_19n XI1_I1574_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I147_XG_MN1 (XI1_I1574_I147_XG_n1 I1_I1574_G18_15n I1_I1574_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I143_XG_MN2 (XI1_I1574_I143_XG_n1 I1_I1574_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I143_XG_MN0 (I1_I1574_G18_11 I1_I1574_P18_15n XI1_I1574_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I143_XG_MN1 (XI1_I1574_I143_XG_n1 I1_I1574_G14_11n I1_I1574_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I185_XG_MN2 (XI1_I1574_I185_XG_n1 I1_I1574_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I185_XG_MN0 (I1_I1574_G18_0 I1_I1574_P18_3n XI1_I1574_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I185_XG_MN1 (XI1_I1574_I185_XG_n1 I1_I1574_G2_0n I1_I1574_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I135_XG_MN2 (XI1_I1574_I135_XG_n1 I1_I1574_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I135_XG_MN0 (I1_I1574_G10_3 I1_I1574_P10_7n XI1_I1574_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I135_XG_MN1 (XI1_I1574_I135_XG_n1 I1_I1574_G6_3n I1_I1574_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I131_XG_MN2 (XI2_I1_I42_I131_XG_n1 I2_I1_I42_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I131_XG_MN0 (I2_I1_I42_G6_0 I2_I1_I42_P6_3n XI2_I1_I42_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I131_XG_MN1 (XI2_I1_I42_I131_XG_n1 I2_I1_I42_G2_0n I2_I1_I42_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I183_XG_MN2 (XI2_I1_I42_I183_XG_n1 I2_I1_I42_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I183_XG_MN0 (I2_I1_I42_G16_0 I2_I1_I42_P16_1n XI2_I1_I42_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I183_XG_MN1 (XI2_I1_I42_I183_XG_n1 I2_I1_I42_G0_0n I2_I1_I42_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I136_XG_MN2 (XI2_I1_I42_I136_XG_n1 I2_I1_I42_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I136_XG_MN0 (I2_I1_I42_G11_4 I2_I1_I42_P11_8n XI2_I1_I42_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I136_XG_MN1 (XI2_I1_I42_I136_XG_n1 I2_I1_I42_G7_4n I2_I1_I42_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I186_XG_MN2 (XI2_I1_I42_I186_XG_n1 I2_I1_I42_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I186_XG_MN0 (I2_I1_I42_G19_0 I2_I1_I42_P19_4n XI2_I1_I42_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I186_XG_MN1 (XI2_I1_I42_I186_XG_n1 I2_I1_I42_G3_0n I2_I1_I42_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I196_XG_MN2 (XI2_I1_I42_I196_XG_n1 I2_I1_I42_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I196_XG_MN0 (I2_I1_I42_G25_0 I2_I1_I42_P25_10n XI2_I1_I42_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I196_XG_MN1 (XI2_I1_I42_I196_XG_n1 I2_I1_I42_G9_0n I2_I1_I42_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I87_XG_MN2 (XI1_I1712_I87_XG_n1 I1_I1712_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I87_XG_MN0 (I1_I1712_G21_20 I1_I1712_pn21 XI1_I1712_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I87_XG_MN1 (XI1_I1712_I87_XG_n1 I1_I1712_gn20 I1_I1712_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I86_XG_MN2 (XI1_I1712_I86_XG_n1 I1_I1712_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I86_XG_MN0 (I1_I1712_G20_19 I1_I1712_pn20 XI1_I1712_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I86_XG_MN1 (XI1_I1712_I86_XG_n1 I1_I1712_gn19 I1_I1712_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I85_XG_MN2 (XI1_I1712_I85_XG_n1 I1_I1712_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I85_XG_MN0 (I1_I1712_G19_18 I1_I1712_pn19 XI1_I1712_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I85_XG_MN1 (XI1_I1712_I85_XG_n1 I1_I1712_gn18 I1_I1712_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I79_XG_MN2 (XI1_I1712_I79_XG_n1 I1_I1712_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I79_XG_MN0 (I1_I1712_G13_12 I1_I1712_pn13 XI1_I1712_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I79_XG_MN1 (XI1_I1712_I79_XG_n1 I1_I1712_gn12 I1_I1712_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I78_XG_MN2 (XI1_I1712_I78_XG_n1 I1_I1712_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I78_XG_MN0 (I1_I1712_G12_11 I1_I1712_pn12 XI1_I1712_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I78_XG_MN1 (XI1_I1712_I78_XG_n1 I1_I1712_gn11 I1_I1712_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I77_XG_MN2 (XI1_I1712_I77_XG_n1 I1_I1712_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I77_XG_MN0 (I1_I1712_G11_10 I1_I1712_pn11 XI1_I1712_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I77_XG_MN1 (XI1_I1712_I77_XG_n1 I1_I1712_gn10 I1_I1712_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I67_XG_MN2 (XI1_I1666_I67_XG_n1 I1_I1666_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I67_XG_MN0 (I1_I1666_G1_0 I1_I1666_pn1 XI1_I1666_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I67_XG_MN1 (XI1_I1666_I67_XG_n1 I1_I1666_G0_0n I1_I1666_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I68_XG_MN2 (XI1_I1666_I68_XG_n1 I1_I1666_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I68_XG_MN0 (I1_I1666_G2_1 I1_I1666_pn2 XI1_I1666_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I68_XG_MN1 (XI1_I1666_I68_XG_n1 I1_I1666_gn1 I1_I1666_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I69_XG_MN2 (XI1_I1666_I69_XG_n1 I1_I1666_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I69_XG_MN0 (I1_I1666_G3_2 I1_I1666_pn3 XI1_I1666_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I69_XG_MN1 (XI1_I1666_I69_XG_n1 I1_I1666_gn2 I1_I1666_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I201_XG_MN2 (XI1_I1574_I201_XG_n1 I1_I1574_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I201_XG_MN0 (I1_c22_m I1_I1574_P30_15n XI1_I1574_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I201_XG_MN1 (XI1_I1574_I201_XG_n1 I1_I1574_G14_0n I1_c22_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I192_XG_MN2 (XI1_I1574_I192_XG_n1 I1_I1574_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I192_XG_MN0 (I1_I1574_G22_0 I1_I1574_P22_7n XI1_I1574_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I192_XG_MN1 (XI1_I1574_I192_XG_n1 I1_I1574_G6_0n I1_I1574_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I197_XG_MN2 (XI1_I1574_I197_XG_n1 I1_I1574_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I197_XG_MN0 (I1_I1574_G26_0 I1_I1574_P26_11n XI1_I1574_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I197_XG_MN1 (XI1_I1574_I197_XG_n1 I1_I1574_G10_0n I1_I1574_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I65_XG_MN2 (XI1_I1574_I65_XG_n1 I1_I1574_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I65_XG_MN0 (I1_I1574_G0_0 I1_I1574_pn0 XI1_I1574_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1574_I65_XG_MN1 (XI1_I1574_I65_XG_n1 I1_I1574_cinn I1_I1574_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I74_XG_MN2 (XI2_I1_I42_I74_XG_n1 I2_I1_I42_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I74_XG_MN0 (I2_I1_I42_G8_7 I2_I1_I42_pn8 XI2_I1_I42_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I74_XG_MN1 (XI2_I1_I42_I74_XG_n1 I2_I1_I42_gn7 I2_I1_I42_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I75_XG_MN2 (XI2_I1_I42_I75_XG_n1 I2_I1_I42_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I75_XG_MN0 (I2_I1_I42_G9_8 I2_I1_I42_pn9 XI2_I1_I42_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I75_XG_MN1 (XI2_I1_I42_I75_XG_n1 I2_I1_I42_gn8 I2_I1_I42_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I133_XG_MN2 (XI2_I1_I42_I133_XG_n1 I2_I1_I42_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I133_XG_MN0 (I2_I1_I42_G8_1 I2_I1_I42_P8_5n XI2_I1_I42_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I133_XG_MN1 (XI2_I1_I42_I133_XG_n1 I2_I1_I42_G4_1n I2_I1_I42_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I132_XG_MN2 (XI2_I1_I42_I132_XG_n1 I2_I1_I42_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I132_XG_MN0 (I2_I1_I42_G7_0 I2_I1_I42_P7_4n XI2_I1_I42_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I132_XG_MN1 (XI2_I1_I42_I132_XG_n1 I2_I1_I42_G3_0n I2_I1_I42_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I134_XG_MN2 (XI2_I1_I42_I134_XG_n1 I2_I1_I42_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I134_XG_MN0 (I2_I1_I42_G9_2 I2_I1_I42_P9_6n XI2_I1_I42_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I134_XG_MN1 (XI2_I1_I42_I134_XG_n1 I2_I1_I42_G5_2n I2_I1_I42_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I184_XG_MN2 (XI2_I1_I42_I184_XG_n1 I2_I1_I42_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I184_XG_MN0 (I2_I1_I42_G17_0 I2_I1_I42_P17_2n XI2_I1_I42_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I184_XG_MN1 (XI2_I1_I42_I184_XG_n1 I2_I1_I42_G1_0n I2_I1_I42_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I81_XG_MN2 (XI1_I1712_I81_XG_n1 I1_I1712_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I81_XG_MN0 (I1_I1712_G15_14 I1_I1712_pn15 XI1_I1712_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I81_XG_MN1 (XI1_I1712_I81_XG_n1 I1_I1712_gn14 I1_I1712_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I80_XG_MN2 (XI1_I1712_I80_XG_n1 I1_I1712_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I80_XG_MN0 (I1_I1712_G14_13 I1_I1712_pn14 XI1_I1712_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1712_I80_XG_MN1 (XI1_I1712_I80_XG_n1 I1_I1712_gn13 I1_I1712_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I185_XG_MN2 (XI1_I1666_I185_XG_n1 I1_I1666_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I185_XG_MN0 (I1_I1666_G18_0 I1_I1666_P18_3n XI1_I1666_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I185_XG_MN1 (XI1_I1666_I185_XG_n1 I1_I1666_G2_0n I1_I1666_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I183_XG_MN2 (XI1_I1666_I183_XG_n1 I1_I1666_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I183_XG_MN0 (I1_I1666_G16_0 I1_I1666_P16_1n XI1_I1666_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I183_XG_MN1 (XI1_I1666_I183_XG_n1 I1_I1666_G0_0n I1_I1666_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I128_XG_MN2 (XI1_I1666_I128_XG_n1 I1_I1666_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I128_XG_MN0 (I1_I1666_G4_0 I1_I1666_P4_1n XI1_I1666_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I128_XG_MN1 (XI1_I1666_I128_XG_n1 I1_I1666_G0_0n I1_I1666_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I70_XG_MN2 (XI1_I1666_I70_XG_n1 I1_I1666_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I70_XG_MN0 (I1_I1666_G4_3 I1_I1666_pn4 XI1_I1666_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I70_XG_MN1 (XI1_I1666_I70_XG_n1 I1_I1666_gn3 I1_I1666_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I71_XG_MN2 (XI1_I1666_I71_XG_n1 I1_I1666_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I71_XG_MN0 (I1_I1666_G5_4 I1_I1666_pn5 XI1_I1666_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I71_XG_MN1 (XI1_I1666_I71_XG_n1 I1_I1666_gn4 I1_I1666_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I73_XG_MN2 (XI2_I1_I42_I73_XG_n1 I2_I1_I42_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I73_XG_MN0 (I2_I1_I42_G7_6 I2_I1_I42_pn7 XI2_I1_I42_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I73_XG_MN1 (XI2_I1_I42_I73_XG_n1 I2_I1_I42_gn6 I2_I1_I42_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I72_XG_MN2 (XI2_I1_I42_I72_XG_n1 I2_I1_I42_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I72_XG_MN0 (I2_I1_I42_G6_5 I2_I1_I42_pn6 XI2_I1_I42_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I72_XG_MN1 (XI2_I1_I42_I72_XG_n1 I2_I1_I42_gn5 I2_I1_I42_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I130_XG_MN2 (XI2_I1_I42_I130_XG_n1 I2_I1_I42_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I130_XG_MN0 (I2_I1_I42_G5_0 I2_I1_I42_P5_2n XI2_I1_I42_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I130_XG_MN1 (XI2_I1_I42_I130_XG_n1 I2_I1_I42_G1_0n I2_I1_I42_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I131_XG_MN2 (XI1_I1666_I131_XG_n1 I1_I1666_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I131_XG_MN0 (I1_I1666_G6_0 I1_I1666_P6_3n XI1_I1666_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I131_XG_MN1 (XI1_I1666_I131_XG_n1 I1_I1666_G2_0n I1_I1666_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I133_XG_MN2 (XI1_I1666_I133_XG_n1 I1_I1666_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I133_XG_MN0 (I1_I1666_G8_1 I1_I1666_P8_5n XI1_I1666_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I133_XG_MN1 (XI1_I1666_I133_XG_n1 I1_I1666_G4_1n I1_I1666_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I130_XG_MN2 (XI1_I1666_I130_XG_n1 I1_I1666_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I130_XG_MN0 (I1_I1666_G5_0 I1_I1666_P5_2n XI1_I1666_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I130_XG_MN1 (XI1_I1666_I130_XG_n1 I1_I1666_G1_0n I1_I1666_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I72_XG_MN2 (XI1_I1666_I72_XG_n1 I1_I1666_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I72_XG_MN0 (I1_I1666_G6_5 I1_I1666_pn6 XI1_I1666_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I72_XG_MN1 (XI1_I1666_I72_XG_n1 I1_I1666_gn5 I1_I1666_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I73_XG_MN2 (XI1_I1666_I73_XG_n1 I1_I1666_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I73_XG_MN0 (I1_I1666_G7_6 I1_I1666_pn7 XI1_I1666_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I73_XG_MN1 (XI1_I1666_I73_XG_n1 I1_I1666_gn6 I1_I1666_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I74_XG_MN2 (XI1_I1666_I74_XG_n1 I1_I1666_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I74_XG_MN0 (I1_I1666_G8_7 I1_I1666_pn8 XI1_I1666_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I74_XG_MN1 (XI1_I1666_I74_XG_n1 I1_I1666_gn7 I1_I1666_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I65_XG_MN2 (XI1_I1620_I65_XG_n1 I1_I1620_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I65_XG_MN0 (I1_I1620_G0_0 I1_I1620_pn0 XI1_I1620_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I65_XG_MN1 (XI1_I1620_I65_XG_n1 I1_I1620_cinn I1_I1620_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I71_XG_MN2 (XI2_I1_I42_I71_XG_n1 I2_I1_I42_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I71_XG_MN0 (I2_I1_I42_G5_4 I2_I1_I42_pn5 XI2_I1_I42_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I71_XG_MN1 (XI2_I1_I42_I71_XG_n1 I2_I1_I42_gn4 I2_I1_I42_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I128_XG_MN2 (XI2_I1_I42_I128_XG_n1 I2_I1_I42_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I128_XG_MN0 (I2_I1_I42_G4_0 I2_I1_I42_P4_1n XI2_I1_I42_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I128_XG_MN1 (XI2_I1_I42_I128_XG_n1 I2_I1_I42_G0_0n I2_I1_I42_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I135_XG_MN2 (XI1_I1666_I135_XG_n1 I1_I1666_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I135_XG_MN0 (I1_I1666_G10_3 I1_I1666_P10_7n XI1_I1666_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I135_XG_MN1 (XI1_I1666_I135_XG_n1 I1_I1666_G6_3n I1_I1666_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I195_XG_MN2 (XI1_I1666_I195_XG_n1 I1_I1666_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I195_XG_MN0 (I1_I1666_G24_0 I1_I1666_P24_9n XI1_I1666_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I195_XG_MN1 (XI1_I1666_I195_XG_n1 I1_I1666_G8_0n I1_I1666_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I132_XG_MN2 (XI1_I1666_I132_XG_n1 I1_I1666_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I132_XG_MN0 (I1_I1666_G7_0 I1_I1666_P7_4n XI1_I1666_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I132_XG_MN1 (XI1_I1666_I132_XG_n1 I1_I1666_G3_0n I1_I1666_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I184_XG_MN2 (XI1_I1666_I184_XG_n1 I1_I1666_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I184_XG_MN0 (I1_I1666_G17_0 I1_I1666_P17_2n XI1_I1666_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I184_XG_MN1 (XI1_I1666_I184_XG_n1 I1_I1666_G1_0n I1_I1666_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I134_XG_MN2 (XI1_I1666_I134_XG_n1 I1_I1666_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I134_XG_MN0 (I1_I1666_G9_2 I1_I1666_P9_6n XI1_I1666_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I134_XG_MN1 (XI1_I1666_I134_XG_n1 I1_I1666_G5_2n I1_I1666_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I75_XG_MN2 (XI1_I1666_I75_XG_n1 I1_I1666_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I75_XG_MN0 (I1_I1666_G9_8 I1_I1666_pn9 XI1_I1666_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I75_XG_MN1 (XI1_I1666_I75_XG_n1 I1_I1666_gn8 I1_I1666_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I76_XG_MN2 (XI1_I1666_I76_XG_n1 I1_I1666_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I76_XG_MN0 (I1_I1666_G10_9 I1_I1666_pn10 XI1_I1666_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I76_XG_MN1 (XI1_I1666_I76_XG_n1 I1_I1666_gn9 I1_I1666_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I75_XG_MN2 (XI1_I1620_I75_XG_n1 I1_I1620_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I75_XG_MN0 (I1_I1620_G9_8 I1_I1620_pn9 XI1_I1620_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I75_XG_MN1 (XI1_I1620_I75_XG_n1 I1_I1620_gn8 I1_I1620_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I74_XG_MN2 (XI1_I1620_I74_XG_n1 I1_I1620_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I74_XG_MN0 (I1_I1620_G8_7 I1_I1620_pn8 XI1_I1620_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I74_XG_MN1 (XI1_I1620_I74_XG_n1 I1_I1620_gn7 I1_I1620_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I73_XG_MN2 (XI1_I1620_I73_XG_n1 I1_I1620_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I73_XG_MN0 (I1_I1620_G7_6 I1_I1620_pn7 XI1_I1620_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I73_XG_MN1 (XI1_I1620_I73_XG_n1 I1_I1620_gn6 I1_I1620_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I70_XG_MN2 (XI2_I1_I42_I70_XG_n1 I2_I1_I42_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I70_XG_MN0 (I2_I1_I42_G4_3 I2_I1_I42_pn4 XI2_I1_I42_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I70_XG_MN1 (XI2_I1_I42_I70_XG_n1 I2_I1_I42_gn3 I2_I1_I42_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I69_XG_MN2 (XI2_I1_I42_I69_XG_n1 I2_I1_I42_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I69_XG_MN0 (I2_I1_I42_G3_2 I2_I1_I42_pn3 XI2_I1_I42_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I69_XG_MN1 (XI2_I1_I42_I69_XG_n1 I2_I1_I42_gn2 I2_I1_I42_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I95_XG_MN2 (XI1_I1758_I95_XG_n1 I1_I1758_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I95_XG_MN0 (I1_I1758_G29_28 I1_I1758_pn29 XI1_I1758_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I95_XG_MN1 (XI1_I1758_I95_XG_n1 I1_I1758_gn28 I1_I1758_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I94_XG_MN2 (XI1_I1758_I94_XG_n1 I1_I1758_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I94_XG_MN0 (I1_I1758_G28_27 I1_I1758_pn28 XI1_I1758_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I94_XG_MN1 (XI1_I1758_I94_XG_n1 I1_I1758_gn27 I1_I1758_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I93_XG_MN2 (XI1_I1758_I93_XG_n1 I1_I1758_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I93_XG_MN0 (I1_I1758_G27_26 I1_I1758_pn27 XI1_I1758_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I93_XG_MN1 (XI1_I1758_I93_XG_n1 I1_I1758_gn26 I1_I1758_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I188_XG_MN2 (XI1_I1666_I188_XG_n1 I1_I1666_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I188_XG_MN0 (I1_I1666_G20_0 I1_I1666_P20_5n XI1_I1666_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I188_XG_MN1 (XI1_I1666_I188_XG_n1 I1_I1666_G4_0n I1_I1666_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I141_XG_MN2 (XI1_I1666_I141_XG_n1 I1_I1666_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I141_XG_MN0 (I1_I1666_G16_9 I1_I1666_P16_13n XI1_I1666_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I141_XG_MN1 (XI1_I1666_I141_XG_n1 I1_I1666_G12_9n I1_I1666_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I137_XG_MN2 (XI1_I1666_I137_XG_n1 I1_I1666_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I137_XG_MN0 (I1_I1666_G12_5 I1_I1666_P12_9n XI1_I1666_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I137_XG_MN1 (XI1_I1666_I137_XG_n1 I1_I1666_G8_5n I1_I1666_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I186_XG_MN2 (XI1_I1666_I186_XG_n1 I1_I1666_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I186_XG_MN0 (I1_I1666_G19_0 I1_I1666_P19_4n XI1_I1666_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I186_XG_MN1 (XI1_I1666_I186_XG_n1 I1_I1666_G3_0n I1_I1666_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I136_XG_MN2 (XI1_I1666_I136_XG_n1 I1_I1666_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I136_XG_MN0 (I1_I1666_G11_4 I1_I1666_P11_8n XI1_I1666_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I136_XG_MN1 (XI1_I1666_I136_XG_n1 I1_I1666_G7_4n I1_I1666_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I77_XG_MN2 (XI1_I1666_I77_XG_n1 I1_I1666_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I77_XG_MN0 (I1_I1666_G11_10 I1_I1666_pn11 XI1_I1666_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I77_XG_MN1 (XI1_I1666_I77_XG_n1 I1_I1666_gn10 I1_I1666_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I78_XG_MN2 (XI1_I1666_I78_XG_n1 I1_I1666_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I78_XG_MN0 (I1_I1666_G12_11 I1_I1666_pn12 XI1_I1666_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I78_XG_MN1 (XI1_I1666_I78_XG_n1 I1_I1666_gn11 I1_I1666_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I80_XG_MN2 (XI1_I1620_I80_XG_n1 I1_I1620_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I80_XG_MN0 (I1_I1620_G14_13 I1_I1620_pn14 XI1_I1620_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I80_XG_MN1 (XI1_I1620_I80_XG_n1 I1_I1620_gn13 I1_I1620_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I79_XG_MN2 (XI1_I1620_I79_XG_n1 I1_I1620_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I79_XG_MN0 (I1_I1620_G13_12 I1_I1620_pn13 XI1_I1620_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I79_XG_MN1 (XI1_I1620_I79_XG_n1 I1_I1620_gn12 I1_I1620_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I78_XG_MN2 (XI1_I1620_I78_XG_n1 I1_I1620_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I78_XG_MN0 (I1_I1620_G12_11 I1_I1620_pn12 XI1_I1620_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I78_XG_MN1 (XI1_I1620_I78_XG_n1 I1_I1620_gn11 I1_I1620_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I72_XG_MN2 (XI1_I1620_I72_XG_n1 I1_I1620_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I72_XG_MN0 (I1_I1620_G6_5 I1_I1620_pn6 XI1_I1620_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I72_XG_MN1 (XI1_I1620_I72_XG_n1 I1_I1620_gn5 I1_I1620_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I69_XG_MN2 (XI1_I1620_I69_XG_n1 I1_I1620_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I69_XG_MN0 (I1_I1620_G3_2 I1_I1620_pn3 XI1_I1620_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I69_XG_MN1 (XI1_I1620_I69_XG_n1 I1_I1620_gn2 I1_I1620_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I68_XG_MN2 (XI1_I1620_I68_XG_n1 I1_I1620_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I68_XG_MN0 (I1_I1620_G2_1 I1_I1620_pn2 XI1_I1620_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I68_XG_MN1 (XI1_I1620_I68_XG_n1 I1_I1620_gn1 I1_I1620_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I67_XG_MN2 (XI1_I1620_I67_XG_n1 I1_I1620_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I67_XG_MN0 (I1_I1620_G1_0 I1_I1620_pn1 XI1_I1620_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I67_XG_MN1 (XI1_I1620_I67_XG_n1 I1_I1620_G0_0n I1_I1620_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I92_XG_MN2 (XI1_I1758_I92_XG_n1 I1_I1758_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I92_XG_MN0 (I1_I1758_G26_25 I1_I1758_pn26 XI1_I1758_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I92_XG_MN1 (XI1_I1758_I92_XG_n1 I1_I1758_gn25 I1_I1758_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I91_XG_MN2 (XI1_I1758_I91_XG_n1 I1_I1758_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I91_XG_MN0 (I1_I1758_G25_24 I1_I1758_pn25 XI1_I1758_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I91_XG_MN1 (XI1_I1758_I91_XG_n1 I1_I1758_gn24 I1_I1758_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I89_XG_MN2 (XI1_I1758_I89_XG_n1 I1_I1758_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I89_XG_MN0 (I1_I1758_G23_22 I1_I1758_pn23 XI1_I1758_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I89_XG_MN1 (XI1_I1758_I89_XG_n1 I1_I1758_gn22 I1_I1758_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I90_XG_MN2 (XI1_I1758_I90_XG_n1 I1_I1758_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I90_XG_MN0 (I1_I1758_G24_23 I1_I1758_pn24 XI1_I1758_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I90_XG_MN1 (XI1_I1758_I90_XG_n1 I1_I1758_gn23 I1_I1758_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I88_XG_MN2 (XI1_I1758_I88_XG_n1 I1_I1758_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I88_XG_MN0 (I1_I1758_G22_21 I1_I1758_pn22 XI1_I1758_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I88_XG_MN1 (XI1_I1758_I88_XG_n1 I1_I1758_gn21 I1_I1758_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I85_XG_MN2 (XI1_I1758_I85_XG_n1 I1_I1758_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I85_XG_MN0 (I1_I1758_G19_18 I1_I1758_pn19 XI1_I1758_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I85_XG_MN1 (XI1_I1758_I85_XG_n1 I1_I1758_gn18 I1_I1758_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I84_XG_MN2 (XI1_I1758_I84_XG_n1 I1_I1758_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I84_XG_MN0 (I1_I1758_G18_17 I1_I1758_pn18 XI1_I1758_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I84_XG_MN1 (XI1_I1758_I84_XG_n1 I1_I1758_gn17 I1_I1758_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I83_XG_MN2 (XI1_I1758_I83_XG_n1 I1_I1758_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I83_XG_MN0 (I1_I1758_G17_16 I1_I1758_pn17 XI1_I1758_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I83_XG_MN1 (XI1_I1758_I83_XG_n1 I1_I1758_gn16 I1_I1758_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I81_XG_MN2 (XI1_I1758_I81_XG_n1 I1_I1758_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I81_XG_MN0 (I1_I1758_G15_14 I1_I1758_pn15 XI1_I1758_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I81_XG_MN1 (XI1_I1758_I81_XG_n1 I1_I1758_gn14 I1_I1758_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I79_XG_MN2 (XI1_I1758_I79_XG_n1 I1_I1758_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I79_XG_MN0 (I1_I1758_G13_12 I1_I1758_pn13 XI1_I1758_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I79_XG_MN1 (XI1_I1758_I79_XG_n1 I1_I1758_gn12 I1_I1758_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I197_XG_MN2 (XI1_I1666_I197_XG_n1 I1_I1666_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I197_XG_MN0 (I1_I1666_G26_0 I1_I1666_P26_11n XI1_I1666_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I197_XG_MN1 (XI1_I1666_I197_XG_n1 I1_I1666_G10_0n I1_I1666_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I139_XG_MN2 (XI1_I1666_I139_XG_n1 I1_I1666_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I139_XG_MN0 (I1_I1666_G14_7 I1_I1666_P14_11n XI1_I1666_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I139_XG_MN1 (XI1_I1666_I139_XG_n1 I1_I1666_G10_7n I1_I1666_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I143_XG_MN2 (XI1_I1666_I143_XG_n1 I1_I1666_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I143_XG_MN0 (I1_I1666_G18_11 I1_I1666_P18_15n XI1_I1666_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I143_XG_MN1 (XI1_I1666_I143_XG_n1 I1_I1666_G14_11n I1_I1666_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I196_XG_MN2 (XI1_I1666_I196_XG_n1 I1_I1666_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I196_XG_MN0 (I1_I1666_G25_0 I1_I1666_P25_10n XI1_I1666_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I196_XG_MN1 (XI1_I1666_I196_XG_n1 I1_I1666_G9_0n I1_I1666_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I142_XG_MN2 (XI1_I1666_I142_XG_n1 I1_I1666_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I142_XG_MN0 (I1_I1666_G17_10 I1_I1666_P17_14n XI1_I1666_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I142_XG_MN1 (XI1_I1666_I142_XG_n1 I1_I1666_G13_10n I1_I1666_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I138_XG_MN2 (XI1_I1666_I138_XG_n1 I1_I1666_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I138_XG_MN0 (I1_I1666_G13_6 I1_I1666_P13_10n XI1_I1666_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I138_XG_MN1 (XI1_I1666_I138_XG_n1 I1_I1666_G9_6n I1_I1666_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I80_XG_MN2 (XI1_I1666_I80_XG_n1 I1_I1666_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I80_XG_MN0 (I1_I1666_G14_13 I1_I1666_pn14 XI1_I1666_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I80_XG_MN1 (XI1_I1666_I80_XG_n1 I1_I1666_gn13 I1_I1666_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I79_XG_MN2 (XI1_I1666_I79_XG_n1 I1_I1666_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I79_XG_MN0 (I1_I1666_G13_12 I1_I1666_pn13 XI1_I1666_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I79_XG_MN1 (XI1_I1666_I79_XG_n1 I1_I1666_gn12 I1_I1666_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I82_XG_MN2 (XI1_I1620_I82_XG_n1 I1_I1620_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I82_XG_MN0 (I1_I1620_G16_15 I1_I1620_pn16 XI1_I1620_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I82_XG_MN1 (XI1_I1620_I82_XG_n1 I1_I1620_gn15 I1_I1620_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I131_XG_MN2 (XI1_I1620_I131_XG_n1 I1_I1620_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I131_XG_MN0 (I1_I1620_G6_0 I1_I1620_P6_3n XI1_I1620_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I131_XG_MN1 (XI1_I1620_I131_XG_n1 I1_I1620_G2_0n I1_I1620_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I81_XG_MN2 (XI1_I1620_I81_XG_n1 I1_I1620_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I81_XG_MN0 (I1_I1620_G15_14 I1_I1620_pn15 XI1_I1620_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I81_XG_MN1 (XI1_I1620_I81_XG_n1 I1_I1620_gn14 I1_I1620_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I128_XG_MN2 (XI1_I1620_I128_XG_n1 I1_I1620_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I128_XG_MN0 (I1_I1620_G4_0 I1_I1620_P4_1n XI1_I1620_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I128_XG_MN1 (XI1_I1620_I128_XG_n1 I1_I1620_G0_0n I1_I1620_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I97_XG_MN2 (XI1_I1758_I97_XG_n1 I1_I1758_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I97_XG_MN0 (I1_I1758_G31_30 I1_I1758_pn31 XI1_I1758_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I97_XG_MN1 (XI1_I1758_I97_XG_n1 I1_I1758_gn30 I1_I1758_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I96_XG_MN2 (XI1_I1758_I96_XG_n1 I1_I1758_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I96_XG_MN0 (I1_I1758_G30_29 I1_I1758_pn30 XI1_I1758_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I96_XG_MN1 (XI1_I1758_I96_XG_n1 I1_I1758_gn29 I1_I1758_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I144_XG_MN2 (XI1_I1758_I144_XG_n1 I1_I1758_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I144_XG_MN0 (I1_I1758_G19_12 I1_I1758_P19_16n XI1_I1758_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I144_XG_MN1 (XI1_I1758_I144_XG_n1 I1_I1758_G15_12n I1_I1758_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I77_XG_MN2 (XI1_I1758_I77_XG_n1 I1_I1758_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I77_XG_MN0 (I1_I1758_G11_10 I1_I1758_pn11 XI1_I1758_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I77_XG_MN1 (XI1_I1758_I77_XG_n1 I1_I1758_gn10 I1_I1758_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I199_XG_MN2 (XI1_I1666_I199_XG_n1 I1_I1666_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I199_XG_MN0 (I1_I1666_G28_0 I1_I1666_P28_13n XI1_I1666_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I199_XG_MN1 (XI1_I1666_I199_XG_n1 I1_I1666_G12_0n I1_I1666_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I145_XG_MN2 (XI1_I1666_I145_XG_n1 I1_I1666_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I145_XG_MN0 (I1_I1666_G20_13 I1_I1666_P20_17n XI1_I1666_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I145_XG_MN1 (XI1_I1666_I145_XG_n1 I1_I1666_G16_13n I1_I1666_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I198_XG_MN2 (XI1_I1666_I198_XG_n1 I1_I1666_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I198_XG_MN0 (I1_I1666_G27_0 I1_I1666_P27_12n XI1_I1666_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I198_XG_MN1 (XI1_I1666_I198_XG_n1 I1_I1666_G11_0n I1_I1666_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I190_XG_MN2 (XI1_I1666_I190_XG_n1 I1_I1666_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I190_XG_MN0 (I1_I1666_G21_0 I1_I1666_P21_6n XI1_I1666_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I190_XG_MN1 (XI1_I1666_I190_XG_n1 I1_I1666_G5_0n I1_I1666_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I140_XG_MN2 (XI1_I1666_I140_XG_n1 I1_I1666_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I140_XG_MN0 (I1_I1666_G15_8 I1_I1666_P15_12n XI1_I1666_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I140_XG_MN1 (XI1_I1666_I140_XG_n1 I1_I1666_G11_8n I1_I1666_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I81_XG_MN2 (XI1_I1666_I81_XG_n1 I1_I1666_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I81_XG_MN0 (I1_I1666_G15_14 I1_I1666_pn15 XI1_I1666_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I81_XG_MN1 (XI1_I1666_I81_XG_n1 I1_I1666_gn14 I1_I1666_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I185_XG_MN2 (XI1_I1620_I185_XG_n1 I1_I1620_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I185_XG_MN0 (I1_I1620_G18_0 I1_I1620_P18_3n XI1_I1620_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I185_XG_MN1 (XI1_I1620_I185_XG_n1 I1_I1620_G2_0n I1_I1620_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I83_XG_MN2 (XI1_I1620_I83_XG_n1 I1_I1620_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I83_XG_MN0 (I1_I1620_G17_16 I1_I1620_pn17 XI1_I1620_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I83_XG_MN1 (XI1_I1620_I83_XG_n1 I1_I1620_gn16 I1_I1620_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I135_XG_MN2 (XI1_I1620_I135_XG_n1 I1_I1620_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I135_XG_MN0 (I1_I1620_G10_3 I1_I1620_P10_7n XI1_I1620_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I135_XG_MN1 (XI1_I1620_I135_XG_n1 I1_I1620_G6_3n I1_I1620_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I137_XG_MN2 (XI1_I1620_I137_XG_n1 I1_I1620_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I137_XG_MN0 (I1_I1620_G12_5 I1_I1620_P12_9n XI1_I1620_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I137_XG_MN1 (XI1_I1620_I137_XG_n1 I1_I1620_G8_5n I1_I1620_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I133_XG_MN2 (XI1_I1620_I133_XG_n1 I1_I1620_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I133_XG_MN0 (I1_I1620_G8_1 I1_I1620_P8_5n XI1_I1620_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I133_XG_MN1 (XI1_I1620_I133_XG_n1 I1_I1620_G4_1n I1_I1620_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I156_XG_MN2 (XI1_I1758_I156_XG_n1 I1_I1758_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I156_XG_MN0 (I1_I1758_G31_24 I1_I1758_P31_28n XI1_I1758_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I156_XG_MN1 (XI1_I1758_I156_XG_n1 I1_I1758_G27_24n I1_I1758_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I154_XG_MN2 (XI1_I1758_I154_XG_n1 I1_I1758_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I154_XG_MN0 (I1_I1758_G29_22 I1_I1758_P29_26n XI1_I1758_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I154_XG_MN1 (XI1_I1758_I154_XG_n1 I1_I1758_G25_22n I1_I1758_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I152_XG_MN2 (XI1_I1758_I152_XG_n1 I1_I1758_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I152_XG_MN0 (I1_I1758_G27_20 I1_I1758_P27_24n XI1_I1758_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I152_XG_MN1 (XI1_I1758_I152_XG_n1 I1_I1758_G23_20n I1_I1758_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I140_XG_MN2 (XI1_I1758_I140_XG_n1 I1_I1758_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I140_XG_MN0 (I1_I1758_G15_8 I1_I1758_P15_12n XI1_I1758_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I140_XG_MN1 (XI1_I1758_I140_XG_n1 I1_I1758_G11_8n I1_I1758_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I142_XG_MN2 (XI1_I1758_I142_XG_n1 I1_I1758_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I142_XG_MN0 (I1_I1758_G17_10 I1_I1758_P17_14n XI1_I1758_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I142_XG_MN1 (XI1_I1758_I142_XG_n1 I1_I1758_G13_10n I1_I1758_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I76_XG_MN2 (XI1_I1758_I76_XG_n1 I1_I1758_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I76_XG_MN0 (I1_I1758_G10_9 I1_I1758_pn10 XI1_I1758_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I76_XG_MN1 (XI1_I1758_I76_XG_n1 I1_I1758_gn9 I1_I1758_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I75_XG_MN2 (XI1_I1758_I75_XG_n1 I1_I1758_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I75_XG_MN0 (I1_I1758_G9_8 I1_I1758_pn9 XI1_I1758_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I75_XG_MN1 (XI1_I1758_I75_XG_n1 I1_I1758_gn8 I1_I1758_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I74_XG_MN2 (XI1_I1758_I74_XG_n1 I1_I1758_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I74_XG_MN0 (I1_I1758_G8_7 I1_I1758_pn8 XI1_I1758_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I74_XG_MN1 (XI1_I1758_I74_XG_n1 I1_I1758_gn7 I1_I1758_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I192_XG_MN2 (XI1_I1666_I192_XG_n1 I1_I1666_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I192_XG_MN0 (I1_I1666_G22_0 I1_I1666_P22_7n XI1_I1666_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I192_XG_MN1 (XI1_I1666_I192_XG_n1 I1_I1666_G6_0n I1_I1666_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I149_XG_MN2 (XI1_I1666_I149_XG_n1 I1_I1666_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I149_XG_MN0 (I1_I1666_G24_17 I1_I1666_P24_21n XI1_I1666_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I149_XG_MN1 (XI1_I1666_I149_XG_n1 I1_I1666_G20_17n I1_I1666_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I200_XG_MN2 (XI1_I1666_I200_XG_n1 I1_I1666_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I200_XG_MN0 (I1_I1666_G29_0 I1_I1666_P29_14n XI1_I1666_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I200_XG_MN1 (XI1_I1666_I200_XG_n1 I1_I1666_G13_0n I1_I1666_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I144_XG_MN2 (XI1_I1666_I144_XG_n1 I1_I1666_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I144_XG_MN0 (I1_I1666_G19_12 I1_I1666_P19_16n XI1_I1666_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I144_XG_MN1 (XI1_I1666_I144_XG_n1 I1_I1666_G15_12n I1_I1666_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I146_XG_MN2 (XI1_I1666_I146_XG_n1 I1_I1666_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I146_XG_MN0 (I1_I1666_G21_14 I1_I1666_P21_18n XI1_I1666_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I146_XG_MN1 (XI1_I1666_I146_XG_n1 I1_I1666_G17_14n I1_I1666_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I84_XG_MN2 (XI1_I1666_I84_XG_n1 I1_I1666_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I84_XG_MN0 (I1_I1666_G18_17 I1_I1666_pn18 XI1_I1666_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I84_XG_MN1 (XI1_I1666_I84_XG_n1 I1_I1666_gn17 I1_I1666_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I82_XG_MN2 (XI1_I1666_I82_XG_n1 I1_I1666_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I82_XG_MN0 (I1_I1666_G16_15 I1_I1666_pn16 XI1_I1666_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I82_XG_MN1 (XI1_I1666_I82_XG_n1 I1_I1666_gn15 I1_I1666_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I83_XG_MN2 (XI1_I1666_I83_XG_n1 I1_I1666_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I83_XG_MN0 (I1_I1666_G17_16 I1_I1666_pn17 XI1_I1666_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I83_XG_MN1 (XI1_I1666_I83_XG_n1 I1_I1666_gn16 I1_I1666_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I143_XG_MN2 (XI1_I1620_I143_XG_n1 I1_I1620_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I143_XG_MN0 (I1_I1620_G18_11 I1_I1620_P18_15n XI1_I1620_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I143_XG_MN1 (XI1_I1620_I143_XG_n1 I1_I1620_G14_11n I1_I1620_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I139_XG_MN2 (XI1_I1620_I139_XG_n1 I1_I1620_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I139_XG_MN0 (I1_I1620_G14_7 I1_I1620_P14_11n XI1_I1620_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I139_XG_MN1 (XI1_I1620_I139_XG_n1 I1_I1620_G10_7n I1_I1620_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I141_XG_MN2 (XI1_I1620_I141_XG_n1 I1_I1620_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I141_XG_MN0 (I1_I1620_G16_9 I1_I1620_P16_13n XI1_I1620_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I141_XG_MN1 (XI1_I1620_I141_XG_n1 I1_I1620_G12_9n I1_I1620_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I130_XG_MN2 (XI1_I1620_I130_XG_n1 I1_I1620_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I130_XG_MN0 (I1_I1620_G5_0 I1_I1620_P5_2n XI1_I1620_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I130_XG_MN1 (XI1_I1620_I130_XG_n1 I1_I1620_G1_0n I1_I1620_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I183_XG_MN2 (XI1_I1620_I183_XG_n1 I1_I1620_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I183_XG_MN0 (I1_I1620_G16_0 I1_I1620_P16_1n XI1_I1620_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I183_XG_MN1 (XI1_I1620_I183_XG_n1 I1_I1620_G0_0n I1_I1620_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I65_XG_MN2 (XI2_I1_I42_I65_XG_n1 I2_I1_I42_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I65_XG_MN0 (I2_I1_I42_G0_0 I2_I1_I42_pn0 XI2_I1_I42_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI2_I1_I42_I65_XG_MN1 (XI2_I1_I42_I65_XG_n1 I2_I1_I42_cinn I2_I1_I42_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I202_XG_MN2 (XI1_I1758_I202_XG_n1 I1_I1758_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I202_XG_MN0 (I1_c26_o I1_I1758_P31_16n XI1_I1758_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I202_XG_MN1 (XI1_I1758_I202_XG_n1 I1_I1758_G15_0n I1_c26_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I200_XG_MN2 (XI1_I1758_I200_XG_n1 I1_I1758_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I200_XG_MN0 (I1_I1758_G29_0 I1_I1758_P29_14n XI1_I1758_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I200_XG_MN1 (XI1_I1758_I200_XG_n1 I1_I1758_G13_0n I1_I1758_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I194_XG_MN2 (XI1_I1758_I194_XG_n1 I1_I1758_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I194_XG_MN0 (I1_I1758_G23_0 I1_I1758_P23_8n XI1_I1758_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I194_XG_MN1 (XI1_I1758_I194_XG_n1 I1_I1758_G7_0n I1_I1758_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I196_XG_MN2 (XI1_I1758_I196_XG_n1 I1_I1758_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I196_XG_MN0 (I1_I1758_G25_0 I1_I1758_P25_10n XI1_I1758_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I196_XG_MN1 (XI1_I1758_I196_XG_n1 I1_I1758_G9_0n I1_I1758_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I138_XG_MN2 (XI1_I1758_I138_XG_n1 I1_I1758_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I138_XG_MN0 (I1_I1758_G13_6 I1_I1758_P13_10n XI1_I1758_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I138_XG_MN1 (XI1_I1758_I138_XG_n1 I1_I1758_G9_6n I1_I1758_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I136_XG_MN2 (XI1_I1758_I136_XG_n1 I1_I1758_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I136_XG_MN0 (I1_I1758_G11_4 I1_I1758_P11_8n XI1_I1758_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I136_XG_MN1 (XI1_I1758_I136_XG_n1 I1_I1758_G7_4n I1_I1758_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I132_XG_MN2 (XI1_I1758_I132_XG_n1 I1_I1758_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I132_XG_MN0 (I1_I1758_G7_0 I1_I1758_P7_4n XI1_I1758_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I132_XG_MN1 (XI1_I1758_I132_XG_n1 I1_I1758_G3_0n I1_I1758_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I73_XG_MN2 (XI1_I1758_I73_XG_n1 I1_I1758_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I73_XG_MN0 (I1_I1758_G7_6 I1_I1758_pn7 XI1_I1758_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I73_XG_MN1 (XI1_I1758_I73_XG_n1 I1_I1758_gn6 I1_I1758_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I201_XG_MN2 (XI1_I1666_I201_XG_n1 I1_I1666_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I201_XG_MN0 (I1_c24_m I1_I1666_P30_15n XI1_I1666_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I201_XG_MN1 (XI1_I1666_I201_XG_n1 I1_I1666_G14_0n I1_c24_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I151_XG_MN2 (XI1_I1666_I151_XG_n1 I1_I1666_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I151_XG_MN0 (I1_I1666_G26_19 I1_I1666_P26_23n XI1_I1666_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I151_XG_MN1 (XI1_I1666_I151_XG_n1 I1_I1666_G22_19n I1_I1666_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I147_XG_MN2 (XI1_I1666_I147_XG_n1 I1_I1666_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I147_XG_MN0 (I1_I1666_G22_15 I1_I1666_P22_19n XI1_I1666_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I147_XG_MN1 (XI1_I1666_I147_XG_n1 I1_I1666_G18_15n I1_I1666_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I194_XG_MN2 (XI1_I1666_I194_XG_n1 I1_I1666_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I194_XG_MN0 (I1_I1666_G23_0 I1_I1666_P23_8n XI1_I1666_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I194_XG_MN1 (XI1_I1666_I194_XG_n1 I1_I1666_G7_0n I1_I1666_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I150_XG_MN2 (XI1_I1666_I150_XG_n1 I1_I1666_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I150_XG_MN0 (I1_I1666_G25_18 I1_I1666_P25_22n XI1_I1666_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I150_XG_MN1 (XI1_I1666_I150_XG_n1 I1_I1666_G21_18n I1_I1666_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I86_XG_MN2 (XI1_I1666_I86_XG_n1 I1_I1666_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I86_XG_MN0 (I1_I1666_G20_19 I1_I1666_pn20 XI1_I1666_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I86_XG_MN1 (XI1_I1666_I86_XG_n1 I1_I1666_gn19 I1_I1666_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I85_XG_MN2 (XI1_I1666_I85_XG_n1 I1_I1666_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I85_XG_MN0 (I1_I1666_G19_18 I1_I1666_pn19 XI1_I1666_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I85_XG_MN1 (XI1_I1666_I85_XG_n1 I1_I1666_gn18 I1_I1666_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I192_XG_MN2 (XI1_I1620_I192_XG_n1 I1_I1620_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I192_XG_MN0 (I1_I1620_G22_0 I1_I1620_P22_7n XI1_I1620_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I192_XG_MN1 (XI1_I1620_I192_XG_n1 I1_I1620_G6_0n I1_I1620_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I197_XG_MN2 (XI1_I1620_I197_XG_n1 I1_I1620_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I197_XG_MN0 (I1_I1620_G26_0 I1_I1620_P26_11n XI1_I1620_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I197_XG_MN1 (XI1_I1620_I197_XG_n1 I1_I1620_G10_0n I1_I1620_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I147_XG_MN2 (XI1_I1620_I147_XG_n1 I1_I1620_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I147_XG_MN0 (I1_I1620_G22_15 I1_I1620_P22_19n XI1_I1620_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I147_XG_MN1 (XI1_I1620_I147_XG_n1 I1_I1620_G18_15n I1_I1620_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I84_XG_MN2 (XI1_I1620_I84_XG_n1 I1_I1620_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I84_XG_MN0 (I1_I1620_G18_17 I1_I1620_pn18 XI1_I1620_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I84_XG_MN1 (XI1_I1620_I84_XG_n1 I1_I1620_gn17 I1_I1620_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I188_XG_MN2 (XI1_I1620_I188_XG_n1 I1_I1620_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I188_XG_MN0 (I1_I1620_G20_0 I1_I1620_P20_5n XI1_I1620_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I188_XG_MN1 (XI1_I1620_I188_XG_n1 I1_I1620_G4_0n I1_I1620_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I136_XG_MN2 (XI1_I1620_I136_XG_n1 I1_I1620_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I136_XG_MN0 (I1_I1620_G11_4 I1_I1620_P11_8n XI1_I1620_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I136_XG_MN1 (XI1_I1620_I136_XG_n1 I1_I1620_G7_4n I1_I1620_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I142_XG_MN2 (XI1_I1620_I142_XG_n1 I1_I1620_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I142_XG_MN0 (I1_I1620_G17_10 I1_I1620_P17_14n XI1_I1620_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I142_XG_MN1 (XI1_I1620_I142_XG_n1 I1_I1620_G13_10n I1_I1620_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I138_XG_MN2 (XI1_I1620_I138_XG_n1 I1_I1620_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I138_XG_MN0 (I1_I1620_G13_6 I1_I1620_P13_10n XI1_I1620_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I138_XG_MN1 (XI1_I1620_I138_XG_n1 I1_I1620_G9_6n I1_I1620_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I184_XG_MN2 (XI1_I1620_I184_XG_n1 I1_I1620_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I184_XG_MN0 (I1_I1620_G17_0 I1_I1620_P17_2n XI1_I1620_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I184_XG_MN1 (XI1_I1620_I184_XG_n1 I1_I1620_G1_0n I1_I1620_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I198_XG_MN2 (XI1_I1758_I198_XG_n1 I1_I1758_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I198_XG_MN0 (I1_I1758_G27_0 I1_I1758_P27_12n XI1_I1758_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I198_XG_MN1 (XI1_I1758_I198_XG_n1 I1_I1758_G11_0n I1_I1758_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I190_XG_MN2 (XI1_I1758_I190_XG_n1 I1_I1758_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I190_XG_MN0 (I1_I1758_G21_0 I1_I1758_P21_6n XI1_I1758_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I190_XG_MN1 (XI1_I1758_I190_XG_n1 I1_I1758_G5_0n I1_I1758_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I186_XG_MN2 (XI1_I1758_I186_XG_n1 I1_I1758_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I186_XG_MN0 (I1_I1758_G19_0 I1_I1758_P19_4n XI1_I1758_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I186_XG_MN1 (XI1_I1758_I186_XG_n1 I1_I1758_G3_0n I1_I1758_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I184_XG_MN2 (XI1_I1758_I184_XG_n1 I1_I1758_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I184_XG_MN0 (I1_I1758_G17_0 I1_I1758_P17_2n XI1_I1758_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I184_XG_MN1 (XI1_I1758_I184_XG_n1 I1_I1758_G1_0n I1_I1758_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I134_XG_MN2 (XI1_I1758_I134_XG_n1 I1_I1758_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I134_XG_MN0 (I1_I1758_G9_2 I1_I1758_P9_6n XI1_I1758_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I134_XG_MN1 (XI1_I1758_I134_XG_n1 I1_I1758_G5_2n I1_I1758_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I153_XG_MN2 (XI1_I1666_I153_XG_n1 I1_I1666_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I153_XG_MN0 (I1_I1666_G28_21 I1_I1666_P28_25n XI1_I1666_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I153_XG_MN1 (XI1_I1666_I153_XG_n1 I1_I1666_G24_21n I1_I1666_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I202_XG_MN2 (XI1_I1666_I202_XG_n1 I1_I1666_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I202_XG_MN0 (I1_c24_o I1_I1666_P31_16n XI1_I1666_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I202_XG_MN1 (XI1_I1666_I202_XG_n1 I1_I1666_G15_0n I1_c24_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I87_XG_MN2 (XI1_I1666_I87_XG_n1 I1_I1666_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I87_XG_MN0 (I1_I1666_G21_20 I1_I1666_pn21 XI1_I1666_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I87_XG_MN1 (XI1_I1666_I87_XG_n1 I1_I1666_gn20 I1_I1666_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I86_XG_MN2 (XI1_I1620_I86_XG_n1 I1_I1620_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I86_XG_MN0 (I1_I1620_G20_19 I1_I1620_pn20 XI1_I1620_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I86_XG_MN1 (XI1_I1620_I86_XG_n1 I1_I1620_gn19 I1_I1620_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I85_XG_MN2 (XI1_I1620_I85_XG_n1 I1_I1620_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I85_XG_MN0 (I1_I1620_G19_18 I1_I1620_pn19 XI1_I1620_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I85_XG_MN1 (XI1_I1620_I85_XG_n1 I1_I1620_gn18 I1_I1620_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I145_XG_MN2 (XI1_I1620_I145_XG_n1 I1_I1620_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I145_XG_MN0 (I1_I1620_G20_13 I1_I1620_P20_17n XI1_I1620_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I145_XG_MN1 (XI1_I1620_I145_XG_n1 I1_I1620_G16_13n I1_I1620_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I195_XG_MN2 (XI1_I1620_I195_XG_n1 I1_I1620_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I195_XG_MN0 (I1_I1620_G24_0 I1_I1620_P24_9n XI1_I1620_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I195_XG_MN1 (XI1_I1620_I195_XG_n1 I1_I1620_G8_0n I1_I1620_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I140_XG_MN2 (XI1_I1620_I140_XG_n1 I1_I1620_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I140_XG_MN0 (I1_I1620_G15_8 I1_I1620_P15_12n XI1_I1620_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I140_XG_MN1 (XI1_I1620_I140_XG_n1 I1_I1620_G11_8n I1_I1620_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I155_XG_MN2 (XI1_I1758_I155_XG_n1 I1_I1758_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I155_XG_MN0 (I1_I1758_G30_23 I1_I1758_P30_27n XI1_I1758_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I155_XG_MN1 (XI1_I1758_I155_XG_n1 I1_I1758_G26_23n I1_I1758_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I153_XG_MN2 (XI1_I1758_I153_XG_n1 I1_I1758_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I153_XG_MN0 (I1_I1758_G28_21 I1_I1758_P28_25n XI1_I1758_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I153_XG_MN1 (XI1_I1758_I153_XG_n1 I1_I1758_G24_21n I1_I1758_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I151_XG_MN2 (XI1_I1758_I151_XG_n1 I1_I1758_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I151_XG_MN0 (I1_I1758_G26_19 I1_I1758_P26_23n XI1_I1758_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I151_XG_MN1 (XI1_I1758_I151_XG_n1 I1_I1758_G22_19n I1_I1758_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I147_XG_MN2 (XI1_I1758_I147_XG_n1 I1_I1758_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I147_XG_MN0 (I1_I1758_G22_15 I1_I1758_P22_19n XI1_I1758_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I147_XG_MN1 (XI1_I1758_I147_XG_n1 I1_I1758_G18_15n I1_I1758_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I149_XG_MN2 (XI1_I1758_I149_XG_n1 I1_I1758_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I149_XG_MN0 (I1_I1758_G24_17 I1_I1758_P24_21n XI1_I1758_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I149_XG_MN1 (XI1_I1758_I149_XG_n1 I1_I1758_G20_17n I1_I1758_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I130_XG_MN2 (XI1_I1758_I130_XG_n1 I1_I1758_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I130_XG_MN0 (I1_I1758_G5_0 I1_I1758_P5_2n XI1_I1758_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I130_XG_MN1 (XI1_I1758_I130_XG_n1 I1_I1758_G1_0n I1_I1758_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I72_XG_MN2 (XI1_I1758_I72_XG_n1 I1_I1758_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I72_XG_MN0 (I1_I1758_G6_5 I1_I1758_pn6 XI1_I1758_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I72_XG_MN1 (XI1_I1758_I72_XG_n1 I1_I1758_gn5 I1_I1758_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I71_XG_MN2 (XI1_I1758_I71_XG_n1 I1_I1758_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I71_XG_MN0 (I1_I1758_G5_4 I1_I1758_pn5 XI1_I1758_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I71_XG_MN1 (XI1_I1758_I71_XG_n1 I1_I1758_gn4 I1_I1758_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I155_XG_MN2 (XI1_I1666_I155_XG_n1 I1_I1666_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I155_XG_MN0 (I1_I1666_G30_23 I1_I1666_P30_27n XI1_I1666_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I155_XG_MN1 (XI1_I1666_I155_XG_n1 I1_I1666_G26_23n I1_I1666_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I156_XG_MN2 (XI1_I1666_I156_XG_n1 I1_I1666_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I156_XG_MN0 (I1_I1666_G31_24 I1_I1666_P31_28n XI1_I1666_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I156_XG_MN1 (XI1_I1666_I156_XG_n1 I1_I1666_G27_24n I1_I1666_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I154_XG_MN2 (XI1_I1666_I154_XG_n1 I1_I1666_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I154_XG_MN0 (I1_I1666_G29_22 I1_I1666_P29_26n XI1_I1666_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I154_XG_MN1 (XI1_I1666_I154_XG_n1 I1_I1666_G25_22n I1_I1666_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I201_XG_MN2 (XI1_I1620_I201_XG_n1 I1_I1620_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I201_XG_MN0 (I1_c23_m I1_I1620_P30_15n XI1_I1620_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I201_XG_MN1 (XI1_I1620_I201_XG_n1 I1_I1620_G14_0n I1_c23_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I151_XG_MN2 (XI1_I1620_I151_XG_n1 I1_I1620_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I151_XG_MN0 (I1_I1620_G26_19 I1_I1620_P26_23n XI1_I1620_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I151_XG_MN1 (XI1_I1620_I151_XG_n1 I1_I1620_G22_19n I1_I1620_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I199_XG_MN2 (XI1_I1620_I199_XG_n1 I1_I1620_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I199_XG_MN0 (I1_I1620_G28_0 I1_I1620_P28_13n XI1_I1620_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I199_XG_MN1 (XI1_I1620_I199_XG_n1 I1_I1620_G12_0n I1_I1620_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I149_XG_MN2 (XI1_I1620_I149_XG_n1 I1_I1620_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I149_XG_MN0 (I1_I1620_G24_17 I1_I1620_P24_21n XI1_I1620_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I149_XG_MN1 (XI1_I1620_I149_XG_n1 I1_I1620_G20_17n I1_I1620_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I144_XG_MN2 (XI1_I1620_I144_XG_n1 I1_I1620_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I144_XG_MN0 (I1_I1620_G19_12 I1_I1620_P19_16n XI1_I1620_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I144_XG_MN1 (XI1_I1620_I144_XG_n1 I1_I1620_G15_12n I1_I1620_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I186_XG_MN2 (XI1_I1620_I186_XG_n1 I1_I1620_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I186_XG_MN0 (I1_I1620_G19_0 I1_I1620_P19_4n XI1_I1620_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I186_XG_MN1 (XI1_I1620_I186_XG_n1 I1_I1620_G3_0n I1_I1620_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I201_XG_MN2 (XI1_I1758_I201_XG_n1 I1_I1758_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I201_XG_MN0 (I1_c26_m I1_I1758_P30_15n XI1_I1758_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I201_XG_MN1 (XI1_I1758_I201_XG_n1 I1_I1758_G14_0n I1_c26_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I145_XG_MN2 (XI1_I1758_I145_XG_n1 I1_I1758_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I145_XG_MN0 (I1_I1758_G20_13 I1_I1758_P20_17n XI1_I1758_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I145_XG_MN1 (XI1_I1758_I145_XG_n1 I1_I1758_G16_13n I1_I1758_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I143_XG_MN2 (XI1_I1758_I143_XG_n1 I1_I1758_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I143_XG_MN0 (I1_I1758_G18_11 I1_I1758_P18_15n XI1_I1758_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I143_XG_MN1 (XI1_I1758_I143_XG_n1 I1_I1758_G14_11n I1_I1758_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I137_XG_MN2 (XI1_I1758_I137_XG_n1 I1_I1758_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I137_XG_MN0 (I1_I1758_G12_5 I1_I1758_P12_9n XI1_I1758_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I137_XG_MN1 (XI1_I1758_I137_XG_n1 I1_I1758_G8_5n I1_I1758_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I135_XG_MN2 (XI1_I1758_I135_XG_n1 I1_I1758_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I135_XG_MN0 (I1_I1758_G10_3 I1_I1758_P10_7n XI1_I1758_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I135_XG_MN1 (XI1_I1758_I135_XG_n1 I1_I1758_G6_3n I1_I1758_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I70_XG_MN2 (XI1_I1758_I70_XG_n1 I1_I1758_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I70_XG_MN0 (I1_I1758_G4_3 I1_I1758_pn4 XI1_I1758_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I70_XG_MN1 (XI1_I1758_I70_XG_n1 I1_I1758_gn3 I1_I1758_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I69_XG_MN2 (XI1_I1758_I69_XG_n1 I1_I1758_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I69_XG_MN0 (I1_I1758_G3_2 I1_I1758_pn3 XI1_I1758_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I69_XG_MN1 (XI1_I1758_I69_XG_n1 I1_I1758_gn2 I1_I1758_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I91_XG_MN2 (XI1_I1666_I91_XG_n1 I1_I1666_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I91_XG_MN0 (I1_I1666_G25_24 I1_I1666_pn25 XI1_I1666_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I91_XG_MN1 (XI1_I1666_I91_XG_n1 I1_I1666_gn24 I1_I1666_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I90_XG_MN2 (XI1_I1666_I90_XG_n1 I1_I1666_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I90_XG_MN0 (I1_I1666_G24_23 I1_I1666_pn24 XI1_I1666_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I90_XG_MN1 (XI1_I1666_I90_XG_n1 I1_I1666_gn23 I1_I1666_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I87_XG_MN2 (XI1_I1620_I87_XG_n1 I1_I1620_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I87_XG_MN0 (I1_I1620_G21_20 I1_I1620_pn21 XI1_I1620_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I87_XG_MN1 (XI1_I1620_I87_XG_n1 I1_I1620_gn20 I1_I1620_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I88_XG_MN2 (XI1_I1620_I88_XG_n1 I1_I1620_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I88_XG_MN0 (I1_I1620_G22_21 I1_I1620_pn22 XI1_I1620_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I88_XG_MN1 (XI1_I1620_I88_XG_n1 I1_I1620_gn21 I1_I1620_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I202_XG_MN2 (XI1_I1620_I202_XG_n1 I1_I1620_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I202_XG_MN0 (I1_c23_o I1_I1620_P31_16n XI1_I1620_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I202_XG_MN1 (XI1_I1620_I202_XG_n1 I1_I1620_G15_0n I1_c23_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I146_XG_MN2 (XI1_I1620_I146_XG_n1 I1_I1620_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I146_XG_MN0 (I1_I1620_G21_14 I1_I1620_P21_18n XI1_I1620_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I146_XG_MN1 (XI1_I1620_I146_XG_n1 I1_I1620_G17_14n I1_I1620_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I190_XG_MN2 (XI1_I1620_I190_XG_n1 I1_I1620_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I190_XG_MN0 (I1_I1620_G21_0 I1_I1620_P21_6n XI1_I1620_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I190_XG_MN1 (XI1_I1620_I190_XG_n1 I1_I1620_G5_0n I1_I1620_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I199_XG_MN2 (XI1_I1758_I199_XG_n1 I1_I1758_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I199_XG_MN0 (I1_I1758_G28_0 I1_I1758_P28_13n XI1_I1758_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I199_XG_MN1 (XI1_I1758_I199_XG_n1 I1_I1758_G12_0n I1_I1758_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I197_XG_MN2 (XI1_I1758_I197_XG_n1 I1_I1758_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I197_XG_MN0 (I1_I1758_G26_0 I1_I1758_P26_11n XI1_I1758_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I197_XG_MN1 (XI1_I1758_I197_XG_n1 I1_I1758_G10_0n I1_I1758_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I192_XG_MN2 (XI1_I1758_I192_XG_n1 I1_I1758_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I192_XG_MN0 (I1_I1758_G22_0 I1_I1758_P22_7n XI1_I1758_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I192_XG_MN1 (XI1_I1758_I192_XG_n1 I1_I1758_G6_0n I1_I1758_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I188_XG_MN2 (XI1_I1758_I188_XG_n1 I1_I1758_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I188_XG_MN0 (I1_I1758_G20_0 I1_I1758_P20_5n XI1_I1758_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I188_XG_MN1 (XI1_I1758_I188_XG_n1 I1_I1758_G4_0n I1_I1758_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I185_XG_MN2 (XI1_I1758_I185_XG_n1 I1_I1758_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I185_XG_MN0 (I1_I1758_G18_0 I1_I1758_P18_3n XI1_I1758_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I185_XG_MN1 (XI1_I1758_I185_XG_n1 I1_I1758_G2_0n I1_I1758_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I133_XG_MN2 (XI1_I1758_I133_XG_n1 I1_I1758_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I133_XG_MN0 (I1_I1758_G8_1 I1_I1758_P8_5n XI1_I1758_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I133_XG_MN1 (XI1_I1758_I133_XG_n1 I1_I1758_G4_1n I1_I1758_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I131_XG_MN2 (XI1_I1758_I131_XG_n1 I1_I1758_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I131_XG_MN0 (I1_I1758_G6_0 I1_I1758_P6_3n XI1_I1758_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I131_XG_MN1 (XI1_I1758_I131_XG_n1 I1_I1758_G2_0n I1_I1758_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I68_XG_MN2 (XI1_I1758_I68_XG_n1 I1_I1758_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I68_XG_MN0 (I1_I1758_G2_1 I1_I1758_pn2 XI1_I1758_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I68_XG_MN1 (XI1_I1758_I68_XG_n1 I1_I1758_gn1 I1_I1758_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I67_XG_MN2 (XI1_I1758_I67_XG_n1 I1_I1758_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I67_XG_MN0 (I1_I1758_G1_0 I1_I1758_pn1 XI1_I1758_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I67_XG_MN1 (XI1_I1758_I67_XG_n1 I1_I1758_G0_0n I1_I1758_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I97_XG_MN2 (XI1_I1666_I97_XG_n1 I1_I1666_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I97_XG_MN0 (I1_I1666_G31_30 I1_I1666_pn31 XI1_I1666_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I97_XG_MN1 (XI1_I1666_I97_XG_n1 I1_I1666_gn30 I1_I1666_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I96_XG_MN2 (XI1_I1666_I96_XG_n1 I1_I1666_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I96_XG_MN0 (I1_I1666_G30_29 I1_I1666_pn30 XI1_I1666_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I96_XG_MN1 (XI1_I1666_I96_XG_n1 I1_I1666_gn29 I1_I1666_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I92_XG_MN2 (XI1_I1666_I92_XG_n1 I1_I1666_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I92_XG_MN0 (I1_I1666_G26_25 I1_I1666_pn26 XI1_I1666_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I92_XG_MN1 (XI1_I1666_I92_XG_n1 I1_I1666_gn25 I1_I1666_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I155_XG_MN2 (XI1_I1620_I155_XG_n1 I1_I1620_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I155_XG_MN0 (I1_I1620_G30_23 I1_I1620_P30_27n XI1_I1620_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I155_XG_MN1 (XI1_I1620_I155_XG_n1 I1_I1620_G26_23n I1_I1620_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I89_XG_MN2 (XI1_I1620_I89_XG_n1 I1_I1620_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I89_XG_MN0 (I1_I1620_G23_22 I1_I1620_pn23 XI1_I1620_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I89_XG_MN1 (XI1_I1620_I89_XG_n1 I1_I1620_gn22 I1_I1620_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I90_XG_MN2 (XI1_I1620_I90_XG_n1 I1_I1620_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I90_XG_MN0 (I1_I1620_G24_23 I1_I1620_pn24 XI1_I1620_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I90_XG_MN1 (XI1_I1620_I90_XG_n1 I1_I1620_gn23 I1_I1620_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I153_XG_MN2 (XI1_I1620_I153_XG_n1 I1_I1620_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I153_XG_MN0 (I1_I1620_G28_21 I1_I1620_P28_25n XI1_I1620_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I153_XG_MN1 (XI1_I1620_I153_XG_n1 I1_I1620_G24_21n I1_I1620_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I148_XG_MN2 (XI1_I1620_I148_XG_n1 I1_I1620_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I148_XG_MN0 (I1_I1620_G23_16 I1_I1620_P23_20n XI1_I1620_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I148_XG_MN1 (XI1_I1620_I148_XG_n1 I1_I1620_G19_16n I1_I1620_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I194_XG_MN2 (XI1_I1620_I194_XG_n1 I1_I1620_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I194_XG_MN0 (I1_I1620_G23_0 I1_I1620_P23_8n XI1_I1620_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I194_XG_MN1 (XI1_I1620_I194_XG_n1 I1_I1620_G7_0n I1_I1620_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I150_XG_MN2 (XI1_I1620_I150_XG_n1 I1_I1620_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I150_XG_MN0 (I1_I1620_G25_18 I1_I1620_P25_22n XI1_I1620_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I150_XG_MN1 (XI1_I1620_I150_XG_n1 I1_I1620_G21_18n I1_I1620_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I196_XG_MN2 (XI1_I1620_I196_XG_n1 I1_I1620_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I196_XG_MN0 (I1_I1620_G25_0 I1_I1620_P25_10n XI1_I1620_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I196_XG_MN1 (XI1_I1620_I196_XG_n1 I1_I1620_G9_0n I1_I1620_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I195_XG_MN2 (XI1_I1758_I195_XG_n1 I1_I1758_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I195_XG_MN0 (I1_I1758_G24_0 I1_I1758_P24_9n XI1_I1758_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I195_XG_MN1 (XI1_I1758_I195_XG_n1 I1_I1758_G8_0n I1_I1758_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I183_XG_MN2 (XI1_I1758_I183_XG_n1 I1_I1758_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I183_XG_MN0 (I1_I1758_G16_0 I1_I1758_P16_1n XI1_I1758_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I183_XG_MN1 (XI1_I1758_I183_XG_n1 I1_I1758_G0_0n I1_I1758_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I128_XG_MN2 (XI1_I1758_I128_XG_n1 I1_I1758_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I128_XG_MN0 (I1_I1758_G4_0 I1_I1758_P4_1n XI1_I1758_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I128_XG_MN1 (XI1_I1758_I128_XG_n1 I1_I1758_G0_0n I1_I1758_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I65_XG_MN2 (XI1_I1758_I65_XG_n1 I1_I1758_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I65_XG_MN0 (I1_I1758_G0_0 I1_I1758_pn0 XI1_I1758_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1758_I65_XG_MN1 (XI1_I1758_I65_XG_n1 I1_I1758_cinn I1_I1758_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I95_XG_MN2 (XI1_I1666_I95_XG_n1 I1_I1666_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I95_XG_MN0 (I1_I1666_G29_28 I1_I1666_pn29 XI1_I1666_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1666_I95_XG_MN1 (XI1_I1666_I95_XG_n1 I1_I1666_gn28 I1_I1666_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I97_XG_MN2 (XI1_I1620_I97_XG_n1 I1_I1620_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I97_XG_MN0 (I1_I1620_G31_30 I1_I1620_pn31 XI1_I1620_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I97_XG_MN1 (XI1_I1620_I97_XG_n1 I1_I1620_gn30 I1_I1620_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I92_XG_MN2 (XI1_I1620_I92_XG_n1 I1_I1620_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I92_XG_MN0 (I1_I1620_G26_25 I1_I1620_pn26 XI1_I1620_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I92_XG_MN1 (XI1_I1620_I92_XG_n1 I1_I1620_gn25 I1_I1620_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I91_XG_MN2 (XI1_I1620_I91_XG_n1 I1_I1620_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I91_XG_MN0 (I1_I1620_G25_24 I1_I1620_pn25 XI1_I1620_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I91_XG_MN1 (XI1_I1620_I91_XG_n1 I1_I1620_gn24 I1_I1620_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I152_XG_MN2 (XI1_I1620_I152_XG_n1 I1_I1620_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I152_XG_MN0 (I1_I1620_G27_20 I1_I1620_P27_24n XI1_I1620_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I152_XG_MN1 (XI1_I1620_I152_XG_n1 I1_I1620_G23_20n I1_I1620_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I198_XG_MN2 (XI1_I1620_I198_XG_n1 I1_I1620_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I198_XG_MN0 (I1_I1620_G27_0 I1_I1620_P27_12n XI1_I1620_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I198_XG_MN1 (XI1_I1620_I198_XG_n1 I1_I1620_G11_0n I1_I1620_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I200_XG_MN2 (XI1_I1620_I200_XG_n1 I1_I1620_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I200_XG_MN0 (I1_I1620_G29_0 I1_I1620_P29_14n XI1_I1620_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I200_XG_MN1 (XI1_I1620_I200_XG_n1 I1_I1620_G13_0n I1_I1620_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I81_XG_MN2 (XI1_I1804_I81_XG_n1 I1_I1804_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I81_XG_MN0 (I1_I1804_G15_14 I1_I1804_pn15 XI1_I1804_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I81_XG_MN1 (XI1_I1804_I81_XG_n1 I1_I1804_gn14 I1_I1804_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I79_XG_MN2 (XI1_I1804_I79_XG_n1 I1_I1804_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I79_XG_MN0 (I1_I1804_G13_12 I1_I1804_pn13 XI1_I1804_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I79_XG_MN1 (XI1_I1804_I79_XG_n1 I1_I1804_gn12 I1_I1804_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I96_XG_MN2 (XI1_I1620_I96_XG_n1 I1_I1620_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I96_XG_MN0 (I1_I1620_G30_29 I1_I1620_pn30 XI1_I1620_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I96_XG_MN1 (XI1_I1620_I96_XG_n1 I1_I1620_gn29 I1_I1620_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I95_XG_MN2 (XI1_I1620_I95_XG_n1 I1_I1620_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I95_XG_MN0 (I1_I1620_G29_28 I1_I1620_pn29 XI1_I1620_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I95_XG_MN1 (XI1_I1620_I95_XG_n1 I1_I1620_gn28 I1_I1620_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I156_XG_MN2 (XI1_I1620_I156_XG_n1 I1_I1620_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I156_XG_MN0 (I1_I1620_G31_24 I1_I1620_P31_28n XI1_I1620_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I156_XG_MN1 (XI1_I1620_I156_XG_n1 I1_I1620_G27_24n I1_I1620_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I154_XG_MN2 (XI1_I1620_I154_XG_n1 I1_I1620_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I154_XG_MN0 (I1_I1620_G29_22 I1_I1620_P29_26n XI1_I1620_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I154_XG_MN1 (XI1_I1620_I154_XG_n1 I1_I1620_G25_22n I1_I1620_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I129_XG_MN2 (XI0_I1660_I129_XG_n1 I0_I1660_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I129_XG_MN0 (I0_I1660_G0_0 I0_I1660_pn0 XI0_I1660_I129_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I129_XG_MN1 (XI0_I1660_I129_XG_n1 I0_I1660_cinn I0_I1660_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I89_XG_MN2 (XI1_I1804_I89_XG_n1 I1_I1804_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I89_XG_MN0 (I1_I1804_G23_22 I1_I1804_pn23 XI1_I1804_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I89_XG_MN1 (XI1_I1804_I89_XG_n1 I1_I1804_gn22 I1_I1804_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I86_XG_MN2 (XI1_I1804_I86_XG_n1 I1_I1804_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I86_XG_MN0 (I1_I1804_G20_19 I1_I1804_pn20 XI1_I1804_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I86_XG_MN1 (XI1_I1804_I86_XG_n1 I1_I1804_gn19 I1_I1804_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I85_XG_MN2 (XI1_I1804_I85_XG_n1 I1_I1804_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I85_XG_MN0 (I1_I1804_G19_18 I1_I1804_pn19 XI1_I1804_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I85_XG_MN1 (XI1_I1804_I85_XG_n1 I1_I1804_gn18 I1_I1804_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I84_XG_MN2 (XI1_I1804_I84_XG_n1 I1_I1804_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I84_XG_MN0 (I1_I1804_G18_17 I1_I1804_pn18 XI1_I1804_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I84_XG_MN1 (XI1_I1804_I84_XG_n1 I1_I1804_gn17 I1_I1804_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I83_XG_MN2 (XI1_I1804_I83_XG_n1 I1_I1804_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I83_XG_MN0 (I1_I1804_G17_16 I1_I1804_pn17 XI1_I1804_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I83_XG_MN1 (XI1_I1804_I83_XG_n1 I1_I1804_gn16 I1_I1804_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I82_XG_MN2 (XI1_I1804_I82_XG_n1 I1_I1804_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I82_XG_MN0 (I1_I1804_G16_15 I1_I1804_pn16 XI1_I1804_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I82_XG_MN1 (XI1_I1804_I82_XG_n1 I1_I1804_gn15 I1_I1804_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I80_XG_MN2 (XI1_I1804_I80_XG_n1 I1_I1804_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I80_XG_MN0 (I1_I1804_G14_13 I1_I1804_pn14 XI1_I1804_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I80_XG_MN1 (XI1_I1804_I80_XG_n1 I1_I1804_gn13 I1_I1804_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I78_XG_MN2 (XI1_I1804_I78_XG_n1 I1_I1804_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I78_XG_MN0 (I1_I1804_G12_11 I1_I1804_pn12 XI1_I1804_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I78_XG_MN1 (XI1_I1804_I78_XG_n1 I1_I1804_gn11 I1_I1804_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I77_XG_MN2 (XI1_I1804_I77_XG_n1 I1_I1804_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I77_XG_MN0 (I1_I1804_G11_10 I1_I1804_pn11 XI1_I1804_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I77_XG_MN1 (XI1_I1804_I77_XG_n1 I1_I1804_gn10 I1_I1804_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I76_XG_MN2 (XI1_I1804_I76_XG_n1 I1_I1804_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I76_XG_MN0 (I1_I1804_G10_9 I1_I1804_pn10 XI1_I1804_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I76_XG_MN1 (XI1_I1804_I76_XG_n1 I1_I1804_gn9 I1_I1804_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I75_XG_MN2 (XI1_I1804_I75_XG_n1 I1_I1804_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I75_XG_MN0 (I1_I1804_G9_8 I1_I1804_pn9 XI1_I1804_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I75_XG_MN1 (XI1_I1804_I75_XG_n1 I1_I1804_gn8 I1_I1804_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I74_XG_MN2 (XI1_I1804_I74_XG_n1 I1_I1804_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I74_XG_MN0 (I1_I1804_G8_7 I1_I1804_pn8 XI1_I1804_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I74_XG_MN1 (XI1_I1804_I74_XG_n1 I1_I1804_gn7 I1_I1804_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I73_XG_MN2 (XI1_I1804_I73_XG_n1 I1_I1804_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I73_XG_MN0 (I1_I1804_G7_6 I1_I1804_pn7 XI1_I1804_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I73_XG_MN1 (XI1_I1804_I73_XG_n1 I1_I1804_gn6 I1_I1804_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I72_XG_MN2 (XI1_I1804_I72_XG_n1 I1_I1804_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I72_XG_MN0 (I1_I1804_G6_5 I1_I1804_pn6 XI1_I1804_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I72_XG_MN1 (XI1_I1804_I72_XG_n1 I1_I1804_gn5 I1_I1804_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I65_XG_MN2 (XI1_I1804_I65_XG_n1 I1_I1804_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I65_XG_MN0 (I1_I1804_G0_0 I1_I1804_pn0 XI1_I1804_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I65_XG_MN1 (XI1_I1804_I65_XG_n1 I1_I1804_cinn I1_I1804_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I94_XG_MN2 (XI1_I1620_I94_XG_n1 I1_I1620_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I94_XG_MN0 (I1_I1620_G28_27 I1_I1620_pn28 XI1_I1620_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I94_XG_MN1 (XI1_I1620_I94_XG_n1 I1_I1620_gn27 I1_I1620_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I93_XG_MN2 (XI1_I1620_I93_XG_n1 I1_I1620_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I93_XG_MN0 (I1_I1620_G27_26 I1_I1620_pn27 XI1_I1620_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1620_I93_XG_MN1 (XI1_I1620_I93_XG_n1 I1_I1620_gn26 I1_I1620_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I97_XG_MN2 (XI1_I1804_I97_XG_n1 I1_I1804_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I97_XG_MN0 (I1_I1804_G31_30 I1_I1804_pn31 XI1_I1804_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I97_XG_MN1 (XI1_I1804_I97_XG_n1 I1_I1804_gn30 I1_I1804_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I92_XG_MN2 (XI1_I1804_I92_XG_n1 I1_I1804_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I92_XG_MN0 (I1_I1804_G26_25 I1_I1804_pn26 XI1_I1804_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I92_XG_MN1 (XI1_I1804_I92_XG_n1 I1_I1804_gn25 I1_I1804_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I93_XG_MN2 (XI1_I1804_I93_XG_n1 I1_I1804_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I93_XG_MN0 (I1_I1804_G27_26 I1_I1804_pn27 XI1_I1804_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I93_XG_MN1 (XI1_I1804_I93_XG_n1 I1_I1804_gn26 I1_I1804_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I91_XG_MN2 (XI1_I1804_I91_XG_n1 I1_I1804_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I91_XG_MN0 (I1_I1804_G25_24 I1_I1804_pn25 XI1_I1804_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I91_XG_MN1 (XI1_I1804_I91_XG_n1 I1_I1804_gn24 I1_I1804_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I90_XG_MN2 (XI1_I1804_I90_XG_n1 I1_I1804_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I90_XG_MN0 (I1_I1804_G24_23 I1_I1804_pn24 XI1_I1804_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I90_XG_MN1 (XI1_I1804_I90_XG_n1 I1_I1804_gn23 I1_I1804_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I149_XG_MN2 (XI1_I1804_I149_XG_n1 I1_I1804_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I149_XG_MN0 (I1_I1804_G24_17 I1_I1804_P24_21n XI1_I1804_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I149_XG_MN1 (XI1_I1804_I149_XG_n1 I1_I1804_G20_17n I1_I1804_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I145_XG_MN2 (XI1_I1804_I145_XG_n1 I1_I1804_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I145_XG_MN0 (I1_I1804_G20_13 I1_I1804_P20_17n XI1_I1804_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I145_XG_MN1 (XI1_I1804_I145_XG_n1 I1_I1804_G16_13n I1_I1804_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I141_XG_MN2 (XI1_I1804_I141_XG_n1 I1_I1804_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I141_XG_MN0 (I1_I1804_G16_9 I1_I1804_P16_13n XI1_I1804_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I141_XG_MN1 (XI1_I1804_I141_XG_n1 I1_I1804_G12_9n I1_I1804_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I137_XG_MN2 (XI1_I1804_I137_XG_n1 I1_I1804_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I137_XG_MN0 (I1_I1804_G12_5 I1_I1804_P12_9n XI1_I1804_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I137_XG_MN1 (XI1_I1804_I137_XG_n1 I1_I1804_G8_5n I1_I1804_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I65_XG_MN2 (XI1_I1850_I65_XG_n1 I1_I1850_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I65_XG_MN0 (I1_I1850_G0_0 I1_I1850_pn0 XI1_I1850_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I65_XG_MN1 (XI1_I1850_I65_XG_n1 I1_I1850_cinn I1_I1850_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I65_XG_MN2 (XI1_I1896_I65_XG_n1 I1_I1896_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I65_XG_MN0 (I1_I1896_G0_0 I1_I1896_pn0 XI1_I1896_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I65_XG_MN1 (XI1_I1896_I65_XG_n1 I1_I1896_cinn I1_I1896_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I65_XG_MN2 (XI1_I1942_I65_XG_n1 I1_I1942_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I65_XG_MN0 (I1_I1942_G0_0 I1_I1942_pn0 XI1_I1942_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I65_XG_MN1 (XI1_I1942_I65_XG_n1 I1_I1942_cinn I1_I1942_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I140_XG_MN2 (XI0_I1660_I140_XG_n1 I0_I1660_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I140_XG_MN0 (I0_I1660_G10_9 I0_I1660_pn10 XI0_I1660_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I140_XG_MN1 (XI0_I1660_I140_XG_n1 I0_I1660_gn9 I0_I1660_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I94_XG_MN2 (XI1_I1804_I94_XG_n1 I1_I1804_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I94_XG_MN0 (I1_I1804_G28_27 I1_I1804_pn28 XI1_I1804_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I94_XG_MN1 (XI1_I1804_I94_XG_n1 I1_I1804_gn27 I1_I1804_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I155_XG_MN2 (XI1_I1804_I155_XG_n1 I1_I1804_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I155_XG_MN0 (I1_I1804_G30_23 I1_I1804_P30_27n XI1_I1804_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I155_XG_MN1 (XI1_I1804_I155_XG_n1 I1_I1804_G26_23n I1_I1804_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I153_XG_MN2 (XI1_I1804_I153_XG_n1 I1_I1804_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I153_XG_MN0 (I1_I1804_G28_21 I1_I1804_P28_25n XI1_I1804_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I153_XG_MN1 (XI1_I1804_I153_XG_n1 I1_I1804_G24_21n I1_I1804_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I143_XG_MN2 (XI1_I1804_I143_XG_n1 I1_I1804_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I143_XG_MN0 (I1_I1804_G18_11 I1_I1804_P18_15n XI1_I1804_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I143_XG_MN1 (XI1_I1804_I143_XG_n1 I1_I1804_G14_11n I1_I1804_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I139_XG_MN2 (XI1_I1804_I139_XG_n1 I1_I1804_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I139_XG_MN0 (I1_I1804_G14_7 I1_I1804_P14_11n XI1_I1804_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I139_XG_MN1 (XI1_I1804_I139_XG_n1 I1_I1804_G10_7n I1_I1804_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I195_XG_MN2 (XI1_I1804_I195_XG_n1 I1_I1804_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I195_XG_MN0 (I1_I1804_G24_0 I1_I1804_P24_9n XI1_I1804_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I195_XG_MN1 (XI1_I1804_I195_XG_n1 I1_I1804_G8_0n I1_I1804_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I133_XG_MN2 (XI1_I1804_I133_XG_n1 I1_I1804_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I133_XG_MN0 (I1_I1804_G8_1 I1_I1804_P8_5n XI1_I1804_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I133_XG_MN1 (XI1_I1804_I133_XG_n1 I1_I1804_G4_1n I1_I1804_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I128_XG_MN2 (XI1_I1804_I128_XG_n1 I1_I1804_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I128_XG_MN0 (I1_I1804_G4_0 I1_I1804_P4_1n XI1_I1804_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I128_XG_MN1 (XI1_I1804_I128_XG_n1 I1_I1804_G0_0n I1_I1804_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I67_XG_MN2 (XI1_I1804_I67_XG_n1 I1_I1804_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I67_XG_MN0 (I1_I1804_G1_0 I1_I1804_pn1 XI1_I1804_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I67_XG_MN1 (XI1_I1804_I67_XG_n1 I1_I1804_G0_0n I1_I1804_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I68_XG_MN2 (XI1_I1896_I68_XG_n1 I1_I1896_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I68_XG_MN0 (I1_I1896_G2_1 I1_I1896_pn2 XI1_I1896_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I68_XG_MN1 (XI1_I1896_I68_XG_n1 I1_I1896_gn1 I1_I1896_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I67_XG_MN2 (XI1_I1896_I67_XG_n1 I1_I1896_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I67_XG_MN0 (I1_I1896_G1_0 I1_I1896_pn1 XI1_I1896_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I67_XG_MN1 (XI1_I1896_I67_XG_n1 I1_I1896_G0_0n I1_I1896_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I70_XG_MN2 (XI1_I1942_I70_XG_n1 I1_I1942_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I70_XG_MN0 (I1_I1942_G4_3 I1_I1942_pn4 XI1_I1942_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I70_XG_MN1 (XI1_I1942_I70_XG_n1 I1_I1942_gn3 I1_I1942_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I69_XG_MN2 (XI1_I1942_I69_XG_n1 I1_I1942_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I69_XG_MN0 (I1_I1942_G3_2 I1_I1942_pn3 XI1_I1942_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I69_XG_MN1 (XI1_I1942_I69_XG_n1 I1_I1942_gn2 I1_I1942_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I68_XG_MN2 (XI1_I1942_I68_XG_n1 I1_I1942_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I68_XG_MN0 (I1_I1942_G2_1 I1_I1942_pn2 XI1_I1942_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I68_XG_MN1 (XI1_I1942_I68_XG_n1 I1_I1942_gn1 I1_I1942_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I67_XG_MN2 (XI1_I1942_I67_XG_n1 I1_I1942_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I67_XG_MN0 (I1_I1942_G1_0 I1_I1942_pn1 XI1_I1942_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I67_XG_MN1 (XI1_I1942_I67_XG_n1 I1_I1942_G0_0n I1_I1942_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I69_XG_MN2 (XI1_I1988_I69_XG_n1 I1_I1988_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I69_XG_MN0 (I1_I1988_G3_2 I1_I1988_pn3 XI1_I1988_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I69_XG_MN1 (XI1_I1988_I69_XG_n1 I1_I1988_gn2 I1_I1988_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I68_XG_MN2 (XI1_I1988_I68_XG_n1 I1_I1988_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I68_XG_MN0 (I1_I1988_G2_1 I1_I1988_pn2 XI1_I1988_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I68_XG_MN1 (XI1_I1988_I68_XG_n1 I1_I1988_gn1 I1_I1988_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I65_XG_MN2 (XI1_I1988_I65_XG_n1 I1_I1988_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I65_XG_MN0 (I1_I1988_G0_0 I1_I1988_pn0 XI1_I1988_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I65_XG_MN1 (XI1_I1988_I65_XG_n1 I1_I1988_cinn I1_I1988_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I65_XG_MN2 (XI1_I2066_I65_XG_n1 I1_I2066_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I65_XG_MN0 (I1_I2066_G0_0 I1_I2066_pn0 XI1_I2066_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I65_XG_MN1 (XI1_I2066_I65_XG_n1 I1_I2066_cinn I1_I2066_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I137_XG_MN2 (XI0_I1660_I137_XG_n1 I0_I1660_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I137_XG_MN0 (I0_I1660_G7_6 I0_I1660_pn7 XI0_I1660_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I137_XG_MN1 (XI0_I1660_I137_XG_n1 I0_I1660_gn6 I0_I1660_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I138_XG_MN2 (XI0_I1660_I138_XG_n1 I0_I1660_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I138_XG_MN0 (I0_I1660_G8_7 I0_I1660_pn8 XI0_I1660_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I138_XG_MN1 (XI0_I1660_I138_XG_n1 I0_I1660_gn7 I0_I1660_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I139_XG_MN2 (XI0_I1660_I139_XG_n1 I0_I1660_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I139_XG_MN0 (I0_I1660_G9_8 I0_I1660_pn9 XI0_I1660_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I139_XG_MN1 (XI0_I1660_I139_XG_n1 I0_I1660_gn8 I0_I1660_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I141_XG_MN2 (XI0_I1660_I141_XG_n1 I0_I1660_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I141_XG_MN0 (I0_I1660_G11_10 I0_I1660_pn11 XI0_I1660_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I141_XG_MN1 (XI0_I1660_I141_XG_n1 I0_I1660_gn10 I0_I1660_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I145_XG_MN2 (XI0_I1660_I145_XG_n1 I0_I1660_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I145_XG_MN0 (I0_I1660_G15_14 I0_I1660_pn15 XI0_I1660_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I145_XG_MN1 (XI0_I1660_I145_XG_n1 I0_I1660_gn14 I0_I1660_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I146_XG_MN2 (XI0_I1660_I146_XG_n1 I0_I1660_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I146_XG_MN0 (I0_I1660_G16_15 I0_I1660_pn16 XI0_I1660_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I146_XG_MN1 (XI0_I1660_I146_XG_n1 I0_I1660_gn15 I0_I1660_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I147_XG_MN2 (XI0_I1660_I147_XG_n1 I0_I1660_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I147_XG_MN0 (I0_I1660_G17_16 I0_I1660_pn17 XI0_I1660_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I147_XG_MN1 (XI0_I1660_I147_XG_n1 I0_I1660_gn16 I0_I1660_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I148_XG_MN2 (XI0_I1660_I148_XG_n1 I0_I1660_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I148_XG_MN0 (I0_I1660_G18_17 I0_I1660_pn18 XI0_I1660_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I148_XG_MN1 (XI0_I1660_I148_XG_n1 I0_I1660_gn17 I0_I1660_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I149_XG_MN2 (XI0_I1660_I149_XG_n1 I0_I1660_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I149_XG_MN0 (I0_I1660_G19_18 I0_I1660_pn19 XI0_I1660_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I149_XG_MN1 (XI0_I1660_I149_XG_n1 I0_I1660_gn18 I0_I1660_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I152_XG_MN2 (XI0_I1660_I152_XG_n1 I0_I1660_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I152_XG_MN0 (I0_I1660_G22_21 I0_I1660_pn22 XI0_I1660_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I152_XG_MN1 (XI0_I1660_I152_XG_n1 I0_I1660_gn21 I0_I1660_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I153_XG_MN2 (XI0_I1660_I153_XG_n1 I0_I1660_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I153_XG_MN0 (I0_I1660_G23_22 I0_I1660_pn23 XI0_I1660_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I153_XG_MN1 (XI0_I1660_I153_XG_n1 I0_I1660_gn22 I0_I1660_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I154_XG_MN2 (XI0_I1660_I154_XG_n1 I0_I1660_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I154_XG_MN0 (I0_I1660_G24_23 I0_I1660_pn24 XI0_I1660_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I154_XG_MN1 (XI0_I1660_I154_XG_n1 I0_I1660_gn23 I0_I1660_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I155_XG_MN2 (XI0_I1660_I155_XG_n1 I0_I1660_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I155_XG_MN0 (I0_I1660_G25_24 I0_I1660_pn25 XI0_I1660_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I155_XG_MN1 (XI0_I1660_I155_XG_n1 I0_I1660_gn24 I0_I1660_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I156_XG_MN2 (XI0_I1660_I156_XG_n1 I0_I1660_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I156_XG_MN0 (I0_I1660_G26_25 I0_I1660_pn26 XI0_I1660_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I156_XG_MN1 (XI0_I1660_I156_XG_n1 I0_I1660_gn25 I0_I1660_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I96_XG_MN2 (XI1_I1804_I96_XG_n1 I1_I1804_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I96_XG_MN0 (I1_I1804_G30_29 I1_I1804_pn30 XI1_I1804_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I96_XG_MN1 (XI1_I1804_I96_XG_n1 I1_I1804_gn29 I1_I1804_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I95_XG_MN2 (XI1_I1804_I95_XG_n1 I1_I1804_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I95_XG_MN0 (I1_I1804_G29_28 I1_I1804_pn29 XI1_I1804_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I95_XG_MN1 (XI1_I1804_I95_XG_n1 I1_I1804_gn28 I1_I1804_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I201_XG_MN2 (XI1_I1804_I201_XG_n1 I1_I1804_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I201_XG_MN0 (I1_c27_m I1_I1804_P30_15n XI1_I1804_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I201_XG_MN1 (XI1_I1804_I201_XG_n1 I1_I1804_G14_0n I1_c27_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I199_XG_MN2 (XI1_I1804_I199_XG_n1 I1_I1804_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I199_XG_MN0 (I1_I1804_G28_0 I1_I1804_P28_13n XI1_I1804_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I199_XG_MN1 (XI1_I1804_I199_XG_n1 I1_I1804_G12_0n I1_I1804_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I192_XG_MN2 (XI1_I1804_I192_XG_n1 I1_I1804_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I192_XG_MN0 (I1_I1804_G22_0 I1_I1804_P22_7n XI1_I1804_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I192_XG_MN1 (XI1_I1804_I192_XG_n1 I1_I1804_G6_0n I1_I1804_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I197_XG_MN2 (XI1_I1804_I197_XG_n1 I1_I1804_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I197_XG_MN0 (I1_I1804_G26_0 I1_I1804_P26_11n XI1_I1804_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I197_XG_MN1 (XI1_I1804_I197_XG_n1 I1_I1804_G10_0n I1_I1804_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I188_XG_MN2 (XI1_I1804_I188_XG_n1 I1_I1804_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I188_XG_MN0 (I1_I1804_G20_0 I1_I1804_P20_5n XI1_I1804_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I188_XG_MN1 (XI1_I1804_I188_XG_n1 I1_I1804_G4_0n I1_I1804_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I185_XG_MN2 (XI1_I1804_I185_XG_n1 I1_I1804_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I185_XG_MN0 (I1_I1804_G18_0 I1_I1804_P18_3n XI1_I1804_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I185_XG_MN1 (XI1_I1804_I185_XG_n1 I1_I1804_G2_0n I1_I1804_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I131_XG_MN2 (XI1_I1804_I131_XG_n1 I1_I1804_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I131_XG_MN0 (I1_I1804_G6_0 I1_I1804_P6_3n XI1_I1804_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I131_XG_MN1 (XI1_I1804_I131_XG_n1 I1_I1804_G2_0n I1_I1804_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I69_XG_MN2 (XI1_I1850_I69_XG_n1 I1_I1850_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I69_XG_MN0 (I1_I1850_G3_2 I1_I1850_pn3 XI1_I1850_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I69_XG_MN1 (XI1_I1850_I69_XG_n1 I1_I1850_gn2 I1_I1850_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I67_XG_MN2 (XI1_I1850_I67_XG_n1 I1_I1850_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I67_XG_MN0 (I1_I1850_G1_0 I1_I1850_pn1 XI1_I1850_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I67_XG_MN1 (XI1_I1850_I67_XG_n1 I1_I1850_G0_0n I1_I1850_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I68_XG_MN2 (XI1_I1850_I68_XG_n1 I1_I1850_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I68_XG_MN0 (I1_I1850_G2_1 I1_I1850_pn2 XI1_I1850_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I68_XG_MN1 (XI1_I1850_I68_XG_n1 I1_I1850_gn1 I1_I1850_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I70_XG_MN2 (XI1_I1896_I70_XG_n1 I1_I1896_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I70_XG_MN0 (I1_I1896_G4_3 I1_I1896_pn4 XI1_I1896_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I70_XG_MN1 (XI1_I1896_I70_XG_n1 I1_I1896_gn3 I1_I1896_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I69_XG_MN2 (XI1_I1896_I69_XG_n1 I1_I1896_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I69_XG_MN0 (I1_I1896_G3_2 I1_I1896_pn3 XI1_I1896_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I69_XG_MN1 (XI1_I1896_I69_XG_n1 I1_I1896_gn2 I1_I1896_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I72_XG_MN2 (XI1_I1942_I72_XG_n1 I1_I1942_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I72_XG_MN0 (I1_I1942_G6_5 I1_I1942_pn6 XI1_I1942_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I72_XG_MN1 (XI1_I1942_I72_XG_n1 I1_I1942_gn5 I1_I1942_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I71_XG_MN2 (XI1_I1942_I71_XG_n1 I1_I1942_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I71_XG_MN0 (I1_I1942_G5_4 I1_I1942_pn5 XI1_I1942_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I71_XG_MN1 (XI1_I1942_I71_XG_n1 I1_I1942_gn4 I1_I1942_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I133_XG_MN2 (XI1_I1942_I133_XG_n1 I1_I1942_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I133_XG_MN0 (I1_I1942_G8_1 I1_I1942_P8_5n XI1_I1942_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I133_XG_MN1 (XI1_I1942_I133_XG_n1 I1_I1942_G4_1n I1_I1942_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I128_XG_MN2 (XI1_I1942_I128_XG_n1 I1_I1942_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I128_XG_MN0 (I1_I1942_G4_0 I1_I1942_P4_1n XI1_I1942_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I128_XG_MN1 (XI1_I1942_I128_XG_n1 I1_I1942_G0_0n I1_I1942_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I72_XG_MN2 (XI1_I1988_I72_XG_n1 I1_I1988_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I72_XG_MN0 (I1_I1988_G6_5 I1_I1988_pn6 XI1_I1988_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I72_XG_MN1 (XI1_I1988_I72_XG_n1 I1_I1988_gn5 I1_I1988_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I71_XG_MN2 (XI1_I1988_I71_XG_n1 I1_I1988_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I71_XG_MN0 (I1_I1988_G5_4 I1_I1988_pn5 XI1_I1988_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I71_XG_MN1 (XI1_I1988_I71_XG_n1 I1_I1988_gn4 I1_I1988_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I70_XG_MN2 (XI1_I1988_I70_XG_n1 I1_I1988_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I70_XG_MN0 (I1_I1988_G4_3 I1_I1988_pn4 XI1_I1988_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I70_XG_MN1 (XI1_I1988_I70_XG_n1 I1_I1988_gn3 I1_I1988_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I67_XG_MN2 (XI1_I1988_I67_XG_n1 I1_I1988_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I67_XG_MN0 (I1_I1988_G1_0 I1_I1988_pn1 XI1_I1988_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I67_XG_MN1 (XI1_I1988_I67_XG_n1 I1_I1988_G0_0n I1_I1988_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I135_XG_MN2 (XI0_I1660_I135_XG_n1 I0_I1660_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I135_XG_MN0 (I0_I1660_G5_4 I0_I1660_pn5 XI0_I1660_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I135_XG_MN1 (XI0_I1660_I135_XG_n1 I0_I1660_gn4 I0_I1660_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I136_XG_MN2 (XI0_I1660_I136_XG_n1 I0_I1660_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I136_XG_MN0 (I0_I1660_G6_5 I0_I1660_pn6 XI0_I1660_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I136_XG_MN1 (XI0_I1660_I136_XG_n1 I0_I1660_gn5 I0_I1660_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I70_XG_MN2 (XI1_I1850_I70_XG_n1 I1_I1850_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I70_XG_MN0 (I1_I1850_G4_3 I1_I1850_pn4 XI1_I1850_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I70_XG_MN1 (XI1_I1850_I70_XG_n1 I1_I1850_gn3 I1_I1850_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I71_XG_MN2 (XI1_I1896_I71_XG_n1 I1_I1896_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I71_XG_MN0 (I1_I1896_G5_4 I1_I1896_pn5 XI1_I1896_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I71_XG_MN1 (XI1_I1896_I71_XG_n1 I1_I1896_gn4 I1_I1896_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I73_XG_MN2 (XI1_I1942_I73_XG_n1 I1_I1942_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I73_XG_MN0 (I1_I1942_G7_6 I1_I1942_pn7 XI1_I1942_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I73_XG_MN1 (XI1_I1942_I73_XG_n1 I1_I1942_gn6 I1_I1942_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I74_XG_MN2 (XI1_I1942_I74_XG_n1 I1_I1942_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I74_XG_MN0 (I1_I1942_G8_7 I1_I1942_pn8 XI1_I1942_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I74_XG_MN1 (XI1_I1942_I74_XG_n1 I1_I1942_gn7 I1_I1942_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I130_XG_MN2 (XI1_I1942_I130_XG_n1 I1_I1942_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I130_XG_MN0 (I1_I1942_G5_0 I1_I1942_P5_2n XI1_I1942_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I130_XG_MN1 (XI1_I1942_I130_XG_n1 I1_I1942_G1_0n I1_I1942_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I183_XG_MN2 (XI1_I1942_I183_XG_n1 I1_I1942_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I183_XG_MN0 (I1_I1942_G16_0 I1_I1942_P16_1n XI1_I1942_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I183_XG_MN1 (XI1_I1942_I183_XG_n1 I1_I1942_G0_0n I1_I1942_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I74_XG_MN2 (XI1_I1988_I74_XG_n1 I1_I1988_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I74_XG_MN0 (I1_I1988_G8_7 I1_I1988_pn8 XI1_I1988_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I74_XG_MN1 (XI1_I1988_I74_XG_n1 I1_I1988_gn7 I1_I1988_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I73_XG_MN2 (XI1_I1988_I73_XG_n1 I1_I1988_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I73_XG_MN0 (I1_I1988_G7_6 I1_I1988_pn7 XI1_I1988_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I73_XG_MN1 (XI1_I1988_I73_XG_n1 I1_I1988_gn6 I1_I1988_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I130_XG_MN2 (XI1_I1988_I130_XG_n1 I1_I1988_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I130_XG_MN0 (I1_I1988_G5_0 I1_I1988_P5_2n XI1_I1988_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I130_XG_MN1 (XI1_I1988_I130_XG_n1 I1_I1988_G1_0n I1_I1988_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I128_XG_MN2 (XI1_I1988_I128_XG_n1 I1_I1988_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I128_XG_MN0 (I1_I1988_G4_0 I1_I1988_P4_1n XI1_I1988_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I128_XG_MN1 (XI1_I1988_I128_XG_n1 I1_I1988_G0_0n I1_I1988_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I70_XG_MN2 (XI1_I2066_I70_XG_n1 I1_I2066_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I70_XG_MN0 (I1_I2066_G4_3 I1_I2066_pn4 XI1_I2066_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I70_XG_MN1 (XI1_I2066_I70_XG_n1 I1_I2066_gn3 I1_I2066_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I133_XG_MN2 (XI0_I1660_I133_XG_n1 I0_I1660_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I133_XG_MN0 (I0_I1660_G3_2 I0_I1660_pn3 XI0_I1660_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I133_XG_MN1 (XI0_I1660_I133_XG_n1 I0_I1660_gn2 I0_I1660_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I134_XG_MN2 (XI0_I1660_I134_XG_n1 I0_I1660_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I134_XG_MN0 (I0_I1660_G4_3 I0_I1660_pn4 XI0_I1660_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I134_XG_MN1 (XI0_I1660_I134_XG_n1 I0_I1660_gn3 I0_I1660_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I260_XG_MN2 (XI0_I1660_I260_XG_n1 I0_I1660_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I260_XG_MN0 (I0_I1660_G7_0 I0_I1660_P7_4n XI0_I1660_I260_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I260_XG_MN1 (XI0_I1660_I260_XG_n1 I0_I1660_G3_0n I0_I1660_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I262_XG_MN2 (XI0_I1660_I262_XG_n1 I0_I1660_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I262_XG_MN0 (I0_I1660_G9_2 I0_I1660_P9_6n XI0_I1660_I262_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I262_XG_MN1 (XI0_I1660_I262_XG_n1 I0_I1660_G5_2n I0_I1660_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I264_XG_MN2 (XI0_I1660_I264_XG_n1 I0_I1660_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I264_XG_MN0 (I0_I1660_G11_4 I0_I1660_P11_8n XI0_I1660_I264_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I264_XG_MN1 (XI0_I1660_I264_XG_n1 I0_I1660_G7_4n I0_I1660_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I266_XG_MN2 (XI0_I1660_I266_XG_n1 I0_I1660_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I266_XG_MN0 (I0_I1660_G13_6 I0_I1660_P13_10n XI0_I1660_I266_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I266_XG_MN1 (XI0_I1660_I266_XG_n1 I0_I1660_G9_6n I0_I1660_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I268_XG_MN2 (XI0_I1660_I268_XG_n1 I0_I1660_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I268_XG_MN0 (I0_I1660_G15_8 I0_I1660_P15_12n XI0_I1660_I268_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I268_XG_MN1 (XI0_I1660_I268_XG_n1 I0_I1660_G11_8n I0_I1660_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I270_XG_MN2 (XI0_I1660_I270_XG_n1 I0_I1660_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I270_XG_MN0 (I0_I1660_G17_10 I0_I1660_P17_14n XI0_I1660_I270_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I270_XG_MN1 (XI0_I1660_I270_XG_n1 I0_I1660_G13_10n I0_I1660_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I272_XG_MN2 (XI0_I1660_I272_XG_n1 I0_I1660_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I272_XG_MN0 (I0_I1660_G19_12 I0_I1660_P19_16n XI0_I1660_I272_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I272_XG_MN1 (XI0_I1660_I272_XG_n1 I0_I1660_G15_12n I0_I1660_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I274_XG_MN2 (XI0_I1660_I274_XG_n1 I0_I1660_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I274_XG_MN0 (I0_I1660_G21_14 I0_I1660_P21_18n XI0_I1660_I274_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I274_XG_MN1 (XI0_I1660_I274_XG_n1 I0_I1660_G17_14n I0_I1660_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I276_XG_MN2 (XI0_I1660_I276_XG_n1 I0_I1660_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I276_XG_MN0 (I0_I1660_G23_16 I0_I1660_P23_20n XI0_I1660_I276_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I276_XG_MN1 (XI0_I1660_I276_XG_n1 I0_I1660_G19_16n I0_I1660_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I278_XG_MN2 (XI0_I1660_I278_XG_n1 I0_I1660_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I278_XG_MN0 (I0_I1660_G25_18 I0_I1660_P25_22n XI0_I1660_I278_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I278_XG_MN1 (XI0_I1660_I278_XG_n1 I0_I1660_G21_18n I0_I1660_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I282_XG_MN2 (XI0_I1660_I282_XG_n1 I0_I1660_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I282_XG_MN0 (I0_I1660_G29_22 I0_I1660_P29_26n XI0_I1660_I282_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I282_XG_MN1 (XI0_I1660_I282_XG_n1 I0_I1660_G25_22n I0_I1660_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I280_XG_MN2 (XI0_I1660_I280_XG_n1 I0_I1660_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I280_XG_MN0 (I0_I1660_G27_20 I0_I1660_P27_24n XI0_I1660_I280_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I280_XG_MN1 (XI0_I1660_I280_XG_n1 I0_I1660_G23_20n I0_I1660_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I159_XG_MN2 (XI0_I1660_I159_XG_n1 I0_I1660_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I159_XG_MN0 (I0_I1660_G29_28 I0_I1660_pn29 XI0_I1660_I159_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I159_XG_MN1 (XI0_I1660_I159_XG_n1 I0_I1660_gn28 I0_I1660_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I160_XG_MN2 (XI0_I1660_I160_XG_n1 I0_I1660_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I160_XG_MN0 (I0_I1660_G30_29 I0_I1660_pn30 XI0_I1660_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I160_XG_MN1 (XI0_I1660_I160_XG_n1 I0_I1660_gn29 I0_I1660_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I154_XG_MN2 (XI1_I1804_I154_XG_n1 I1_I1804_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I154_XG_MN0 (I1_I1804_G29_22 I1_I1804_P29_26n XI1_I1804_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I154_XG_MN1 (XI1_I1804_I154_XG_n1 I1_I1804_G25_22n I1_I1804_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I150_XG_MN2 (XI1_I1804_I150_XG_n1 I1_I1804_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I150_XG_MN0 (I1_I1804_G25_18 I1_I1804_P25_22n XI1_I1804_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I150_XG_MN1 (XI1_I1804_I150_XG_n1 I1_I1804_G21_18n I1_I1804_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I146_XG_MN2 (XI1_I1804_I146_XG_n1 I1_I1804_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I146_XG_MN0 (I1_I1804_G21_14 I1_I1804_P21_18n XI1_I1804_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I146_XG_MN1 (XI1_I1804_I146_XG_n1 I1_I1804_G17_14n I1_I1804_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I142_XG_MN2 (XI1_I1804_I142_XG_n1 I1_I1804_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I142_XG_MN0 (I1_I1804_G17_10 I1_I1804_P17_14n XI1_I1804_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I142_XG_MN1 (XI1_I1804_I142_XG_n1 I1_I1804_G13_10n I1_I1804_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I138_XG_MN2 (XI1_I1804_I138_XG_n1 I1_I1804_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I138_XG_MN0 (I1_I1804_G13_6 I1_I1804_P13_10n XI1_I1804_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I138_XG_MN1 (XI1_I1804_I138_XG_n1 I1_I1804_G9_6n I1_I1804_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I134_XG_MN2 (XI1_I1804_I134_XG_n1 I1_I1804_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I134_XG_MN0 (I1_I1804_G9_2 I1_I1804_P9_6n XI1_I1804_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I134_XG_MN1 (XI1_I1804_I134_XG_n1 I1_I1804_G5_2n I1_I1804_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I130_XG_MN2 (XI1_I1804_I130_XG_n1 I1_I1804_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I130_XG_MN0 (I1_I1804_G5_0 I1_I1804_P5_2n XI1_I1804_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I130_XG_MN1 (XI1_I1804_I130_XG_n1 I1_I1804_G1_0n I1_I1804_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I71_XG_MN2 (XI1_I1850_I71_XG_n1 I1_I1850_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I71_XG_MN0 (I1_I1850_G5_4 I1_I1850_pn5 XI1_I1850_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I71_XG_MN1 (XI1_I1850_I71_XG_n1 I1_I1850_gn4 I1_I1850_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I73_XG_MN2 (XI1_I1896_I73_XG_n1 I1_I1896_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I73_XG_MN0 (I1_I1896_G7_6 I1_I1896_pn7 XI1_I1896_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I73_XG_MN1 (XI1_I1896_I73_XG_n1 I1_I1896_gn6 I1_I1896_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I72_XG_MN2 (XI1_I1896_I72_XG_n1 I1_I1896_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I72_XG_MN0 (I1_I1896_G6_5 I1_I1896_pn6 XI1_I1896_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I72_XG_MN1 (XI1_I1896_I72_XG_n1 I1_I1896_gn5 I1_I1896_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I131_XG_MN2 (XI1_I1896_I131_XG_n1 I1_I1896_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I131_XG_MN0 (I1_I1896_G6_0 I1_I1896_P6_3n XI1_I1896_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I131_XG_MN1 (XI1_I1896_I131_XG_n1 I1_I1896_G2_0n I1_I1896_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I128_XG_MN2 (XI1_I1896_I128_XG_n1 I1_I1896_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I128_XG_MN0 (I1_I1896_G4_0 I1_I1896_P4_1n XI1_I1896_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I128_XG_MN1 (XI1_I1896_I128_XG_n1 I1_I1896_G0_0n I1_I1896_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I75_XG_MN2 (XI1_I1942_I75_XG_n1 I1_I1942_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I75_XG_MN0 (I1_I1942_G9_8 I1_I1942_pn9 XI1_I1942_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I75_XG_MN1 (XI1_I1942_I75_XG_n1 I1_I1942_gn8 I1_I1942_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I134_XG_MN2 (XI1_I1942_I134_XG_n1 I1_I1942_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I134_XG_MN0 (I1_I1942_G9_2 I1_I1942_P9_6n XI1_I1942_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I134_XG_MN1 (XI1_I1942_I134_XG_n1 I1_I1942_G5_2n I1_I1942_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I132_XG_MN2 (XI1_I1942_I132_XG_n1 I1_I1942_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I132_XG_MN0 (I1_I1942_G7_0 I1_I1942_P7_4n XI1_I1942_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I132_XG_MN1 (XI1_I1942_I132_XG_n1 I1_I1942_G3_0n I1_I1942_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I131_XG_MN2 (XI1_I1942_I131_XG_n1 I1_I1942_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I131_XG_MN0 (I1_I1942_G6_0 I1_I1942_P6_3n XI1_I1942_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I131_XG_MN1 (XI1_I1942_I131_XG_n1 I1_I1942_G2_0n I1_I1942_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I75_XG_MN2 (XI1_I1988_I75_XG_n1 I1_I1988_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I75_XG_MN0 (I1_I1988_G9_8 I1_I1988_pn9 XI1_I1988_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I75_XG_MN1 (XI1_I1988_I75_XG_n1 I1_I1988_gn8 I1_I1988_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I134_XG_MN2 (XI1_I1988_I134_XG_n1 I1_I1988_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I134_XG_MN0 (I1_I1988_G9_2 I1_I1988_P9_6n XI1_I1988_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I134_XG_MN1 (XI1_I1988_I134_XG_n1 I1_I1988_G5_2n I1_I1988_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I184_XG_MN2 (XI1_I1988_I184_XG_n1 I1_I1988_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I184_XG_MN0 (I1_I1988_G17_0 I1_I1988_P17_2n XI1_I1988_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I184_XG_MN1 (XI1_I1988_I184_XG_n1 I1_I1988_G1_0n I1_I1988_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I133_XG_MN2 (XI1_I1988_I133_XG_n1 I1_I1988_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I133_XG_MN0 (I1_I1988_G8_1 I1_I1988_P8_5n XI1_I1988_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I133_XG_MN1 (XI1_I1988_I133_XG_n1 I1_I1988_G4_1n I1_I1988_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I183_XG_MN2 (XI1_I1988_I183_XG_n1 I1_I1988_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I183_XG_MN0 (I1_I1988_G16_0 I1_I1988_P16_1n XI1_I1988_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I183_XG_MN1 (XI1_I1988_I183_XG_n1 I1_I1988_G0_0n I1_I1988_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I72_XG_MN2 (XI1_I2066_I72_XG_n1 I1_I2066_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I72_XG_MN0 (I1_I2066_G6_5 I1_I2066_pn6 XI1_I2066_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I72_XG_MN1 (XI1_I2066_I72_XG_n1 I1_I2066_gn5 I1_I2066_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I71_XG_MN2 (XI1_I2066_I71_XG_n1 I1_I2066_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I71_XG_MN0 (I1_I2066_G5_4 I1_I2066_pn5 XI1_I2066_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I71_XG_MN1 (XI1_I2066_I71_XG_n1 I1_I2066_gn4 I1_I2066_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I68_XG_MN2 (XI1_I2066_I68_XG_n1 I1_I2066_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I68_XG_MN0 (I1_I2066_G2_1 I1_I2066_pn2 XI1_I2066_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I68_XG_MN1 (XI1_I2066_I68_XG_n1 I1_I2066_gn1 I1_I2066_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I69_XG_MN2 (XI1_I2066_I69_XG_n1 I1_I2066_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I69_XG_MN0 (I1_I2066_G3_2 I1_I2066_pn3 XI1_I2066_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I69_XG_MN1 (XI1_I2066_I69_XG_n1 I1_I2066_gn2 I1_I2066_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I131_XG_MN2 (XI0_I1660_I131_XG_n1 I0_I1660_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I131_XG_MN0 (I0_I1660_G1_0 I0_I1660_pn1 XI0_I1660_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I131_XG_MN1 (XI0_I1660_I131_XG_n1 I0_I1660_G0_0n I0_I1660_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I132_XG_MN2 (XI0_I1660_I132_XG_n1 I0_I1660_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I132_XG_MN0 (I0_I1660_G2_1 I0_I1660_pn2 XI0_I1660_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I132_XG_MN1 (XI0_I1660_I132_XG_n1 I0_I1660_gn1 I0_I1660_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I258_XG_MN2 (XI0_I1660_I258_XG_n1 I0_I1660_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I258_XG_MN0 (I0_I1660_G5_0 I0_I1660_P5_2n XI0_I1660_I258_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I258_XG_MN1 (XI0_I1660_I258_XG_n1 I0_I1660_G1_0n I0_I1660_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I376_XG_MN2 (XI0_I1660_I376_XG_n1 I0_I1660_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I376_XG_MN0 (I0_I1660_G17_0 I0_I1660_P17_2n XI0_I1660_I376_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I376_XG_MN1 (XI0_I1660_I376_XG_n1 I0_I1660_G1_0n I0_I1660_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I277_XG_MN2 (XI0_I1660_I277_XG_n1 I0_I1660_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I277_XG_MN0 (I0_I1660_G24_17 I0_I1660_P24_21n XI0_I1660_I277_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I277_XG_MN1 (XI0_I1660_I277_XG_n1 I0_I1660_G20_17n I0_I1660_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I378_XG_MN2 (XI0_I1660_I378_XG_n1 I0_I1660_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I378_XG_MN0 (I0_I1660_G19_0 I0_I1660_P19_4n XI0_I1660_I378_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I378_XG_MN1 (XI0_I1660_I378_XG_n1 I0_I1660_G3_0n I0_I1660_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I382_XG_MN2 (XI0_I1660_I382_XG_n1 I0_I1660_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I382_XG_MN0 (I0_I1660_G21_0 I0_I1660_P21_6n XI0_I1660_I382_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I382_XG_MN1 (XI0_I1660_I382_XG_n1 I0_I1660_G5_0n I0_I1660_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I386_XG_MN2 (XI0_I1660_I386_XG_n1 I0_I1660_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I386_XG_MN0 (I0_I1660_G23_0 I0_I1660_P23_8n XI0_I1660_I386_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I386_XG_MN1 (XI0_I1660_I386_XG_n1 I0_I1660_G7_0n I0_I1660_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I284_XG_MN2 (XI0_I1660_I284_XG_n1 I0_I1660_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I284_XG_MN0 (I0_I1660_G31_24 I0_I1660_P31_28n XI0_I1660_I284_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I284_XG_MN1 (XI0_I1660_I284_XG_n1 I0_I1660_G27_24n I0_I1660_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I286_XG_MN2 (XI0_I1660_I286_XG_n1 I0_I1660_G33_30n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I286_XG_MN0 (I0_I1660_G33_26 I0_I1660_P33_30n XI0_I1660_I286_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I286_XG_MN1 (XI0_I1660_I286_XG_n1 I0_I1660_G29_26n I0_I1660_G33_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I161_XG_MN2 (XI0_I1660_I161_XG_n1 I0_I1660_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I161_XG_MN0 (I0_I1660_G31_30 I0_I1660_pn31 XI0_I1660_I161_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I161_XG_MN1 (XI0_I1660_I161_XG_n1 I0_I1660_gn30 I0_I1660_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I156_XG_MN2 (XI1_I1804_I156_XG_n1 I1_I1804_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I156_XG_MN0 (I1_I1804_G31_24 I1_I1804_P31_28n XI1_I1804_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I156_XG_MN1 (XI1_I1804_I156_XG_n1 I1_I1804_G27_24n I1_I1804_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I190_XG_MN2 (XI1_I1804_I190_XG_n1 I1_I1804_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I190_XG_MN0 (I1_I1804_G21_0 I1_I1804_P21_6n XI1_I1804_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I190_XG_MN1 (XI1_I1804_I190_XG_n1 I1_I1804_G5_0n I1_I1804_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I196_XG_MN2 (XI1_I1804_I196_XG_n1 I1_I1804_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I196_XG_MN0 (I1_I1804_G25_0 I1_I1804_P25_10n XI1_I1804_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I196_XG_MN1 (XI1_I1804_I196_XG_n1 I1_I1804_G9_0n I1_I1804_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I136_XG_MN2 (XI1_I1804_I136_XG_n1 I1_I1804_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I136_XG_MN0 (I1_I1804_G11_4 I1_I1804_P11_8n XI1_I1804_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I136_XG_MN1 (XI1_I1804_I136_XG_n1 I1_I1804_G7_4n I1_I1804_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I184_XG_MN2 (XI1_I1804_I184_XG_n1 I1_I1804_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I184_XG_MN0 (I1_I1804_G17_0 I1_I1804_P17_2n XI1_I1804_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I184_XG_MN1 (XI1_I1804_I184_XG_n1 I1_I1804_G1_0n I1_I1804_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I132_XG_MN2 (XI1_I1804_I132_XG_n1 I1_I1804_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I132_XG_MN0 (I1_I1804_G7_0 I1_I1804_P7_4n XI1_I1804_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I132_XG_MN1 (XI1_I1804_I132_XG_n1 I1_I1804_G3_0n I1_I1804_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I72_XG_MN2 (XI1_I1850_I72_XG_n1 I1_I1850_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I72_XG_MN0 (I1_I1850_G6_5 I1_I1850_pn6 XI1_I1850_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I72_XG_MN1 (XI1_I1850_I72_XG_n1 I1_I1850_gn5 I1_I1850_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I74_XG_MN2 (XI1_I1896_I74_XG_n1 I1_I1896_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I74_XG_MN0 (I1_I1896_G8_7 I1_I1896_pn8 XI1_I1896_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I74_XG_MN1 (XI1_I1896_I74_XG_n1 I1_I1896_gn7 I1_I1896_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I132_XG_MN2 (XI1_I1896_I132_XG_n1 I1_I1896_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I132_XG_MN0 (I1_I1896_G7_0 I1_I1896_P7_4n XI1_I1896_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I132_XG_MN1 (XI1_I1896_I132_XG_n1 I1_I1896_G3_0n I1_I1896_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I130_XG_MN2 (XI1_I1896_I130_XG_n1 I1_I1896_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I130_XG_MN0 (I1_I1896_G5_0 I1_I1896_P5_2n XI1_I1896_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I130_XG_MN1 (XI1_I1896_I130_XG_n1 I1_I1896_G1_0n I1_I1896_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I133_XG_MN2 (XI1_I1896_I133_XG_n1 I1_I1896_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I133_XG_MN0 (I1_I1896_G8_1 I1_I1896_P8_5n XI1_I1896_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I133_XG_MN1 (XI1_I1896_I133_XG_n1 I1_I1896_G4_1n I1_I1896_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I77_XG_MN2 (XI1_I1942_I77_XG_n1 I1_I1942_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I77_XG_MN0 (I1_I1942_G11_10 I1_I1942_pn11 XI1_I1942_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I77_XG_MN1 (XI1_I1942_I77_XG_n1 I1_I1942_gn10 I1_I1942_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I76_XG_MN2 (XI1_I1942_I76_XG_n1 I1_I1942_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I76_XG_MN0 (I1_I1942_G10_9 I1_I1942_pn10 XI1_I1942_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I76_XG_MN1 (XI1_I1942_I76_XG_n1 I1_I1942_gn9 I1_I1942_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I184_XG_MN2 (XI1_I1942_I184_XG_n1 I1_I1942_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I184_XG_MN0 (I1_I1942_G17_0 I1_I1942_P17_2n XI1_I1942_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I184_XG_MN1 (XI1_I1942_I184_XG_n1 I1_I1942_G1_0n I1_I1942_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I135_XG_MN2 (XI1_I1942_I135_XG_n1 I1_I1942_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I135_XG_MN0 (I1_I1942_G10_3 I1_I1942_P10_7n XI1_I1942_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I135_XG_MN1 (XI1_I1942_I135_XG_n1 I1_I1942_G6_3n I1_I1942_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I185_XG_MN2 (XI1_I1942_I185_XG_n1 I1_I1942_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I185_XG_MN0 (I1_I1942_G18_0 I1_I1942_P18_3n XI1_I1942_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I185_XG_MN1 (XI1_I1942_I185_XG_n1 I1_I1942_G2_0n I1_I1942_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I77_XG_MN2 (XI1_I1988_I77_XG_n1 I1_I1988_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I77_XG_MN0 (I1_I1988_G11_10 I1_I1988_pn11 XI1_I1988_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I77_XG_MN1 (XI1_I1988_I77_XG_n1 I1_I1988_gn10 I1_I1988_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I76_XG_MN2 (XI1_I1988_I76_XG_n1 I1_I1988_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I76_XG_MN0 (I1_I1988_G10_9 I1_I1988_pn10 XI1_I1988_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I76_XG_MN1 (XI1_I1988_I76_XG_n1 I1_I1988_gn9 I1_I1988_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I136_XG_MN2 (XI1_I1988_I136_XG_n1 I1_I1988_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I136_XG_MN0 (I1_I1988_G11_4 I1_I1988_P11_8n XI1_I1988_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I136_XG_MN1 (XI1_I1988_I136_XG_n1 I1_I1988_G7_4n I1_I1988_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I132_XG_MN2 (XI1_I1988_I132_XG_n1 I1_I1988_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I132_XG_MN0 (I1_I1988_G7_0 I1_I1988_P7_4n XI1_I1988_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I132_XG_MN1 (XI1_I1988_I132_XG_n1 I1_I1988_G3_0n I1_I1988_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I135_XG_MN2 (XI1_I1988_I135_XG_n1 I1_I1988_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I135_XG_MN0 (I1_I1988_G10_3 I1_I1988_P10_7n XI1_I1988_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I135_XG_MN1 (XI1_I1988_I135_XG_n1 I1_I1988_G6_3n I1_I1988_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I131_XG_MN2 (XI1_I1988_I131_XG_n1 I1_I1988_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I131_XG_MN0 (I1_I1988_G6_0 I1_I1988_P6_3n XI1_I1988_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I131_XG_MN1 (XI1_I1988_I131_XG_n1 I1_I1988_G2_0n I1_I1988_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I75_XG_MN2 (XI1_I2066_I75_XG_n1 I1_I2066_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I75_XG_MN0 (I1_I2066_G9_8 I1_I2066_pn9 XI1_I2066_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I75_XG_MN1 (XI1_I2066_I75_XG_n1 I1_I2066_gn8 I1_I2066_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I74_XG_MN2 (XI1_I2066_I74_XG_n1 I1_I2066_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I74_XG_MN0 (I1_I2066_G8_7 I1_I2066_pn8 XI1_I2066_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I74_XG_MN1 (XI1_I2066_I74_XG_n1 I1_I2066_gn7 I1_I2066_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I73_XG_MN2 (XI1_I2066_I73_XG_n1 I1_I2066_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I73_XG_MN0 (I1_I2066_G7_6 I1_I2066_pn7 XI1_I2066_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I73_XG_MN1 (XI1_I2066_I73_XG_n1 I1_I2066_gn6 I1_I2066_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I67_XG_MN2 (XI1_I2066_I67_XG_n1 I1_I2066_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I67_XG_MN0 (I1_I2066_G1_0 I1_I2066_pn1 XI1_I2066_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I67_XG_MN1 (XI1_I2066_I67_XG_n1 I1_I2066_G0_0n I1_I2066_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I256_XG_MN2 (XI0_I1660_I256_XG_n1 I0_I1660_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I256_XG_MN0 (I0_I1660_G4_0 I0_I1660_P4_1n XI0_I1660_I256_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I256_XG_MN1 (XI0_I1660_I256_XG_n1 I0_I1660_G0_0n I0_I1660_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I261_XG_MN2 (XI0_I1660_I261_XG_n1 I0_I1660_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I261_XG_MN0 (I0_I1660_G8_1 I0_I1660_P8_5n XI0_I1660_I261_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I261_XG_MN1 (XI0_I1660_I261_XG_n1 I0_I1660_G4_1n I0_I1660_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I375_XG_MN2 (XI0_I1660_I375_XG_n1 I0_I1660_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I375_XG_MN0 (I0_I1660_G16_0 I0_I1660_P16_1n XI0_I1660_I375_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I375_XG_MN1 (XI0_I1660_I375_XG_n1 I0_I1660_G0_0n I0_I1660_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I265_XG_MN2 (XI0_I1660_I265_XG_n1 I0_I1660_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I265_XG_MN0 (I0_I1660_G12_5 I0_I1660_P12_9n XI0_I1660_I265_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I265_XG_MN1 (XI0_I1660_I265_XG_n1 I0_I1660_G8_5n I0_I1660_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I269_XG_MN2 (XI0_I1660_I269_XG_n1 I0_I1660_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I269_XG_MN0 (I0_I1660_G16_9 I0_I1660_P16_13n XI0_I1660_I269_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I269_XG_MN1 (XI0_I1660_I269_XG_n1 I0_I1660_G12_9n I0_I1660_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I398_XG_MN2 (XI0_I1660_I398_XG_n1 I0_I1660_G35_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I398_XG_MN0 (I0_I1660_G35_4 I0_I1660_P35_20n XI0_I1660_I398_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I398_XG_MN1 (XI0_I1660_I398_XG_n1 I0_I1660_G19_4n I0_I1660_G35_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I400_XG_MN2 (XI0_I1660_I400_XG_n1 I0_I1660_G37_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I400_XG_MN0 (I0_I1660_G37_6 I0_I1660_P37_22n XI0_I1660_I400_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I400_XG_MN1 (XI0_I1660_I400_XG_n1 I0_I1660_G21_6n I0_I1660_G37_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I412_XG_MN2 (XI0_I1660_I412_XG_n1 I0_I1660_G49_34n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I412_XG_MN0 (I0_I1660_G49_18 I0_I1660_P49_34n XI0_I1660_I412_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I412_XG_MN1 (XI0_I1660_I412_XG_n1 I0_I1660_G33_18n I0_I1660_G49_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I388_XG_MN2 (XI0_I1660_I388_XG_n1 I0_I1660_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I388_XG_MN0 (I0_I1660_G25_0 I0_I1660_P25_10n XI0_I1660_I388_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I388_XG_MN1 (XI0_I1660_I388_XG_n1 I0_I1660_G9_0n I0_I1660_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I402_XG_MN2 (XI0_I1660_I402_XG_n1 I0_I1660_G39_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I402_XG_MN0 (I0_I1660_G39_8 I0_I1660_P39_24n XI0_I1660_I402_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I402_XG_MN1 (XI0_I1660_I402_XG_n1 I0_I1660_G23_8n I0_I1660_G39_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I390_XG_MN2 (XI0_I1660_I390_XG_n1 I0_I1660_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I390_XG_MN0 (I0_I1660_G27_0 I0_I1660_P27_12n XI0_I1660_I390_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I390_XG_MN1 (XI0_I1660_I390_XG_n1 I0_I1660_G11_0n I0_I1660_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I288_XG_MN2 (XI0_I1660_I288_XG_n1 I0_I1660_G35_32n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I288_XG_MN0 (I0_I1660_G35_28 I0_I1660_P35_32n XI0_I1660_I288_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I288_XG_MN1 (XI0_I1660_I288_XG_n1 I0_I1660_G31_28n I0_I1660_G35_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I164_XG_MN2 (XI0_I1660_I164_XG_n1 I0_I1660_gn34 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I164_XG_MN0 (I0_I1660_G34_33 I0_I1660_pn34 XI0_I1660_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I164_XG_MN1 (XI0_I1660_I164_XG_n1 I0_I1660_gn33 I0_I1660_G34_33 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I202_XG_MN2 (XI1_I1804_I202_XG_n1 I1_I1804_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I202_XG_MN0 (I1_c27_o I1_I1804_P31_16n XI1_I1804_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I202_XG_MN1 (XI1_I1804_I202_XG_n1 I1_I1804_G15_0n I1_c27_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I198_XG_MN2 (XI1_I1804_I198_XG_n1 I1_I1804_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I198_XG_MN0 (I1_I1804_G27_0 I1_I1804_P27_12n XI1_I1804_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I198_XG_MN1 (XI1_I1804_I198_XG_n1 I1_I1804_G11_0n I1_I1804_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I194_XG_MN2 (XI1_I1804_I194_XG_n1 I1_I1804_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I194_XG_MN0 (I1_I1804_G23_0 I1_I1804_P23_8n XI1_I1804_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I194_XG_MN1 (XI1_I1804_I194_XG_n1 I1_I1804_G7_0n I1_I1804_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I144_XG_MN2 (XI1_I1804_I144_XG_n1 I1_I1804_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I144_XG_MN0 (I1_I1804_G19_12 I1_I1804_P19_16n XI1_I1804_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I144_XG_MN1 (XI1_I1804_I144_XG_n1 I1_I1804_G15_12n I1_I1804_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I186_XG_MN2 (XI1_I1804_I186_XG_n1 I1_I1804_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I186_XG_MN0 (I1_I1804_G19_0 I1_I1804_P19_4n XI1_I1804_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I186_XG_MN1 (XI1_I1804_I186_XG_n1 I1_I1804_G3_0n I1_I1804_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I140_XG_MN2 (XI1_I1804_I140_XG_n1 I1_I1804_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I140_XG_MN0 (I1_I1804_G15_8 I1_I1804_P15_12n XI1_I1804_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1804_I140_XG_MN1 (XI1_I1804_I140_XG_n1 I1_I1804_G11_8n I1_I1804_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I75_XG_MN2 (XI1_I1896_I75_XG_n1 I1_I1896_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I75_XG_MN0 (I1_I1896_G9_8 I1_I1896_pn9 XI1_I1896_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I75_XG_MN1 (XI1_I1896_I75_XG_n1 I1_I1896_gn8 I1_I1896_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I134_XG_MN2 (XI1_I1896_I134_XG_n1 I1_I1896_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I134_XG_MN0 (I1_I1896_G9_2 I1_I1896_P9_6n XI1_I1896_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I134_XG_MN1 (XI1_I1896_I134_XG_n1 I1_I1896_G5_2n I1_I1896_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I183_XG_MN2 (XI1_I1896_I183_XG_n1 I1_I1896_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I183_XG_MN0 (I1_I1896_G16_0 I1_I1896_P16_1n XI1_I1896_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I183_XG_MN1 (XI1_I1896_I183_XG_n1 I1_I1896_G0_0n I1_I1896_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I78_XG_MN2 (XI1_I1942_I78_XG_n1 I1_I1942_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I78_XG_MN0 (I1_I1942_G12_11 I1_I1942_pn12 XI1_I1942_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I78_XG_MN1 (XI1_I1942_I78_XG_n1 I1_I1942_gn11 I1_I1942_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I136_XG_MN2 (XI1_I1942_I136_XG_n1 I1_I1942_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I136_XG_MN0 (I1_I1942_G11_4 I1_I1942_P11_8n XI1_I1942_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I136_XG_MN1 (XI1_I1942_I136_XG_n1 I1_I1942_G7_4n I1_I1942_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I186_XG_MN2 (XI1_I1942_I186_XG_n1 I1_I1942_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I186_XG_MN0 (I1_I1942_G19_0 I1_I1942_P19_4n XI1_I1942_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I186_XG_MN1 (XI1_I1942_I186_XG_n1 I1_I1942_G3_0n I1_I1942_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I141_XG_MN2 (XI1_I1942_I141_XG_n1 I1_I1942_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I141_XG_MN0 (I1_I1942_G16_9 I1_I1942_P16_13n XI1_I1942_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I141_XG_MN1 (XI1_I1942_I141_XG_n1 I1_I1942_G12_9n I1_I1942_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I137_XG_MN2 (XI1_I1942_I137_XG_n1 I1_I1942_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I137_XG_MN0 (I1_I1942_G12_5 I1_I1942_P12_9n XI1_I1942_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I137_XG_MN1 (XI1_I1942_I137_XG_n1 I1_I1942_G8_5n I1_I1942_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I78_XG_MN2 (XI1_I1988_I78_XG_n1 I1_I1988_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I78_XG_MN0 (I1_I1988_G12_11 I1_I1988_pn12 XI1_I1988_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I78_XG_MN1 (XI1_I1988_I78_XG_n1 I1_I1988_gn11 I1_I1988_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I138_XG_MN2 (XI1_I1988_I138_XG_n1 I1_I1988_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I138_XG_MN0 (I1_I1988_G13_6 I1_I1988_P13_10n XI1_I1988_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I138_XG_MN1 (XI1_I1988_I138_XG_n1 I1_I1988_G9_6n I1_I1988_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I141_XG_MN2 (XI1_I1988_I141_XG_n1 I1_I1988_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I141_XG_MN0 (I1_I1988_G16_9 I1_I1988_P16_13n XI1_I1988_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I141_XG_MN1 (XI1_I1988_I141_XG_n1 I1_I1988_G12_9n I1_I1988_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I137_XG_MN2 (XI1_I1988_I137_XG_n1 I1_I1988_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I137_XG_MN0 (I1_I1988_G12_5 I1_I1988_P12_9n XI1_I1988_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I137_XG_MN1 (XI1_I1988_I137_XG_n1 I1_I1988_G8_5n I1_I1988_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I195_XG_MN2 (XI1_I1988_I195_XG_n1 I1_I1988_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I195_XG_MN0 (I1_I1988_G24_0 I1_I1988_P24_9n XI1_I1988_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I195_XG_MN1 (XI1_I1988_I195_XG_n1 I1_I1988_G8_0n I1_I1988_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I76_XG_MN2 (XI1_I2066_I76_XG_n1 I1_I2066_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I76_XG_MN0 (I1_I2066_G10_9 I1_I2066_pn10 XI1_I2066_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I76_XG_MN1 (XI1_I2066_I76_XG_n1 I1_I2066_gn9 I1_I2066_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I128_XG_MN2 (XI1_I2066_I128_XG_n1 I1_I2066_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I128_XG_MN0 (I1_I2066_G4_0 I1_I2066_P4_1n XI1_I2066_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I128_XG_MN1 (XI1_I2066_I128_XG_n1 I1_I2066_G0_0n I1_I2066_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I259_XG_MN2 (XI0_I1660_I259_XG_n1 I0_I1660_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I259_XG_MN0 (I0_I1660_G6_0 I0_I1660_P6_3n XI0_I1660_I259_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I259_XG_MN1 (XI0_I1660_I259_XG_n1 I0_I1660_G2_0n I0_I1660_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I263_XG_MN2 (XI0_I1660_I263_XG_n1 I0_I1660_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I263_XG_MN0 (I0_I1660_G10_3 I0_I1660_P10_7n XI0_I1660_I263_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I263_XG_MN1 (XI0_I1660_I263_XG_n1 I0_I1660_G6_3n I0_I1660_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I267_XG_MN2 (XI0_I1660_I267_XG_n1 I0_I1660_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I267_XG_MN0 (I0_I1660_G14_7 I0_I1660_P14_11n XI0_I1660_I267_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I267_XG_MN1 (XI0_I1660_I267_XG_n1 I0_I1660_G10_7n I0_I1660_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I271_XG_MN2 (XI0_I1660_I271_XG_n1 I0_I1660_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I271_XG_MN0 (I0_I1660_G18_11 I0_I1660_P18_15n XI0_I1660_I271_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I271_XG_MN1 (XI0_I1660_I271_XG_n1 I0_I1660_G14_11n I0_I1660_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I380_XG_MN2 (XI0_I1660_I380_XG_n1 I0_I1660_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I380_XG_MN0 (I0_I1660_G20_0 I0_I1660_P20_5n XI0_I1660_I380_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I380_XG_MN1 (XI0_I1660_I380_XG_n1 I0_I1660_G4_0n I0_I1660_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I387_XG_MN2 (XI0_I1660_I387_XG_n1 I0_I1660_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I387_XG_MN0 (I0_I1660_G24_0 I0_I1660_P24_9n XI0_I1660_I387_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I387_XG_MN1 (XI0_I1660_I387_XG_n1 I0_I1660_G8_0n I0_I1660_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I281_XG_MN2 (XI0_I1660_I281_XG_n1 I0_I1660_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I281_XG_MN0 (I0_I1660_G28_21 I0_I1660_P28_25n XI0_I1660_I281_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I281_XG_MN1 (XI0_I1660_I281_XG_n1 I0_I1660_G24_21n I0_I1660_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I285_XG_MN2 (XI0_I1660_I285_XG_n1 I0_I1660_G32_29n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I285_XG_MN0 (I0_I1660_G32_25 I0_I1660_P32_29n XI0_I1660_I285_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I285_XG_MN1 (XI0_I1660_I285_XG_n1 I0_I1660_G28_25n I0_I1660_G32_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I392_XG_MN2 (XI0_I1660_I392_XG_n1 I0_I1660_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I392_XG_MN0 (I0_I1660_G29_0 I0_I1660_P29_14n XI0_I1660_I392_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I392_XG_MN1 (XI0_I1660_I392_XG_n1 I0_I1660_G13_0n I0_I1660_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I406_XG_MN2 (XI0_I1660_I406_XG_n1 I0_I1660_G43_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I406_XG_MN0 (I0_I1660_G43_12 I0_I1660_P43_28n XI0_I1660_I406_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I406_XG_MN1 (XI0_I1660_I406_XG_n1 I0_I1660_G27_12n I0_I1660_G43_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I394_XG_MN2 (XI0_I1660_I394_XG_n1 I0_I1660_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I394_XG_MN0 (I0_I1660_G31_0 I0_I1660_P31_16n XI0_I1660_I394_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I394_XG_MN1 (XI0_I1660_I394_XG_n1 I0_I1660_G15_0n I0_I1660_G31_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I290_XG_MN2 (XI0_I1660_I290_XG_n1 I0_I1660_G37_34n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I290_XG_MN0 (I0_I1660_G37_30 I0_I1660_P37_34n XI0_I1660_I290_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I290_XG_MN1 (XI0_I1660_I290_XG_n1 I0_I1660_G33_30n I0_I1660_G37_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I292_XG_MN2 (XI0_I1660_I292_XG_n1 I0_I1660_G39_36n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I292_XG_MN0 (I0_I1660_G39_32 I0_I1660_P39_36n XI0_I1660_I292_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I292_XG_MN1 (XI0_I1660_I292_XG_n1 I0_I1660_G35_32n I0_I1660_G39_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I166_XG_MN2 (XI0_I1660_I166_XG_n1 I0_I1660_gn36 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I166_XG_MN0 (I0_I1660_G36_35 I0_I1660_pn36 XI0_I1660_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I166_XG_MN1 (XI0_I1660_I166_XG_n1 I0_I1660_gn35 I0_I1660_G36_35 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I165_XG_MN2 (XI0_I1660_I165_XG_n1 I0_I1660_gn35 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I165_XG_MN0 (I0_I1660_G35_34 I0_I1660_pn35 XI0_I1660_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I165_XG_MN1 (XI0_I1660_I165_XG_n1 I0_I1660_gn34 I0_I1660_G35_34 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I167_XG_MN2 (XI0_I1660_I167_XG_n1 I0_I1660_gn37 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I167_XG_MN0 (I0_I1660_G37_36 I0_I1660_pn37 XI0_I1660_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I167_XG_MN1 (XI0_I1660_I167_XG_n1 I0_I1660_gn36 I0_I1660_G37_36 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I136_XG_MN2 (XI1_I1850_I136_XG_n1 I1_I1850_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I136_XG_MN0 (I1_I1850_G11_4 I1_I1850_P11_8n XI1_I1850_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I136_XG_MN1 (XI1_I1850_I136_XG_n1 I1_I1850_G7_4n I1_I1850_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I132_XG_MN2 (XI1_I1850_I132_XG_n1 I1_I1850_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I132_XG_MN0 (I1_I1850_G7_0 I1_I1850_P7_4n XI1_I1850_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I132_XG_MN1 (XI1_I1850_I132_XG_n1 I1_I1850_G3_0n I1_I1850_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I134_XG_MN2 (XI1_I1850_I134_XG_n1 I1_I1850_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I134_XG_MN0 (I1_I1850_G9_2 I1_I1850_P9_6n XI1_I1850_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I134_XG_MN1 (XI1_I1850_I134_XG_n1 I1_I1850_G5_2n I1_I1850_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I130_XG_MN2 (XI1_I1850_I130_XG_n1 I1_I1850_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I130_XG_MN0 (I1_I1850_G5_0 I1_I1850_P5_2n XI1_I1850_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I130_XG_MN1 (XI1_I1850_I130_XG_n1 I1_I1850_G1_0n I1_I1850_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I77_XG_MN2 (XI1_I1850_I77_XG_n1 I1_I1850_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I77_XG_MN0 (I1_I1850_G11_10 I1_I1850_pn11 XI1_I1850_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I77_XG_MN1 (XI1_I1850_I77_XG_n1 I1_I1850_gn10 I1_I1850_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I76_XG_MN2 (XI1_I1850_I76_XG_n1 I1_I1850_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I76_XG_MN0 (I1_I1850_G10_9 I1_I1850_pn10 XI1_I1850_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I76_XG_MN1 (XI1_I1850_I76_XG_n1 I1_I1850_gn9 I1_I1850_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I75_XG_MN2 (XI1_I1850_I75_XG_n1 I1_I1850_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I75_XG_MN0 (I1_I1850_G9_8 I1_I1850_pn9 XI1_I1850_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I75_XG_MN1 (XI1_I1850_I75_XG_n1 I1_I1850_gn8 I1_I1850_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I128_XG_MN2 (XI1_I1850_I128_XG_n1 I1_I1850_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I128_XG_MN0 (I1_I1850_G4_0 I1_I1850_P4_1n XI1_I1850_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I128_XG_MN1 (XI1_I1850_I128_XG_n1 I1_I1850_G0_0n I1_I1850_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I77_XG_MN2 (XI1_I1896_I77_XG_n1 I1_I1896_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I77_XG_MN0 (I1_I1896_G11_10 I1_I1896_pn11 XI1_I1896_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I77_XG_MN1 (XI1_I1896_I77_XG_n1 I1_I1896_gn10 I1_I1896_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I76_XG_MN2 (XI1_I1896_I76_XG_n1 I1_I1896_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I76_XG_MN0 (I1_I1896_G10_9 I1_I1896_pn10 XI1_I1896_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I76_XG_MN1 (XI1_I1896_I76_XG_n1 I1_I1896_gn9 I1_I1896_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I136_XG_MN2 (XI1_I1896_I136_XG_n1 I1_I1896_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I136_XG_MN0 (I1_I1896_G11_4 I1_I1896_P11_8n XI1_I1896_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I136_XG_MN1 (XI1_I1896_I136_XG_n1 I1_I1896_G7_4n I1_I1896_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I184_XG_MN2 (XI1_I1896_I184_XG_n1 I1_I1896_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I184_XG_MN0 (I1_I1896_G17_0 I1_I1896_P17_2n XI1_I1896_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I184_XG_MN1 (XI1_I1896_I184_XG_n1 I1_I1896_G1_0n I1_I1896_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I135_XG_MN2 (XI1_I1896_I135_XG_n1 I1_I1896_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I135_XG_MN0 (I1_I1896_G10_3 I1_I1896_P10_7n XI1_I1896_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I135_XG_MN1 (XI1_I1896_I135_XG_n1 I1_I1896_G6_3n I1_I1896_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I79_XG_MN2 (XI1_I1942_I79_XG_n1 I1_I1942_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I79_XG_MN0 (I1_I1942_G13_12 I1_I1942_pn13 XI1_I1942_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I79_XG_MN1 (XI1_I1942_I79_XG_n1 I1_I1942_gn12 I1_I1942_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I138_XG_MN2 (XI1_I1942_I138_XG_n1 I1_I1942_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I138_XG_MN0 (I1_I1942_G13_6 I1_I1942_P13_10n XI1_I1942_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I138_XG_MN1 (XI1_I1942_I138_XG_n1 I1_I1942_G9_6n I1_I1942_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I196_XG_MN2 (XI1_I1942_I196_XG_n1 I1_I1942_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I196_XG_MN0 (I1_I1942_G25_0 I1_I1942_P25_10n XI1_I1942_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I196_XG_MN1 (XI1_I1942_I196_XG_n1 I1_I1942_G9_0n I1_I1942_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I139_XG_MN2 (XI1_I1942_I139_XG_n1 I1_I1942_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I139_XG_MN0 (I1_I1942_G14_7 I1_I1942_P14_11n XI1_I1942_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I139_XG_MN1 (XI1_I1942_I139_XG_n1 I1_I1942_G10_7n I1_I1942_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I195_XG_MN2 (XI1_I1942_I195_XG_n1 I1_I1942_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I195_XG_MN0 (I1_I1942_G24_0 I1_I1942_P24_9n XI1_I1942_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I195_XG_MN1 (XI1_I1942_I195_XG_n1 I1_I1942_G8_0n I1_I1942_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I79_XG_MN2 (XI1_I1988_I79_XG_n1 I1_I1988_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I79_XG_MN0 (I1_I1988_G13_12 I1_I1988_pn13 XI1_I1988_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I79_XG_MN1 (XI1_I1988_I79_XG_n1 I1_I1988_gn12 I1_I1988_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I80_XG_MN2 (XI1_I1988_I80_XG_n1 I1_I1988_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I80_XG_MN0 (I1_I1988_G14_13 I1_I1988_pn14 XI1_I1988_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I80_XG_MN1 (XI1_I1988_I80_XG_n1 I1_I1988_gn13 I1_I1988_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I142_XG_MN2 (XI1_I1988_I142_XG_n1 I1_I1988_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I142_XG_MN0 (I1_I1988_G17_10 I1_I1988_P17_14n XI1_I1988_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I142_XG_MN1 (XI1_I1988_I142_XG_n1 I1_I1988_G13_10n I1_I1988_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I196_XG_MN2 (XI1_I1988_I196_XG_n1 I1_I1988_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I196_XG_MN0 (I1_I1988_G25_0 I1_I1988_P25_10n XI1_I1988_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I196_XG_MN1 (XI1_I1988_I196_XG_n1 I1_I1988_G9_0n I1_I1988_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I139_XG_MN2 (XI1_I1988_I139_XG_n1 I1_I1988_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I139_XG_MN0 (I1_I1988_G14_7 I1_I1988_P14_11n XI1_I1988_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I139_XG_MN1 (XI1_I1988_I139_XG_n1 I1_I1988_G10_7n I1_I1988_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I185_XG_MN2 (XI1_I1988_I185_XG_n1 I1_I1988_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I185_XG_MN0 (I1_I1988_G18_0 I1_I1988_P18_3n XI1_I1988_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I185_XG_MN1 (XI1_I1988_I185_XG_n1 I1_I1988_G2_0n I1_I1988_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I78_XG_MN2 (XI1_I2066_I78_XG_n1 I1_I2066_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I78_XG_MN0 (I1_I2066_G12_11 I1_I2066_pn12 XI1_I2066_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I78_XG_MN1 (XI1_I2066_I78_XG_n1 I1_I2066_gn11 I1_I2066_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I77_XG_MN2 (XI1_I2066_I77_XG_n1 I1_I2066_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I77_XG_MN0 (I1_I2066_G11_10 I1_I2066_pn11 XI1_I2066_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I77_XG_MN1 (XI1_I2066_I77_XG_n1 I1_I2066_gn10 I1_I2066_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I133_XG_MN2 (XI1_I2066_I133_XG_n1 I1_I2066_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I133_XG_MN0 (I1_I2066_G8_1 I1_I2066_P8_5n XI1_I2066_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I133_XG_MN1 (XI1_I2066_I133_XG_n1 I1_I2066_G4_1n I1_I2066_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I183_XG_MN2 (XI1_I2066_I183_XG_n1 I1_I2066_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I183_XG_MN0 (I1_I2066_G16_0 I1_I2066_P16_1n XI1_I2066_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I183_XG_MN1 (XI1_I2066_I183_XG_n1 I1_I2066_G0_0n I1_I2066_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I130_XG_MN2 (XI1_I2066_I130_XG_n1 I1_I2066_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I130_XG_MN0 (I1_I2066_G5_0 I1_I2066_P5_2n XI1_I2066_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I130_XG_MN1 (XI1_I2066_I130_XG_n1 I1_I2066_G1_0n I1_I2066_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I395_XG_MN2 (XI0_I1660_I395_XG_n1 I0_I1660_G32_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I395_XG_MN0 (I0_I1660_G32_1 I0_I1660_P32_17n XI0_I1660_I395_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I395_XG_MN1 (XI0_I1660_I395_XG_n1 I0_I1660_G16_1n I0_I1660_G32_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I399_XG_MN2 (XI0_I1660_I399_XG_n1 I0_I1660_G36_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I399_XG_MN0 (I0_I1660_G36_5 I0_I1660_P36_21n XI0_I1660_I399_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I399_XG_MN1 (XI0_I1660_I399_XG_n1 I0_I1660_G20_5n I0_I1660_G36_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I403_XG_MN2 (XI0_I1660_I403_XG_n1 I0_I1660_G40_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I403_XG_MN0 (I0_I1660_G40_9 I0_I1660_P40_25n XI0_I1660_I403_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I403_XG_MN1 (XI0_I1660_I403_XG_n1 I0_I1660_G24_9n I0_I1660_G40_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I391_XG_MN2 (XI0_I1660_I391_XG_n1 I0_I1660_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I391_XG_MN0 (I0_I1660_G28_0 I0_I1660_P28_13n XI0_I1660_I391_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I391_XG_MN1 (XI0_I1660_I391_XG_n1 I0_I1660_G12_0n I0_I1660_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I289_XG_MN2 (XI0_I1660_I289_XG_n1 I0_I1660_G36_33n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I289_XG_MN0 (I0_I1660_G36_29 I0_I1660_P36_33n XI0_I1660_I289_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I289_XG_MN1 (XI0_I1660_I289_XG_n1 I0_I1660_G32_29n I0_I1660_G36_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I404_XG_MN2 (XI0_I1660_I404_XG_n1 I0_I1660_G41_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I404_XG_MN0 (I0_I1660_G41_10 I0_I1660_P41_26n XI0_I1660_I404_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I404_XG_MN1 (XI0_I1660_I404_XG_n1 I0_I1660_G25_10n I0_I1660_G41_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I414_XG_MN2 (XI0_I1660_I414_XG_n1 I0_I1660_G51_36n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I414_XG_MN0 (I0_I1660_G51_20 I0_I1660_P51_36n XI0_I1660_I414_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I414_XG_MN1 (XI0_I1660_I414_XG_n1 I0_I1660_G35_20n I0_I1660_G51_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I410_XG_MN2 (XI0_I1660_I410_XG_n1 I0_I1660_G47_32n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I410_XG_MN0 (I0_I1660_G47_16 I0_I1660_P47_32n XI0_I1660_I410_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I410_XG_MN1 (XI0_I1660_I410_XG_n1 I0_I1660_G31_16n I0_I1660_G47_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I294_XG_MN2 (XI0_I1660_I294_XG_n1 I0_I1660_G41_38n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I294_XG_MN0 (I0_I1660_G41_34 I0_I1660_P41_38n XI0_I1660_I294_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I294_XG_MN1 (XI0_I1660_I294_XG_n1 I0_I1660_G37_34n I0_I1660_G41_34 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I296_XG_MN2 (XI0_I1660_I296_XG_n1 I0_I1660_G43_40n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I296_XG_MN0 (I0_I1660_G43_36 I0_I1660_P43_40n XI0_I1660_I296_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I296_XG_MN1 (XI0_I1660_I296_XG_n1 I0_I1660_G39_36n I0_I1660_G43_36 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I171_XG_MN2 (XI0_I1660_I171_XG_n1 I0_I1660_gn41 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I171_XG_MN0 (I0_I1660_G41_40 I0_I1660_pn41 XI0_I1660_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I171_XG_MN1 (XI0_I1660_I171_XG_n1 I0_I1660_gn40 I0_I1660_G41_40 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I170_XG_MN2 (XI0_I1660_I170_XG_n1 I0_I1660_gn40 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I170_XG_MN0 (I0_I1660_G40_39 I0_I1660_pn40 XI0_I1660_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I170_XG_MN1 (XI0_I1660_I170_XG_n1 I0_I1660_gn39 I0_I1660_G40_39 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I186_XG_MN2 (XI1_I1850_I186_XG_n1 I1_I1850_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I186_XG_MN0 (I1_I1850_G19_0 I1_I1850_P19_4n XI1_I1850_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I186_XG_MN1 (XI1_I1850_I186_XG_n1 I1_I1850_G3_0n I1_I1850_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I138_XG_MN2 (XI1_I1850_I138_XG_n1 I1_I1850_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I138_XG_MN0 (I1_I1850_G13_6 I1_I1850_P13_10n XI1_I1850_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I138_XG_MN1 (XI1_I1850_I138_XG_n1 I1_I1850_G9_6n I1_I1850_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I184_XG_MN2 (XI1_I1850_I184_XG_n1 I1_I1850_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I184_XG_MN0 (I1_I1850_G17_0 I1_I1850_P17_2n XI1_I1850_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I184_XG_MN1 (XI1_I1850_I184_XG_n1 I1_I1850_G1_0n I1_I1850_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I79_XG_MN2 (XI1_I1850_I79_XG_n1 I1_I1850_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I79_XG_MN0 (I1_I1850_G13_12 I1_I1850_pn13 XI1_I1850_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I79_XG_MN1 (XI1_I1850_I79_XG_n1 I1_I1850_gn12 I1_I1850_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I78_XG_MN2 (XI1_I1850_I78_XG_n1 I1_I1850_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I78_XG_MN0 (I1_I1850_G12_11 I1_I1850_pn12 XI1_I1850_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I78_XG_MN1 (XI1_I1850_I78_XG_n1 I1_I1850_gn11 I1_I1850_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I78_XG_MN2 (XI1_I1896_I78_XG_n1 I1_I1896_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I78_XG_MN0 (I1_I1896_G12_11 I1_I1896_pn12 XI1_I1896_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I78_XG_MN1 (XI1_I1896_I78_XG_n1 I1_I1896_gn11 I1_I1896_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I138_XG_MN2 (XI1_I1896_I138_XG_n1 I1_I1896_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I138_XG_MN0 (I1_I1896_G13_6 I1_I1896_P13_10n XI1_I1896_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I138_XG_MN1 (XI1_I1896_I138_XG_n1 I1_I1896_G9_6n I1_I1896_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I137_XG_MN2 (XI1_I1896_I137_XG_n1 I1_I1896_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I137_XG_MN0 (I1_I1896_G12_5 I1_I1896_P12_9n XI1_I1896_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I137_XG_MN1 (XI1_I1896_I137_XG_n1 I1_I1896_G8_5n I1_I1896_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I185_XG_MN2 (XI1_I1896_I185_XG_n1 I1_I1896_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I185_XG_MN0 (I1_I1896_G18_0 I1_I1896_P18_3n XI1_I1896_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I185_XG_MN1 (XI1_I1896_I185_XG_n1 I1_I1896_G2_0n I1_I1896_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I81_XG_MN2 (XI1_I1942_I81_XG_n1 I1_I1942_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I81_XG_MN0 (I1_I1942_G15_14 I1_I1942_pn15 XI1_I1942_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I81_XG_MN1 (XI1_I1942_I81_XG_n1 I1_I1942_gn14 I1_I1942_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I140_XG_MN2 (XI1_I1942_I140_XG_n1 I1_I1942_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I140_XG_MN0 (I1_I1942_G15_8 I1_I1942_P15_12n XI1_I1942_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I140_XG_MN1 (XI1_I1942_I140_XG_n1 I1_I1942_G11_8n I1_I1942_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I143_XG_MN2 (XI1_I1942_I143_XG_n1 I1_I1942_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I143_XG_MN0 (I1_I1942_G18_11 I1_I1942_P18_15n XI1_I1942_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I143_XG_MN1 (XI1_I1942_I143_XG_n1 I1_I1942_G14_11n I1_I1942_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I188_XG_MN2 (XI1_I1942_I188_XG_n1 I1_I1942_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I188_XG_MN0 (I1_I1942_G20_0 I1_I1942_P20_5n XI1_I1942_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I188_XG_MN1 (XI1_I1942_I188_XG_n1 I1_I1942_G4_0n I1_I1942_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I81_XG_MN2 (XI1_I1988_I81_XG_n1 I1_I1988_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I81_XG_MN0 (I1_I1988_G15_14 I1_I1988_pn15 XI1_I1988_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I81_XG_MN1 (XI1_I1988_I81_XG_n1 I1_I1988_gn14 I1_I1988_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I140_XG_MN2 (XI1_I1988_I140_XG_n1 I1_I1988_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I140_XG_MN0 (I1_I1988_G15_8 I1_I1988_P15_12n XI1_I1988_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I140_XG_MN1 (XI1_I1988_I140_XG_n1 I1_I1988_G11_8n I1_I1988_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I186_XG_MN2 (XI1_I1988_I186_XG_n1 I1_I1988_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I186_XG_MN0 (I1_I1988_G19_0 I1_I1988_P19_4n XI1_I1988_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I186_XG_MN1 (XI1_I1988_I186_XG_n1 I1_I1988_G3_0n I1_I1988_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I143_XG_MN2 (XI1_I1988_I143_XG_n1 I1_I1988_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I143_XG_MN0 (I1_I1988_G18_11 I1_I1988_P18_15n XI1_I1988_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I143_XG_MN1 (XI1_I1988_I143_XG_n1 I1_I1988_G14_11n I1_I1988_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I79_XG_MN2 (XI1_I2066_I79_XG_n1 I1_I2066_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I79_XG_MN0 (I1_I2066_G13_12 I1_I2066_pn13 XI1_I2066_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I79_XG_MN1 (XI1_I2066_I79_XG_n1 I1_I2066_gn12 I1_I2066_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I141_XG_MN2 (XI1_I2066_I141_XG_n1 I1_I2066_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I141_XG_MN0 (I1_I2066_G16_9 I1_I2066_P16_13n XI1_I2066_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I141_XG_MN1 (XI1_I2066_I141_XG_n1 I1_I2066_G12_9n I1_I2066_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I137_XG_MN2 (XI1_I2066_I137_XG_n1 I1_I2066_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I137_XG_MN0 (I1_I2066_G12_5 I1_I2066_P12_9n XI1_I2066_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I137_XG_MN1 (XI1_I2066_I137_XG_n1 I1_I2066_G8_5n I1_I2066_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I195_XG_MN2 (XI1_I2066_I195_XG_n1 I1_I2066_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I195_XG_MN0 (I1_I2066_G24_0 I1_I2066_P24_9n XI1_I2066_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I195_XG_MN1 (XI1_I2066_I195_XG_n1 I1_I2066_G8_0n I1_I2066_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I134_XG_MN2 (XI1_I2066_I134_XG_n1 I1_I2066_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I134_XG_MN0 (I1_I2066_G9_2 I1_I2066_P9_6n XI1_I2066_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I134_XG_MN1 (XI1_I2066_I134_XG_n1 I1_I2066_G5_2n I1_I2066_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I377_XG_MN2 (XI0_I1660_I377_XG_n1 I0_I1660_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I377_XG_MN0 (I0_I1660_G18_0 I0_I1660_P18_3n XI0_I1660_I377_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I377_XG_MN1 (XI0_I1660_I377_XG_n1 I0_I1660_G2_0n I0_I1660_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I397_XG_MN2 (XI0_I1660_I397_XG_n1 I0_I1660_G34_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I397_XG_MN0 (I0_I1660_G34_3 I0_I1660_P34_19n XI0_I1660_I397_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I397_XG_MN1 (XI0_I1660_I397_XG_n1 I0_I1660_G18_3n I0_I1660_G34_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I275_XG_MN2 (XI0_I1660_I275_XG_n1 I0_I1660_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I275_XG_MN0 (I0_I1660_G22_15 I0_I1660_P22_19n XI0_I1660_I275_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I275_XG_MN1 (XI0_I1660_I275_XG_n1 I0_I1660_G18_15n I0_I1660_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I411_XG_MN2 (XI0_I1660_I411_XG_n1 I0_I1660_G48_33n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I411_XG_MN0 (I0_I1660_G48_17 I0_I1660_P48_33n XI0_I1660_I411_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I411_XG_MN1 (XI0_I1660_I411_XG_n1 I0_I1660_G32_17n I0_I1660_G48_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I279_XG_MN2 (XI0_I1660_I279_XG_n1 I0_I1660_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I279_XG_MN0 (I0_I1660_G26_19 I0_I1660_P26_23n XI0_I1660_I279_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I279_XG_MN1 (XI0_I1660_I279_XG_n1 I0_I1660_G22_19n I0_I1660_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I283_XG_MN2 (XI0_I1660_I283_XG_n1 I0_I1660_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I283_XG_MN0 (I0_I1660_G30_23 I0_I1660_P30_27n XI0_I1660_I283_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I283_XG_MN1 (XI0_I1660_I283_XG_n1 I0_I1660_G26_23n I0_I1660_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I293_XG_MN2 (XI0_I1660_I293_XG_n1 I0_I1660_G40_37n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I293_XG_MN0 (I0_I1660_G40_33 I0_I1660_P40_37n XI0_I1660_I293_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I293_XG_MN1 (XI0_I1660_I293_XG_n1 I0_I1660_G36_33n I0_I1660_G40_33 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I416_XG_MN2 (XI0_I1660_I416_XG_n1 I0_I1660_G53_38n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I416_XG_MN0 (I0_I1660_G53_22 I0_I1660_P53_38n XI0_I1660_I416_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I416_XG_MN1 (XI0_I1660_I416_XG_n1 I0_I1660_G37_22n I0_I1660_G53_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I418_XG_MN2 (XI0_I1660_I418_XG_n1 I0_I1660_G55_40n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I418_XG_MN0 (I0_I1660_G55_24 I0_I1660_P55_40n XI0_I1660_I418_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I418_XG_MN1 (XI0_I1660_I418_XG_n1 I0_I1660_G39_24n I0_I1660_G55_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I300_XG_MN2 (XI0_I1660_I300_XG_n1 I0_I1660_G47_44n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I300_XG_MN0 (I0_I1660_G47_40 I0_I1660_P47_44n XI0_I1660_I300_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I300_XG_MN1 (XI0_I1660_I300_XG_n1 I0_I1660_G43_40n I0_I1660_G47_40 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I174_XG_MN2 (XI0_I1660_I174_XG_n1 I0_I1660_gn44 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I174_XG_MN0 (I0_I1660_G44_43 I0_I1660_pn44 XI0_I1660_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I174_XG_MN1 (XI0_I1660_I174_XG_n1 I0_I1660_gn43 I0_I1660_G44_43 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I173_XG_MN2 (XI0_I1660_I173_XG_n1 I0_I1660_gn43 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I173_XG_MN0 (I0_I1660_G43_42 I0_I1660_pn43 XI0_I1660_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I173_XG_MN1 (XI0_I1660_I173_XG_n1 I0_I1660_gn42 I0_I1660_G43_42 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I172_XG_MN2 (XI0_I1660_I172_XG_n1 I0_I1660_gn42 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I172_XG_MN0 (I0_I1660_G42_41 I0_I1660_pn42 XI0_I1660_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I172_XG_MN1 (XI0_I1660_I172_XG_n1 I0_I1660_gn41 I0_I1660_G42_41 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I140_XG_MN2 (XI1_I1850_I140_XG_n1 I1_I1850_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I140_XG_MN0 (I1_I1850_G15_8 I1_I1850_P15_12n XI1_I1850_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I140_XG_MN1 (XI1_I1850_I140_XG_n1 I1_I1850_G11_8n I1_I1850_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I81_XG_MN2 (XI1_I1850_I81_XG_n1 I1_I1850_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I81_XG_MN0 (I1_I1850_G15_14 I1_I1850_pn15 XI1_I1850_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I81_XG_MN1 (XI1_I1850_I81_XG_n1 I1_I1850_gn14 I1_I1850_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I80_XG_MN2 (XI1_I1850_I80_XG_n1 I1_I1850_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I80_XG_MN0 (I1_I1850_G14_13 I1_I1850_pn14 XI1_I1850_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I80_XG_MN1 (XI1_I1850_I80_XG_n1 I1_I1850_gn13 I1_I1850_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I133_XG_MN2 (XI1_I1850_I133_XG_n1 I1_I1850_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I133_XG_MN0 (I1_I1850_G8_1 I1_I1850_P8_5n XI1_I1850_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I133_XG_MN1 (XI1_I1850_I133_XG_n1 I1_I1850_G4_1n I1_I1850_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I131_XG_MN2 (XI1_I1850_I131_XG_n1 I1_I1850_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I131_XG_MN0 (I1_I1850_G6_0 I1_I1850_P6_3n XI1_I1850_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I131_XG_MN1 (XI1_I1850_I131_XG_n1 I1_I1850_G2_0n I1_I1850_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I80_XG_MN2 (XI1_I1896_I80_XG_n1 I1_I1896_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I80_XG_MN0 (I1_I1896_G14_13 I1_I1896_pn14 XI1_I1896_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I80_XG_MN1 (XI1_I1896_I80_XG_n1 I1_I1896_gn13 I1_I1896_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I79_XG_MN2 (XI1_I1896_I79_XG_n1 I1_I1896_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I79_XG_MN0 (I1_I1896_G13_12 I1_I1896_pn13 XI1_I1896_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I79_XG_MN1 (XI1_I1896_I79_XG_n1 I1_I1896_gn12 I1_I1896_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I142_XG_MN2 (XI1_I1896_I142_XG_n1 I1_I1896_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I142_XG_MN0 (I1_I1896_G17_10 I1_I1896_P17_14n XI1_I1896_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I142_XG_MN1 (XI1_I1896_I142_XG_n1 I1_I1896_G13_10n I1_I1896_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I186_XG_MN2 (XI1_I1896_I186_XG_n1 I1_I1896_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I186_XG_MN0 (I1_I1896_G19_0 I1_I1896_P19_4n XI1_I1896_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I186_XG_MN1 (XI1_I1896_I186_XG_n1 I1_I1896_G3_0n I1_I1896_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I141_XG_MN2 (XI1_I1896_I141_XG_n1 I1_I1896_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I141_XG_MN0 (I1_I1896_G16_9 I1_I1896_P16_13n XI1_I1896_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I141_XG_MN1 (XI1_I1896_I141_XG_n1 I1_I1896_G12_9n I1_I1896_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I83_XG_MN2 (XI1_I1942_I83_XG_n1 I1_I1942_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I83_XG_MN0 (I1_I1942_G17_16 I1_I1942_pn17 XI1_I1942_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I83_XG_MN1 (XI1_I1942_I83_XG_n1 I1_I1942_gn16 I1_I1942_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I82_XG_MN2 (XI1_I1942_I82_XG_n1 I1_I1942_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I82_XG_MN0 (I1_I1942_G16_15 I1_I1942_pn16 XI1_I1942_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I82_XG_MN1 (XI1_I1942_I82_XG_n1 I1_I1942_gn15 I1_I1942_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I144_XG_MN2 (XI1_I1942_I144_XG_n1 I1_I1942_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I144_XG_MN0 (I1_I1942_G19_12 I1_I1942_P19_16n XI1_I1942_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I144_XG_MN1 (XI1_I1942_I144_XG_n1 I1_I1942_G15_12n I1_I1942_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I190_XG_MN2 (XI1_I1942_I190_XG_n1 I1_I1942_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I190_XG_MN0 (I1_I1942_G21_0 I1_I1942_P21_6n XI1_I1942_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I190_XG_MN1 (XI1_I1942_I190_XG_n1 I1_I1942_G5_0n I1_I1942_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I145_XG_MN2 (XI1_I1942_I145_XG_n1 I1_I1942_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I145_XG_MN0 (I1_I1942_G20_13 I1_I1942_P20_17n XI1_I1942_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I145_XG_MN1 (XI1_I1942_I145_XG_n1 I1_I1942_G16_13n I1_I1942_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I82_XG_MN2 (XI1_I1988_I82_XG_n1 I1_I1988_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I82_XG_MN0 (I1_I1988_G16_15 I1_I1988_pn16 XI1_I1988_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I82_XG_MN1 (XI1_I1988_I82_XG_n1 I1_I1988_gn15 I1_I1988_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I83_XG_MN2 (XI1_I1988_I83_XG_n1 I1_I1988_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I83_XG_MN0 (I1_I1988_G17_16 I1_I1988_pn17 XI1_I1988_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I83_XG_MN1 (XI1_I1988_I83_XG_n1 I1_I1988_gn16 I1_I1988_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I144_XG_MN2 (XI1_I1988_I144_XG_n1 I1_I1988_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I144_XG_MN0 (I1_I1988_G19_12 I1_I1988_P19_16n XI1_I1988_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I144_XG_MN1 (XI1_I1988_I144_XG_n1 I1_I1988_G15_12n I1_I1988_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I190_XG_MN2 (XI1_I1988_I190_XG_n1 I1_I1988_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I190_XG_MN0 (I1_I1988_G21_0 I1_I1988_P21_6n XI1_I1988_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I190_XG_MN1 (XI1_I1988_I190_XG_n1 I1_I1988_G5_0n I1_I1988_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I145_XG_MN2 (XI1_I1988_I145_XG_n1 I1_I1988_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I145_XG_MN0 (I1_I1988_G20_13 I1_I1988_P20_17n XI1_I1988_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I145_XG_MN1 (XI1_I1988_I145_XG_n1 I1_I1988_G16_13n I1_I1988_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I188_XG_MN2 (XI1_I1988_I188_XG_n1 I1_I1988_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I188_XG_MN0 (I1_I1988_G20_0 I1_I1988_P20_5n XI1_I1988_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I188_XG_MN1 (XI1_I1988_I188_XG_n1 I1_I1988_G4_0n I1_I1988_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I81_XG_MN2 (XI1_I2066_I81_XG_n1 I1_I2066_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I81_XG_MN0 (I1_I2066_G15_14 I1_I2066_pn15 XI1_I2066_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I81_XG_MN1 (XI1_I2066_I81_XG_n1 I1_I2066_gn14 I1_I2066_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I80_XG_MN2 (XI1_I2066_I80_XG_n1 I1_I2066_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I80_XG_MN0 (I1_I2066_G14_13 I1_I2066_pn14 XI1_I2066_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I80_XG_MN1 (XI1_I2066_I80_XG_n1 I1_I2066_gn13 I1_I2066_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I135_XG_MN2 (XI1_I2066_I135_XG_n1 I1_I2066_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I135_XG_MN0 (I1_I2066_G10_3 I1_I2066_P10_7n XI1_I2066_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I135_XG_MN1 (XI1_I2066_I135_XG_n1 I1_I2066_G6_3n I1_I2066_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I131_XG_MN2 (XI1_I2066_I131_XG_n1 I1_I2066_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I131_XG_MN0 (I1_I2066_G6_0 I1_I2066_P6_3n XI1_I2066_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I131_XG_MN1 (XI1_I2066_I131_XG_n1 I1_I2066_G2_0n I1_I2066_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I184_XG_MN2 (XI1_I2066_I184_XG_n1 I1_I2066_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I184_XG_MN0 (I1_I2066_G17_0 I1_I2066_P17_2n XI1_I2066_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I184_XG_MN1 (XI1_I2066_I184_XG_n1 I1_I2066_G1_0n I1_I2066_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I389_XG_MN2 (XI0_I1660_I389_XG_n1 I0_I1660_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I389_XG_MN0 (I0_I1660_G26_0 I0_I1660_P26_11n XI0_I1660_I389_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I389_XG_MN1 (XI0_I1660_I389_XG_n1 I0_I1660_G10_0n I0_I1660_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I407_XG_MN2 (XI0_I1660_I407_XG_n1 I0_I1660_G44_29n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I407_XG_MN0 (I0_I1660_G44_13 I0_I1660_P44_29n XI0_I1660_I407_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I407_XG_MN1 (XI0_I1660_I407_XG_n1 I0_I1660_G28_13n I0_I1660_G44_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I287_XG_MN2 (XI0_I1660_I287_XG_n1 I0_I1660_G34_31n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I287_XG_MN0 (I0_I1660_G34_27 I0_I1660_P34_31n XI0_I1660_I287_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I287_XG_MN1 (XI0_I1660_I287_XG_n1 I0_I1660_G30_27n I0_I1660_G34_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I297_XG_MN2 (XI0_I1660_I297_XG_n1 I0_I1660_G44_41n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I297_XG_MN0 (I0_I1660_G44_37 I0_I1660_P44_41n XI0_I1660_I297_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I297_XG_MN1 (XI0_I1660_I297_XG_n1 I0_I1660_G40_37n I0_I1660_G44_37 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I408_XG_MN2 (XI0_I1660_I408_XG_n1 I0_I1660_G45_30n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I408_XG_MN0 (I0_I1660_G45_14 I0_I1660_P45_30n XI0_I1660_I408_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I408_XG_MN1 (XI0_I1660_I408_XG_n1 I0_I1660_G29_14n I0_I1660_G45_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I426_XG_MN2 (XI0_I1660_I426_XG_n1 I0_I1660_G63_48n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I426_XG_MN0 (I0_I1660_G63_32 I0_I1660_P63_48n XI0_I1660_I426_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I426_XG_MN1 (XI0_I1660_I426_XG_n1 I0_I1660_G47_32n I0_I1660_G63_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I298_XG_MN2 (XI0_I1660_I298_XG_n1 I0_I1660_G45_42n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I298_XG_MN0 (I0_I1660_G45_38 I0_I1660_P45_42n XI0_I1660_I298_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I298_XG_MN1 (XI0_I1660_I298_XG_n1 I0_I1660_G41_38n I0_I1660_G45_38 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I175_XG_MN2 (XI0_I1660_I175_XG_n1 I0_I1660_gn45 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I175_XG_MN0 (I0_I1660_G45_44 I0_I1660_pn45 XI0_I1660_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I175_XG_MN1 (XI0_I1660_I175_XG_n1 I0_I1660_gn44 I0_I1660_G45_44 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I202_XG_MN2 (XI1_I1850_I202_XG_n1 I1_I1850_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I202_XG_MN0 (I1_c28_o I1_I1850_P31_16n XI1_I1850_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I202_XG_MN1 (XI1_I1850_I202_XG_n1 I1_I1850_G15_0n I1_c28_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I144_XG_MN2 (XI1_I1850_I144_XG_n1 I1_I1850_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I144_XG_MN0 (I1_I1850_G19_12 I1_I1850_P19_16n XI1_I1850_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I144_XG_MN1 (XI1_I1850_I144_XG_n1 I1_I1850_G15_12n I1_I1850_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I142_XG_MN2 (XI1_I1850_I142_XG_n1 I1_I1850_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I142_XG_MN0 (I1_I1850_G17_10 I1_I1850_P17_14n XI1_I1850_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I142_XG_MN1 (XI1_I1850_I142_XG_n1 I1_I1850_G13_10n I1_I1850_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I141_XG_MN2 (XI1_I1850_I141_XG_n1 I1_I1850_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I141_XG_MN0 (I1_I1850_G16_9 I1_I1850_P16_13n XI1_I1850_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
