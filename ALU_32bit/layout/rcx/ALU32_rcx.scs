    I_MXI2_I3_I380_MP1 (XI2_I3_I380_p1 I2_S_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I404_MP2 (XI2_I3_I404_p1 I2_I3_o26_2 I2_I3_q26_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I404_MP0 (VDD I2_I3_SEL_AS_b3_4 XI2_I3_I404_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I404_MP1 (XI2_I3_I404_p1 I2_S_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I416_MP2 (XI2_I3_I416_p1 I2_I3_o27_2 I2_I3_q27_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I416_MP0 (VDD I2_I3_SEL_AS_b3_5 XI2_I3_I416_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I416_MP1 (XI2_I3_I416_p1 I2_S_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I428_MP2 (XI2_I3_I428_p1 I2_I3_o28_2 I2_I3_q28_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I428_MP0 (VDD I2_I3_SEL_AS_b3_5 XI2_I3_I428_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I428_MP1 (XI2_I3_I428_p1 I2_S_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I126_XG_MP2 (XI1_I1712_I126_XG_p1 I1_I1712_G30_29 I1_I1712_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I126_XG_MP0 (VDD I1_I1712_P30_29 XI1_I1712_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I126_XG_MP1 (XI1_I1712_I126_XG_p1 I1_I1712_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I124_XG_MP2 (XI1_I1712_I124_XG_p1 I1_I1712_G28_27 I1_I1712_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I124_XG_MP0 (VDD I1_I1712_P28_27 XI1_I1712_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I124_XG_MP1 (XI1_I1712_I124_XG_p1 I1_I1712_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I122_XG_MP2 (XI1_I1712_I122_XG_p1 I1_I1712_G26_25 I1_I1712_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I122_XG_MP0 (VDD I1_I1712_P26_25 XI1_I1712_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I122_XG_MP1 (XI1_I1712_I122_XG_p1 I1_I1712_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I120_XG_MP2 (XI1_I1712_I120_XG_p1 I1_I1712_G24_23 I1_I1712_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I120_XG_MP0 (VDD I1_I1712_P24_23 XI1_I1712_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I120_XG_MP1 (XI1_I1712_I120_XG_p1 I1_I1712_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I175_XG_MP2 (XI1_I1712_I175_XG_p1 I1_I1712_G24_17 I1_I1712_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I175_XG_MP0 (VDD I1_I1712_P24_17 XI1_I1712_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I175_XG_MP1 (XI1_I1712_I175_XG_p1 I1_I1712_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I167_XG_MP2 (XI1_I1712_I167_XG_p1 I1_I1712_G16_9 I1_I1712_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I167_XG_MP0 (VDD I1_I1712_P16_9 XI1_I1712_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I167_XG_MP1 (XI1_I1712_I167_XG_p1 I1_I1712_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I157_XG_MP2 (XI1_I1712_I157_XG_p1 I1_I1712_G8_1 I1_I1712_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I157_XG_MP0 (VDD I1_I1712_P8_1 XI1_I1712_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I157_XG_MP1 (XI1_I1712_I157_XG_p1 I1_I1712_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I100_XG_MP2 (XI1_I1712_I100_XG_p1 I1_I1712_G4_3 I1_I1712_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I100_XG_MP0 (VDD I1_I1712_P4_3 XI1_I1712_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I100_XG_MP1 (XI1_I1712_I100_XG_p1 I1_I1712_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I98_XG_MP2 (XI1_I1712_I98_XG_p1 I1_I1712_G2_1 I1_I1712_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I98_XG_MP0 (VDD I1_I1712_P2_1 XI1_I1712_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I98_XG_MP1 (XI1_I1712_I98_XG_p1 I1_I1712_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I126_XG_MP2 (XI1_I1574_I126_XG_p1 I1_I1574_G30_29 I1_I1574_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I126_XG_MP0 (VDD I1_I1574_P30_29 XI1_I1574_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I126_XG_MP1 (XI1_I1574_I126_XG_p1 I1_I1574_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I124_XG_MP2 (XI1_I1574_I124_XG_p1 I1_I1574_G28_27 I1_I1574_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I124_XG_MP0 (VDD I1_I1574_P28_27 XI1_I1574_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I124_XG_MP1 (XI1_I1574_I124_XG_p1 I1_I1574_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I179_XG_MP2 (XI1_I1574_I179_XG_p1 I1_I1574_G28_21 I1_I1574_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I179_XG_MP0 (VDD I1_I1574_P28_21 XI1_I1574_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I179_XG_MP1 (XI1_I1574_I179_XG_p1 I1_I1574_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I171_XG_MP2 (XI1_I1574_I171_XG_p1 I1_I1574_G20_13 I1_I1574_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I171_XG_MP0 (VDD I1_I1574_P20_13 XI1_I1574_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I171_XG_MP1 (XI1_I1574_I171_XG_p1 I1_I1574_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I163_XG_MP2 (XI1_I1574_I163_XG_p1 I1_I1574_G12_5 I1_I1574_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I163_XG_MP0 (VDD I1_I1574_P12_5 XI1_I1574_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I163_XG_MP1 (XI1_I1574_I163_XG_p1 I1_I1574_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I175_XG_MP2 (XI1_I1574_I175_XG_p1 I1_I1574_G24_17 I1_I1574_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I175_XG_MP0 (VDD I1_I1574_P24_17 XI1_I1574_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I175_XG_MP1 (XI1_I1574_I175_XG_p1 I1_I1574_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I167_XG_MP2 (XI1_I1574_I167_XG_p1 I1_I1574_G16_9 I1_I1574_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I167_XG_MP0 (VDD I1_I1574_P16_9 XI1_I1574_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I167_XG_MP1 (XI1_I1574_I167_XG_p1 I1_I1574_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I100_XG_MP2 (XI1_I1574_I100_XG_p1 I1_I1574_G4_3 I1_I1574_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I100_XG_MP0 (VDD I1_I1574_P4_3 XI1_I1574_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I100_XG_MP1 (XI1_I1574_I100_XG_p1 I1_I1574_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I236_MP2 (XI2_I3_I236_p1 I2_I3_o12_2 I2_I3_q12_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I236_MP0 (VDD I2_I3_SEL_AS_b3_2 XI2_I3_I236_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I236_MP1 (XI2_I3_I236_p1 I2_S_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I108_XG_MP2 (XI2_I1_I42_I108_XG_p1 I2_I1_I42_G12_11 I2_I1_I42_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I108_XG_MP0 (VDD I2_I1_I42_P12_11 XI2_I1_I42_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I108_XG_MP1 (XI2_I1_I42_I108_XG_p1 I2_I1_I42_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I175_XG_MP2 (XI2_I1_I42_I175_XG_p1 I2_I1_I42_G24_17 I2_I1_I42_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I175_XG_MP0 (VDD I2_I1_I42_P24_17 XI2_I1_I42_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I175_XG_MP1 (XI2_I1_I42_I175_XG_p1 I2_I1_I42_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I169_XG_MP2 (XI2_I1_I42_I169_XG_p1 I2_I1_I42_G18_11 I2_I1_I42_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I169_XG_MP0 (VDD I2_I1_I42_P18_11 XI2_I1_I42_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I169_XG_MP1 (XI2_I1_I42_I169_XG_p1 I2_I1_I42_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I111_XG_MP2 (XI2_I1_I42_I111_XG_p1 I2_I1_I42_G15_14 I2_I1_I42_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I111_XG_MP0 (VDD I2_I1_I42_P15_14 XI2_I1_I42_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I111_XG_MP1 (XI2_I1_I42_I111_XG_p1 I2_I1_I42_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I178_XG_MP2 (XI2_I1_I42_I178_XG_p1 I2_I1_I42_G27_20 I2_I1_I42_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I178_XG_MP0 (VDD I2_I1_I42_P27_20 XI2_I1_I42_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I178_XG_MP1 (XI2_I1_I42_I178_XG_p1 I2_I1_I42_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I121_XG_MP2 (XI2_I1_I42_I121_XG_p1 I2_I1_I42_G25_24 I2_I1_I42_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I121_XG_MP0 (VDD I2_I1_I42_P25_24 XI2_I1_I42_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I121_XG_MP1 (XI2_I1_I42_I121_XG_p1 I2_I1_I42_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I123_XG_MP2 (XI2_I1_I42_I123_XG_p1 I2_I1_I42_G27_26 I2_I1_I42_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I123_XG_MP0 (VDD I2_I1_I42_P27_26 XI2_I1_I42_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I123_XG_MP1 (XI2_I1_I42_I123_XG_p1 I2_I1_I42_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I125_XG_MP2 (XI2_I1_I42_I125_XG_p1 I2_I1_I42_G29_28 I2_I1_I42_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I125_XG_MP0 (VDD I2_I1_I42_P29_28 XI2_I1_I42_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I125_XG_MP1 (XI2_I1_I42_I125_XG_p1 I2_I1_I42_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I127_XG_MP2 (XI2_I1_I42_I127_XG_p1 I2_I1_I42_G31_30 I2_I1_I42_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I127_XG_MP0 (VDD I2_I1_I42_P31_30 XI2_I1_I42_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I127_XG_MP1 (XI2_I1_I42_I127_XG_p1 I2_I1_I42_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I452_MP2 (XI2_I3_I452_p1 I2_I3_o30_2 I2_I3_q30_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I452_MP0 (VDD I2_I3_SEL_AS_b3_5 XI2_I3_I452_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I452_MP1 (XI2_I3_I452_p1 I2_S_30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I464_MP2 (XI2_I3_I464_p1 I2_I3_o31_2 I2_I3_q31_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I464_MP0 (VDD I2_I3_SEL_AS_b3_5 XI2_I3_I464_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I464_MP1 (XI2_I3_I464_p1 I2_S_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I181_XG_MP2 (XI1_I1712_I181_XG_p1 I1_I1712_G30_23 I1_I1712_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I181_XG_MP0 (VDD I1_I1712_P30_23 XI1_I1712_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I181_XG_MP1 (XI1_I1712_I181_XG_p1 I1_I1712_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I118_XG_MP2 (XI1_I1712_I118_XG_p1 I1_I1712_G22_21 I1_I1712_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I118_XG_MP0 (VDD I1_I1712_P22_21 XI1_I1712_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I118_XG_MP1 (XI1_I1712_I118_XG_p1 I1_I1712_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I177_XG_MP2 (XI1_I1712_I177_XG_p1 I1_I1712_G26_19 I1_I1712_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I177_XG_MP0 (VDD I1_I1712_P26_19 XI1_I1712_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I177_XG_MP1 (XI1_I1712_I177_XG_p1 I1_I1712_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I173_XG_MP2 (XI1_I1712_I173_XG_p1 I1_I1712_G22_15 I1_I1712_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I173_XG_MP0 (VDD I1_I1712_P22_15 XI1_I1712_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I173_XG_MP1 (XI1_I1712_I173_XG_p1 I1_I1712_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I165_XG_MP2 (XI1_I1712_I165_XG_p1 I1_I1712_G14_7 I1_I1712_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I165_XG_MP0 (VDD I1_I1712_P14_7 XI1_I1712_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I165_XG_MP1 (XI1_I1712_I165_XG_p1 I1_I1712_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I169_XG_MP2 (XI1_I1712_I169_XG_p1 I1_I1712_G18_11 I1_I1712_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I169_XG_MP0 (VDD I1_I1712_P18_11 XI1_I1712_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I169_XG_MP1 (XI1_I1712_I169_XG_p1 I1_I1712_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I160_XG_MP2 (XI1_I1712_I160_XG_p1 I1_I1712_G10_3 I1_I1712_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I160_XG_MP0 (VDD I1_I1712_P10_3 XI1_I1712_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I160_XG_MP1 (XI1_I1712_I160_XG_p1 I1_I1712_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I104_XG_MP2 (XI1_I1712_I104_XG_p1 I1_I1712_G8_7 I1_I1712_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I104_XG_MP0 (VDD I1_I1712_P8_7 XI1_I1712_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I104_XG_MP1 (XI1_I1712_I104_XG_p1 I1_I1712_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I102_XG_MP2 (XI1_I1712_I102_XG_p1 I1_I1712_G6_5 I1_I1712_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I102_XG_MP0 (VDD I1_I1712_P6_5 XI1_I1712_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I102_XG_MP1 (XI1_I1712_I102_XG_p1 I1_I1712_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I122_XG_MP2 (XI1_I1574_I122_XG_p1 I1_I1574_G26_25 I1_I1574_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I122_XG_MP0 (VDD I1_I1574_P26_25 XI1_I1574_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I122_XG_MP1 (XI1_I1574_I122_XG_p1 I1_I1574_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I120_XG_MP2 (XI1_I1574_I120_XG_p1 I1_I1574_G24_23 I1_I1574_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I120_XG_MP0 (VDD I1_I1574_P24_23 XI1_I1574_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I120_XG_MP1 (XI1_I1574_I120_XG_p1 I1_I1574_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I116_XG_MP2 (XI1_I1574_I116_XG_p1 I1_I1574_G20_19 I1_I1574_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I116_XG_MP0 (VDD I1_I1574_P20_19 XI1_I1574_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I116_XG_MP1 (XI1_I1574_I116_XG_p1 I1_I1574_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I114_XG_MP2 (XI1_I1574_I114_XG_p1 I1_I1574_G18_17 I1_I1574_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I114_XG_MP0 (VDD I1_I1574_P18_17 XI1_I1574_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I114_XG_MP1 (XI1_I1574_I114_XG_p1 I1_I1574_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I157_XG_MP2 (XI1_I1574_I157_XG_p1 I1_I1574_G8_1 I1_I1574_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I157_XG_MP0 (VDD I1_I1574_P8_1 XI1_I1574_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I157_XG_MP1 (XI1_I1574_I157_XG_p1 I1_I1574_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I98_XG_MP2 (XI1_I1574_I98_XG_p1 I1_I1574_G2_1 I1_I1574_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I98_XG_MP0 (VDD I1_I1574_P2_1 XI1_I1574_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I98_XG_MP1 (XI1_I1574_I98_XG_p1 I1_I1574_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I224_MP2 (XI2_I3_I224_p1 I2_I3_o11_2 I2_I3_q11_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I224_MP0 (VDD I2_I3_SEL_AS_b3_2 XI2_I3_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I224_MP1 (XI2_I3_I224_p1 I2_S_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I106_XG_MP2 (XI2_I1_I42_I106_XG_p1 I2_I1_I42_G10_9 I2_I1_I42_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I106_XG_MP0 (VDD I2_I1_I42_P10_9 XI2_I1_I42_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I106_XG_MP1 (XI2_I1_I42_I106_XG_p1 I2_I1_I42_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I160_XG_MP2 (XI2_I1_I42_I160_XG_p1 I2_I1_I42_G10_3 I2_I1_I42_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I160_XG_MP0 (VDD I2_I1_I42_P10_3 XI2_I1_I42_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I160_XG_MP1 (XI2_I1_I42_I160_XG_p1 I2_I1_I42_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I109_XG_MP2 (XI2_I1_I42_I109_XG_p1 I2_I1_I42_G13_12 I2_I1_I42_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I109_XG_MP0 (VDD I2_I1_I42_P13_12 XI2_I1_I42_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I109_XG_MP1 (XI2_I1_I42_I109_XG_p1 I2_I1_I42_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I164_XG_MP2 (XI2_I1_I42_I164_XG_p1 I2_I1_I42_G13_6 I2_I1_I42_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I164_XG_MP0 (VDD I2_I1_I42_P13_6 XI2_I1_I42_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I164_XG_MP1 (XI2_I1_I42_I164_XG_p1 I2_I1_I42_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I172_XG_MP2 (XI2_I1_I42_I172_XG_p1 I2_I1_I42_G21_14 I2_I1_I42_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I172_XG_MP0 (VDD I2_I1_I42_P21_14 XI2_I1_I42_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I172_XG_MP1 (XI2_I1_I42_I172_XG_p1 I2_I1_I42_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I166_XG_MP2 (XI2_I1_I42_I166_XG_p1 I2_I1_I42_G15_8 I2_I1_I42_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I166_XG_MP0 (VDD I2_I1_I42_P15_8 XI2_I1_I42_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I166_XG_MP1 (XI2_I1_I42_I166_XG_p1 I2_I1_I42_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I174_XG_MP2 (XI2_I1_I42_I174_XG_p1 I2_I1_I42_G23_16 I2_I1_I42_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I174_XG_MP0 (VDD I2_I1_I42_P23_16 XI2_I1_I42_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I174_XG_MP1 (XI2_I1_I42_I174_XG_p1 I2_I1_I42_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I180_XG_MP2 (XI2_I1_I42_I180_XG_p1 I2_I1_I42_G29_22 I2_I1_I42_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I180_XG_MP0 (VDD I2_I1_I42_P29_22 XI2_I1_I42_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I180_XG_MP1 (XI2_I1_I42_I180_XG_p1 I2_I1_I42_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I182_XG_MP2 (XI2_I1_I42_I182_XG_p1 I2_I1_I42_G31_24 I2_I1_I42_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I182_XG_MP0 (VDD I2_I1_I42_P31_24 XI2_I1_I42_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I182_XG_MP1 (XI2_I1_I42_I182_XG_p1 I2_I1_I42_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I116_XG_MP2 (XI1_I1712_I116_XG_p1 I1_I1712_G20_19 I1_I1712_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I116_XG_MP0 (VDD I1_I1712_P20_19 XI1_I1712_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I116_XG_MP1 (XI1_I1712_I116_XG_p1 I1_I1712_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I108_XG_MP2 (XI1_I1712_I108_XG_p1 I1_I1712_G12_11 I1_I1712_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I108_XG_MP0 (VDD I1_I1712_P12_11 XI1_I1712_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I108_XG_MP1 (XI1_I1712_I108_XG_p1 I1_I1712_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I106_XG_MP2 (XI1_I1712_I106_XG_p1 I1_I1712_G10_9 I1_I1712_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I106_XG_MP0 (VDD I1_I1712_P10_9 XI1_I1712_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I106_XG_MP1 (XI1_I1712_I106_XG_p1 I1_I1712_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I118_XG_MP2 (XI1_I1574_I118_XG_p1 I1_I1574_G22_21 I1_I1574_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I118_XG_MP0 (VDD I1_I1574_P22_21 XI1_I1574_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I118_XG_MP1 (XI1_I1574_I118_XG_p1 I1_I1574_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I177_XG_MP2 (XI1_I1574_I177_XG_p1 I1_I1574_G26_19 I1_I1574_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I177_XG_MP0 (VDD I1_I1574_P26_19 XI1_I1574_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I177_XG_MP1 (XI1_I1574_I177_XG_p1 I1_I1574_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I169_XG_MP2 (XI1_I1574_I169_XG_p1 I1_I1574_G18_11 I1_I1574_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I169_XG_MP0 (VDD I1_I1574_P18_11 XI1_I1574_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I169_XG_MP1 (XI1_I1574_I169_XG_p1 I1_I1574_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I160_XG_MP2 (XI1_I1574_I160_XG_p1 I1_I1574_G10_3 I1_I1574_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I160_XG_MP0 (VDD I1_I1574_P10_3 XI1_I1574_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I160_XG_MP1 (XI1_I1574_I160_XG_p1 I1_I1574_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I63_MP2 (XI1_I63_p1 I1_nak9 I1_nakn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I63_MP0 (VDD I1_A_31_b3_1 XI1_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I63_MP1 (XI1_I63_p1 A_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I167_XG_MP2 (XI2_I1_I42_I167_XG_p1 I2_I1_I42_G16_9 I2_I1_I42_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I167_XG_MP0 (VDD I2_I1_I42_P16_9 XI2_I1_I42_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I167_XG_MP1 (XI2_I1_I42_I167_XG_p1 I2_I1_I42_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I107_XG_MP2 (XI2_I1_I42_I107_XG_p1 I2_I1_I42_G11_10 I2_I1_I42_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I107_XG_MP0 (VDD I2_I1_I42_P11_10 XI2_I1_I42_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I107_XG_MP1 (XI2_I1_I42_I107_XG_p1 I2_I1_I42_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I162_XG_MP2 (XI2_I1_I42_I162_XG_p1 I2_I1_I42_G11_4 I2_I1_I42_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I162_XG_MP0 (VDD I2_I1_I42_P11_4 XI2_I1_I42_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I162_XG_MP1 (XI2_I1_I42_I162_XG_p1 I2_I1_I42_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I168_XG_MP2 (XI2_I1_I42_I168_XG_p1 I2_I1_I42_G17_10 I2_I1_I42_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I168_XG_MP0 (VDD I2_I1_I42_P17_10 XI2_I1_I42_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I168_XG_MP1 (XI2_I1_I42_I168_XG_p1 I2_I1_I42_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I170_XG_MP2 (XI2_I1_I42_I170_XG_p1 I2_I1_I42_G19_12 I2_I1_I42_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I170_XG_MP0 (VDD I2_I1_I42_P19_12 XI2_I1_I42_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I170_XG_MP1 (XI2_I1_I42_I170_XG_p1 I2_I1_I42_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I176_XG_MP2 (XI2_I1_I42_I176_XG_p1 I2_I1_I42_G25_18 I2_I1_I42_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I176_XG_MP0 (VDD I2_I1_I42_P25_18 XI2_I1_I42_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I176_XG_MP1 (XI2_I1_I42_I176_XG_p1 I2_I1_I42_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I98_XG_MP2 (XI1_I1666_I98_XG_p1 I1_I1666_G2_1 I1_I1666_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I98_XG_MP0 (VDD I1_I1666_P2_1 XI1_I1666_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I98_XG_MP1 (XI1_I1666_I98_XG_p1 I1_I1666_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I181_XG_MP2 (XI1_I1574_I181_XG_p1 I1_I1574_G30_23 I1_I1574_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I181_XG_MP0 (VDD I1_I1574_P30_23 XI1_I1574_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I181_XG_MP1 (XI1_I1574_I181_XG_p1 I1_I1574_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I173_XG_MP2 (XI1_I1574_I173_XG_p1 I1_I1574_G22_15 I1_I1574_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I173_XG_MP0 (VDD I1_I1574_P22_15 XI1_I1574_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I173_XG_MP1 (XI1_I1574_I173_XG_p1 I1_I1574_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I165_XG_MP2 (XI1_I1574_I165_XG_p1 I1_I1574_G14_7 I1_I1574_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I165_XG_MP0 (VDD I1_I1574_P14_7 XI1_I1574_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I165_XG_MP1 (XI1_I1574_I165_XG_p1 I1_I1574_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I60_MP2 (XI1_I60_p1 I1_nak8 I1_nakn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I60_MP0 (VDD I1_A_31_b3_1 XI1_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I60_MP1 (XI1_I60_p1 A_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I104_XG_MP2 (XI2_I1_I42_I104_XG_p1 I2_I1_I42_G8_7 I2_I1_I42_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I104_XG_MP0 (VDD I2_I1_I42_P8_7 XI2_I1_I42_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I104_XG_MP1 (XI2_I1_I42_I104_XG_p1 I2_I1_I42_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I157_XG_MP2 (XI2_I1_I42_I157_XG_p1 I2_I1_I42_G8_1 I2_I1_I42_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I157_XG_MP0 (VDD I2_I1_I42_P8_1 XI2_I1_I42_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I157_XG_MP1 (XI2_I1_I42_I157_XG_p1 I2_I1_I42_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I105_XG_MP2 (XI2_I1_I42_I105_XG_p1 I2_I1_I42_G9_8 I2_I1_I42_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I105_XG_MP0 (VDD I2_I1_I42_P9_8 XI2_I1_I42_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I105_XG_MP1 (XI2_I1_I42_I105_XG_p1 I2_I1_I42_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I103_XG_MP2 (XI2_I1_I42_I103_XG_p1 I2_I1_I42_G7_6 I2_I1_I42_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I103_XG_MP0 (VDD I2_I1_I42_P7_6 XI2_I1_I42_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I103_XG_MP1 (XI2_I1_I42_I103_XG_p1 I2_I1_I42_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I158_XG_MP2 (XI2_I1_I42_I158_XG_p1 I2_I1_I42_G9_2 I2_I1_I42_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I158_XG_MP0 (VDD I2_I1_I42_P9_2 XI2_I1_I42_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I158_XG_MP1 (XI2_I1_I42_I158_XG_p1 I2_I1_I42_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I100_XG_MP2 (XI1_I1666_I100_XG_p1 I1_I1666_G4_3 I1_I1666_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I100_XG_MP0 (VDD I1_I1666_P4_3 XI1_I1666_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I100_XG_MP1 (XI1_I1666_I100_XG_p1 I1_I1666_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I99_XG_MP2 (XI1_I1666_I99_XG_p1 I1_I1666_G3_2 I1_I1666_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I99_XG_MP0 (VDD I1_I1666_P3_2 XI1_I1666_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I99_XG_MP1 (XI1_I1666_I99_XG_p1 I1_I1666_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I101_XG_MP2 (XI1_I1666_I101_XG_p1 I1_I1666_G5_4 I1_I1666_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I101_XG_MP0 (VDD I1_I1666_P5_4 XI1_I1666_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I101_XG_MP1 (XI1_I1666_I101_XG_p1 I1_I1666_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I54_MP2 (XI1_I54_p1 I1_nak6 I1_nakn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I54_MP0 (VDD I1_A_31_b3_1 XI1_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I54_MP1 (XI1_I54_p1 A_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I57_MP2 (XI1_I57_p1 I1_nak7 I1_nakn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I57_MP0 (VDD I1_A_31_b3_1 XI1_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I57_MP1 (XI1_I57_p1 A_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I102_XG_MP2 (XI2_I1_I42_I102_XG_p1 I2_I1_I42_G6_5 I2_I1_I42_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I102_XG_MP0 (VDD I2_I1_I42_P6_5 XI2_I1_I42_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I102_XG_MP1 (XI2_I1_I42_I102_XG_p1 I2_I1_I42_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I101_XG_MP2 (XI2_I1_I42_I101_XG_p1 I2_I1_I42_G5_4 I2_I1_I42_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I101_XG_MP0 (VDD I2_I1_I42_P5_4 XI2_I1_I42_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I101_XG_MP1 (XI2_I1_I42_I101_XG_p1 I2_I1_I42_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I167_XG_MP2 (XI1_I1666_I167_XG_p1 I1_I1666_G16_9 I1_I1666_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I167_XG_MP0 (VDD I1_I1666_P16_9 XI1_I1666_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I167_XG_MP1 (XI1_I1666_I167_XG_p1 I1_I1666_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I157_XG_MP2 (XI1_I1666_I157_XG_p1 I1_I1666_G8_1 I1_I1666_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I157_XG_MP0 (VDD I1_I1666_P8_1 XI1_I1666_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I157_XG_MP1 (XI1_I1666_I157_XG_p1 I1_I1666_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I104_XG_MP2 (XI1_I1666_I104_XG_p1 I1_I1666_G8_7 I1_I1666_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I104_XG_MP0 (VDD I1_I1666_P8_7 XI1_I1666_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I104_XG_MP1 (XI1_I1666_I104_XG_p1 I1_I1666_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I102_XG_MP2 (XI1_I1666_I102_XG_p1 I1_I1666_G6_5 I1_I1666_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I102_XG_MP0 (VDD I1_I1666_P6_5 XI1_I1666_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I102_XG_MP1 (XI1_I1666_I102_XG_p1 I1_I1666_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I103_XG_MP2 (XI1_I1666_I103_XG_p1 I1_I1666_G7_6 I1_I1666_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I103_XG_MP0 (VDD I1_I1666_P7_6 XI1_I1666_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I103_XG_MP1 (XI1_I1666_I103_XG_p1 I1_I1666_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I100_XG_MP2 (XI2_I1_I42_I100_XG_p1 I2_I1_I42_G4_3 I2_I1_I42_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I100_XG_MP0 (VDD I2_I1_I42_P4_3 XI2_I1_I42_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I100_XG_MP1 (XI2_I1_I42_I100_XG_p1 I2_I1_I42_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I99_XG_MP2 (XI2_I1_I42_I99_XG_p1 I2_I1_I42_G3_2 I2_I1_I42_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I99_XG_MP0 (VDD I2_I1_I42_P3_2 XI2_I1_I42_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I99_XG_MP1 (XI2_I1_I42_I99_XG_p1 I2_I1_I42_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I160_XG_MP2 (XI1_I1666_I160_XG_p1 I1_I1666_G10_3 I1_I1666_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I160_XG_MP0 (VDD I1_I1666_P10_3 XI1_I1666_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I160_XG_MP1 (XI1_I1666_I160_XG_p1 I1_I1666_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I169_XG_MP2 (XI1_I1666_I169_XG_p1 I1_I1666_G18_11 I1_I1666_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I169_XG_MP0 (VDD I1_I1666_P18_11 XI1_I1666_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I169_XG_MP1 (XI1_I1666_I169_XG_p1 I1_I1666_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I106_XG_MP2 (XI1_I1666_I106_XG_p1 I1_I1666_G10_9 I1_I1666_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I106_XG_MP0 (VDD I1_I1666_P10_9 XI1_I1666_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I106_XG_MP1 (XI1_I1666_I106_XG_p1 I1_I1666_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I158_XG_MP2 (XI1_I1666_I158_XG_p1 I1_I1666_G9_2 I1_I1666_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I158_XG_MP0 (VDD I1_I1666_P9_2 XI1_I1666_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I158_XG_MP1 (XI1_I1666_I158_XG_p1 I1_I1666_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I168_XG_MP2 (XI1_I1666_I168_XG_p1 I1_I1666_G17_10 I1_I1666_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I168_XG_MP0 (VDD I1_I1666_P17_10 XI1_I1666_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I168_XG_MP1 (XI1_I1666_I168_XG_p1 I1_I1666_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I105_XG_MP2 (XI1_I1666_I105_XG_p1 I1_I1666_G9_8 I1_I1666_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I105_XG_MP0 (VDD I1_I1666_P9_8 XI1_I1666_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I105_XG_MP1 (XI1_I1666_I105_XG_p1 I1_I1666_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I98_XG_MP2 (XI2_I1_I42_I98_XG_p1 I2_I1_I42_G2_1 I2_I1_I42_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I98_XG_MP0 (VDD I2_I1_I42_P2_1 XI2_I1_I42_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I98_XG_MP1 (XI2_I1_I42_I98_XG_p1 I2_I1_I42_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I163_XG_MP2 (XI1_I1666_I163_XG_p1 I1_I1666_G12_5 I1_I1666_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I163_XG_MP0 (VDD I1_I1666_P12_5 XI1_I1666_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I163_XG_MP1 (XI1_I1666_I163_XG_p1 I1_I1666_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I171_XG_MP2 (XI1_I1666_I171_XG_p1 I1_I1666_G20_13 I1_I1666_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I171_XG_MP0 (VDD I1_I1666_P20_13 XI1_I1666_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I171_XG_MP1 (XI1_I1666_I171_XG_p1 I1_I1666_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I108_XG_MP2 (XI1_I1666_I108_XG_p1 I1_I1666_G12_11 I1_I1666_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I108_XG_MP0 (VDD I1_I1666_P12_11 XI1_I1666_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I108_XG_MP1 (XI1_I1666_I108_XG_p1 I1_I1666_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I162_XG_MP2 (XI1_I1666_I162_XG_p1 I1_I1666_G11_4 I1_I1666_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I162_XG_MP0 (VDD I1_I1666_P11_4 XI1_I1666_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I162_XG_MP1 (XI1_I1666_I162_XG_p1 I1_I1666_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I170_XG_MP2 (XI1_I1666_I170_XG_p1 I1_I1666_G19_12 I1_I1666_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I170_XG_MP0 (VDD I1_I1666_P19_12 XI1_I1666_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I170_XG_MP1 (XI1_I1666_I170_XG_p1 I1_I1666_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I107_XG_MP2 (XI1_I1666_I107_XG_p1 I1_I1666_G11_10 I1_I1666_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I107_XG_MP0 (VDD I1_I1666_P11_10 XI1_I1666_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I107_XG_MP1 (XI1_I1666_I107_XG_p1 I1_I1666_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I98_XG_MP2 (XI1_I1620_I98_XG_p1 I1_I1620_G2_1 I1_I1620_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I98_XG_MP0 (VDD I1_I1620_P2_1 XI1_I1620_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I98_XG_MP1 (XI1_I1620_I98_XG_p1 I1_I1620_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I177_XG_MP2 (XI1_I1666_I177_XG_p1 I1_I1666_G26_19 I1_I1666_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I177_XG_MP0 (VDD I1_I1666_P26_19 XI1_I1666_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I177_XG_MP1 (XI1_I1666_I177_XG_p1 I1_I1666_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I175_XG_MP2 (XI1_I1666_I175_XG_p1 I1_I1666_G24_17 I1_I1666_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I175_XG_MP0 (VDD I1_I1666_P24_17 XI1_I1666_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I175_XG_MP1 (XI1_I1666_I175_XG_p1 I1_I1666_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I110_XG_MP2 (XI1_I1666_I110_XG_p1 I1_I1666_G14_13 I1_I1666_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I110_XG_MP0 (VDD I1_I1666_P14_13 XI1_I1666_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I110_XG_MP1 (XI1_I1666_I110_XG_p1 I1_I1666_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I164_XG_MP2 (XI1_I1666_I164_XG_p1 I1_I1666_G13_6 I1_I1666_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I164_XG_MP0 (VDD I1_I1666_P13_6 XI1_I1666_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I164_XG_MP1 (XI1_I1666_I164_XG_p1 I1_I1666_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I176_XG_MP2 (XI1_I1666_I176_XG_p1 I1_I1666_G25_18 I1_I1666_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I176_XG_MP0 (VDD I1_I1666_P25_18 XI1_I1666_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I176_XG_MP1 (XI1_I1666_I176_XG_p1 I1_I1666_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I109_XG_MP2 (XI1_I1666_I109_XG_p1 I1_I1666_G13_12 I1_I1666_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I109_XG_MP0 (VDD I1_I1666_P13_12 XI1_I1666_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I109_XG_MP1 (XI1_I1666_I109_XG_p1 I1_I1666_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I106_XG_MP2 (XI1_I1620_I106_XG_p1 I1_I1620_G10_9 I1_I1620_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I106_XG_MP0 (VDD I1_I1620_P10_9 XI1_I1620_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I106_XG_MP1 (XI1_I1620_I106_XG_p1 I1_I1620_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I102_XG_MP2 (XI1_I1620_I102_XG_p1 I1_I1620_G6_5 I1_I1620_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I102_XG_MP0 (VDD I1_I1620_P6_5 XI1_I1620_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I102_XG_MP1 (XI1_I1620_I102_XG_p1 I1_I1620_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I99_XG_MP2 (XI1_I1620_I99_XG_p1 I1_I1620_G3_2 I1_I1620_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I99_XG_MP0 (VDD I1_I1620_P3_2 XI1_I1620_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I99_XG_MP1 (XI1_I1620_I99_XG_p1 I1_I1620_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I100_XG_MP2 (XI1_I1620_I100_XG_p1 I1_I1620_G4_3 I1_I1620_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I100_XG_MP0 (VDD I1_I1620_P4_3 XI1_I1620_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I100_XG_MP1 (XI1_I1620_I100_XG_p1 I1_I1620_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I127_XG_MP2 (XI1_I1758_I127_XG_p1 I1_I1758_G31_30 I1_I1758_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I127_XG_MP0 (VDD I1_I1758_P31_30 XI1_I1758_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I127_XG_MP1 (XI1_I1758_I127_XG_p1 I1_I1758_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I125_XG_MP2 (XI1_I1758_I125_XG_p1 I1_I1758_G29_28 I1_I1758_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I125_XG_MP0 (VDD I1_I1758_P29_28 XI1_I1758_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I125_XG_MP1 (XI1_I1758_I125_XG_p1 I1_I1758_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I123_XG_MP2 (XI1_I1758_I123_XG_p1 I1_I1758_G27_26 I1_I1758_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I123_XG_MP0 (VDD I1_I1758_P27_26 XI1_I1758_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I123_XG_MP1 (XI1_I1758_I123_XG_p1 I1_I1758_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I121_XG_MP2 (XI1_I1758_I121_XG_p1 I1_I1758_G25_24 I1_I1758_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I121_XG_MP0 (VDD I1_I1758_P25_24 XI1_I1758_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I121_XG_MP1 (XI1_I1758_I121_XG_p1 I1_I1758_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I119_XG_MP2 (XI1_I1758_I119_XG_p1 I1_I1758_G23_22 I1_I1758_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I119_XG_MP0 (VDD I1_I1758_P23_22 XI1_I1758_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I119_XG_MP1 (XI1_I1758_I119_XG_p1 I1_I1758_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I117_XG_MP2 (XI1_I1758_I117_XG_p1 I1_I1758_G21_20 I1_I1758_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I117_XG_MP0 (VDD I1_I1758_P21_20 XI1_I1758_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I117_XG_MP1 (XI1_I1758_I117_XG_p1 I1_I1758_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I115_XG_MP2 (XI1_I1758_I115_XG_p1 I1_I1758_G19_18 I1_I1758_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I115_XG_MP0 (VDD I1_I1758_P19_18 XI1_I1758_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I115_XG_MP1 (XI1_I1758_I115_XG_p1 I1_I1758_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I113_XG_MP2 (XI1_I1758_I113_XG_p1 I1_I1758_G17_16 I1_I1758_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I113_XG_MP0 (VDD I1_I1758_P17_16 XI1_I1758_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I113_XG_MP1 (XI1_I1758_I113_XG_p1 I1_I1758_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I111_XG_MP2 (XI1_I1758_I111_XG_p1 I1_I1758_G15_14 I1_I1758_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I111_XG_MP0 (VDD I1_I1758_P15_14 XI1_I1758_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I111_XG_MP1 (XI1_I1758_I111_XG_p1 I1_I1758_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I165_XG_MP2 (XI1_I1666_I165_XG_p1 I1_I1666_G14_7 I1_I1666_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I165_XG_MP0 (VDD I1_I1666_P14_7 XI1_I1666_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I165_XG_MP1 (XI1_I1666_I165_XG_p1 I1_I1666_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I179_XG_MP2 (XI1_I1666_I179_XG_p1 I1_I1666_G28_21 I1_I1666_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I179_XG_MP0 (VDD I1_I1666_P28_21 XI1_I1666_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I179_XG_MP1 (XI1_I1666_I179_XG_p1 I1_I1666_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I112_XG_MP2 (XI1_I1666_I112_XG_p1 I1_I1666_G16_15 I1_I1666_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I112_XG_MP0 (VDD I1_I1666_P16_15 XI1_I1666_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I112_XG_MP1 (XI1_I1666_I112_XG_p1 I1_I1666_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I172_XG_MP2 (XI1_I1666_I172_XG_p1 I1_I1666_G21_14 I1_I1666_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I172_XG_MP0 (VDD I1_I1666_P21_14 XI1_I1666_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I172_XG_MP1 (XI1_I1666_I172_XG_p1 I1_I1666_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I111_XG_MP2 (XI1_I1666_I111_XG_p1 I1_I1666_G15_14 I1_I1666_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I111_XG_MP0 (VDD I1_I1666_P15_14 XI1_I1666_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I111_XG_MP1 (XI1_I1666_I111_XG_p1 I1_I1666_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I160_XG_MP2 (XI1_I1620_I160_XG_p1 I1_I1620_G10_3 I1_I1620_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I160_XG_MP0 (VDD I1_I1620_P10_3 XI1_I1620_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I160_XG_MP1 (XI1_I1620_I160_XG_p1 I1_I1620_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I110_XG_MP2 (XI1_I1620_I110_XG_p1 I1_I1620_G14_13 I1_I1620_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I110_XG_MP0 (VDD I1_I1620_P14_13 XI1_I1620_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I110_XG_MP1 (XI1_I1620_I110_XG_p1 I1_I1620_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I108_XG_MP2 (XI1_I1620_I108_XG_p1 I1_I1620_G12_11 I1_I1620_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I108_XG_MP0 (VDD I1_I1620_P12_11 XI1_I1620_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I108_XG_MP1 (XI1_I1620_I108_XG_p1 I1_I1620_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I104_XG_MP2 (XI1_I1620_I104_XG_p1 I1_I1620_G8_7 I1_I1620_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I104_XG_MP0 (VDD I1_I1620_P8_7 XI1_I1620_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I104_XG_MP1 (XI1_I1620_I104_XG_p1 I1_I1620_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I107_XG_MP2 (XI1_I1620_I107_XG_p1 I1_I1620_G11_10 I1_I1620_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I107_XG_MP0 (VDD I1_I1620_P11_10 XI1_I1620_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I107_XG_MP1 (XI1_I1620_I107_XG_p1 I1_I1620_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I105_XG_MP2 (XI1_I1620_I105_XG_p1 I1_I1620_G9_8 I1_I1620_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I105_XG_MP0 (VDD I1_I1620_P9_8 XI1_I1620_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I105_XG_MP1 (XI1_I1620_I105_XG_p1 I1_I1620_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I103_XG_MP2 (XI1_I1620_I103_XG_p1 I1_I1620_G7_6 I1_I1620_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I103_XG_MP0 (VDD I1_I1620_P7_6 XI1_I1620_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I103_XG_MP1 (XI1_I1620_I103_XG_p1 I1_I1620_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I101_XG_MP2 (XI1_I1620_I101_XG_p1 I1_I1620_G5_4 I1_I1620_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I101_XG_MP0 (VDD I1_I1620_P5_4 XI1_I1620_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I101_XG_MP1 (XI1_I1620_I101_XG_p1 I1_I1620_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I167_XG_MP2 (XI1_I1620_I167_XG_p1 I1_I1620_G16_9 I1_I1620_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I167_XG_MP0 (VDD I1_I1620_P16_9 XI1_I1620_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I167_XG_MP1 (XI1_I1620_I167_XG_p1 I1_I1620_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I157_XG_MP2 (XI1_I1620_I157_XG_p1 I1_I1620_G8_1 I1_I1620_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I157_XG_MP0 (VDD I1_I1620_P8_1 XI1_I1620_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I157_XG_MP1 (XI1_I1620_I157_XG_p1 I1_I1620_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I182_XG_MP2 (XI1_I1758_I182_XG_p1 I1_I1758_G31_24 I1_I1758_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I182_XG_MP0 (VDD I1_I1758_P31_24 XI1_I1758_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I182_XG_MP1 (XI1_I1758_I182_XG_p1 I1_I1758_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I180_XG_MP2 (XI1_I1758_I180_XG_p1 I1_I1758_G29_22 I1_I1758_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I180_XG_MP0 (VDD I1_I1758_P29_22 XI1_I1758_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I180_XG_MP1 (XI1_I1758_I180_XG_p1 I1_I1758_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I174_XG_MP2 (XI1_I1758_I174_XG_p1 I1_I1758_G23_16 I1_I1758_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I174_XG_MP0 (VDD I1_I1758_P23_16 XI1_I1758_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I174_XG_MP1 (XI1_I1758_I174_XG_p1 I1_I1758_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I178_XG_MP2 (XI1_I1758_I178_XG_p1 I1_I1758_G27_20 I1_I1758_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I178_XG_MP0 (VDD I1_I1758_P27_20 XI1_I1758_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I178_XG_MP1 (XI1_I1758_I178_XG_p1 I1_I1758_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I176_XG_MP2 (XI1_I1758_I176_XG_p1 I1_I1758_G25_18 I1_I1758_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I176_XG_MP0 (VDD I1_I1758_P25_18 XI1_I1758_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I176_XG_MP1 (XI1_I1758_I176_XG_p1 I1_I1758_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I109_XG_MP2 (XI1_I1758_I109_XG_p1 I1_I1758_G13_12 I1_I1758_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I109_XG_MP0 (VDD I1_I1758_P13_12 XI1_I1758_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I109_XG_MP1 (XI1_I1758_I109_XG_p1 I1_I1758_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I107_XG_MP2 (XI1_I1758_I107_XG_p1 I1_I1758_G11_10 I1_I1758_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I107_XG_MP0 (VDD I1_I1758_P11_10 XI1_I1758_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I107_XG_MP1 (XI1_I1758_I107_XG_p1 I1_I1758_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I173_XG_MP2 (XI1_I1666_I173_XG_p1 I1_I1666_G22_15 I1_I1666_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I173_XG_MP0 (VDD I1_I1666_P22_15 XI1_I1666_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I173_XG_MP1 (XI1_I1666_I173_XG_p1 I1_I1666_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I116_XG_MP2 (XI1_I1666_I116_XG_p1 I1_I1666_G20_19 I1_I1666_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I116_XG_MP0 (VDD I1_I1666_P20_19 XI1_I1666_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I116_XG_MP1 (XI1_I1666_I116_XG_p1 I1_I1666_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I114_XG_MP2 (XI1_I1666_I114_XG_p1 I1_I1666_G18_17 I1_I1666_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I114_XG_MP0 (VDD I1_I1666_P18_17 XI1_I1666_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I114_XG_MP1 (XI1_I1666_I114_XG_p1 I1_I1666_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I166_XG_MP2 (XI1_I1666_I166_XG_p1 I1_I1666_G15_8 I1_I1666_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I166_XG_MP0 (VDD I1_I1666_P15_8 XI1_I1666_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I166_XG_MP1 (XI1_I1666_I166_XG_p1 I1_I1666_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I178_XG_MP2 (XI1_I1666_I178_XG_p1 I1_I1666_G27_20 I1_I1666_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I178_XG_MP0 (VDD I1_I1666_P27_20 XI1_I1666_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I178_XG_MP1 (XI1_I1666_I178_XG_p1 I1_I1666_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I115_XG_MP2 (XI1_I1666_I115_XG_p1 I1_I1666_G19_18 I1_I1666_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I115_XG_MP0 (VDD I1_I1666_P19_18 XI1_I1666_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I115_XG_MP1 (XI1_I1666_I115_XG_p1 I1_I1666_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I113_XG_MP2 (XI1_I1666_I113_XG_p1 I1_I1666_G17_16 I1_I1666_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I113_XG_MP0 (VDD I1_I1666_P17_16 XI1_I1666_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I113_XG_MP1 (XI1_I1666_I113_XG_p1 I1_I1666_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I165_XG_MP2 (XI1_I1620_I165_XG_p1 I1_I1620_G14_7 I1_I1620_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I165_XG_MP0 (VDD I1_I1620_P14_7 XI1_I1620_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I165_XG_MP1 (XI1_I1620_I165_XG_p1 I1_I1620_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I169_XG_MP2 (XI1_I1620_I169_XG_p1 I1_I1620_G18_11 I1_I1620_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I169_XG_MP0 (VDD I1_I1620_P18_11 XI1_I1620_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I169_XG_MP1 (XI1_I1620_I169_XG_p1 I1_I1620_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I114_XG_MP2 (XI1_I1620_I114_XG_p1 I1_I1620_G18_17 I1_I1620_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I114_XG_MP0 (VDD I1_I1620_P18_17 XI1_I1620_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I114_XG_MP1 (XI1_I1620_I114_XG_p1 I1_I1620_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I112_XG_MP2 (XI1_I1620_I112_XG_p1 I1_I1620_G16_15 I1_I1620_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I112_XG_MP0 (VDD I1_I1620_P16_15 XI1_I1620_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I112_XG_MP1 (XI1_I1620_I112_XG_p1 I1_I1620_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I163_XG_MP2 (XI1_I1620_I163_XG_p1 I1_I1620_G12_5 I1_I1620_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I163_XG_MP0 (VDD I1_I1620_P12_5 XI1_I1620_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I163_XG_MP1 (XI1_I1620_I163_XG_p1 I1_I1620_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I109_XG_MP2 (XI1_I1620_I109_XG_p1 I1_I1620_G13_12 I1_I1620_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I109_XG_MP0 (VDD I1_I1620_P13_12 XI1_I1620_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I109_XG_MP1 (XI1_I1620_I109_XG_p1 I1_I1620_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2108_MP2 (XI1_I2108_p1 I1_nqk10 I1_nqkn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2108_MP0 (VDD I1_sq_b3_1 XI1_I2108_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2108_MP1 (XI1_I2108_p1 I1_qu10_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I176_MP2 (XI2_I3_I176_p1 I2_I3_o7_2 I2_I3_q7_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I176_MP0 (VDD I2_I3_SEL_AS_b3_1 XI2_I3_I176_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I176_MP1 (XI2_I3_I176_p1 I2_S_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I212_MP2 (XI2_I3_I212_p1 I2_I3_o10_2 I2_I3_q10_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I212_MP0 (VDD I2_I3_SEL_AS_b3_1 XI2_I3_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I212_MP1 (XI2_I3_I212_p1 I2_S_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I166_XG_MP2 (XI1_I1758_I166_XG_p1 I1_I1758_G15_8 I1_I1758_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I166_XG_MP0 (VDD I1_I1758_P15_8 XI1_I1758_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I166_XG_MP1 (XI1_I1758_I166_XG_p1 I1_I1758_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I172_XG_MP2 (XI1_I1758_I172_XG_p1 I1_I1758_G21_14 I1_I1758_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I172_XG_MP0 (VDD I1_I1758_P21_14 XI1_I1758_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I172_XG_MP1 (XI1_I1758_I172_XG_p1 I1_I1758_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I164_XG_MP2 (XI1_I1758_I164_XG_p1 I1_I1758_G13_6 I1_I1758_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I164_XG_MP0 (VDD I1_I1758_P13_6 XI1_I1758_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I164_XG_MP1 (XI1_I1758_I164_XG_p1 I1_I1758_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I170_XG_MP2 (XI1_I1758_I170_XG_p1 I1_I1758_G19_12 I1_I1758_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I170_XG_MP0 (VDD I1_I1758_P19_12 XI1_I1758_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I170_XG_MP1 (XI1_I1758_I170_XG_p1 I1_I1758_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I162_XG_MP2 (XI1_I1758_I162_XG_p1 I1_I1758_G11_4 I1_I1758_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I162_XG_MP0 (VDD I1_I1758_P11_4 XI1_I1758_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I162_XG_MP1 (XI1_I1758_I162_XG_p1 I1_I1758_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I105_XG_MP2 (XI1_I1758_I105_XG_p1 I1_I1758_G9_8 I1_I1758_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I105_XG_MP0 (VDD I1_I1758_P9_8 XI1_I1758_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I105_XG_MP1 (XI1_I1758_I105_XG_p1 I1_I1758_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I103_XG_MP2 (XI1_I1758_I103_XG_p1 I1_I1758_G7_6 I1_I1758_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I103_XG_MP0 (VDD I1_I1758_P7_6 XI1_I1758_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I103_XG_MP1 (XI1_I1758_I103_XG_p1 I1_I1758_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I118_XG_MP2 (XI1_I1666_I118_XG_p1 I1_I1666_G22_21 I1_I1666_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I118_XG_MP0 (VDD I1_I1666_P22_21 XI1_I1666_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I118_XG_MP1 (XI1_I1666_I118_XG_p1 I1_I1666_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I174_XG_MP2 (XI1_I1666_I174_XG_p1 I1_I1666_G23_16 I1_I1666_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I174_XG_MP0 (VDD I1_I1666_P23_16 XI1_I1666_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I174_XG_MP1 (XI1_I1666_I174_XG_p1 I1_I1666_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I180_XG_MP2 (XI1_I1666_I180_XG_p1 I1_I1666_G29_22 I1_I1666_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I180_XG_MP0 (VDD I1_I1666_P29_22 XI1_I1666_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I180_XG_MP1 (XI1_I1666_I180_XG_p1 I1_I1666_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I117_XG_MP2 (XI1_I1666_I117_XG_p1 I1_I1666_G21_20 I1_I1666_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I117_XG_MP0 (VDD I1_I1666_P21_20 XI1_I1666_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I117_XG_MP1 (XI1_I1666_I117_XG_p1 I1_I1666_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I173_XG_MP2 (XI1_I1620_I173_XG_p1 I1_I1620_G22_15 I1_I1620_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I173_XG_MP0 (VDD I1_I1620_P22_15 XI1_I1620_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I173_XG_MP1 (XI1_I1620_I173_XG_p1 I1_I1620_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I177_XG_MP2 (XI1_I1620_I177_XG_p1 I1_I1620_G26_19 I1_I1620_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I177_XG_MP0 (VDD I1_I1620_P26_19 XI1_I1620_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I177_XG_MP1 (XI1_I1620_I177_XG_p1 I1_I1620_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I113_XG_MP2 (XI1_I1620_I113_XG_p1 I1_I1620_G17_16 I1_I1620_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I113_XG_MP0 (VDD I1_I1620_P17_16 XI1_I1620_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I113_XG_MP1 (XI1_I1620_I113_XG_p1 I1_I1620_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I111_XG_MP2 (XI1_I1620_I111_XG_p1 I1_I1620_G15_14 I1_I1620_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I111_XG_MP0 (VDD I1_I1620_P15_14 XI1_I1620_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I111_XG_MP1 (XI1_I1620_I111_XG_p1 I1_I1620_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I168_XG_MP2 (XI1_I1620_I168_XG_p1 I1_I1620_G17_10 I1_I1620_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I168_XG_MP0 (VDD I1_I1620_P17_10 XI1_I1620_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I168_XG_MP1 (XI1_I1620_I168_XG_p1 I1_I1620_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I158_XG_MP2 (XI1_I1620_I158_XG_p1 I1_I1620_G9_2 I1_I1620_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I158_XG_MP0 (VDD I1_I1620_P9_2 XI1_I1620_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I158_XG_MP1 (XI1_I1620_I158_XG_p1 I1_I1620_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2102_MP2 (XI1_I2102_p1 I1_nqk8 I1_nqkn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2102_MP0 (VDD I1_sq_b3_1 XI1_I2102_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2102_MP1 (XI1_I2102_p1 I1_qu8_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2105_MP2 (XI1_I2105_p1 I1_nqk9 I1_nqkn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2105_MP0 (VDD I1_sq_b3_1 XI1_I2105_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2105_MP1 (XI1_I2105_p1 I1_qu9_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I200_MP2 (XI2_I3_I200_p1 I2_I3_o9_2 I2_I3_q9_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I200_MP0 (VDD I2_I3_SEL_AS_b3_1 XI2_I3_I200_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I200_MP1 (XI2_I3_I200_p1 I2_S_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I164_MP2 (XI2_I3_I164_p1 I2_I3_o6_2 I2_I3_q6_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I164_MP0 (VDD I2_I3_SEL_AS_b3_1 XI2_I3_I164_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I164_MP1 (XI2_I3_I164_p1 I2_S_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I188_MP2 (XI2_I3_I188_p1 I2_I3_o8_2 I2_I3_q8_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I188_MP0 (VDD I2_I3_SEL_AS_b3_1 XI2_I3_I188_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I188_MP1 (XI2_I3_I188_p1 I2_S_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I126_XG_MP2 (XI1_I1758_I126_XG_p1 I1_I1758_G30_29 I1_I1758_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I126_XG_MP0 (VDD I1_I1758_P30_29 XI1_I1758_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I126_XG_MP1 (XI1_I1758_I126_XG_p1 I1_I1758_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I124_XG_MP2 (XI1_I1758_I124_XG_p1 I1_I1758_G28_27 I1_I1758_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I124_XG_MP0 (VDD I1_I1758_P28_27 XI1_I1758_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I124_XG_MP1 (XI1_I1758_I124_XG_p1 I1_I1758_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I122_XG_MP2 (XI1_I1758_I122_XG_p1 I1_I1758_G26_25 I1_I1758_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I122_XG_MP0 (VDD I1_I1758_P26_25 XI1_I1758_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I122_XG_MP1 (XI1_I1758_I122_XG_p1 I1_I1758_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I120_XG_MP2 (XI1_I1758_I120_XG_p1 I1_I1758_G24_23 I1_I1758_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I120_XG_MP0 (VDD I1_I1758_P24_23 XI1_I1758_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I120_XG_MP1 (XI1_I1758_I120_XG_p1 I1_I1758_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I118_XG_MP2 (XI1_I1758_I118_XG_p1 I1_I1758_G22_21 I1_I1758_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I118_XG_MP0 (VDD I1_I1758_P22_21 XI1_I1758_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I118_XG_MP1 (XI1_I1758_I118_XG_p1 I1_I1758_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I168_XG_MP2 (XI1_I1758_I168_XG_p1 I1_I1758_G17_10 I1_I1758_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I168_XG_MP0 (VDD I1_I1758_P17_10 XI1_I1758_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I168_XG_MP1 (XI1_I1758_I168_XG_p1 I1_I1758_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I158_XG_MP2 (XI1_I1758_I158_XG_p1 I1_I1758_G9_2 I1_I1758_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I158_XG_MP0 (VDD I1_I1758_P9_2 XI1_I1758_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I158_XG_MP1 (XI1_I1758_I158_XG_p1 I1_I1758_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I181_XG_MP2 (XI1_I1666_I181_XG_p1 I1_I1666_G30_23 I1_I1666_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I181_XG_MP0 (VDD I1_I1666_P30_23 XI1_I1666_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I181_XG_MP1 (XI1_I1666_I181_XG_p1 I1_I1666_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I182_XG_MP2 (XI1_I1666_I182_XG_p1 I1_I1666_G31_24 I1_I1666_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I182_XG_MP0 (VDD I1_I1666_P31_24 XI1_I1666_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I182_XG_MP1 (XI1_I1666_I182_XG_p1 I1_I1666_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I119_XG_MP2 (XI1_I1666_I119_XG_p1 I1_I1666_G23_22 I1_I1666_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I119_XG_MP0 (VDD I1_I1666_P23_22 XI1_I1666_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I119_XG_MP1 (XI1_I1666_I119_XG_p1 I1_I1666_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I175_XG_MP2 (XI1_I1620_I175_XG_p1 I1_I1620_G24_17 I1_I1620_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I175_XG_MP0 (VDD I1_I1620_P24_17 XI1_I1620_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I175_XG_MP1 (XI1_I1620_I175_XG_p1 I1_I1620_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I171_XG_MP2 (XI1_I1620_I171_XG_p1 I1_I1620_G20_13 I1_I1620_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I171_XG_MP0 (VDD I1_I1620_P20_13 XI1_I1620_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I171_XG_MP1 (XI1_I1620_I171_XG_p1 I1_I1620_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I162_XG_MP2 (XI1_I1620_I162_XG_p1 I1_I1620_G11_4 I1_I1620_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I162_XG_MP0 (VDD I1_I1620_P11_4 XI1_I1620_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I162_XG_MP1 (XI1_I1620_I162_XG_p1 I1_I1620_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I164_XG_MP2 (XI1_I1620_I164_XG_p1 I1_I1620_G13_6 I1_I1620_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I164_XG_MP0 (VDD I1_I1620_P13_6 XI1_I1620_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I164_XG_MP1 (XI1_I1620_I164_XG_p1 I1_I1620_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I181_XG_MP2 (XI1_I1758_I181_XG_p1 I1_I1758_G30_23 I1_I1758_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I181_XG_MP0 (VDD I1_I1758_P30_23 XI1_I1758_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I181_XG_MP1 (XI1_I1758_I181_XG_p1 I1_I1758_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I116_XG_MP2 (XI1_I1758_I116_XG_p1 I1_I1758_G20_19 I1_I1758_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I116_XG_MP0 (VDD I1_I1758_P20_19 XI1_I1758_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I116_XG_MP1 (XI1_I1758_I116_XG_p1 I1_I1758_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I114_XG_MP2 (XI1_I1758_I114_XG_p1 I1_I1758_G18_17 I1_I1758_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I114_XG_MP0 (VDD I1_I1758_P18_17 XI1_I1758_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I114_XG_MP1 (XI1_I1758_I114_XG_p1 I1_I1758_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I112_XG_MP2 (XI1_I1758_I112_XG_p1 I1_I1758_G16_15 I1_I1758_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I112_XG_MP0 (VDD I1_I1758_P16_15 XI1_I1758_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I112_XG_MP1 (XI1_I1758_I112_XG_p1 I1_I1758_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I110_XG_MP2 (XI1_I1758_I110_XG_p1 I1_I1758_G14_13 I1_I1758_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I110_XG_MP0 (VDD I1_I1758_P14_13 XI1_I1758_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I110_XG_MP1 (XI1_I1758_I110_XG_p1 I1_I1758_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I108_XG_MP2 (XI1_I1758_I108_XG_p1 I1_I1758_G12_11 I1_I1758_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I108_XG_MP0 (VDD I1_I1758_P12_11 XI1_I1758_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I108_XG_MP1 (XI1_I1758_I108_XG_p1 I1_I1758_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I101_XG_MP2 (XI1_I1758_I101_XG_p1 I1_I1758_G5_4 I1_I1758_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I101_XG_MP0 (VDD I1_I1758_P5_4 XI1_I1758_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I101_XG_MP1 (XI1_I1758_I101_XG_p1 I1_I1758_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I122_XG_MP2 (XI1_I1666_I122_XG_p1 I1_I1666_G26_25 I1_I1666_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I122_XG_MP0 (VDD I1_I1666_P26_25 XI1_I1666_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I122_XG_MP1 (XI1_I1666_I122_XG_p1 I1_I1666_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I120_XG_MP2 (XI1_I1666_I120_XG_p1 I1_I1666_G24_23 I1_I1666_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I120_XG_MP0 (VDD I1_I1666_P24_23 XI1_I1666_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I120_XG_MP1 (XI1_I1666_I120_XG_p1 I1_I1666_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I121_XG_MP2 (XI1_I1666_I121_XG_p1 I1_I1666_G25_24 I1_I1666_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I121_XG_MP0 (VDD I1_I1666_P25_24 XI1_I1666_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I121_XG_MP1 (XI1_I1666_I121_XG_p1 I1_I1666_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I118_XG_MP2 (XI1_I1620_I118_XG_p1 I1_I1620_G22_21 I1_I1620_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I118_XG_MP0 (VDD I1_I1620_P22_21 XI1_I1620_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I118_XG_MP1 (XI1_I1620_I118_XG_p1 I1_I1620_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I116_XG_MP2 (XI1_I1620_I116_XG_p1 I1_I1620_G20_19 I1_I1620_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I116_XG_MP0 (VDD I1_I1620_P20_19 XI1_I1620_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I116_XG_MP1 (XI1_I1620_I116_XG_p1 I1_I1620_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I115_XG_MP2 (XI1_I1620_I115_XG_p1 I1_I1620_G19_18 I1_I1620_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I115_XG_MP0 (VDD I1_I1620_P19_18 XI1_I1620_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I115_XG_MP1 (XI1_I1620_I115_XG_p1 I1_I1620_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I170_XG_MP2 (XI1_I1620_I170_XG_p1 I1_I1620_G19_12 I1_I1620_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I170_XG_MP0 (VDD I1_I1620_P19_12 XI1_I1620_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I170_XG_MP1 (XI1_I1620_I170_XG_p1 I1_I1620_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2096_MP2 (XI1_I2096_p1 I1_nqk6 I1_nqkn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2096_MP0 (VDD I1_sq_b3_1 XI1_I2096_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2096_MP1 (XI1_I2096_p1 I1_qu6_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2099_MP2 (XI1_I2099_p1 I1_nqk7 I1_nqkn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2099_MP0 (VDD I1_sq_b3_1 XI1_I2099_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2099_MP1 (XI1_I2099_p1 I1_qu7_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I179_XG_MP2 (XI1_I1758_I179_XG_p1 I1_I1758_G28_21 I1_I1758_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I179_XG_MP0 (VDD I1_I1758_P28_21 XI1_I1758_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I179_XG_MP1 (XI1_I1758_I179_XG_p1 I1_I1758_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I177_XG_MP2 (XI1_I1758_I177_XG_p1 I1_I1758_G26_19 I1_I1758_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I177_XG_MP0 (VDD I1_I1758_P26_19 XI1_I1758_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I177_XG_MP1 (XI1_I1758_I177_XG_p1 I1_I1758_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I173_XG_MP2 (XI1_I1758_I173_XG_p1 I1_I1758_G22_15 I1_I1758_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I173_XG_MP0 (VDD I1_I1758_P22_15 XI1_I1758_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I173_XG_MP1 (XI1_I1758_I173_XG_p1 I1_I1758_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I165_XG_MP2 (XI1_I1758_I165_XG_p1 I1_I1758_G14_7 I1_I1758_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I165_XG_MP0 (VDD I1_I1758_P14_7 XI1_I1758_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I165_XG_MP1 (XI1_I1758_I165_XG_p1 I1_I1758_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I171_XG_MP2 (XI1_I1758_I171_XG_p1 I1_I1758_G20_13 I1_I1758_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I171_XG_MP0 (VDD I1_I1758_P20_13 XI1_I1758_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I171_XG_MP1 (XI1_I1758_I171_XG_p1 I1_I1758_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I106_XG_MP2 (XI1_I1758_I106_XG_p1 I1_I1758_G10_9 I1_I1758_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I106_XG_MP0 (VDD I1_I1758_P10_9 XI1_I1758_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I106_XG_MP1 (XI1_I1758_I106_XG_p1 I1_I1758_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I104_XG_MP2 (XI1_I1758_I104_XG_p1 I1_I1758_G8_7 I1_I1758_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I104_XG_MP0 (VDD I1_I1758_P8_7 XI1_I1758_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I104_XG_MP1 (XI1_I1758_I104_XG_p1 I1_I1758_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I102_XG_MP2 (XI1_I1758_I102_XG_p1 I1_I1758_G6_5 I1_I1758_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I102_XG_MP0 (VDD I1_I1758_P6_5 XI1_I1758_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I102_XG_MP1 (XI1_I1758_I102_XG_p1 I1_I1758_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I99_XG_MP2 (XI1_I1758_I99_XG_p1 I1_I1758_G3_2 I1_I1758_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I99_XG_MP0 (VDD I1_I1758_P3_2 XI1_I1758_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I99_XG_MP1 (XI1_I1758_I99_XG_p1 I1_I1758_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I124_XG_MP2 (XI1_I1666_I124_XG_p1 I1_I1666_G28_27 I1_I1666_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I124_XG_MP0 (VDD I1_I1666_P28_27 XI1_I1666_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I124_XG_MP1 (XI1_I1666_I124_XG_p1 I1_I1666_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I127_XG_MP2 (XI1_I1666_I127_XG_p1 I1_I1666_G31_30 I1_I1666_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I127_XG_MP0 (VDD I1_I1666_P31_30 XI1_I1666_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I127_XG_MP1 (XI1_I1666_I127_XG_p1 I1_I1666_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I125_XG_MP2 (XI1_I1666_I125_XG_p1 I1_I1666_G29_28 I1_I1666_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I125_XG_MP0 (VDD I1_I1666_P29_28 XI1_I1666_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I125_XG_MP1 (XI1_I1666_I125_XG_p1 I1_I1666_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I123_XG_MP2 (XI1_I1666_I123_XG_p1 I1_I1666_G27_26 I1_I1666_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I123_XG_MP0 (VDD I1_I1666_P27_26 XI1_I1666_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I123_XG_MP1 (XI1_I1666_I123_XG_p1 I1_I1666_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I181_XG_MP2 (XI1_I1620_I181_XG_p1 I1_I1620_G30_23 I1_I1620_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I181_XG_MP0 (VDD I1_I1620_P30_23 XI1_I1620_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I181_XG_MP1 (XI1_I1620_I181_XG_p1 I1_I1620_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I120_XG_MP2 (XI1_I1620_I120_XG_p1 I1_I1620_G24_23 I1_I1620_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I120_XG_MP0 (VDD I1_I1620_P24_23 XI1_I1620_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I120_XG_MP1 (XI1_I1620_I120_XG_p1 I1_I1620_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I179_XG_MP2 (XI1_I1620_I179_XG_p1 I1_I1620_G28_21 I1_I1620_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I179_XG_MP0 (VDD I1_I1620_P28_21 XI1_I1620_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I179_XG_MP1 (XI1_I1620_I179_XG_p1 I1_I1620_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I117_XG_MP2 (XI1_I1620_I117_XG_p1 I1_I1620_G21_20 I1_I1620_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I117_XG_MP0 (VDD I1_I1620_P21_20 XI1_I1620_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I117_XG_MP1 (XI1_I1620_I117_XG_p1 I1_I1620_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I174_XG_MP2 (XI1_I1620_I174_XG_p1 I1_I1620_G23_16 I1_I1620_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I174_XG_MP0 (VDD I1_I1620_P23_16 XI1_I1620_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I174_XG_MP1 (XI1_I1620_I174_XG_p1 I1_I1620_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I166_XG_MP2 (XI1_I1620_I166_XG_p1 I1_I1620_G15_8 I1_I1620_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I166_XG_MP0 (VDD I1_I1620_P15_8 XI1_I1620_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I166_XG_MP1 (XI1_I1620_I166_XG_p1 I1_I1620_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I172_XG_MP2 (XI1_I1620_I172_XG_p1 I1_I1620_G21_14 I1_I1620_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I172_XG_MP0 (VDD I1_I1620_P21_14 XI1_I1620_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I172_XG_MP1 (XI1_I1620_I172_XG_p1 I1_I1620_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I51_MP2 (XI1_I51_p1 I1_nak5 I1_nakn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I51_MP0 (VDD I1_A_31_b3_0 XI1_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I51_MP1 (XI1_I51_p1 A_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I175_XG_MP2 (XI1_I1758_I175_XG_p1 I1_I1758_G24_17 I1_I1758_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I175_XG_MP0 (VDD I1_I1758_P24_17 XI1_I1758_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I175_XG_MP1 (XI1_I1758_I175_XG_p1 I1_I1758_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I169_XG_MP2 (XI1_I1758_I169_XG_p1 I1_I1758_G18_11 I1_I1758_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I169_XG_MP0 (VDD I1_I1758_P18_11 XI1_I1758_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I169_XG_MP1 (XI1_I1758_I169_XG_p1 I1_I1758_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I163_XG_MP2 (XI1_I1758_I163_XG_p1 I1_I1758_G12_5 I1_I1758_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I163_XG_MP0 (VDD I1_I1758_P12_5 XI1_I1758_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I163_XG_MP1 (XI1_I1758_I163_XG_p1 I1_I1758_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I160_XG_MP2 (XI1_I1758_I160_XG_p1 I1_I1758_G10_3 I1_I1758_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I160_XG_MP0 (VDD I1_I1758_P10_3 XI1_I1758_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I160_XG_MP1 (XI1_I1758_I160_XG_p1 I1_I1758_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I167_XG_MP2 (XI1_I1758_I167_XG_p1 I1_I1758_G16_9 I1_I1758_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I167_XG_MP0 (VDD I1_I1758_P16_9 XI1_I1758_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I167_XG_MP1 (XI1_I1758_I167_XG_p1 I1_I1758_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I100_XG_MP2 (XI1_I1758_I100_XG_p1 I1_I1758_G4_3 I1_I1758_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I100_XG_MP0 (VDD I1_I1758_P4_3 XI1_I1758_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I100_XG_MP1 (XI1_I1758_I100_XG_p1 I1_I1758_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I126_XG_MP2 (XI1_I1666_I126_XG_p1 I1_I1666_G30_29 I1_I1666_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I126_XG_MP0 (VDD I1_I1666_P30_29 XI1_I1666_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I126_XG_MP1 (XI1_I1666_I126_XG_p1 I1_I1666_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I122_XG_MP2 (XI1_I1620_I122_XG_p1 I1_I1620_G26_25 I1_I1620_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I122_XG_MP0 (VDD I1_I1620_P26_25 XI1_I1620_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I122_XG_MP1 (XI1_I1620_I122_XG_p1 I1_I1620_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I119_XG_MP2 (XI1_I1620_I119_XG_p1 I1_I1620_G23_22 I1_I1620_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I119_XG_MP0 (VDD I1_I1620_P23_22 XI1_I1620_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I119_XG_MP1 (XI1_I1620_I119_XG_p1 I1_I1620_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I182_XG_MP2 (XI1_I1620_I182_XG_p1 I1_I1620_G31_24 I1_I1620_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I182_XG_MP0 (VDD I1_I1620_P31_24 XI1_I1620_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I182_XG_MP1 (XI1_I1620_I182_XG_p1 I1_I1620_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I176_XG_MP2 (XI1_I1620_I176_XG_p1 I1_I1620_G25_18 I1_I1620_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I176_XG_MP0 (VDD I1_I1620_P25_18 XI1_I1620_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I176_XG_MP1 (XI1_I1620_I176_XG_p1 I1_I1620_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I92_MP2 (XI2_I3_I92_p1 I2_I3_o0_2 I2_I3_q0_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I92_MP0 (VDD I2_I3_SEL_AS_b3_0 XI2_I3_I92_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I92_MP1 (XI2_I3_I92_p1 I2_S_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I152_MP2 (XI2_I3_I152_p1 I2_I3_o5_2 I2_I3_q5_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I152_MP0 (VDD I2_I3_SEL_AS_b3_0 XI2_I3_I152_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I152_MP1 (XI2_I3_I152_p1 I2_S_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I157_XG_MP2 (XI1_I1758_I157_XG_p1 I1_I1758_G8_1 I1_I1758_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I157_XG_MP0 (VDD I1_I1758_P8_1 XI1_I1758_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I157_XG_MP1 (XI1_I1758_I157_XG_p1 I1_I1758_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I98_XG_MP2 (XI1_I1758_I98_XG_p1 I1_I1758_G2_1 I1_I1758_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I98_XG_MP0 (VDD I1_I1758_P2_1 XI1_I1758_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I98_XG_MP1 (XI1_I1758_I98_XG_p1 I1_I1758_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I126_XG_MP2 (XI1_I1620_I126_XG_p1 I1_I1620_G30_29 I1_I1620_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I126_XG_MP0 (VDD I1_I1620_P30_29 XI1_I1620_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I126_XG_MP1 (XI1_I1620_I126_XG_p1 I1_I1620_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I124_XG_MP2 (XI1_I1620_I124_XG_p1 I1_I1620_G28_27 I1_I1620_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I124_XG_MP0 (VDD I1_I1620_P28_27 XI1_I1620_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I124_XG_MP1 (XI1_I1620_I124_XG_p1 I1_I1620_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I121_XG_MP2 (XI1_I1620_I121_XG_p1 I1_I1620_G25_24 I1_I1620_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I121_XG_MP0 (VDD I1_I1620_P25_24 XI1_I1620_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I121_XG_MP1 (XI1_I1620_I121_XG_p1 I1_I1620_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I178_XG_MP2 (XI1_I1620_I178_XG_p1 I1_I1620_G27_20 I1_I1620_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I178_XG_MP0 (VDD I1_I1620_P27_20 XI1_I1620_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I178_XG_MP1 (XI1_I1620_I178_XG_p1 I1_I1620_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I180_XG_MP2 (XI1_I1620_I180_XG_p1 I1_I1620_G29_22 I1_I1620_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I180_XG_MP0 (VDD I1_I1620_P29_22 XI1_I1620_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I180_XG_MP1 (XI1_I1620_I180_XG_p1 I1_I1620_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I45_MP2 (XI1_I45_p1 I1_nak3 I1_nakn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I45_MP0 (VDD I1_A_31_b3_0 XI1_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I45_MP1 (XI1_I45_p1 A_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I48_MP2 (XI1_I48_p1 I1_nak4 I1_nakn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I48_MP0 (VDD I1_A_31_b3_0 XI1_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I48_MP1 (XI1_I48_p1 A_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2093_MP2 (XI1_I2093_p1 I1_nqk5 I1_nqkn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2093_MP0 (VDD I1_sq_b3_0 XI1_I2093_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2093_MP1 (XI1_I2093_p1 I1_qu5_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I140_MP2 (XI2_I3_I140_p1 I2_I3_o4_2 I2_I3_q4_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I140_MP0 (VDD I2_I3_SEL_AS_b3_0 XI2_I3_I140_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I140_MP1 (XI2_I3_I140_p1 I2_S_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I127_XG_MP2 (XI1_I1620_I127_XG_p1 I1_I1620_G31_30 I1_I1620_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I127_XG_MP0 (VDD I1_I1620_P31_30 XI1_I1620_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I127_XG_MP1 (XI1_I1620_I127_XG_p1 I1_I1620_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I123_XG_MP2 (XI1_I1620_I123_XG_p1 I1_I1620_G27_26 I1_I1620_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I123_XG_MP0 (VDD I1_I1620_P27_26 XI1_I1620_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I123_XG_MP1 (XI1_I1620_I123_XG_p1 I1_I1620_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I42_MP2 (XI1_I42_p1 I1_nak2 I1_nakn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I42_MP0 (VDD I1_A_31_b3_0 XI1_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I42_MP1 (XI1_I42_p1 A_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I39_MP2 (XI1_I39_p1 I1_nak1 I1_nakn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I39_MP0 (VDD I1_A_31_b3_0 XI1_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I39_MP1 (XI1_I39_p1 A_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2090_MP2 (XI1_I2090_p1 I1_nqk4 I1_nqkn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2090_MP0 (VDD I1_sq_b3_0 XI1_I2090_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2090_MP1 (XI1_I2090_p1 I1_qu4_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I104_MP2 (XI2_I3_I104_p1 I2_I3_o1_2 I2_I3_q1_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I104_MP0 (VDD I2_I3_SEL_AS_b3_0 XI2_I3_I104_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I104_MP1 (XI2_I3_I104_p1 I2_S_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I116_XG_MP2 (XI1_I1804_I116_XG_p1 I1_I1804_G20_19 I1_I1804_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I116_XG_MP0 (VDD I1_I1804_P20_19 XI1_I1804_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I116_XG_MP1 (XI1_I1804_I116_XG_p1 I1_I1804_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I114_XG_MP2 (XI1_I1804_I114_XG_p1 I1_I1804_G18_17 I1_I1804_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I114_XG_MP0 (VDD I1_I1804_P18_17 XI1_I1804_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I114_XG_MP1 (XI1_I1804_I114_XG_p1 I1_I1804_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I110_XG_MP2 (XI1_I1804_I110_XG_p1 I1_I1804_G14_13 I1_I1804_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I110_XG_MP0 (VDD I1_I1804_P14_13 XI1_I1804_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I110_XG_MP1 (XI1_I1804_I110_XG_p1 I1_I1804_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I106_XG_MP2 (XI1_I1804_I106_XG_p1 I1_I1804_G10_9 I1_I1804_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I106_XG_MP0 (VDD I1_I1804_P10_9 XI1_I1804_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I106_XG_MP1 (XI1_I1804_I106_XG_p1 I1_I1804_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I125_XG_MP2 (XI1_I1620_I125_XG_p1 I1_I1620_G29_28 I1_I1620_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I125_XG_MP0 (VDD I1_I1620_P29_28 XI1_I1620_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I125_XG_MP1 (XI1_I1620_I125_XG_p1 I1_I1620_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2087_MP2 (XI1_I2087_p1 I1_nqk3 I1_nqkn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2087_MP0 (VDD I1_sq_b3_0 XI1_I2087_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2087_MP1 (XI1_I2087_p1 I1_qu3_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2084_MP2 (XI1_I2084_p1 I1_nqk2 I1_nqkn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2084_MP0 (VDD I1_sq_b3_0 XI1_I2084_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2084_MP1 (XI1_I2084_p1 I1_qu2_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2081_MP2 (XI1_I2081_p1 I1_nqk1 I1_nqkn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2081_MP0 (VDD I1_sq_b3_0 XI1_I2081_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2081_MP1 (XI1_I2081_p1 I1_qu1_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I122_XG_MP2 (XI1_I1804_I122_XG_p1 I1_I1804_G26_25 I1_I1804_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I122_XG_MP0 (VDD I1_I1804_P26_25 XI1_I1804_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I122_XG_MP1 (XI1_I1804_I122_XG_p1 I1_I1804_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I120_XG_MP2 (XI1_I1804_I120_XG_p1 I1_I1804_G24_23 I1_I1804_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I120_XG_MP0 (VDD I1_I1804_P24_23 XI1_I1804_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I120_XG_MP1 (XI1_I1804_I120_XG_p1 I1_I1804_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I118_XG_MP2 (XI1_I1804_I118_XG_p1 I1_I1804_G22_21 I1_I1804_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I118_XG_MP0 (VDD I1_I1804_P22_21 XI1_I1804_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I118_XG_MP1 (XI1_I1804_I118_XG_p1 I1_I1804_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I112_XG_MP2 (XI1_I1804_I112_XG_p1 I1_I1804_G16_15 I1_I1804_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I112_XG_MP0 (VDD I1_I1804_P16_15 XI1_I1804_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I112_XG_MP1 (XI1_I1804_I112_XG_p1 I1_I1804_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I175_XG_MP2 (XI1_I1804_I175_XG_p1 I1_I1804_G24_17 I1_I1804_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I175_XG_MP0 (VDD I1_I1804_P24_17 XI1_I1804_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I175_XG_MP1 (XI1_I1804_I175_XG_p1 I1_I1804_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I108_XG_MP2 (XI1_I1804_I108_XG_p1 I1_I1804_G12_11 I1_I1804_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I108_XG_MP0 (VDD I1_I1804_P12_11 XI1_I1804_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I108_XG_MP1 (XI1_I1804_I108_XG_p1 I1_I1804_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I167_XG_MP2 (XI1_I1804_I167_XG_p1 I1_I1804_G16_9 I1_I1804_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I167_XG_MP0 (VDD I1_I1804_P16_9 XI1_I1804_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I167_XG_MP1 (XI1_I1804_I167_XG_p1 I1_I1804_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I104_XG_MP2 (XI1_I1804_I104_XG_p1 I1_I1804_G8_7 I1_I1804_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I104_XG_MP0 (VDD I1_I1804_P8_7 XI1_I1804_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I104_XG_MP1 (XI1_I1804_I104_XG_p1 I1_I1804_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I102_XG_MP2 (XI1_I1804_I102_XG_p1 I1_I1804_G6_5 I1_I1804_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I102_XG_MP0 (VDD I1_I1804_P6_5 XI1_I1804_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I102_XG_MP1 (XI1_I1804_I102_XG_p1 I1_I1804_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I100_XG_MP2 (XI1_I1804_I100_XG_p1 I1_I1804_G4_3 I1_I1804_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I100_XG_MP0 (VDD I1_I1804_P4_3 XI1_I1804_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I100_XG_MP1 (XI1_I1804_I100_XG_p1 I1_I1804_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I124_XG_MP2 (XI1_I1804_I124_XG_p1 I1_I1804_G28_27 I1_I1804_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I124_XG_MP0 (VDD I1_I1804_P28_27 XI1_I1804_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I124_XG_MP1 (XI1_I1804_I124_XG_p1 I1_I1804_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I179_XG_MP2 (XI1_I1804_I179_XG_p1 I1_I1804_G28_21 I1_I1804_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I179_XG_MP0 (VDD I1_I1804_P28_21 XI1_I1804_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I179_XG_MP1 (XI1_I1804_I179_XG_p1 I1_I1804_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I177_XG_MP2 (XI1_I1804_I177_XG_p1 I1_I1804_G26_19 I1_I1804_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I177_XG_MP0 (VDD I1_I1804_P26_19 XI1_I1804_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I177_XG_MP1 (XI1_I1804_I177_XG_p1 I1_I1804_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I171_XG_MP2 (XI1_I1804_I171_XG_p1 I1_I1804_G20_13 I1_I1804_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I171_XG_MP0 (VDD I1_I1804_P20_13 XI1_I1804_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I171_XG_MP1 (XI1_I1804_I171_XG_p1 I1_I1804_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I163_XG_MP2 (XI1_I1804_I163_XG_p1 I1_I1804_G12_5 I1_I1804_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I163_XG_MP0 (VDD I1_I1804_P12_5 XI1_I1804_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I163_XG_MP1 (XI1_I1804_I163_XG_p1 I1_I1804_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I169_XG_MP2 (XI1_I1804_I169_XG_p1 I1_I1804_G18_11 I1_I1804_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I169_XG_MP0 (VDD I1_I1804_P18_11 XI1_I1804_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I169_XG_MP1 (XI1_I1804_I169_XG_p1 I1_I1804_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I157_XG_MP2 (XI1_I1804_I157_XG_p1 I1_I1804_G8_1 I1_I1804_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I157_XG_MP0 (VDD I1_I1804_P8_1 XI1_I1804_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I157_XG_MP1 (XI1_I1804_I157_XG_p1 I1_I1804_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I98_XG_MP2 (XI1_I1804_I98_XG_p1 I1_I1804_G2_1 I1_I1804_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I98_XG_MP0 (VDD I1_I1804_P2_1 XI1_I1804_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I98_XG_MP1 (XI1_I1804_I98_XG_p1 I1_I1804_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I99_XG_MP2 (XI1_I1942_I99_XG_p1 I1_I1942_G3_2 I1_I1942_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I99_XG_MP0 (VDD I1_I1942_P3_2 XI1_I1942_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I99_XG_MP1 (XI1_I1942_I99_XG_p1 I1_I1942_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I100_XG_MP2 (XI1_I1942_I100_XG_p1 I1_I1942_G4_3 I1_I1942_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I100_XG_MP0 (VDD I1_I1942_P4_3 XI1_I1942_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I100_XG_MP1 (XI1_I1942_I100_XG_p1 I1_I1942_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I98_XG_MP2 (XI1_I1942_I98_XG_p1 I1_I1942_G2_1 I1_I1942_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I98_XG_MP0 (VDD I1_I1942_P2_1 XI1_I1942_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I98_XG_MP1 (XI1_I1942_I98_XG_p1 I1_I1942_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I126_XG_MP2 (XI1_I1804_I126_XG_p1 I1_I1804_G30_29 I1_I1804_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I126_XG_MP0 (VDD I1_I1804_P30_29 XI1_I1804_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I126_XG_MP1 (XI1_I1804_I126_XG_p1 I1_I1804_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I181_XG_MP2 (XI1_I1804_I181_XG_p1 I1_I1804_G30_23 I1_I1804_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I181_XG_MP0 (VDD I1_I1804_P30_23 XI1_I1804_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I181_XG_MP1 (XI1_I1804_I181_XG_p1 I1_I1804_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I173_XG_MP2 (XI1_I1804_I173_XG_p1 I1_I1804_G22_15 I1_I1804_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I173_XG_MP0 (VDD I1_I1804_P22_15 XI1_I1804_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I173_XG_MP1 (XI1_I1804_I173_XG_p1 I1_I1804_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I165_XG_MP2 (XI1_I1804_I165_XG_p1 I1_I1804_G14_7 I1_I1804_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I165_XG_MP0 (VDD I1_I1804_P14_7 XI1_I1804_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I165_XG_MP1 (XI1_I1804_I165_XG_p1 I1_I1804_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I160_XG_MP2 (XI1_I1804_I160_XG_p1 I1_I1804_G10_3 I1_I1804_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I160_XG_MP0 (VDD I1_I1804_P10_3 XI1_I1804_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I160_XG_MP1 (XI1_I1804_I160_XG_p1 I1_I1804_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I101_XG_MP2 (XI1_I1804_I101_XG_p1 I1_I1804_G5_4 I1_I1804_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I101_XG_MP0 (VDD I1_I1804_P5_4 XI1_I1804_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I101_XG_MP1 (XI1_I1804_I101_XG_p1 I1_I1804_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I99_XG_MP2 (XI1_I1804_I99_XG_p1 I1_I1804_G3_2 I1_I1804_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I99_XG_MP0 (VDD I1_I1804_P3_2 XI1_I1804_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I99_XG_MP1 (XI1_I1804_I99_XG_p1 I1_I1804_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I98_XG_MP2 (XI1_I1896_I98_XG_p1 I1_I1896_G2_1 I1_I1896_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I98_XG_MP0 (VDD I1_I1896_P2_1 XI1_I1896_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I98_XG_MP1 (XI1_I1896_I98_XG_p1 I1_I1896_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I101_XG_MP2 (XI1_I1942_I101_XG_p1 I1_I1942_G5_4 I1_I1942_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I101_XG_MP0 (VDD I1_I1942_P5_4 XI1_I1942_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I101_XG_MP1 (XI1_I1942_I101_XG_p1 I1_I1942_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I102_XG_MP2 (XI1_I1942_I102_XG_p1 I1_I1942_G6_5 I1_I1942_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I102_XG_MP0 (VDD I1_I1942_P6_5 XI1_I1942_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I102_XG_MP1 (XI1_I1942_I102_XG_p1 I1_I1942_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I101_XG_MP2 (XI1_I1988_I101_XG_p1 I1_I1988_G5_4 I1_I1988_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I101_XG_MP0 (VDD I1_I1988_P5_4 XI1_I1988_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I101_XG_MP1 (XI1_I1988_I101_XG_p1 I1_I1988_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I99_XG_MP2 (XI1_I1988_I99_XG_p1 I1_I1988_G3_2 I1_I1988_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I99_XG_MP0 (VDD I1_I1988_P3_2 XI1_I1988_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I99_XG_MP1 (XI1_I1988_I99_XG_p1 I1_I1988_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I100_XG_MP2 (XI1_I1988_I100_XG_p1 I1_I1988_G4_3 I1_I1988_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I100_XG_MP0 (VDD I1_I1988_P4_3 XI1_I1988_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I100_XG_MP1 (XI1_I1988_I100_XG_p1 I1_I1988_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I98_XG_MP2 (XI1_I1988_I98_XG_p1 I1_I1988_G2_1 I1_I1988_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I98_XG_MP0 (VDD I1_I1988_P2_1 XI1_I1988_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I98_XG_MP1 (XI1_I1988_I98_XG_p1 I1_I1988_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I199_XG_MP2 (XI0_I1660_I199_XG_p1 I0_I1660_G7_6 I0_I1660_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I199_XG_MP0 (VDD I0_I1660_P7_6 XI0_I1660_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I199_XG_MP1 (XI0_I1660_I199_XG_p1 I0_I1660_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I203_XG_MP2 (XI0_I1660_I203_XG_p1 I0_I1660_G11_10 I0_I1660_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I203_XG_MP0 (VDD I0_I1660_P11_10 XI0_I1660_I203_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I203_XG_MP1 (XI0_I1660_I203_XG_p1 I0_I1660_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I205_XG_MP2 (XI0_I1660_I205_XG_p1 I0_I1660_G13_12 I0_I1660_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I205_XG_MP0 (VDD I0_I1660_P13_12 XI0_I1660_I205_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I205_XG_MP1 (XI0_I1660_I205_XG_p1 I0_I1660_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I207_XG_MP2 (XI0_I1660_I207_XG_p1 I0_I1660_G15_14 I0_I1660_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I207_XG_MP0 (VDD I0_I1660_P15_14 XI0_I1660_I207_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I207_XG_MP1 (XI0_I1660_I207_XG_p1 I0_I1660_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I209_XG_MP2 (XI0_I1660_I209_XG_p1 I0_I1660_G17_16 I0_I1660_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I209_XG_MP0 (VDD I0_I1660_P17_16 XI0_I1660_I209_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I209_XG_MP1 (XI0_I1660_I209_XG_p1 I0_I1660_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I211_XG_MP2 (XI0_I1660_I211_XG_p1 I0_I1660_G19_18 I0_I1660_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I211_XG_MP0 (VDD I0_I1660_P19_18 XI0_I1660_I211_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I211_XG_MP1 (XI0_I1660_I211_XG_p1 I0_I1660_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I213_XG_MP2 (XI0_I1660_I213_XG_p1 I0_I1660_G21_20 I0_I1660_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I213_XG_MP0 (VDD I0_I1660_P21_20 XI0_I1660_I213_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I213_XG_MP1 (XI0_I1660_I213_XG_p1 I0_I1660_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I215_XG_MP2 (XI0_I1660_I215_XG_p1 I0_I1660_G23_22 I0_I1660_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I215_XG_MP0 (VDD I0_I1660_P23_22 XI0_I1660_I215_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I215_XG_MP1 (XI0_I1660_I215_XG_p1 I0_I1660_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I125_XG_MP2 (XI1_I1804_I125_XG_p1 I1_I1804_G29_28 I1_I1804_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I125_XG_MP0 (VDD I1_I1804_P29_28 XI1_I1804_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I125_XG_MP1 (XI1_I1804_I125_XG_p1 I1_I1804_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I123_XG_MP2 (XI1_I1804_I123_XG_p1 I1_I1804_G27_26 I1_I1804_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I123_XG_MP0 (VDD I1_I1804_P27_26 XI1_I1804_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I123_XG_MP1 (XI1_I1804_I123_XG_p1 I1_I1804_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I121_XG_MP2 (XI1_I1804_I121_XG_p1 I1_I1804_G25_24 I1_I1804_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I121_XG_MP0 (VDD I1_I1804_P25_24 XI1_I1804_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I121_XG_MP1 (XI1_I1804_I121_XG_p1 I1_I1804_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I119_XG_MP2 (XI1_I1804_I119_XG_p1 I1_I1804_G23_22 I1_I1804_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I119_XG_MP0 (VDD I1_I1804_P23_22 XI1_I1804_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I119_XG_MP1 (XI1_I1804_I119_XG_p1 I1_I1804_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I117_XG_MP2 (XI1_I1804_I117_XG_p1 I1_I1804_G21_20 I1_I1804_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I117_XG_MP0 (VDD I1_I1804_P21_20 XI1_I1804_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I117_XG_MP1 (XI1_I1804_I117_XG_p1 I1_I1804_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I113_XG_MP2 (XI1_I1804_I113_XG_p1 I1_I1804_G17_16 I1_I1804_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I113_XG_MP0 (VDD I1_I1804_P17_16 XI1_I1804_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I113_XG_MP1 (XI1_I1804_I113_XG_p1 I1_I1804_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I111_XG_MP2 (XI1_I1804_I111_XG_p1 I1_I1804_G15_14 I1_I1804_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I111_XG_MP0 (VDD I1_I1804_P15_14 XI1_I1804_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I111_XG_MP1 (XI1_I1804_I111_XG_p1 I1_I1804_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I109_XG_MP2 (XI1_I1804_I109_XG_p1 I1_I1804_G13_12 I1_I1804_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I109_XG_MP0 (VDD I1_I1804_P13_12 XI1_I1804_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I109_XG_MP1 (XI1_I1804_I109_XG_p1 I1_I1804_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I107_XG_MP2 (XI1_I1804_I107_XG_p1 I1_I1804_G11_10 I1_I1804_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I107_XG_MP0 (VDD I1_I1804_P11_10 XI1_I1804_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I107_XG_MP1 (XI1_I1804_I107_XG_p1 I1_I1804_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I105_XG_MP2 (XI1_I1804_I105_XG_p1 I1_I1804_G9_8 I1_I1804_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I105_XG_MP0 (VDD I1_I1804_P9_8 XI1_I1804_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I105_XG_MP1 (XI1_I1804_I105_XG_p1 I1_I1804_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I103_XG_MP2 (XI1_I1804_I103_XG_p1 I1_I1804_G7_6 I1_I1804_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I103_XG_MP0 (VDD I1_I1804_P7_6 XI1_I1804_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I103_XG_MP1 (XI1_I1804_I103_XG_p1 I1_I1804_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I99_XG_MP2 (XI1_I1850_I99_XG_p1 I1_I1850_G3_2 I1_I1850_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I99_XG_MP0 (VDD I1_I1850_P3_2 XI1_I1850_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I99_XG_MP1 (XI1_I1850_I99_XG_p1 I1_I1850_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I101_XG_MP2 (XI1_I1896_I101_XG_p1 I1_I1896_G5_4 I1_I1896_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I101_XG_MP0 (VDD I1_I1896_P5_4 XI1_I1896_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I101_XG_MP1 (XI1_I1896_I101_XG_p1 I1_I1896_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I99_XG_MP2 (XI1_I1896_I99_XG_p1 I1_I1896_G3_2 I1_I1896_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I99_XG_MP0 (VDD I1_I1896_P3_2 XI1_I1896_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I99_XG_MP1 (XI1_I1896_I99_XG_p1 I1_I1896_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I100_XG_MP2 (XI1_I1896_I100_XG_p1 I1_I1896_G4_3 I1_I1896_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I100_XG_MP0 (VDD I1_I1896_P4_3 XI1_I1896_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I100_XG_MP1 (XI1_I1896_I100_XG_p1 I1_I1896_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I103_XG_MP2 (XI1_I1942_I103_XG_p1 I1_I1942_G7_6 I1_I1942_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I103_XG_MP0 (VDD I1_I1942_P7_6 XI1_I1942_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I103_XG_MP1 (XI1_I1942_I103_XG_p1 I1_I1942_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I104_XG_MP2 (XI1_I1942_I104_XG_p1 I1_I1942_G8_7 I1_I1942_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I104_XG_MP0 (VDD I1_I1942_P8_7 XI1_I1942_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I104_XG_MP1 (XI1_I1942_I104_XG_p1 I1_I1942_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I167_XG_MP2 (XI1_I1942_I167_XG_p1 I1_I1942_G16_9 I1_I1942_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I167_XG_MP0 (VDD I1_I1942_P16_9 XI1_I1942_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I167_XG_MP1 (XI1_I1942_I167_XG_p1 I1_I1942_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I157_XG_MP2 (XI1_I1942_I157_XG_p1 I1_I1942_G8_1 I1_I1942_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I157_XG_MP0 (VDD I1_I1942_P8_1 XI1_I1942_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I157_XG_MP1 (XI1_I1942_I157_XG_p1 I1_I1942_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I103_XG_MP2 (XI1_I1988_I103_XG_p1 I1_I1988_G7_6 I1_I1988_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I103_XG_MP0 (VDD I1_I1988_P7_6 XI1_I1988_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I103_XG_MP1 (XI1_I1988_I103_XG_p1 I1_I1988_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I102_XG_MP2 (XI1_I1988_I102_XG_p1 I1_I1988_G6_5 I1_I1988_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I102_XG_MP0 (VDD I1_I1988_P6_5 XI1_I1988_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I102_XG_MP1 (XI1_I1988_I102_XG_p1 I1_I1988_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I157_XG_MP2 (XI1_I1988_I157_XG_p1 I1_I1988_G8_1 I1_I1988_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I157_XG_MP0 (VDD I1_I1988_P8_1 XI1_I1988_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I157_XG_MP1 (XI1_I1988_I157_XG_p1 I1_I1988_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I197_XG_MP2 (XI0_I1660_I197_XG_p1 I0_I1660_G5_4 I0_I1660_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I197_XG_MP0 (VDD I0_I1660_P5_4 XI0_I1660_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I197_XG_MP1 (XI0_I1660_I197_XG_p1 I0_I1660_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I201_XG_MP2 (XI0_I1660_I201_XG_p1 I0_I1660_G9_8 I0_I1660_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I201_XG_MP0 (VDD I0_I1660_P9_8 XI0_I1660_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I201_XG_MP1 (XI0_I1660_I201_XG_p1 I0_I1660_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I324_XG_MP2 (XI0_I1660_I324_XG_p1 I0_I1660_G13_6 I0_I1660_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I324_XG_MP0 (VDD I0_I1660_P13_6 XI0_I1660_I324_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I324_XG_MP1 (XI0_I1660_I324_XG_p1 I0_I1660_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I328_XG_MP2 (XI0_I1660_I328_XG_p1 I0_I1660_G17_10 I0_I1660_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I328_XG_MP0 (VDD I0_I1660_P17_10 XI0_I1660_I328_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I328_XG_MP1 (XI0_I1660_I328_XG_p1 I0_I1660_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I210_XG_MP2 (XI0_I1660_I210_XG_p1 I0_I1660_G18_17 I0_I1660_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I210_XG_MP0 (VDD I0_I1660_P18_17 XI0_I1660_I210_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I210_XG_MP1 (XI0_I1660_I210_XG_p1 I0_I1660_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I322_XG_MP2 (XI0_I1660_I322_XG_p1 I0_I1660_G11_4 I0_I1660_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I322_XG_MP0 (VDD I0_I1660_P11_4 XI0_I1660_I322_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I322_XG_MP1 (XI0_I1660_I322_XG_p1 I0_I1660_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I212_XG_MP2 (XI0_I1660_I212_XG_p1 I0_I1660_G20_19 I0_I1660_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I212_XG_MP0 (VDD I0_I1660_P20_19 XI0_I1660_I212_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I212_XG_MP1 (XI0_I1660_I212_XG_p1 I0_I1660_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I330_XG_MP2 (XI0_I1660_I330_XG_p1 I0_I1660_G19_12 I0_I1660_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I330_XG_MP0 (VDD I0_I1660_P19_12 XI0_I1660_I330_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I330_XG_MP1 (XI0_I1660_I330_XG_p1 I0_I1660_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I214_XG_MP2 (XI0_I1660_I214_XG_p1 I0_I1660_G22_21 I0_I1660_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I214_XG_MP0 (VDD I0_I1660_P22_21 XI0_I1660_I214_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I214_XG_MP1 (XI0_I1660_I214_XG_p1 I0_I1660_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I216_XG_MP2 (XI0_I1660_I216_XG_p1 I0_I1660_G24_23 I0_I1660_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I216_XG_MP0 (VDD I0_I1660_P24_23 XI0_I1660_I216_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I216_XG_MP1 (XI0_I1660_I216_XG_p1 I0_I1660_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I326_XG_MP2 (XI0_I1660_I326_XG_p1 I0_I1660_G15_8 I0_I1660_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I326_XG_MP0 (VDD I0_I1660_P15_8 XI0_I1660_I326_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I326_XG_MP1 (XI0_I1660_I326_XG_p1 I0_I1660_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I218_XG_MP2 (XI0_I1660_I218_XG_p1 I0_I1660_G26_25 I0_I1660_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I218_XG_MP0 (VDD I0_I1660_P26_25 XI0_I1660_I218_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I218_XG_MP1 (XI0_I1660_I218_XG_p1 I0_I1660_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I334_XG_MP2 (XI0_I1660_I334_XG_p1 I0_I1660_G23_16 I0_I1660_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I334_XG_MP0 (VDD I0_I1660_P23_16 XI0_I1660_I334_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I334_XG_MP1 (XI0_I1660_I334_XG_p1 I0_I1660_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I217_XG_MP2 (XI0_I1660_I217_XG_p1 I0_I1660_G25_24 I0_I1660_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I217_XG_MP0 (VDD I0_I1660_P25_24 XI0_I1660_I217_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I217_XG_MP1 (XI0_I1660_I217_XG_p1 I0_I1660_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I219_XG_MP2 (XI0_I1660_I219_XG_p1 I0_I1660_G27_26 I0_I1660_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I219_XG_MP0 (VDD I0_I1660_P27_26 XI0_I1660_I219_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I219_XG_MP1 (XI0_I1660_I219_XG_p1 I0_I1660_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I221_XG_MP2 (XI0_I1660_I221_XG_p1 I0_I1660_G29_28 I0_I1660_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I221_XG_MP0 (VDD I0_I1660_P29_28 XI0_I1660_I221_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I221_XG_MP1 (XI0_I1660_I221_XG_p1 I0_I1660_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I127_XG_MP2 (XI1_I1804_I127_XG_p1 I1_I1804_G31_30 I1_I1804_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I127_XG_MP0 (VDD I1_I1804_P31_30 XI1_I1804_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I127_XG_MP1 (XI1_I1804_I127_XG_p1 I1_I1804_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I115_XG_MP2 (XI1_I1804_I115_XG_p1 I1_I1804_G19_18 I1_I1804_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I115_XG_MP0 (VDD I1_I1804_P19_18 XI1_I1804_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I115_XG_MP1 (XI1_I1804_I115_XG_p1 I1_I1804_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I176_XG_MP2 (XI1_I1804_I176_XG_p1 I1_I1804_G25_18 I1_I1804_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I176_XG_MP0 (VDD I1_I1804_P25_18 XI1_I1804_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I176_XG_MP1 (XI1_I1804_I176_XG_p1 I1_I1804_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I168_XG_MP2 (XI1_I1804_I168_XG_p1 I1_I1804_G17_10 I1_I1804_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I168_XG_MP0 (VDD I1_I1804_P17_10 XI1_I1804_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I168_XG_MP1 (XI1_I1804_I168_XG_p1 I1_I1804_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I158_XG_MP2 (XI1_I1804_I158_XG_p1 I1_I1804_G9_2 I1_I1804_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I158_XG_MP0 (VDD I1_I1804_P9_2 XI1_I1804_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I158_XG_MP1 (XI1_I1804_I158_XG_p1 I1_I1804_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I103_XG_MP2 (XI1_I1896_I103_XG_p1 I1_I1896_G7_6 I1_I1896_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I103_XG_MP0 (VDD I1_I1896_P7_6 XI1_I1896_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I103_XG_MP1 (XI1_I1896_I103_XG_p1 I1_I1896_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I102_XG_MP2 (XI1_I1896_I102_XG_p1 I1_I1896_G6_5 I1_I1896_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I102_XG_MP0 (VDD I1_I1896_P6_5 XI1_I1896_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I102_XG_MP1 (XI1_I1896_I102_XG_p1 I1_I1896_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I105_XG_MP2 (XI1_I1942_I105_XG_p1 I1_I1942_G9_8 I1_I1942_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I105_XG_MP0 (VDD I1_I1942_P9_8 XI1_I1942_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I105_XG_MP1 (XI1_I1942_I105_XG_p1 I1_I1942_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I158_XG_MP2 (XI1_I1942_I158_XG_p1 I1_I1942_G9_2 I1_I1942_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I158_XG_MP0 (VDD I1_I1942_P9_2 XI1_I1942_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I158_XG_MP1 (XI1_I1942_I158_XG_p1 I1_I1942_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I168_XG_MP2 (XI1_I1988_I168_XG_p1 I1_I1988_G17_10 I1_I1988_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I168_XG_MP0 (VDD I1_I1988_P17_10 XI1_I1988_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I168_XG_MP1 (XI1_I1988_I168_XG_p1 I1_I1988_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I105_XG_MP2 (XI1_I1988_I105_XG_p1 I1_I1988_G9_8 I1_I1988_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I105_XG_MP0 (VDD I1_I1988_P9_8 XI1_I1988_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I105_XG_MP1 (XI1_I1988_I105_XG_p1 I1_I1988_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I158_XG_MP2 (XI1_I1988_I158_XG_p1 I1_I1988_G9_2 I1_I1988_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I158_XG_MP0 (VDD I1_I1988_P9_2 XI1_I1988_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I158_XG_MP1 (XI1_I1988_I158_XG_p1 I1_I1988_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I104_XG_MP2 (XI1_I1988_I104_XG_p1 I1_I1988_G8_7 I1_I1988_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I104_XG_MP0 (VDD I1_I1988_P8_7 XI1_I1988_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I104_XG_MP1 (XI1_I1988_I104_XG_p1 I1_I1988_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I167_XG_MP2 (XI1_I1988_I167_XG_p1 I1_I1988_G16_9 I1_I1988_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I167_XG_MP0 (VDD I1_I1988_P16_9 XI1_I1988_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I167_XG_MP1 (XI1_I1988_I167_XG_p1 I1_I1988_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I194_XG_MP2 (XI0_I1660_I194_XG_p1 I0_I1660_G2_1 I0_I1660_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I194_XG_MP0 (VDD I0_I1660_P2_1 XI0_I1660_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I194_XG_MP1 (XI0_I1660_I194_XG_p1 I0_I1660_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I196_XG_MP2 (XI0_I1660_I196_XG_p1 I0_I1660_G4_3 I0_I1660_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I196_XG_MP0 (VDD I0_I1660_P4_3 XI0_I1660_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I196_XG_MP1 (XI0_I1660_I196_XG_p1 I0_I1660_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I195_XG_MP2 (XI0_I1660_I195_XG_p1 I0_I1660_G3_2 I0_I1660_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I195_XG_MP0 (VDD I0_I1660_P3_2 XI0_I1660_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I195_XG_MP1 (XI0_I1660_I195_XG_p1 I0_I1660_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I198_XG_MP2 (XI0_I1660_I198_XG_p1 I0_I1660_G6_5 I0_I1660_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I198_XG_MP0 (VDD I0_I1660_P6_5 XI0_I1660_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I198_XG_MP1 (XI0_I1660_I198_XG_p1 I0_I1660_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I200_XG_MP2 (XI0_I1660_I200_XG_p1 I0_I1660_G8_7 I0_I1660_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I200_XG_MP0 (VDD I0_I1660_P8_7 XI0_I1660_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I200_XG_MP1 (XI0_I1660_I200_XG_p1 I0_I1660_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I202_XG_MP2 (XI0_I1660_I202_XG_p1 I0_I1660_G10_9 I0_I1660_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I202_XG_MP0 (VDD I0_I1660_P10_9 XI0_I1660_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I202_XG_MP1 (XI0_I1660_I202_XG_p1 I0_I1660_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I204_XG_MP2 (XI0_I1660_I204_XG_p1 I0_I1660_G12_11 I0_I1660_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I204_XG_MP0 (VDD I0_I1660_P12_11 XI0_I1660_I204_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I204_XG_MP1 (XI0_I1660_I204_XG_p1 I0_I1660_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I318_XG_MP2 (XI0_I1660_I318_XG_p1 I0_I1660_G9_2 I0_I1660_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I318_XG_MP0 (VDD I0_I1660_P9_2 XI0_I1660_I318_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I318_XG_MP1 (XI0_I1660_I318_XG_p1 I0_I1660_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I206_XG_MP2 (XI0_I1660_I206_XG_p1 I0_I1660_G14_13 I0_I1660_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I206_XG_MP0 (VDD I0_I1660_P14_13 XI0_I1660_I206_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I206_XG_MP1 (XI0_I1660_I206_XG_p1 I0_I1660_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I208_XG_MP2 (XI0_I1660_I208_XG_p1 I0_I1660_G16_15 I0_I1660_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I208_XG_MP0 (VDD I0_I1660_P16_15 XI0_I1660_I208_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I208_XG_MP1 (XI0_I1660_I208_XG_p1 I0_I1660_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I332_XG_MP2 (XI0_I1660_I332_XG_p1 I0_I1660_G21_14 I0_I1660_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I332_XG_MP0 (VDD I0_I1660_P21_14 XI0_I1660_I332_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I332_XG_MP1 (XI0_I1660_I332_XG_p1 I0_I1660_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I220_XG_MP2 (XI0_I1660_I220_XG_p1 I0_I1660_G28_27 I0_I1660_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I220_XG_MP0 (VDD I0_I1660_P28_27 XI0_I1660_I220_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I220_XG_MP1 (XI0_I1660_I220_XG_p1 I0_I1660_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I222_XG_MP2 (XI0_I1660_I222_XG_p1 I0_I1660_G30_29 I0_I1660_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I222_XG_MP0 (VDD I0_I1660_P30_29 XI0_I1660_I222_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I222_XG_MP1 (XI0_I1660_I222_XG_p1 I0_I1660_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I336_XG_MP2 (XI0_I1660_I336_XG_p1 I0_I1660_G25_18 I0_I1660_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I336_XG_MP0 (VDD I0_I1660_P25_18 XI0_I1660_I336_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I336_XG_MP1 (XI0_I1660_I336_XG_p1 I0_I1660_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I344_XG_MP2 (XI0_I1660_I344_XG_p1 I0_I1660_G33_26 I0_I1660_G33_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I344_XG_MP0 (VDD I0_I1660_P33_26 XI0_I1660_I344_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I344_XG_MP1 (XI0_I1660_I344_XG_p1 I0_I1660_G25_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I338_XG_MP2 (XI0_I1660_I338_XG_p1 I0_I1660_G27_20 I0_I1660_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I338_XG_MP0 (VDD I0_I1660_P27_20 XI0_I1660_I338_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I338_XG_MP1 (XI0_I1660_I338_XG_p1 I0_I1660_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I342_XG_MP2 (XI0_I1660_I342_XG_p1 I0_I1660_G31_24 I0_I1660_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I342_XG_MP0 (VDD I0_I1660_P31_24 XI0_I1660_I342_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I342_XG_MP1 (XI0_I1660_I342_XG_p1 I0_I1660_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I223_XG_MP2 (XI0_I1660_I223_XG_p1 I0_I1660_G31_30 I0_I1660_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I223_XG_MP0 (VDD I0_I1660_P31_30 XI0_I1660_I223_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I223_XG_MP1 (XI0_I1660_I223_XG_p1 I0_I1660_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I225_XG_MP2 (XI0_I1660_I225_XG_p1 I0_I1660_G33_32 I0_I1660_G33_30n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I225_XG_MP0 (VDD I0_I1660_P33_32 XI0_I1660_I225_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I225_XG_MP1 (XI0_I1660_I225_XG_p1 I0_I1660_G31_30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I180_XG_MP2 (XI1_I1804_I180_XG_p1 I1_I1804_G29_22 I1_I1804_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I180_XG_MP0 (VDD I1_I1804_P29_22 XI1_I1804_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I180_XG_MP1 (XI1_I1804_I180_XG_p1 I1_I1804_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I172_XG_MP2 (XI1_I1804_I172_XG_p1 I1_I1804_G21_14 I1_I1804_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I172_XG_MP0 (VDD I1_I1804_P21_14 XI1_I1804_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I172_XG_MP1 (XI1_I1804_I172_XG_p1 I1_I1804_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I164_XG_MP2 (XI1_I1804_I164_XG_p1 I1_I1804_G13_6 I1_I1804_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I164_XG_MP0 (VDD I1_I1804_P13_6 XI1_I1804_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I164_XG_MP1 (XI1_I1804_I164_XG_p1 I1_I1804_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I101_XG_MP2 (XI1_I1850_I101_XG_p1 I1_I1850_G5_4 I1_I1850_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I101_XG_MP0 (VDD I1_I1850_P5_4 XI1_I1850_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I101_XG_MP1 (XI1_I1850_I101_XG_p1 I1_I1850_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I98_XG_MP2 (XI1_I1850_I98_XG_p1 I1_I1850_G2_1 I1_I1850_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I98_XG_MP0 (VDD I1_I1850_P2_1 XI1_I1850_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I98_XG_MP1 (XI1_I1850_I98_XG_p1 I1_I1850_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I104_XG_MP2 (XI1_I1896_I104_XG_p1 I1_I1896_G8_7 I1_I1896_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I104_XG_MP0 (VDD I1_I1896_P8_7 XI1_I1896_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I104_XG_MP1 (XI1_I1896_I104_XG_p1 I1_I1896_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I157_XG_MP2 (XI1_I1896_I157_XG_p1 I1_I1896_G8_1 I1_I1896_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I157_XG_MP0 (VDD I1_I1896_P8_1 XI1_I1896_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I157_XG_MP1 (XI1_I1896_I157_XG_p1 I1_I1896_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I168_XG_MP2 (XI1_I1942_I168_XG_p1 I1_I1942_G17_10 I1_I1942_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I168_XG_MP0 (VDD I1_I1942_P17_10 XI1_I1942_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I168_XG_MP1 (XI1_I1942_I168_XG_p1 I1_I1942_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I106_XG_MP2 (XI1_I1942_I106_XG_p1 I1_I1942_G10_9 I1_I1942_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I106_XG_MP0 (VDD I1_I1942_P10_9 XI1_I1942_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I106_XG_MP1 (XI1_I1942_I106_XG_p1 I1_I1942_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I169_XG_MP2 (XI1_I1942_I169_XG_p1 I1_I1942_G18_11 I1_I1942_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I169_XG_MP0 (VDD I1_I1942_P18_11 XI1_I1942_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I169_XG_MP1 (XI1_I1942_I169_XG_p1 I1_I1942_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I160_XG_MP2 (XI1_I1942_I160_XG_p1 I1_I1942_G10_3 I1_I1942_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I160_XG_MP0 (VDD I1_I1942_P10_3 XI1_I1942_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I160_XG_MP1 (XI1_I1942_I160_XG_p1 I1_I1942_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I107_XG_MP2 (XI1_I1988_I107_XG_p1 I1_I1988_G11_10 I1_I1988_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I107_XG_MP0 (VDD I1_I1988_P11_10 XI1_I1988_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I107_XG_MP1 (XI1_I1988_I107_XG_p1 I1_I1988_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I106_XG_MP2 (XI1_I1988_I106_XG_p1 I1_I1988_G10_9 I1_I1988_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I106_XG_MP0 (VDD I1_I1988_P10_9 XI1_I1988_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I106_XG_MP1 (XI1_I1988_I106_XG_p1 I1_I1988_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I160_XG_MP2 (XI1_I1988_I160_XG_p1 I1_I1988_G10_3 I1_I1988_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I160_XG_MP0 (VDD I1_I1988_P10_3 XI1_I1988_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I160_XG_MP1 (XI1_I1988_I160_XG_p1 I1_I1988_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I102_XG_MP2 (XI1_I2066_I102_XG_p1 I1_I2066_G6_5 I1_I2066_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I102_XG_MP0 (VDD I1_I2066_P6_5 XI1_I2066_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I102_XG_MP1 (XI1_I2066_I102_XG_p1 I1_I2066_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I100_XG_MP2 (XI1_I2066_I100_XG_p1 I1_I2066_G4_3 I1_I2066_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I100_XG_MP0 (VDD I1_I2066_P4_3 XI1_I2066_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I100_XG_MP1 (XI1_I2066_I100_XG_p1 I1_I2066_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I98_XG_MP2 (XI1_I2066_I98_XG_p1 I1_I2066_G2_1 I1_I2066_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I98_XG_MP0 (VDD I1_I2066_P2_1 XI1_I2066_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I98_XG_MP1 (XI1_I2066_I98_XG_p1 I1_I2066_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2173_MP2 (XI1_I2173_p1 I1_nrk1 I1_nrkn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2173_MP0 (VDD I1_A_31_b3_5 XI1_I2173_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2173_MP1 (XI1_I2173_p1 I1_ru1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I323_XG_MP2 (XI0_I1660_I323_XG_p1 I0_I1660_G12_5 I0_I1660_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I323_XG_MP0 (VDD I0_I1660_P12_5 XI0_I1660_I323_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I323_XG_MP1 (XI0_I1660_I323_XG_p1 I0_I1660_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I428_XG_MP2 (XI0_I1660_I428_XG_p1 I0_I1660_G33_2 I0_I1660_G33_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I428_XG_MP0 (VDD I0_I1660_P33_2 XI0_I1660_I428_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I428_XG_MP1 (XI0_I1660_I428_XG_p1 I0_I1660_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I331_XG_MP2 (XI0_I1660_I331_XG_p1 I0_I1660_G20_13 I0_I1660_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I331_XG_MP0 (VDD I0_I1660_P20_13 XI0_I1660_I331_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I331_XG_MP1 (XI0_I1660_I331_XG_p1 I0_I1660_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I335_XG_MP2 (XI0_I1660_I335_XG_p1 I0_I1660_G24_17 I0_I1660_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I335_XG_MP0 (VDD I0_I1660_P24_17 XI0_I1660_I335_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I335_XG_MP1 (XI0_I1660_I335_XG_p1 I0_I1660_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I430_XG_MP2 (XI0_I1660_I430_XG_p1 I0_I1660_G35_4 I0_I1660_G35_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I430_XG_MP0 (VDD I0_I1660_P35_4 XI0_I1660_I430_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I430_XG_MP1 (XI0_I1660_I430_XG_p1 I0_I1660_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I432_XG_MP2 (XI0_I1660_I432_XG_p1 I0_I1660_G37_6 I0_I1660_G37_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I432_XG_MP0 (VDD I0_I1660_P37_6 XI0_I1660_I432_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I432_XG_MP1 (XI0_I1660_I432_XG_p1 I0_I1660_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I224_XG_MP2 (XI0_I1660_I224_XG_p1 I0_I1660_G32_31 I0_I1660_G32_29n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I224_XG_MP0 (VDD I0_I1660_P32_31 XI0_I1660_I224_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I224_XG_MP1 (XI0_I1660_I224_XG_p1 I0_I1660_G30_29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I452_XG_MP2 (XI0_I1660_I452_XG_p1 I0_I1660_G49_18 I0_I1660_G49_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I452_XG_MP0 (VDD I0_I1660_P49_18 XI0_I1660_I452_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I452_XG_MP1 (XI0_I1660_I452_XG_p1 I0_I1660_G17_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I434_XG_MP2 (XI0_I1660_I434_XG_p1 I0_I1660_G39_8 I0_I1660_G39_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I434_XG_MP0 (VDD I0_I1660_P39_8 XI0_I1660_I434_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I434_XG_MP1 (XI0_I1660_I434_XG_p1 I0_I1660_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I340_XG_MP2 (XI0_I1660_I340_XG_p1 I0_I1660_G29_22 I0_I1660_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I340_XG_MP0 (VDD I0_I1660_P29_22 XI0_I1660_I340_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I340_XG_MP1 (XI0_I1660_I340_XG_p1 I0_I1660_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I346_XG_MP2 (XI0_I1660_I346_XG_p1 I0_I1660_G35_28 I0_I1660_G35_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I346_XG_MP0 (VDD I0_I1660_P35_28 XI0_I1660_I346_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I346_XG_MP1 (XI0_I1660_I346_XG_p1 I0_I1660_G27_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I350_XG_MP2 (XI0_I1660_I350_XG_p1 I0_I1660_G39_32 I0_I1660_G39_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I350_XG_MP0 (VDD I0_I1660_P39_32 XI0_I1660_I350_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I350_XG_MP1 (XI0_I1660_I350_XG_p1 I0_I1660_G31_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I227_XG_MP2 (XI0_I1660_I227_XG_p1 I0_I1660_G35_34 I0_I1660_G35_32n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I227_XG_MP0 (VDD I0_I1660_P35_34 XI0_I1660_I227_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I227_XG_MP1 (XI0_I1660_I227_XG_p1 I0_I1660_G33_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I182_XG_MP2 (XI1_I1804_I182_XG_p1 I1_I1804_G31_24 I1_I1804_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I182_XG_MP0 (VDD I1_I1804_P31_24 XI1_I1804_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I182_XG_MP1 (XI1_I1804_I182_XG_p1 I1_I1804_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I178_XG_MP2 (XI1_I1804_I178_XG_p1 I1_I1804_G27_20 I1_I1804_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I178_XG_MP0 (VDD I1_I1804_P27_20 XI1_I1804_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I178_XG_MP1 (XI1_I1804_I178_XG_p1 I1_I1804_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I174_XG_MP2 (XI1_I1804_I174_XG_p1 I1_I1804_G23_16 I1_I1804_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I174_XG_MP0 (VDD I1_I1804_P23_16 XI1_I1804_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I174_XG_MP1 (XI1_I1804_I174_XG_p1 I1_I1804_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I166_XG_MP2 (XI1_I1804_I166_XG_p1 I1_I1804_G15_8 I1_I1804_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I166_XG_MP0 (VDD I1_I1804_P15_8 XI1_I1804_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I166_XG_MP1 (XI1_I1804_I166_XG_p1 I1_I1804_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I170_XG_MP2 (XI1_I1804_I170_XG_p1 I1_I1804_G19_12 I1_I1804_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I170_XG_MP0 (VDD I1_I1804_P19_12 XI1_I1804_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I170_XG_MP1 (XI1_I1804_I170_XG_p1 I1_I1804_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I162_XG_MP2 (XI1_I1804_I162_XG_p1 I1_I1804_G11_4 I1_I1804_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I162_XG_MP0 (VDD I1_I1804_P11_4 XI1_I1804_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I162_XG_MP1 (XI1_I1804_I162_XG_p1 I1_I1804_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I100_XG_MP2 (XI1_I1850_I100_XG_p1 I1_I1850_G4_3 I1_I1850_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I100_XG_MP0 (VDD I1_I1850_P4_3 XI1_I1850_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I100_XG_MP1 (XI1_I1850_I100_XG_p1 I1_I1850_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I105_XG_MP2 (XI1_I1896_I105_XG_p1 I1_I1896_G9_8 I1_I1896_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I105_XG_MP0 (VDD I1_I1896_P9_8 XI1_I1896_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I105_XG_MP1 (XI1_I1896_I105_XG_p1 I1_I1896_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I158_XG_MP2 (XI1_I1896_I158_XG_p1 I1_I1896_G9_2 I1_I1896_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I158_XG_MP0 (VDD I1_I1896_P9_2 XI1_I1896_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I158_XG_MP1 (XI1_I1896_I158_XG_p1 I1_I1896_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I167_XG_MP2 (XI1_I1896_I167_XG_p1 I1_I1896_G16_9 I1_I1896_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I167_XG_MP0 (VDD I1_I1896_P16_9 XI1_I1896_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I167_XG_MP1 (XI1_I1896_I167_XG_p1 I1_I1896_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I107_XG_MP2 (XI1_I1942_I107_XG_p1 I1_I1942_G11_10 I1_I1942_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I107_XG_MP0 (VDD I1_I1942_P11_10 XI1_I1942_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I107_XG_MP1 (XI1_I1942_I107_XG_p1 I1_I1942_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I170_XG_MP2 (XI1_I1942_I170_XG_p1 I1_I1942_G19_12 I1_I1942_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I170_XG_MP0 (VDD I1_I1942_P19_12 XI1_I1942_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I170_XG_MP1 (XI1_I1942_I170_XG_p1 I1_I1942_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I162_XG_MP2 (XI1_I1942_I162_XG_p1 I1_I1942_G11_4 I1_I1942_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I162_XG_MP0 (VDD I1_I1942_P11_4 XI1_I1942_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I162_XG_MP1 (XI1_I1942_I162_XG_p1 I1_I1942_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I108_XG_MP2 (XI1_I1942_I108_XG_p1 I1_I1942_G12_11 I1_I1942_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I108_XG_MP0 (VDD I1_I1942_P12_11 XI1_I1942_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I108_XG_MP1 (XI1_I1942_I108_XG_p1 I1_I1942_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I109_XG_MP2 (XI1_I1988_I109_XG_p1 I1_I1988_G13_12 I1_I1988_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I109_XG_MP0 (VDD I1_I1988_P13_12 XI1_I1988_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I109_XG_MP1 (XI1_I1988_I109_XG_p1 I1_I1988_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I162_XG_MP2 (XI1_I1988_I162_XG_p1 I1_I1988_G11_4 I1_I1988_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I162_XG_MP0 (VDD I1_I1988_P11_4 XI1_I1988_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I162_XG_MP1 (XI1_I1988_I162_XG_p1 I1_I1988_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I108_XG_MP2 (XI1_I1988_I108_XG_p1 I1_I1988_G12_11 I1_I1988_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I108_XG_MP0 (VDD I1_I1988_P12_11 XI1_I1988_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I108_XG_MP1 (XI1_I1988_I108_XG_p1 I1_I1988_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I175_XG_MP2 (XI1_I1988_I175_XG_p1 I1_I1988_G24_17 I1_I1988_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I175_XG_MP0 (VDD I1_I1988_P24_17 XI1_I1988_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I175_XG_MP1 (XI1_I1988_I175_XG_p1 I1_I1988_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I104_XG_MP2 (XI1_I2066_I104_XG_p1 I1_I2066_G8_7 I1_I2066_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I104_XG_MP0 (VDD I1_I2066_P8_7 XI1_I2066_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I104_XG_MP1 (XI1_I2066_I104_XG_p1 I1_I2066_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I101_XG_MP2 (XI1_I2066_I101_XG_p1 I1_I2066_G5_4 I1_I2066_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I101_XG_MP0 (VDD I1_I2066_P5_4 XI1_I2066_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I101_XG_MP1 (XI1_I2066_I101_XG_p1 I1_I2066_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I99_XG_MP2 (XI1_I2066_I99_XG_p1 I1_I2066_G3_2 I1_I2066_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I99_XG_MP0 (VDD I1_I2066_P3_2 XI1_I2066_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I99_XG_MP1 (XI1_I2066_I99_XG_p1 I1_I2066_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I317_XG_MP2 (XI0_I1660_I317_XG_p1 I0_I1660_G8_1 I0_I1660_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I317_XG_MP0 (VDD I0_I1660_P8_1 XI0_I1660_I317_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I317_XG_MP1 (XI0_I1660_I317_XG_p1 I0_I1660_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I427_XG_MP2 (XI0_I1660_I427_XG_p1 I0_I1660_G32_1 I0_I1660_G32_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I427_XG_MP0 (VDD I0_I1660_P32_1 XI0_I1660_I427_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I427_XG_MP1 (XI0_I1660_I427_XG_p1 I0_I1660_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I327_XG_MP2 (XI0_I1660_I327_XG_p1 I0_I1660_G16_9 I0_I1660_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I327_XG_MP0 (VDD I0_I1660_P16_9 XI0_I1660_I327_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I327_XG_MP1 (XI0_I1660_I327_XG_p1 I0_I1660_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I343_XG_MP2 (XI0_I1660_I343_XG_p1 I0_I1660_G32_25 I0_I1660_G32_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I343_XG_MP0 (VDD I0_I1660_P32_25 XI0_I1660_I343_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I343_XG_MP1 (XI0_I1660_I343_XG_p1 I0_I1660_G24_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I339_XG_MP2 (XI0_I1660_I339_XG_p1 I0_I1660_G28_21 I0_I1660_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I339_XG_MP0 (VDD I0_I1660_P28_21 XI0_I1660_I339_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I339_XG_MP1 (XI0_I1660_I339_XG_p1 I0_I1660_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I226_XG_MP2 (XI0_I1660_I226_XG_p1 I0_I1660_G34_33 I0_I1660_G34_31n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I226_XG_MP0 (VDD I0_I1660_P34_33 XI0_I1660_I226_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I226_XG_MP1 (XI0_I1660_I226_XG_p1 I0_I1660_G32_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I228_XG_MP2 (XI0_I1660_I228_XG_p1 I0_I1660_G36_35 I0_I1660_G36_33n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I228_XG_MP0 (VDD I0_I1660_P36_35 XI0_I1660_I228_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I228_XG_MP1 (XI0_I1660_I228_XG_p1 I0_I1660_G34_33 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I348_XG_MP2 (XI0_I1660_I348_XG_p1 I0_I1660_G37_30 I0_I1660_G37_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I348_XG_MP0 (VDD I0_I1660_P37_30 XI0_I1660_I348_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I348_XG_MP1 (XI0_I1660_I348_XG_p1 I0_I1660_G29_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I442_XG_MP2 (XI0_I1660_I442_XG_p1 I0_I1660_G43_12 I0_I1660_G43_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I442_XG_MP0 (VDD I0_I1660_P43_12 XI0_I1660_I442_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I442_XG_MP1 (XI0_I1660_I442_XG_p1 I0_I1660_G11_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I354_XG_MP2 (XI0_I1660_I354_XG_p1 I0_I1660_G43_36 I0_I1660_G43_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I354_XG_MP0 (VDD I0_I1660_P43_36 XI0_I1660_I354_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I354_XG_MP1 (XI0_I1660_I354_XG_p1 I0_I1660_G35_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I229_XG_MP2 (XI0_I1660_I229_XG_p1 I0_I1660_G37_36 I0_I1660_G37_34n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I229_XG_MP0 (VDD I0_I1660_P37_36 XI0_I1660_I229_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I229_XG_MP1 (XI0_I1660_I229_XG_p1 I0_I1660_G35_34 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I105_XG_MP2 (XI1_I1850_I105_XG_p1 I1_I1850_G9_8 I1_I1850_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I105_XG_MP0 (VDD I1_I1850_P9_8 XI1_I1850_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I105_XG_MP1 (XI1_I1850_I105_XG_p1 I1_I1850_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I107_XG_MP2 (XI1_I1850_I107_XG_p1 I1_I1850_G11_10 I1_I1850_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I107_XG_MP0 (VDD I1_I1850_P11_10 XI1_I1850_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I107_XG_MP1 (XI1_I1850_I107_XG_p1 I1_I1850_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I103_XG_MP2 (XI1_I1850_I103_XG_p1 I1_I1850_G7_6 I1_I1850_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I103_XG_MP0 (VDD I1_I1850_P7_6 XI1_I1850_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I103_XG_MP1 (XI1_I1850_I103_XG_p1 I1_I1850_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I102_XG_MP2 (XI1_I1850_I102_XG_p1 I1_I1850_G6_5 I1_I1850_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I102_XG_MP0 (VDD I1_I1850_P6_5 XI1_I1850_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I102_XG_MP1 (XI1_I1850_I102_XG_p1 I1_I1850_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I107_XG_MP2 (XI1_I1896_I107_XG_p1 I1_I1896_G11_10 I1_I1896_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I107_XG_MP0 (VDD I1_I1896_P11_10 XI1_I1896_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I107_XG_MP1 (XI1_I1896_I107_XG_p1 I1_I1896_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I168_XG_MP2 (XI1_I1896_I168_XG_p1 I1_I1896_G17_10 I1_I1896_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I168_XG_MP0 (VDD I1_I1896_P17_10 XI1_I1896_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I168_XG_MP1 (XI1_I1896_I168_XG_p1 I1_I1896_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I106_XG_MP2 (XI1_I1896_I106_XG_p1 I1_I1896_G10_9 I1_I1896_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I106_XG_MP0 (VDD I1_I1896_P10_9 XI1_I1896_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I106_XG_MP1 (XI1_I1896_I106_XG_p1 I1_I1896_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I160_XG_MP2 (XI1_I1896_I160_XG_p1 I1_I1896_G10_3 I1_I1896_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I160_XG_MP0 (VDD I1_I1896_P10_3 XI1_I1896_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I160_XG_MP1 (XI1_I1896_I160_XG_p1 I1_I1896_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I109_XG_MP2 (XI1_I1942_I109_XG_p1 I1_I1942_G13_12 I1_I1942_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I109_XG_MP0 (VDD I1_I1942_P13_12 XI1_I1942_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I109_XG_MP1 (XI1_I1942_I109_XG_p1 I1_I1942_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I176_XG_MP2 (XI1_I1942_I176_XG_p1 I1_I1942_G25_18 I1_I1942_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I176_XG_MP0 (VDD I1_I1942_P25_18 XI1_I1942_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I176_XG_MP1 (XI1_I1942_I176_XG_p1 I1_I1942_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I110_XG_MP2 (XI1_I1942_I110_XG_p1 I1_I1942_G14_13 I1_I1942_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I110_XG_MP0 (VDD I1_I1942_P14_13 XI1_I1942_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I110_XG_MP1 (XI1_I1942_I110_XG_p1 I1_I1942_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I163_XG_MP2 (XI1_I1942_I163_XG_p1 I1_I1942_G12_5 I1_I1942_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I163_XG_MP0 (VDD I1_I1942_P12_5 XI1_I1942_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I163_XG_MP1 (XI1_I1942_I163_XG_p1 I1_I1942_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I175_XG_MP2 (XI1_I1942_I175_XG_p1 I1_I1942_G24_17 I1_I1942_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I175_XG_MP0 (VDD I1_I1942_P24_17 XI1_I1942_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I175_XG_MP1 (XI1_I1942_I175_XG_p1 I1_I1942_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I176_XG_MP2 (XI1_I1988_I176_XG_p1 I1_I1988_G25_18 I1_I1988_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I176_XG_MP0 (VDD I1_I1988_P25_18 XI1_I1988_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I176_XG_MP1 (XI1_I1988_I176_XG_p1 I1_I1988_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I110_XG_MP2 (XI1_I1988_I110_XG_p1 I1_I1988_G14_13 I1_I1988_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I110_XG_MP0 (VDD I1_I1988_P14_13 XI1_I1988_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I110_XG_MP1 (XI1_I1988_I110_XG_p1 I1_I1988_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I169_XG_MP2 (XI1_I1988_I169_XG_p1 I1_I1988_G18_11 I1_I1988_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I169_XG_MP0 (VDD I1_I1988_P18_11 XI1_I1988_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I169_XG_MP1 (XI1_I1988_I169_XG_p1 I1_I1988_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I106_XG_MP2 (XI1_I2066_I106_XG_p1 I1_I2066_G10_9 I1_I2066_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I106_XG_MP0 (VDD I1_I2066_P10_9 XI1_I2066_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I106_XG_MP1 (XI1_I2066_I106_XG_p1 I1_I2066_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I157_XG_MP2 (XI1_I2066_I157_XG_p1 I1_I2066_G8_1 I1_I2066_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I157_XG_MP0 (VDD I1_I2066_P8_1 XI1_I2066_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I157_XG_MP1 (XI1_I2066_I157_XG_p1 I1_I2066_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I103_XG_MP2 (XI1_I2066_I103_XG_p1 I1_I2066_G7_6 I1_I2066_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I103_XG_MP0 (VDD I1_I2066_P7_6 XI1_I2066_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I103_XG_MP1 (XI1_I2066_I103_XG_p1 I1_I2066_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2176_MP2 (XI1_I2176_p1 I1_nrk2 I1_nrkn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2176_MP0 (VDD I1_A_31_b3_6 XI1_I2176_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2176_MP1 (XI1_I2176_p1 I1_ru2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2179_MP2 (XI1_I2179_p1 I1_nrk3 I1_nrkn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2179_MP0 (VDD I1_A_31_b3_6 XI1_I2179_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2179_MP1 (XI1_I2179_p1 I1_ru3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2182_MP2 (XI1_I2182_p1 I1_nrk4 I1_nrkn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2182_MP0 (VDD I1_A_31_b3_6 XI1_I2182_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2182_MP1 (XI1_I2182_p1 I1_ru4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I320_XG_MP2 (XI0_I1660_I320_XG_p1 I0_I1660_G10_3 I0_I1660_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I320_XG_MP0 (VDD I0_I1660_P10_3 XI0_I1660_I320_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I320_XG_MP1 (XI0_I1660_I320_XG_p1 I0_I1660_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I329_XG_MP2 (XI0_I1660_I329_XG_p1 I0_I1660_G18_11 I0_I1660_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I329_XG_MP0 (VDD I0_I1660_P18_11 XI0_I1660_I329_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I329_XG_MP1 (XI0_I1660_I329_XG_p1 I0_I1660_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I325_XG_MP2 (XI0_I1660_I325_XG_p1 I0_I1660_G14_7 I0_I1660_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I325_XG_MP0 (VDD I0_I1660_P14_7 XI0_I1660_I325_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I325_XG_MP1 (XI0_I1660_I325_XG_p1 I0_I1660_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I431_XG_MP2 (XI0_I1660_I431_XG_p1 I0_I1660_G36_5 I0_I1660_G36_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I431_XG_MP0 (VDD I0_I1660_P36_5 XI0_I1660_I431_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I431_XG_MP1 (XI0_I1660_I431_XG_p1 I0_I1660_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I451_XG_MP2 (XI0_I1660_I451_XG_p1 I0_I1660_G48_17 I0_I1660_G48_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I451_XG_MP0 (VDD I0_I1660_P48_17 XI0_I1660_I451_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I451_XG_MP1 (XI0_I1660_I451_XG_p1 I0_I1660_G16_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I436_XG_MP2 (XI0_I1660_I436_XG_p1 I0_I1660_G40_9 I0_I1660_G40_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I436_XG_MP0 (VDD I0_I1660_P40_9 XI0_I1660_I436_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I436_XG_MP1 (XI0_I1660_I436_XG_p1 I0_I1660_G8_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I347_XG_MP2 (XI0_I1660_I347_XG_p1 I0_I1660_G36_29 I0_I1660_G36_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I347_XG_MP0 (VDD I0_I1660_P36_29 XI0_I1660_I347_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I347_XG_MP1 (XI0_I1660_I347_XG_p1 I0_I1660_G28_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I351_XG_MP2 (XI0_I1660_I351_XG_p1 I0_I1660_G40_33 I0_I1660_G40_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I351_XG_MP0 (VDD I0_I1660_P40_33 XI0_I1660_I351_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I351_XG_MP1 (XI0_I1660_I351_XG_p1 I0_I1660_G32_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I438_XG_MP2 (XI0_I1660_I438_XG_p1 I0_I1660_G41_10 I0_I1660_G41_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I438_XG_MP0 (VDD I0_I1660_P41_10 XI0_I1660_I438_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I438_XG_MP1 (XI0_I1660_I438_XG_p1 I0_I1660_G9_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I454_XG_MP2 (XI0_I1660_I454_XG_p1 I0_I1660_G51_20 I0_I1660_G51_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I454_XG_MP0 (VDD I0_I1660_P51_20 XI0_I1660_I454_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I454_XG_MP1 (XI0_I1660_I454_XG_p1 I0_I1660_G19_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I352_XG_MP2 (XI0_I1660_I352_XG_p1 I0_I1660_G41_34 I0_I1660_G41_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I352_XG_MP0 (VDD I0_I1660_P41_34 XI0_I1660_I352_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I352_XG_MP1 (XI0_I1660_I352_XG_p1 I0_I1660_G33_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I450_XG_MP2 (XI0_I1660_I450_XG_p1 I0_I1660_G47_16 I0_I1660_G47_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I450_XG_MP0 (VDD I0_I1660_P47_16 XI0_I1660_I450_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I450_XG_MP1 (XI0_I1660_I450_XG_p1 I0_I1660_G15_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I360_XG_MP2 (XI0_I1660_I360_XG_p1 I0_I1660_G49_42 I0_I1660_G49_34n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I360_XG_MP0 (VDD I0_I1660_P49_42 XI0_I1660_I360_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I360_XG_MP1 (XI0_I1660_I360_XG_p1 I0_I1660_G41_34 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I362_XG_MP2 (XI0_I1660_I362_XG_p1 I0_I1660_G51_44 I0_I1660_G51_36n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I362_XG_MP0 (VDD I0_I1660_P51_44 XI0_I1660_I362_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I362_XG_MP1 (XI0_I1660_I362_XG_p1 I0_I1660_G43_36 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I358_XG_MP2 (XI0_I1660_I358_XG_p1 I0_I1660_G47_40 I0_I1660_G47_32n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I358_XG_MP0 (VDD I0_I1660_P47_40 XI0_I1660_I358_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I358_XG_MP1 (XI0_I1660_I358_XG_p1 I0_I1660_G39_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I231_XG_MP2 (XI0_I1660_I231_XG_p1 I0_I1660_G39_38 I0_I1660_G39_36n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I231_XG_MP0 (VDD I0_I1660_P39_38 XI0_I1660_I231_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I231_XG_MP1 (XI0_I1660_I231_XG_p1 I0_I1660_G37_36 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I233_XG_MP2 (XI0_I1660_I233_XG_p1 I0_I1660_G41_40 I0_I1660_G41_38n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I233_XG_MP0 (VDD I0_I1660_P41_40 XI0_I1660_I233_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I233_XG_MP1 (XI0_I1660_I233_XG_p1 I0_I1660_G39_38 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I162_XG_MP2 (XI1_I1850_I162_XG_p1 I1_I1850_G11_4 I1_I1850_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I162_XG_MP0 (VDD I1_I1850_P11_4 XI1_I1850_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I162_XG_MP1 (XI1_I1850_I162_XG_p1 I1_I1850_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I109_XG_MP2 (XI1_I1850_I109_XG_p1 I1_I1850_G13_12 I1_I1850_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I109_XG_MP0 (VDD I1_I1850_P13_12 XI1_I1850_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I109_XG_MP1 (XI1_I1850_I109_XG_p1 I1_I1850_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I158_XG_MP2 (XI1_I1850_I158_XG_p1 I1_I1850_G9_2 I1_I1850_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I158_XG_MP0 (VDD I1_I1850_P9_2 XI1_I1850_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I158_XG_MP1 (XI1_I1850_I158_XG_p1 I1_I1850_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I106_XG_MP2 (XI1_I1850_I106_XG_p1 I1_I1850_G10_9 I1_I1850_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I106_XG_MP0 (VDD I1_I1850_P10_9 XI1_I1850_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I106_XG_MP1 (XI1_I1850_I106_XG_p1 I1_I1850_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I104_XG_MP2 (XI1_I1850_I104_XG_p1 I1_I1850_G8_7 I1_I1850_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I104_XG_MP0 (VDD I1_I1850_P8_7 XI1_I1850_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I104_XG_MP1 (XI1_I1850_I104_XG_p1 I1_I1850_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I109_XG_MP2 (XI1_I1896_I109_XG_p1 I1_I1896_G13_12 I1_I1896_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I109_XG_MP0 (VDD I1_I1896_P13_12 XI1_I1896_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I109_XG_MP1 (XI1_I1896_I109_XG_p1 I1_I1896_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I162_XG_MP2 (XI1_I1896_I162_XG_p1 I1_I1896_G11_4 I1_I1896_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I162_XG_MP0 (VDD I1_I1896_P11_4 XI1_I1896_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I162_XG_MP1 (XI1_I1896_I162_XG_p1 I1_I1896_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I108_XG_MP2 (XI1_I1896_I108_XG_p1 I1_I1896_G12_11 I1_I1896_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I108_XG_MP0 (VDD I1_I1896_P12_11 XI1_I1896_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I108_XG_MP1 (XI1_I1896_I108_XG_p1 I1_I1896_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I169_XG_MP2 (XI1_I1896_I169_XG_p1 I1_I1896_G18_11 I1_I1896_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I169_XG_MP0 (VDD I1_I1896_P18_11 XI1_I1896_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I169_XG_MP1 (XI1_I1896_I169_XG_p1 I1_I1896_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I111_XG_MP2 (XI1_I1942_I111_XG_p1 I1_I1942_G15_14 I1_I1942_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I111_XG_MP0 (VDD I1_I1942_P15_14 XI1_I1942_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I111_XG_MP1 (XI1_I1942_I111_XG_p1 I1_I1942_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I164_XG_MP2 (XI1_I1942_I164_XG_p1 I1_I1942_G13_6 I1_I1942_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I164_XG_MP0 (VDD I1_I1942_P13_6 XI1_I1942_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I164_XG_MP1 (XI1_I1942_I164_XG_p1 I1_I1942_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I112_XG_MP2 (XI1_I1942_I112_XG_p1 I1_I1942_G16_15 I1_I1942_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I112_XG_MP0 (VDD I1_I1942_P16_15 XI1_I1942_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I112_XG_MP1 (XI1_I1942_I112_XG_p1 I1_I1942_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I171_XG_MP2 (XI1_I1942_I171_XG_p1 I1_I1942_G20_13 I1_I1942_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I171_XG_MP0 (VDD I1_I1942_P20_13 XI1_I1942_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I171_XG_MP1 (XI1_I1942_I171_XG_p1 I1_I1942_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I111_XG_MP2 (XI1_I1988_I111_XG_p1 I1_I1988_G15_14 I1_I1988_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I111_XG_MP0 (VDD I1_I1988_P15_14 XI1_I1988_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I111_XG_MP1 (XI1_I1988_I111_XG_p1 I1_I1988_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I170_XG_MP2 (XI1_I1988_I170_XG_p1 I1_I1988_G19_12 I1_I1988_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I170_XG_MP0 (VDD I1_I1988_P19_12 XI1_I1988_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I170_XG_MP1 (XI1_I1988_I170_XG_p1 I1_I1988_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I164_XG_MP2 (XI1_I1988_I164_XG_p1 I1_I1988_G13_6 I1_I1988_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I164_XG_MP0 (VDD I1_I1988_P13_6 XI1_I1988_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I164_XG_MP1 (XI1_I1988_I164_XG_p1 I1_I1988_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I112_XG_MP2 (XI1_I1988_I112_XG_p1 I1_I1988_G16_15 I1_I1988_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I112_XG_MP0 (VDD I1_I1988_P16_15 XI1_I1988_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I112_XG_MP1 (XI1_I1988_I112_XG_p1 I1_I1988_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I163_XG_MP2 (XI1_I1988_I163_XG_p1 I1_I1988_G12_5 I1_I1988_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I163_XG_MP0 (VDD I1_I1988_P12_5 XI1_I1988_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I163_XG_MP1 (XI1_I1988_I163_XG_p1 I1_I1988_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I108_XG_MP2 (XI1_I2066_I108_XG_p1 I1_I2066_G12_11 I1_I2066_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I108_XG_MP0 (VDD I1_I2066_P12_11 XI1_I2066_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I108_XG_MP1 (XI1_I2066_I108_XG_p1 I1_I2066_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I167_XG_MP2 (XI1_I2066_I167_XG_p1 I1_I2066_G16_9 I1_I2066_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I167_XG_MP0 (VDD I1_I2066_P16_9 XI1_I2066_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I167_XG_MP1 (XI1_I2066_I167_XG_p1 I1_I2066_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I105_XG_MP2 (XI1_I2066_I105_XG_p1 I1_I2066_G9_8 I1_I2066_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I105_XG_MP0 (VDD I1_I2066_P9_8 XI1_I2066_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I105_XG_MP1 (XI1_I2066_I105_XG_p1 I1_I2066_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I158_XG_MP2 (XI1_I2066_I158_XG_p1 I1_I2066_G9_2 I1_I2066_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I158_XG_MP0 (VDD I1_I2066_P9_2 XI1_I2066_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I158_XG_MP1 (XI1_I2066_I158_XG_p1 I1_I2066_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2188_MP2 (XI1_I2188_p1 I1_nrk6 I1_nrkn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2188_MP0 (VDD I1_A_31_b3_6 XI1_I2188_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2188_MP1 (XI1_I2188_p1 I1_ru6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2185_MP2 (XI1_I2185_p1 I1_nrk5 I1_nrkn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2185_MP0 (VDD I1_A_31_b3_6 XI1_I2185_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2185_MP1 (XI1_I2185_p1 I1_ru5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I429_XG_MP2 (XI0_I1660_I429_XG_p1 I0_I1660_G34_3 I0_I1660_G34_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I429_XG_MP0 (VDD I0_I1660_P34_3 XI0_I1660_I429_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I429_XG_MP1 (XI0_I1660_I429_XG_p1 I0_I1660_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I333_XG_MP2 (XI0_I1660_I333_XG_p1 I0_I1660_G22_15 I0_I1660_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I333_XG_MP0 (VDD I0_I1660_P22_15 XI0_I1660_I333_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I333_XG_MP1 (XI0_I1660_I333_XG_p1 I0_I1660_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I337_XG_MP2 (XI0_I1660_I337_XG_p1 I0_I1660_G26_19 I0_I1660_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I337_XG_MP0 (VDD I0_I1660_P26_19 XI0_I1660_I337_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I337_XG_MP1 (XI0_I1660_I337_XG_p1 I0_I1660_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I359_XG_MP2 (XI0_I1660_I359_XG_p1 I0_I1660_G48_41 I0_I1660_G48_33n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I359_XG_MP0 (VDD I0_I1660_P48_41 XI0_I1660_I359_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I359_XG_MP1 (XI0_I1660_I359_XG_p1 I0_I1660_G40_33 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I230_XG_MP2 (XI0_I1660_I230_XG_p1 I0_I1660_G38_37 I0_I1660_G38_35n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I230_XG_MP0 (VDD I0_I1660_P38_37 XI0_I1660_I230_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I230_XG_MP1 (XI0_I1660_I230_XG_p1 I0_I1660_G36_35 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I232_XG_MP2 (XI0_I1660_I232_XG_p1 I0_I1660_G40_39 I0_I1660_G40_37n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I232_XG_MP0 (VDD I0_I1660_P40_39 XI0_I1660_I232_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I232_XG_MP1 (XI0_I1660_I232_XG_p1 I0_I1660_G38_37 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I456_XG_MP2 (XI0_I1660_I456_XG_p1 I0_I1660_G53_22 I0_I1660_G53_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I456_XG_MP0 (VDD I0_I1660_P53_22 XI0_I1660_I456_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I456_XG_MP1 (XI0_I1660_I456_XG_p1 I0_I1660_G21_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I458_XG_MP2 (XI0_I1660_I458_XG_p1 I0_I1660_G55_24 I0_I1660_G55_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I458_XG_MP0 (VDD I0_I1660_P55_24 XI0_I1660_I458_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I458_XG_MP1 (XI0_I1660_I458_XG_p1 I0_I1660_G23_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I466_XG_MP2 (XI0_I1660_I466_XG_p1 I0_I1660_G63_32 I0_I1660_G63_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I466_XG_MP0 (VDD I0_I1660_P63_32 XI0_I1660_I466_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I466_XG_MP1 (XI0_I1660_I466_XG_p1 I0_I1660_G31_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I366_XG_MP2 (XI0_I1660_I366_XG_p1 I0_I1660_G55_48 I0_I1660_G55_40n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I366_XG_MP0 (VDD I0_I1660_P55_48 XI0_I1660_I366_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I366_XG_MP1 (XI0_I1660_I366_XG_p1 I0_I1660_G47_40 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I235_XG_MP2 (XI0_I1660_I235_XG_p1 I0_I1660_G43_42 I0_I1660_G43_40n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I235_XG_MP0 (VDD I0_I1660_P43_42 XI0_I1660_I235_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I235_XG_MP1 (XI0_I1660_I235_XG_p1 I0_I1660_G41_40 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I170_XG_MP2 (XI1_I1850_I170_XG_p1 I1_I1850_G19_12 I1_I1850_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I170_XG_MP0 (VDD I1_I1850_P19_12 XI1_I1850_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I170_XG_MP1 (XI1_I1850_I170_XG_p1 I1_I1850_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I111_XG_MP2 (XI1_I1850_I111_XG_p1 I1_I1850_G15_14 I1_I1850_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I111_XG_MP0 (VDD I1_I1850_P15_14 XI1_I1850_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I111_XG_MP1 (XI1_I1850_I111_XG_p1 I1_I1850_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I164_XG_MP2 (XI1_I1850_I164_XG_p1 I1_I1850_G13_6 I1_I1850_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I164_XG_MP0 (VDD I1_I1850_P13_6 XI1_I1850_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I164_XG_MP1 (XI1_I1850_I164_XG_p1 I1_I1850_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I168_XG_MP2 (XI1_I1850_I168_XG_p1 I1_I1850_G17_10 I1_I1850_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I168_XG_MP0 (VDD I1_I1850_P17_10 XI1_I1850_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I168_XG_MP1 (XI1_I1850_I168_XG_p1 I1_I1850_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I108_XG_MP2 (XI1_I1850_I108_XG_p1 I1_I1850_G12_11 I1_I1850_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I108_XG_MP0 (VDD I1_I1850_P12_11 XI1_I1850_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I108_XG_MP1 (XI1_I1850_I108_XG_p1 I1_I1850_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I157_XG_MP2 (XI1_I1850_I157_XG_p1 I1_I1850_G8_1 I1_I1850_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I157_XG_MP0 (VDD I1_I1850_P8_1 XI1_I1850_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I157_XG_MP1 (XI1_I1850_I157_XG_p1 I1_I1850_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I170_XG_MP2 (XI1_I1896_I170_XG_p1 I1_I1896_G19_12 I1_I1896_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I170_XG_MP0 (VDD I1_I1896_P19_12 XI1_I1896_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I170_XG_MP1 (XI1_I1896_I170_XG_p1 I1_I1896_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I110_XG_MP2 (XI1_I1896_I110_XG_p1 I1_I1896_G14_13 I1_I1896_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I110_XG_MP0 (VDD I1_I1896_P14_13 XI1_I1896_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I110_XG_MP1 (XI1_I1896_I110_XG_p1 I1_I1896_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I163_XG_MP2 (XI1_I1896_I163_XG_p1 I1_I1896_G12_5 I1_I1896_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I163_XG_MP0 (VDD I1_I1896_P12_5 XI1_I1896_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I163_XG_MP1 (XI1_I1896_I163_XG_p1 I1_I1896_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I113_XG_MP2 (XI1_I1942_I113_XG_p1 I1_I1942_G17_16 I1_I1942_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I113_XG_MP0 (VDD I1_I1942_P17_16 XI1_I1942_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I113_XG_MP1 (XI1_I1942_I113_XG_p1 I1_I1942_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I172_XG_MP2 (XI1_I1942_I172_XG_p1 I1_I1942_G21_14 I1_I1942_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I172_XG_MP0 (VDD I1_I1942_P21_14 XI1_I1942_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I172_XG_MP1 (XI1_I1942_I172_XG_p1 I1_I1942_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I114_XG_MP2 (XI1_I1942_I114_XG_p1 I1_I1942_G18_17 I1_I1942_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I114_XG_MP0 (VDD I1_I1942_P18_17 XI1_I1942_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I114_XG_MP1 (XI1_I1942_I114_XG_p1 I1_I1942_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I113_XG_MP2 (XI1_I1988_I113_XG_p1 I1_I1988_G17_16 I1_I1988_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I113_XG_MP0 (VDD I1_I1988_P17_16 XI1_I1988_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I113_XG_MP1 (XI1_I1988_I113_XG_p1 I1_I1988_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I172_XG_MP2 (XI1_I1988_I172_XG_p1 I1_I1988_G21_14 I1_I1988_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I172_XG_MP0 (VDD I1_I1988_P21_14 XI1_I1988_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I172_XG_MP1 (XI1_I1988_I172_XG_p1 I1_I1988_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I116_XG_MP2 (XI1_I1988_I116_XG_p1 I1_I1988_G20_19 I1_I1988_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I116_XG_MP0 (VDD I1_I1988_P20_19 XI1_I1988_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I116_XG_MP1 (XI1_I1988_I116_XG_p1 I1_I1988_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I114_XG_MP2 (XI1_I1988_I114_XG_p1 I1_I1988_G18_17 I1_I1988_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I114_XG_MP0 (VDD I1_I1988_P18_17 XI1_I1988_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I114_XG_MP1 (XI1_I1988_I114_XG_p1 I1_I1988_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I171_XG_MP2 (XI1_I1988_I171_XG_p1 I1_I1988_G20_13 I1_I1988_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I171_XG_MP0 (VDD I1_I1988_P20_13 XI1_I1988_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I171_XG_MP1 (XI1_I1988_I171_XG_p1 I1_I1988_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I165_XG_MP2 (XI1_I1988_I165_XG_p1 I1_I1988_G14_7 I1_I1988_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I165_XG_MP0 (VDD I1_I1988_P14_7 XI1_I1988_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I165_XG_MP1 (XI1_I1988_I165_XG_p1 I1_I1988_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I110_XG_MP2 (XI1_I2066_I110_XG_p1 I1_I2066_G14_13 I1_I2066_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I110_XG_MP0 (VDD I1_I2066_P14_13 XI1_I2066_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I110_XG_MP1 (XI1_I2066_I110_XG_p1 I1_I2066_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I175_XG_MP2 (XI1_I2066_I175_XG_p1 I1_I2066_G24_17 I1_I2066_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I175_XG_MP0 (VDD I1_I2066_P24_17 XI1_I2066_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I175_XG_MP1 (XI1_I2066_I175_XG_p1 I1_I2066_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I160_XG_MP2 (XI1_I2066_I160_XG_p1 I1_I2066_G10_3 I1_I2066_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I160_XG_MP0 (VDD I1_I2066_P10_3 XI1_I2066_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I160_XG_MP1 (XI1_I2066_I160_XG_p1 I1_I2066_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I107_XG_MP2 (XI1_I2066_I107_XG_p1 I1_I2066_G11_10 I1_I2066_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I107_XG_MP0 (VDD I1_I2066_P11_10 XI1_I2066_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I107_XG_MP1 (XI1_I2066_I107_XG_p1 I1_I2066_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I168_XG_MP2 (XI1_I2066_I168_XG_p1 I1_I2066_G17_10 I1_I2066_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I168_XG_MP0 (VDD I1_I2066_P17_10 XI1_I2066_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I168_XG_MP1 (XI1_I2066_I168_XG_p1 I1_I2066_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2191_MP2 (XI1_I2191_p1 I1_nrk7 I1_nrkn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2191_MP0 (VDD I1_A_31_b3_6 XI1_I2191_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2191_MP1 (XI1_I2191_p1 I1_ru7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I345_XG_MP2 (XI0_I1660_I345_XG_p1 I0_I1660_G34_27 I0_I1660_G34_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I345_XG_MP0 (VDD I0_I1660_P34_27 XI0_I1660_I345_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I345_XG_MP1 (XI0_I1660_I345_XG_p1 I0_I1660_G26_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I444_XG_MP2 (XI0_I1660_I444_XG_p1 I0_I1660_G44_13 I0_I1660_G44_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I444_XG_MP0 (VDD I0_I1660_P44_13 XI0_I1660_I444_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I444_XG_MP1 (XI0_I1660_I444_XG_p1 I0_I1660_G12_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I363_XG_MP2 (XI0_I1660_I363_XG_p1 I0_I1660_G52_45 I0_I1660_G52_37n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I363_XG_MP0 (VDD I0_I1660_P52_45 XI0_I1660_I363_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I363_XG_MP1 (XI0_I1660_I363_XG_p1 I0_I1660_G44_37 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I355_XG_MP2 (XI0_I1660_I355_XG_p1 I0_I1660_G44_37 I0_I1660_G44_29n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I355_XG_MP0 (VDD I0_I1660_P44_37 XI0_I1660_I355_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I355_XG_MP1 (XI0_I1660_I355_XG_p1 I0_I1660_G36_29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I234_XG_MP2 (XI0_I1660_I234_XG_p1 I0_I1660_G42_41 I0_I1660_G42_39n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I234_XG_MP0 (VDD I0_I1660_P42_41 XI0_I1660_I234_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I234_XG_MP1 (XI0_I1660_I234_XG_p1 I0_I1660_G40_39 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I446_XG_MP2 (XI0_I1660_I446_XG_p1 I0_I1660_G45_14 I0_I1660_G45_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I446_XG_MP0 (VDD I0_I1660_P45_14 XI0_I1660_I446_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I446_XG_MP1 (XI0_I1660_I446_XG_p1 I0_I1660_G13_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I364_XG_MP2 (XI0_I1660_I364_XG_p1 I0_I1660_G53_46 I0_I1660_G53_38n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I364_XG_MP0 (VDD I0_I1660_P53_46 XI0_I1660_I364_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I364_XG_MP1 (XI0_I1660_I364_XG_p1 I0_I1660_G45_38 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I356_XG_MP2 (XI0_I1660_I356_XG_p1 I0_I1660_G45_38 I0_I1660_G45_30n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I356_XG_MP0 (VDD I0_I1660_P45_38 XI0_I1660_I356_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I356_XG_MP1 (XI0_I1660_I356_XG_p1 I0_I1660_G37_30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I237_XG_MP2 (XI0_I1660_I237_XG_p1 I0_I1660_G45_44 I0_I1660_G45_42n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I237_XG_MP0 (VDD I0_I1660_P45_44 XI0_I1660_I237_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I237_XG_MP1 (XI0_I1660_I237_XG_p1 I0_I1660_G43_42 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I166_XG_MP2 (XI1_I1850_I166_XG_p1 I1_I1850_G15_8 I1_I1850_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I166_XG_MP0 (VDD I1_I1850_P15_8 XI1_I1850_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I166_XG_MP1 (XI1_I1850_I166_XG_p1 I1_I1850_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I115_XG_MP2 (XI1_I1850_I115_XG_p1 I1_I1850_G19_18 I1_I1850_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I115_XG_MP0 (VDD I1_I1850_P19_18 XI1_I1850_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I115_XG_MP1 (XI1_I1850_I115_XG_p1 I1_I1850_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I113_XG_MP2 (XI1_I1850_I113_XG_p1 I1_I1850_G17_16 I1_I1850_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I113_XG_MP0 (VDD I1_I1850_P17_16 XI1_I1850_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I113_XG_MP1 (XI1_I1850_I113_XG_p1 I1_I1850_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I112_XG_MP2 (XI1_I1850_I112_XG_p1 I1_I1850_G16_15 I1_I1850_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I112_XG_MP0 (VDD I1_I1850_P16_15 XI1_I1850_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I112_XG_MP1 (XI1_I1850_I112_XG_p1 I1_I1850_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I110_XG_MP2 (XI1_I1850_I110_XG_p1 I1_I1850_G14_13 I1_I1850_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I110_XG_MP0 (VDD I1_I1850_P14_13 XI1_I1850_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I110_XG_MP1 (XI1_I1850_I110_XG_p1 I1_I1850_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I167_XG_MP2 (XI1_I1850_I167_XG_p1 I1_I1850_G16_9 I1_I1850_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I167_XG_MP0 (VDD I1_I1850_P16_9 XI1_I1850_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I167_XG_MP1 (XI1_I1850_I167_XG_p1 I1_I1850_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I111_XG_MP2 (XI1_I1896_I111_XG_p1 I1_I1896_G15_14 I1_I1896_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I111_XG_MP0 (VDD I1_I1896_P15_14 XI1_I1896_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I111_XG_MP1 (XI1_I1896_I111_XG_p1 I1_I1896_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I112_XG_MP2 (XI1_I1896_I112_XG_p1 I1_I1896_G16_15 I1_I1896_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I112_XG_MP0 (VDD I1_I1896_P16_15 XI1_I1896_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I112_XG_MP1 (XI1_I1896_I112_XG_p1 I1_I1896_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I115_XG_MP2 (XI1_I1942_I115_XG_p1 I1_I1942_G19_18 I1_I1942_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I115_XG_MP0 (VDD I1_I1942_P19_18 XI1_I1942_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I115_XG_MP1 (XI1_I1942_I115_XG_p1 I1_I1942_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I166_XG_MP2 (XI1_I1942_I166_XG_p1 I1_I1942_G15_8 I1_I1942_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I166_XG_MP0 (VDD I1_I1942_P15_8 XI1_I1942_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I166_XG_MP1 (XI1_I1942_I166_XG_p1 I1_I1942_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I116_XG_MP2 (XI1_I1942_I116_XG_p1 I1_I1942_G20_19 I1_I1942_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I116_XG_MP0 (VDD I1_I1942_P20_19 XI1_I1942_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I116_XG_MP1 (XI1_I1942_I116_XG_p1 I1_I1942_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I165_XG_MP2 (XI1_I1942_I165_XG_p1 I1_I1942_G14_7 I1_I1942_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I165_XG_MP0 (VDD I1_I1942_P14_7 XI1_I1942_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I165_XG_MP1 (XI1_I1942_I165_XG_p1 I1_I1942_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I115_XG_MP2 (XI1_I1988_I115_XG_p1 I1_I1988_G19_18 I1_I1988_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I115_XG_MP0 (VDD I1_I1988_P19_18 XI1_I1988_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I115_XG_MP1 (XI1_I1988_I115_XG_p1 I1_I1988_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I117_XG_MP2 (XI1_I1988_I117_XG_p1 I1_I1988_G21_20 I1_I1988_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I117_XG_MP0 (VDD I1_I1988_P21_20 XI1_I1988_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I117_XG_MP1 (XI1_I1988_I117_XG_p1 I1_I1988_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I178_XG_MP2 (XI1_I1988_I178_XG_p1 I1_I1988_G27_20 I1_I1988_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I178_XG_MP0 (VDD I1_I1988_P27_20 XI1_I1988_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I178_XG_MP1 (XI1_I1988_I178_XG_p1 I1_I1988_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I177_XG_MP2 (XI1_I1988_I177_XG_p1 I1_I1988_G26_19 I1_I1988_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I177_XG_MP0 (VDD I1_I1988_P26_19 XI1_I1988_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I177_XG_MP1 (XI1_I1988_I177_XG_p1 I1_I1988_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I112_XG_MP2 (XI1_I2066_I112_XG_p1 I1_I2066_G16_15 I1_I2066_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I112_XG_MP0 (VDD I1_I2066_P16_15 XI1_I2066_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I112_XG_MP1 (XI1_I2066_I112_XG_p1 I1_I2066_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I169_XG_MP2 (XI1_I2066_I169_XG_p1 I1_I2066_G18_11 I1_I2066_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I169_XG_MP0 (VDD I1_I2066_P18_11 XI1_I2066_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I169_XG_MP1 (XI1_I2066_I169_XG_p1 I1_I2066_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I111_XG_MP2 (XI1_I2066_I111_XG_p1 I1_I2066_G15_14 I1_I2066_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I111_XG_MP0 (VDD I1_I2066_P15_14 XI1_I2066_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I111_XG_MP1 (XI1_I2066_I111_XG_p1 I1_I2066_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I109_XG_MP2 (XI1_I2066_I109_XG_p1 I1_I2066_G13_12 I1_I2066_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I109_XG_MP0 (VDD I1_I2066_P13_12 XI1_I2066_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I109_XG_MP1 (XI1_I2066_I109_XG_p1 I1_I2066_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2194_MP2 (XI1_I2194_p1 I1_nrk8 I1_nrkn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2194_MP0 (VDD I1_A_31_b3_7 XI1_I2194_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2194_MP1 (XI1_I2194_p1 I1_ru8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2200_MP2 (XI1_I2200_p1 I1_nrk10 I1_nrkn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2200_MP0 (VDD I1_A_31_b3_7 XI1_I2200_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2200_MP1 (XI1_I2200_p1 I1_ru10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2197_MP2 (XI1_I2197_p1 I1_nrk9 I1_nrkn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2197_MP0 (VDD I1_A_31_b3_7 XI1_I2197_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2197_MP1 (XI1_I2197_p1 I1_ru9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I433_XG_MP2 (XI0_I1660_I433_XG_p1 I0_I1660_G38_7 I0_I1660_G38_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I433_XG_MP0 (VDD I0_I1660_P38_7 XI0_I1660_I433_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I433_XG_MP1 (XI0_I1660_I433_XG_p1 I0_I1660_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I440_XG_MP2 (XI0_I1660_I440_XG_p1 I0_I1660_G42_11 I0_I1660_G42_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I440_XG_MP0 (VDD I0_I1660_P42_11 XI0_I1660_I440_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I440_XG_MP1 (XI0_I1660_I440_XG_p1 I0_I1660_G10_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I341_XG_MP2 (XI0_I1660_I341_XG_p1 I0_I1660_G30_23 I0_I1660_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I341_XG_MP0 (VDD I0_I1660_P30_23 XI0_I1660_I341_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I341_XG_MP1 (XI0_I1660_I341_XG_p1 I0_I1660_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I455_XG_MP2 (XI0_I1660_I455_XG_p1 I0_I1660_G52_21 I0_I1660_G52_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I455_XG_MP0 (VDD I0_I1660_P52_21 XI0_I1660_I455_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I455_XG_MP1 (XI0_I1660_I455_XG_p1 I0_I1660_G20_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I459_XG_MP2 (XI0_I1660_I459_XG_p1 I0_I1660_G56_25 I0_I1660_G56_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I459_XG_MP0 (VDD I0_I1660_P56_25 XI0_I1660_I459_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I459_XG_MP1 (XI0_I1660_I459_XG_p1 I0_I1660_G24_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I236_XG_MP2 (XI0_I1660_I236_XG_p1 I0_I1660_G44_43 I0_I1660_G44_41n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I236_XG_MP0 (VDD I0_I1660_P44_43 XI0_I1660_I236_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I236_XG_MP1 (XI0_I1660_I236_XG_p1 I0_I1660_G42_41 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I460_XG_MP2 (XI0_I1660_I460_XG_p1 I0_I1660_G57_26 I0_I1660_G57_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I460_XG_MP0 (VDD I0_I1660_P57_26 XI0_I1660_I460_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I460_XG_MP1 (XI0_I1660_I460_XG_p1 I0_I1660_G25_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I368_XG_MP2 (XI0_I1660_I368_XG_p1 I0_I1660_G57_50 I0_I1660_G57_42n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I368_XG_MP0 (VDD I0_I1660_P57_50 XI0_I1660_I368_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I368_XG_MP1 (XI0_I1660_I368_XG_p1 I0_I1660_G49_42 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I462_XG_MP2 (XI0_I1660_I462_XG_p1 I0_I1660_G59_28 I0_I1660_G59_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I462_XG_MP0 (VDD I0_I1660_P59_28 XI0_I1660_I462_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I462_XG_MP1 (XI0_I1660_I462_XG_p1 I0_I1660_G27_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I370_XG_MP2 (XI0_I1660_I370_XG_p1 I0_I1660_G59_52 I0_I1660_G59_44n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I370_XG_MP0 (VDD I0_I1660_P59_52 XI0_I1660_I370_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I370_XG_MP1 (XI0_I1660_I370_XG_p1 I0_I1660_G51_44 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I239_XG_MP2 (XI0_I1660_I239_XG_p1 I0_I1660_G47_46 I0_I1660_G47_44n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I239_XG_MP0 (VDD I0_I1660_P47_46 XI0_I1660_I239_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I239_XG_MP1 (XI0_I1660_I239_XG_p1 I0_I1660_G45_44 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I182_XG_MP2 (XI1_I1850_I182_XG_p1 I1_I1850_G31_24 I1_I1850_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I182_XG_MP0 (VDD I1_I1850_P31_24 XI1_I1850_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I182_XG_MP1 (XI1_I1850_I182_XG_p1 I1_I1850_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I174_XG_MP2 (XI1_I1850_I174_XG_p1 I1_I1850_G23_16 I1_I1850_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I174_XG_MP0 (VDD I1_I1850_P23_16 XI1_I1850_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I174_XG_MP1 (XI1_I1850_I174_XG_p1 I1_I1850_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I172_XG_MP2 (XI1_I1850_I172_XG_p1 I1_I1850_G21_14 I1_I1850_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I172_XG_MP0 (VDD I1_I1850_P21_14 XI1_I1850_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I172_XG_MP1 (XI1_I1850_I172_XG_p1 I1_I1850_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I176_XG_MP2 (XI1_I1850_I176_XG_p1 I1_I1850_G25_18 I1_I1850_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I176_XG_MP0 (VDD I1_I1850_P25_18 XI1_I1850_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I176_XG_MP1 (XI1_I1850_I176_XG_p1 I1_I1850_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I114_XG_MP2 (XI1_I1850_I114_XG_p1 I1_I1850_G18_17 I1_I1850_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I114_XG_MP0 (VDD I1_I1850_P18_17 XI1_I1850_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I114_XG_MP1 (XI1_I1850_I114_XG_p1 I1_I1850_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I163_XG_MP2 (XI1_I1850_I163_XG_p1 I1_I1850_G12_5 I1_I1850_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I163_XG_MP0 (VDD I1_I1850_P12_5 XI1_I1850_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I163_XG_MP1 (XI1_I1850_I163_XG_p1 I1_I1850_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I160_XG_MP2 (XI1_I1850_I160_XG_p1 I1_I1850_G10_3 I1_I1850_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I160_XG_MP0 (VDD I1_I1850_P10_3 XI1_I1850_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I160_XG_MP1 (XI1_I1850_I160_XG_p1 I1_I1850_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I113_XG_MP2 (XI1_I1896_I113_XG_p1 I1_I1896_G17_16 I1_I1896_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I113_XG_MP0 (VDD I1_I1896_P17_16 XI1_I1896_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I113_XG_MP1 (XI1_I1896_I113_XG_p1 I1_I1896_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I172_XG_MP2 (XI1_I1896_I172_XG_p1 I1_I1896_G21_14 I1_I1896_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I172_XG_MP0 (VDD I1_I1896_P21_14 XI1_I1896_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I172_XG_MP1 (XI1_I1896_I172_XG_p1 I1_I1896_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I164_XG_MP2 (XI1_I1896_I164_XG_p1 I1_I1896_G13_6 I1_I1896_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I164_XG_MP0 (VDD I1_I1896_P13_6 XI1_I1896_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I164_XG_MP1 (XI1_I1896_I164_XG_p1 I1_I1896_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I114_XG_MP2 (XI1_I1896_I114_XG_p1 I1_I1896_G18_17 I1_I1896_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I114_XG_MP0 (VDD I1_I1896_P18_17 XI1_I1896_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I114_XG_MP1 (XI1_I1896_I114_XG_p1 I1_I1896_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I171_XG_MP2 (XI1_I1896_I171_XG_p1 I1_I1896_G20_13 I1_I1896_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I171_XG_MP0 (VDD I1_I1896_P20_13 XI1_I1896_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I171_XG_MP1 (XI1_I1896_I171_XG_p1 I1_I1896_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I117_XG_MP2 (XI1_I1942_I117_XG_p1 I1_I1942_G21_20 I1_I1942_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I117_XG_MP0 (VDD I1_I1942_P21_20 XI1_I1942_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I117_XG_MP1 (XI1_I1942_I117_XG_p1 I1_I1942_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I178_XG_MP2 (XI1_I1942_I178_XG_p1 I1_I1942_G27_20 I1_I1942_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I178_XG_MP0 (VDD I1_I1942_P27_20 XI1_I1942_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I178_XG_MP1 (XI1_I1942_I178_XG_p1 I1_I1942_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I177_XG_MP2 (XI1_I1942_I177_XG_p1 I1_I1942_G26_19 I1_I1942_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I177_XG_MP0 (VDD I1_I1942_P26_19 XI1_I1942_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I177_XG_MP1 (XI1_I1942_I177_XG_p1 I1_I1942_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I173_XG_MP2 (XI1_I1942_I173_XG_p1 I1_I1942_G22_15 I1_I1942_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I173_XG_MP0 (VDD I1_I1942_P22_15 XI1_I1942_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I173_XG_MP1 (XI1_I1942_I173_XG_p1 I1_I1942_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I166_XG_MP2 (XI1_I1988_I166_XG_p1 I1_I1988_G15_8 I1_I1988_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I166_XG_MP0 (VDD I1_I1988_P15_8 XI1_I1988_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I166_XG_MP1 (XI1_I1988_I166_XG_p1 I1_I1988_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I118_XG_MP2 (XI1_I1988_I118_XG_p1 I1_I1988_G22_21 I1_I1988_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I118_XG_MP0 (VDD I1_I1988_P22_21 XI1_I1988_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I118_XG_MP1 (XI1_I1988_I118_XG_p1 I1_I1988_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I173_XG_MP2 (XI1_I1988_I173_XG_p1 I1_I1988_G22_15 I1_I1988_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I173_XG_MP0 (VDD I1_I1988_P22_15 XI1_I1988_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I173_XG_MP1 (XI1_I1988_I173_XG_p1 I1_I1988_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I114_XG_MP2 (XI1_I2066_I114_XG_p1 I1_I2066_G18_17 I1_I2066_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I114_XG_MP0 (VDD I1_I2066_P18_17 XI1_I2066_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I114_XG_MP1 (XI1_I2066_I114_XG_p1 I1_I2066_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I163_XG_MP2 (XI1_I2066_I163_XG_p1 I1_I2066_G12_5 I1_I2066_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I163_XG_MP0 (VDD I1_I2066_P12_5 XI1_I2066_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I163_XG_MP1 (XI1_I2066_I163_XG_p1 I1_I2066_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I113_XG_MP2 (XI1_I2066_I113_XG_p1 I1_I2066_G17_16 I1_I2066_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I113_XG_MP0 (VDD I1_I2066_P17_16 XI1_I2066_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I113_XG_MP1 (XI1_I2066_I113_XG_p1 I1_I2066_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I176_XG_MP2 (XI1_I2066_I176_XG_p1 I1_I2066_G25_18 I1_I2066_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I176_XG_MP0 (VDD I1_I2066_P25_18 XI1_I2066_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I176_XG_MP1 (XI1_I2066_I176_XG_p1 I1_I2066_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I162_XG_MP2 (XI1_I2066_I162_XG_p1 I1_I2066_G11_4 I1_I2066_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I162_XG_MP0 (VDD I1_I2066_P11_4 XI1_I2066_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I162_XG_MP1 (XI1_I2066_I162_XG_p1 I1_I2066_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2203_MP2 (XI1_I2203_p1 I1_nrk11 I1_nrkn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2203_MP0 (VDD I1_A_31_b3_7 XI1_I2203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2203_MP1 (XI1_I2203_p1 I1_ru11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2209_MP2 (XI1_I2209_p1 I1_nrk13 I1_nrkn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2209_MP0 (VDD I1_A_31_b3_7 XI1_I2209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2209_MP1 (XI1_I2209_p1 I1_ru13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2206_MP2 (XI1_I2206_p1 I1_nrk12 I1_nrkn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2206_MP0 (VDD I1_A_31_b3_7 XI1_I2206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2206_MP1 (XI1_I2206_p1 I1_ru12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I349_XG_MP2 (XI0_I1660_I349_XG_p1 I0_I1660_G38_31 I0_I1660_G38_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I349_XG_MP0 (VDD I0_I1660_P38_31 XI0_I1660_I349_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I349_XG_MP1 (XI0_I1660_I349_XG_p1 I0_I1660_G30_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I361_XG_MP2 (XI0_I1660_I361_XG_p1 I0_I1660_G50_43 I0_I1660_G50_35n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I361_XG_MP0 (VDD I0_I1660_P50_43 XI0_I1660_I361_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I361_XG_MP1 (XI0_I1660_I361_XG_p1 I0_I1660_G42_35 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I353_XG_MP2 (XI0_I1660_I353_XG_p1 I0_I1660_G42_35 I0_I1660_G42_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I353_XG_MP0 (VDD I0_I1660_P42_35 XI0_I1660_I353_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I353_XG_MP1 (XI0_I1660_I353_XG_p1 I0_I1660_G34_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I463_XG_MP2 (XI0_I1660_I463_XG_p1 I0_I1660_G60_29 I0_I1660_G60_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I463_XG_MP0 (VDD I0_I1660_P60_29 XI0_I1660_I463_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I463_XG_MP1 (XI0_I1660_I463_XG_p1 I0_I1660_G28_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I367_XG_MP2 (XI0_I1660_I367_XG_p1 I0_I1660_G56_49 I0_I1660_G56_41n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I367_XG_MP0 (VDD I0_I1660_P56_49 XI0_I1660_I367_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I367_XG_MP1 (XI0_I1660_I367_XG_p1 I0_I1660_G48_41 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I238_XG_MP2 (XI0_I1660_I238_XG_p1 I0_I1660_G46_45 I0_I1660_G46_43n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I238_XG_MP0 (VDD I0_I1660_P46_45 XI0_I1660_I238_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I238_XG_MP1 (XI0_I1660_I238_XG_p1 I0_I1660_G44_43 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I464_XG_MP2 (XI0_I1660_I464_XG_p1 I0_I1660_G61_30 I0_I1660_G61_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I464_XG_MP0 (VDD I0_I1660_P61_30 XI0_I1660_I464_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I464_XG_MP1 (XI0_I1660_I464_XG_p1 I0_I1660_G29_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I372_XG_MP2 (XI0_I1660_I372_XG_p1 I0_I1660_G61_54 I0_I1660_G61_46n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I372_XG_MP0 (VDD I0_I1660_P61_54 XI0_I1660_I372_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I372_XG_MP1 (XI0_I1660_I372_XG_p1 I0_I1660_G53_46 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I374_XG_MP2 (XI0_I1660_I374_XG_p1 I0_I1660_G63_56 I0_I1660_G63_48n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I374_XG_MP0 (VDD I0_I1660_P63_56 XI0_I1660_I374_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I374_XG_MP1 (XI0_I1660_I374_XG_p1 I0_I1660_G55_48 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I241_XG_MP2 (XI0_I1660_I241_XG_p1 I0_I1660_G49_48 I0_I1660_G49_46n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I241_XG_MP0 (VDD I0_I1660_P49_48 XI0_I1660_I241_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I241_XG_MP1 (XI0_I1660_I241_XG_p1 I0_I1660_G47_46 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I178_XG_MP2 (XI1_I1850_I178_XG_p1 I1_I1850_G27_20 I1_I1850_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I178_XG_MP0 (VDD I1_I1850_P27_20 XI1_I1850_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I178_XG_MP1 (XI1_I1850_I178_XG_p1 I1_I1850_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I180_XG_MP2 (XI1_I1850_I180_XG_p1 I1_I1850_G29_22 I1_I1850_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I180_XG_MP0 (VDD I1_I1850_P29_22 XI1_I1850_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I180_XG_MP1 (XI1_I1850_I180_XG_p1 I1_I1850_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I117_XG_MP2 (XI1_I1850_I117_XG_p1 I1_I1850_G21_20 I1_I1850_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I117_XG_MP0 (VDD I1_I1850_P21_20 XI1_I1850_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I117_XG_MP1 (XI1_I1850_I117_XG_p1 I1_I1850_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I171_XG_MP2 (XI1_I1850_I171_XG_p1 I1_I1850_G20_13 I1_I1850_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I171_XG_MP0 (VDD I1_I1850_P20_13 XI1_I1850_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I171_XG_MP1 (XI1_I1850_I171_XG_p1 I1_I1850_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I169_XG_MP2 (XI1_I1850_I169_XG_p1 I1_I1850_G18_11 I1_I1850_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I169_XG_MP0 (VDD I1_I1850_P18_11 XI1_I1850_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I169_XG_MP1 (XI1_I1850_I169_XG_p1 I1_I1850_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I117_XG_MP2 (XI1_I1896_I117_XG_p1 I1_I1896_G21_20 I1_I1896_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I117_XG_MP0 (VDD I1_I1896_P21_20 XI1_I1896_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I117_XG_MP1 (XI1_I1896_I117_XG_p1 I1_I1896_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I115_XG_MP2 (XI1_I1896_I115_XG_p1 I1_I1896_G19_18 I1_I1896_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I115_XG_MP0 (VDD I1_I1896_P19_18 XI1_I1896_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I115_XG_MP1 (XI1_I1896_I115_XG_p1 I1_I1896_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I178_XG_MP2 (XI1_I1896_I178_XG_p1 I1_I1896_G27_20 I1_I1896_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I178_XG_MP0 (VDD I1_I1896_P27_20 XI1_I1896_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I178_XG_MP1 (XI1_I1896_I178_XG_p1 I1_I1896_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I176_XG_MP2 (XI1_I1896_I176_XG_p1 I1_I1896_G25_18 I1_I1896_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I176_XG_MP0 (VDD I1_I1896_P25_18 XI1_I1896_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I176_XG_MP1 (XI1_I1896_I176_XG_p1 I1_I1896_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I116_XG_MP2 (XI1_I1896_I116_XG_p1 I1_I1896_G20_19 I1_I1896_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I116_XG_MP0 (VDD I1_I1896_P20_19 XI1_I1896_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I116_XG_MP1 (XI1_I1896_I116_XG_p1 I1_I1896_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I177_XG_MP2 (XI1_I1896_I177_XG_p1 I1_I1896_G26_19 I1_I1896_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I177_XG_MP0 (VDD I1_I1896_P26_19 XI1_I1896_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I177_XG_MP1 (XI1_I1896_I177_XG_p1 I1_I1896_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I175_XG_MP2 (XI1_I1896_I175_XG_p1 I1_I1896_G24_17 I1_I1896_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I175_XG_MP0 (VDD I1_I1896_P24_17 XI1_I1896_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I175_XG_MP1 (XI1_I1896_I175_XG_p1 I1_I1896_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I119_XG_MP2 (XI1_I1942_I119_XG_p1 I1_I1942_G23_22 I1_I1942_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I119_XG_MP0 (VDD I1_I1942_P23_22 XI1_I1942_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I119_XG_MP1 (XI1_I1942_I119_XG_p1 I1_I1942_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I174_XG_MP2 (XI1_I1942_I174_XG_p1 I1_I1942_G23_16 I1_I1942_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I174_XG_MP0 (VDD I1_I1942_P23_16 XI1_I1942_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I174_XG_MP1 (XI1_I1942_I174_XG_p1 I1_I1942_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I118_XG_MP2 (XI1_I1942_I118_XG_p1 I1_I1942_G22_21 I1_I1942_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I118_XG_MP0 (VDD I1_I1942_P22_21 XI1_I1942_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I118_XG_MP1 (XI1_I1942_I118_XG_p1 I1_I1942_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I119_XG_MP2 (XI1_I1988_I119_XG_p1 I1_I1988_G23_22 I1_I1988_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I119_XG_MP0 (VDD I1_I1988_P23_22 XI1_I1988_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I119_XG_MP1 (XI1_I1988_I119_XG_p1 I1_I1988_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I174_XG_MP2 (XI1_I1988_I174_XG_p1 I1_I1988_G23_16 I1_I1988_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I174_XG_MP0 (VDD I1_I1988_P23_16 XI1_I1988_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I174_XG_MP1 (XI1_I1988_I174_XG_p1 I1_I1988_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I179_XG_MP2 (XI1_I1988_I179_XG_p1 I1_I1988_G28_21 I1_I1988_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I179_XG_MP0 (VDD I1_I1988_P28_21 XI1_I1988_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I179_XG_MP1 (XI1_I1988_I179_XG_p1 I1_I1988_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I116_XG_MP2 (XI1_I2066_I116_XG_p1 I1_I2066_G20_19 I1_I2066_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I116_XG_MP0 (VDD I1_I2066_P20_19 XI1_I2066_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I116_XG_MP1 (XI1_I2066_I116_XG_p1 I1_I2066_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I179_XG_MP2 (XI1_I2066_I179_XG_p1 I1_I2066_G28_21 I1_I2066_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I179_XG_MP0 (VDD I1_I2066_P28_21 XI1_I2066_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I179_XG_MP1 (XI1_I2066_I179_XG_p1 I1_I2066_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I171_XG_MP2 (XI1_I2066_I171_XG_p1 I1_I2066_G20_13 I1_I2066_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I171_XG_MP0 (VDD I1_I2066_P20_13 XI1_I2066_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I171_XG_MP1 (XI1_I2066_I171_XG_p1 I1_I2066_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I115_XG_MP2 (XI1_I2066_I115_XG_p1 I1_I2066_G19_18 I1_I2066_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I115_XG_MP0 (VDD I1_I2066_P19_18 XI1_I2066_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I115_XG_MP1 (XI1_I2066_I115_XG_p1 I1_I2066_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I164_XG_MP2 (XI1_I2066_I164_XG_p1 I1_I2066_G13_6 I1_I2066_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I164_XG_MP0 (VDD I1_I2066_P13_6 XI1_I2066_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I164_XG_MP1 (XI1_I2066_I164_XG_p1 I1_I2066_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I170_XG_MP2 (XI1_I2066_I170_XG_p1 I1_I2066_G19_12 I1_I2066_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I170_XG_MP0 (VDD I1_I2066_P19_12 XI1_I2066_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I170_XG_MP1 (XI1_I2066_I170_XG_p1 I1_I2066_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2224_MP2 (XI1_I2224_p1 I1_nrk18 I1_nrkn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2224_MP0 (VDD I1_A_31_b3_8 XI1_I2224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2224_MP1 (XI1_I2224_p1 I1_ru18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2221_MP2 (XI1_I2221_p1 I1_nrk17 I1_nrkn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2221_MP0 (VDD I1_A_31_b3_8 XI1_I2221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2221_MP1 (XI1_I2221_p1 I1_ru17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I453_XG_MP2 (XI0_I1660_I453_XG_p1 I0_I1660_G50_19 I0_I1660_G50_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I453_XG_MP0 (VDD I0_I1660_P50_19 XI0_I1660_I453_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I453_XG_MP1 (XI0_I1660_I453_XG_p1 I0_I1660_G18_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I448_XG_MP2 (XI0_I1660_I448_XG_p1 I0_I1660_G46_15 I0_I1660_G46_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I448_XG_MP0 (VDD I0_I1660_P46_15 XI0_I1660_I448_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I448_XG_MP1 (XI0_I1660_I448_XG_p1 I0_I1660_G14_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I357_XG_MP2 (XI0_I1660_I357_XG_p1 I0_I1660_G46_39 I0_I1660_G46_31n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I357_XG_MP0 (VDD I0_I1660_P46_39 XI0_I1660_I357_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I357_XG_MP1 (XI0_I1660_I357_XG_p1 I0_I1660_G38_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I371_XG_MP2 (XI0_I1660_I371_XG_p1 I0_I1660_G60_53 I0_I1660_G60_45n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I371_XG_MP0 (VDD I0_I1660_P60_53 XI0_I1660_I371_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I371_XG_MP1 (XI0_I1660_I371_XG_p1 I0_I1660_G52_45 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I240_XG_MP2 (XI0_I1660_I240_XG_p1 I0_I1660_G48_47 I0_I1660_G48_45n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I240_XG_MP0 (VDD I0_I1660_P48_47 XI0_I1660_I240_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I240_XG_MP1 (XI0_I1660_I240_XG_p1 I0_I1660_G46_45 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I242_XG_MP2 (XI0_I1660_I242_XG_p1 I0_I1660_G50_49 I0_I1660_G50_47n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I242_XG_MP0 (VDD I0_I1660_P50_49 XI0_I1660_I242_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I242_XG_MP1 (XI0_I1660_I242_XG_p1 I0_I1660_G48_47 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I243_XG_MP2 (XI0_I1660_I243_XG_p1 I0_I1660_G51_50 I0_I1660_G51_48n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I243_XG_MP0 (VDD I0_I1660_P51_50 XI0_I1660_I243_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I243_XG_MP1 (XI0_I1660_I243_XG_p1 I0_I1660_G49_48 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I119_XG_MP2 (XI1_I1850_I119_XG_p1 I1_I1850_G23_22 I1_I1850_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I119_XG_MP0 (VDD I1_I1850_P23_22 XI1_I1850_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I119_XG_MP1 (XI1_I1850_I119_XG_p1 I1_I1850_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I121_XG_MP2 (XI1_I1850_I121_XG_p1 I1_I1850_G25_24 I1_I1850_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I121_XG_MP0 (VDD I1_I1850_P25_24 XI1_I1850_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I121_XG_MP1 (XI1_I1850_I121_XG_p1 I1_I1850_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I116_XG_MP2 (XI1_I1850_I116_XG_p1 I1_I1850_G20_19 I1_I1850_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I116_XG_MP0 (VDD I1_I1850_P20_19 XI1_I1850_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I116_XG_MP1 (XI1_I1850_I116_XG_p1 I1_I1850_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I165_XG_MP2 (XI1_I1850_I165_XG_p1 I1_I1850_G14_7 I1_I1850_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I165_XG_MP0 (VDD I1_I1850_P14_7 XI1_I1850_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I165_XG_MP1 (XI1_I1850_I165_XG_p1 I1_I1850_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I175_XG_MP2 (XI1_I1850_I175_XG_p1 I1_I1850_G24_17 I1_I1850_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I175_XG_MP0 (VDD I1_I1850_P24_17 XI1_I1850_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I175_XG_MP1 (XI1_I1850_I175_XG_p1 I1_I1850_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I119_XG_MP2 (XI1_I1896_I119_XG_p1 I1_I1896_G23_22 I1_I1896_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I119_XG_MP0 (VDD I1_I1896_P23_22 XI1_I1896_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I119_XG_MP1 (XI1_I1896_I119_XG_p1 I1_I1896_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I166_XG_MP2 (XI1_I1896_I166_XG_p1 I1_I1896_G15_8 I1_I1896_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I166_XG_MP0 (VDD I1_I1896_P15_8 XI1_I1896_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I166_XG_MP1 (XI1_I1896_I166_XG_p1 I1_I1896_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I165_XG_MP2 (XI1_I1896_I165_XG_p1 I1_I1896_G14_7 I1_I1896_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I165_XG_MP0 (VDD I1_I1896_P14_7 XI1_I1896_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I165_XG_MP1 (XI1_I1896_I165_XG_p1 I1_I1896_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I121_XG_MP2 (XI1_I1942_I121_XG_p1 I1_I1942_G25_24 I1_I1942_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I121_XG_MP0 (VDD I1_I1942_P25_24 XI1_I1942_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I121_XG_MP1 (XI1_I1942_I121_XG_p1 I1_I1942_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I180_XG_MP2 (XI1_I1942_I180_XG_p1 I1_I1942_G29_22 I1_I1942_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I180_XG_MP0 (VDD I1_I1942_P29_22 XI1_I1942_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I180_XG_MP1 (XI1_I1942_I180_XG_p1 I1_I1942_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I120_XG_MP2 (XI1_I1942_I120_XG_p1 I1_I1942_G24_23 I1_I1942_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I120_XG_MP0 (VDD I1_I1942_P24_23 XI1_I1942_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I120_XG_MP1 (XI1_I1942_I120_XG_p1 I1_I1942_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I179_XG_MP2 (XI1_I1942_I179_XG_p1 I1_I1942_G28_21 I1_I1942_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I179_XG_MP0 (VDD I1_I1942_P28_21 XI1_I1942_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I179_XG_MP1 (XI1_I1942_I179_XG_p1 I1_I1942_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I121_XG_MP2 (XI1_I1988_I121_XG_p1 I1_I1988_G25_24 I1_I1988_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I121_XG_MP0 (VDD I1_I1988_P25_24 XI1_I1988_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I121_XG_MP1 (XI1_I1988_I121_XG_p1 I1_I1988_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I180_XG_MP2 (XI1_I1988_I180_XG_p1 I1_I1988_G29_22 I1_I1988_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I180_XG_MP0 (VDD I1_I1988_P29_22 XI1_I1988_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I180_XG_MP1 (XI1_I1988_I180_XG_p1 I1_I1988_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I120_XG_MP2 (XI1_I1988_I120_XG_p1 I1_I1988_G24_23 I1_I1988_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I120_XG_MP0 (VDD I1_I1988_P24_23 XI1_I1988_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I120_XG_MP1 (XI1_I1988_I120_XG_p1 I1_I1988_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I177_XG_MP2 (XI1_I2066_I177_XG_p1 I1_I2066_G26_19 I1_I2066_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I177_XG_MP0 (VDD I1_I2066_P26_19 XI1_I2066_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I177_XG_MP1 (XI1_I2066_I177_XG_p1 I1_I2066_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I165_XG_MP2 (XI1_I2066_I165_XG_p1 I1_I2066_G14_7 I1_I2066_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I165_XG_MP0 (VDD I1_I2066_P14_7 XI1_I2066_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I165_XG_MP1 (XI1_I2066_I165_XG_p1 I1_I2066_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I117_XG_MP2 (XI1_I2066_I117_XG_p1 I1_I2066_G21_20 I1_I2066_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I117_XG_MP0 (VDD I1_I2066_P21_20 XI1_I2066_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I117_XG_MP1 (XI1_I2066_I117_XG_p1 I1_I2066_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I172_XG_MP2 (XI1_I2066_I172_XG_p1 I1_I2066_G21_14 I1_I2066_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I172_XG_MP0 (VDD I1_I2066_P21_14 XI1_I2066_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I172_XG_MP1 (XI1_I2066_I172_XG_p1 I1_I2066_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I166_XG_MP2 (XI1_I2066_I166_XG_p1 I1_I2066_G15_8 I1_I2066_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I166_XG_MP0 (VDD I1_I2066_P15_8 XI1_I2066_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I166_XG_MP1 (XI1_I2066_I166_XG_p1 I1_I2066_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2212_MP2 (XI1_I2212_p1 I1_nrk14 I1_nrkn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2212_MP0 (VDD I1_A_31_b3_8 XI1_I2212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2212_MP1 (XI1_I2212_p1 I1_ru14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2227_MP2 (XI1_I2227_p1 I1_nrk19 I1_nrkn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2227_MP0 (VDD I1_A_31_b3_8 XI1_I2227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2227_MP1 (XI1_I2227_p1 I1_ru19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2215_MP2 (XI1_I2215_p1 I1_nrk15 I1_nrkn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2215_MP0 (VDD I1_A_31_b3_8 XI1_I2215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2215_MP1 (XI1_I2215_p1 I1_ru15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2218_MP2 (XI1_I2218_p1 I1_nrk16 I1_nrkn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2218_MP0 (VDD I1_A_31_b3_8 XI1_I2218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2218_MP1 (XI1_I2218_p1 I1_ru16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I461_XG_MP2 (XI0_I1660_I461_XG_p1 I0_I1660_G58_27 I0_I1660_G58_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I461_XG_MP0 (VDD I0_I1660_P58_27 XI0_I1660_I461_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I461_XG_MP1 (XI0_I1660_I461_XG_p1 I0_I1660_G26_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I369_XG_MP2 (XI0_I1660_I369_XG_p1 I0_I1660_G58_51 I0_I1660_G58_43n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I369_XG_MP0 (VDD I0_I1660_P58_51 XI0_I1660_I369_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I369_XG_MP1 (XI0_I1660_I369_XG_p1 I0_I1660_G50_43 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I244_XG_MP2 (XI0_I1660_I244_XG_p1 I0_I1660_G52_51 I0_I1660_G52_49n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I244_XG_MP0 (VDD I0_I1660_P52_51 XI0_I1660_I244_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I244_XG_MP1 (XI0_I1660_I244_XG_p1 I0_I1660_G50_49 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I247_XG_MP2 (XI0_I1660_I247_XG_p1 I0_I1660_G55_54 I0_I1660_G55_52n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I247_XG_MP0 (VDD I0_I1660_P55_54 XI0_I1660_I247_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I247_XG_MP1 (XI0_I1660_I247_XG_p1 I0_I1660_G53_52 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I245_XG_MP2 (XI0_I1660_I245_XG_p1 I0_I1660_G53_52 I0_I1660_G53_50n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I245_XG_MP0 (VDD I0_I1660_P53_52 XI0_I1660_I245_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I245_XG_MP1 (XI0_I1660_I245_XG_p1 I0_I1660_G51_50 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I127_XG_MP2 (XI1_I1850_I127_XG_p1 I1_I1850_G31_30 I1_I1850_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I127_XG_MP0 (VDD I1_I1850_P31_30 XI1_I1850_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I127_XG_MP1 (XI1_I1850_I127_XG_p1 I1_I1850_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I120_XG_MP2 (XI1_I1850_I120_XG_p1 I1_I1850_G24_23 I1_I1850_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I120_XG_MP0 (VDD I1_I1850_P24_23 XI1_I1850_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I120_XG_MP1 (XI1_I1850_I120_XG_p1 I1_I1850_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I118_XG_MP2 (XI1_I1850_I118_XG_p1 I1_I1850_G22_21 I1_I1850_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I118_XG_MP0 (VDD I1_I1850_P22_21 XI1_I1850_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I118_XG_MP1 (XI1_I1850_I118_XG_p1 I1_I1850_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I177_XG_MP2 (XI1_I1850_I177_XG_p1 I1_I1850_G26_19 I1_I1850_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I177_XG_MP0 (VDD I1_I1850_P26_19 XI1_I1850_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I177_XG_MP1 (XI1_I1850_I177_XG_p1 I1_I1850_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I173_XG_MP2 (XI1_I1850_I173_XG_p1 I1_I1850_G22_15 I1_I1850_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I173_XG_MP0 (VDD I1_I1850_P22_15 XI1_I1850_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I173_XG_MP1 (XI1_I1850_I173_XG_p1 I1_I1850_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I121_XG_MP2 (XI1_I1896_I121_XG_p1 I1_I1896_G25_24 I1_I1896_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I121_XG_MP0 (VDD I1_I1896_P25_24 XI1_I1896_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I121_XG_MP1 (XI1_I1896_I121_XG_p1 I1_I1896_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I174_XG_MP2 (XI1_I1896_I174_XG_p1 I1_I1896_G23_16 I1_I1896_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I174_XG_MP0 (VDD I1_I1896_P23_16 XI1_I1896_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I174_XG_MP1 (XI1_I1896_I174_XG_p1 I1_I1896_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I118_XG_MP2 (XI1_I1896_I118_XG_p1 I1_I1896_G22_21 I1_I1896_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I118_XG_MP0 (VDD I1_I1896_P22_21 XI1_I1896_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I118_XG_MP1 (XI1_I1896_I118_XG_p1 I1_I1896_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I120_XG_MP2 (XI1_I1896_I120_XG_p1 I1_I1896_G24_23 I1_I1896_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I120_XG_MP0 (VDD I1_I1896_P24_23 XI1_I1896_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I120_XG_MP1 (XI1_I1896_I120_XG_p1 I1_I1896_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I173_XG_MP2 (XI1_I1896_I173_XG_p1 I1_I1896_G22_15 I1_I1896_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I173_XG_MP0 (VDD I1_I1896_P22_15 XI1_I1896_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I173_XG_MP1 (XI1_I1896_I173_XG_p1 I1_I1896_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I182_XG_MP2 (XI1_I1942_I182_XG_p1 I1_I1942_G31_24 I1_I1942_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I182_XG_MP0 (VDD I1_I1942_P31_24 XI1_I1942_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I182_XG_MP1 (XI1_I1942_I182_XG_p1 I1_I1942_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I181_XG_MP2 (XI1_I1942_I181_XG_p1 I1_I1942_G30_23 I1_I1942_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I181_XG_MP0 (VDD I1_I1942_P30_23 XI1_I1942_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I181_XG_MP1 (XI1_I1942_I181_XG_p1 I1_I1942_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I182_XG_MP2 (XI1_I1988_I182_XG_p1 I1_I1988_G31_24 I1_I1988_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I182_XG_MP0 (VDD I1_I1988_P31_24 XI1_I1988_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I182_XG_MP1 (XI1_I1988_I182_XG_p1 I1_I1988_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I122_XG_MP2 (XI1_I1988_I122_XG_p1 I1_I1988_G26_25 I1_I1988_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I122_XG_MP0 (VDD I1_I1988_P26_25 XI1_I1988_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I122_XG_MP1 (XI1_I1988_I122_XG_p1 I1_I1988_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I181_XG_MP2 (XI1_I1988_I181_XG_p1 I1_I1988_G30_23 I1_I1988_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I181_XG_MP0 (VDD I1_I1988_P30_23 XI1_I1988_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I181_XG_MP1 (XI1_I1988_I181_XG_p1 I1_I1988_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I120_XG_MP2 (XI1_I2066_I120_XG_p1 I1_I2066_G24_23 I1_I2066_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I120_XG_MP0 (VDD I1_I2066_P24_23 XI1_I2066_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I120_XG_MP1 (XI1_I2066_I120_XG_p1 I1_I2066_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I118_XG_MP2 (XI1_I2066_I118_XG_p1 I1_I2066_G22_21 I1_I2066_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I118_XG_MP0 (VDD I1_I2066_P22_21 XI1_I2066_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I118_XG_MP1 (XI1_I2066_I118_XG_p1 I1_I2066_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I173_XG_MP2 (XI1_I2066_I173_XG_p1 I1_I2066_G22_15 I1_I2066_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I173_XG_MP0 (VDD I1_I2066_P22_15 XI1_I2066_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I173_XG_MP1 (XI1_I2066_I173_XG_p1 I1_I2066_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I119_XG_MP2 (XI1_I2066_I119_XG_p1 I1_I2066_G23_22 I1_I2066_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I119_XG_MP0 (VDD I1_I2066_P23_22 XI1_I2066_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I119_XG_MP1 (XI1_I2066_I119_XG_p1 I1_I2066_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I178_XG_MP2 (XI1_I2066_I178_XG_p1 I1_I2066_G27_20 I1_I2066_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I178_XG_MP0 (VDD I1_I2066_P27_20 XI1_I2066_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I178_XG_MP1 (XI1_I2066_I178_XG_p1 I1_I2066_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2233_MP2 (XI1_I2233_p1 I1_nrk21 I1_nrkn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2233_MP0 (VDD I1_A_31_b3_9 XI1_I2233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2233_MP1 (XI1_I2233_p1 I1_ru21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2230_MP2 (XI1_I2230_p1 I1_nrk20 I1_nrkn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2230_MP0 (VDD I1_A_31_b3_9 XI1_I2230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2230_MP1 (XI1_I2230_p1 I1_ru20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I457_XG_MP2 (XI0_I1660_I457_XG_p1 I0_I1660_G54_23 I0_I1660_G54_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I457_XG_MP0 (VDD I0_I1660_P54_23 XI0_I1660_I457_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I457_XG_MP1 (XI0_I1660_I457_XG_p1 I0_I1660_G22_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I465_XG_MP2 (XI0_I1660_I465_XG_p1 I0_I1660_G62_31 I0_I1660_G62_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I465_XG_MP0 (VDD I0_I1660_P62_31 XI0_I1660_I465_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I465_XG_MP1 (XI0_I1660_I465_XG_p1 I0_I1660_G30_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I365_XG_MP2 (XI0_I1660_I365_XG_p1 I0_I1660_G54_47 I0_I1660_G54_39n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I365_XG_MP0 (VDD I0_I1660_P54_47 XI0_I1660_I365_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I365_XG_MP1 (XI0_I1660_I365_XG_p1 I0_I1660_G46_39 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I246_XG_MP2 (XI0_I1660_I246_XG_p1 I0_I1660_G54_53 I0_I1660_G54_51n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I246_XG_MP0 (VDD I0_I1660_P54_53 XI0_I1660_I246_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I246_XG_MP1 (XI0_I1660_I246_XG_p1 I0_I1660_G52_51 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I251_XG_MP2 (XI0_I1660_I251_XG_p1 I0_I1660_G59_58 I0_I1660_G59_56n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I251_XG_MP0 (VDD I0_I1660_P59_58 XI0_I1660_I251_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I251_XG_MP1 (XI0_I1660_I251_XG_p1 I0_I1660_G57_56 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I249_XG_MP2 (XI0_I1660_I249_XG_p1 I0_I1660_G57_56 I0_I1660_G57_54n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I249_XG_MP0 (VDD I0_I1660_P57_56 XI0_I1660_I249_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I249_XG_MP1 (XI0_I1660_I249_XG_p1 I0_I1660_G55_54 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I124_XG_MP2 (XI1_I1850_I124_XG_p1 I1_I1850_G28_27 I1_I1850_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I124_XG_MP0 (VDD I1_I1850_P28_27 XI1_I1850_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I124_XG_MP1 (XI1_I1850_I124_XG_p1 I1_I1850_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I122_XG_MP2 (XI1_I1850_I122_XG_p1 I1_I1850_G26_25 I1_I1850_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I122_XG_MP0 (VDD I1_I1850_P26_25 XI1_I1850_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I122_XG_MP1 (XI1_I1850_I122_XG_p1 I1_I1850_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I179_XG_MP2 (XI1_I1850_I179_XG_p1 I1_I1850_G28_21 I1_I1850_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I179_XG_MP0 (VDD I1_I1850_P28_21 XI1_I1850_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I179_XG_MP1 (XI1_I1850_I179_XG_p1 I1_I1850_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I123_XG_MP2 (XI1_I1896_I123_XG_p1 I1_I1896_G27_26 I1_I1896_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I123_XG_MP0 (VDD I1_I1896_P27_26 XI1_I1896_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I123_XG_MP1 (XI1_I1896_I123_XG_p1 I1_I1896_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I180_XG_MP2 (XI1_I1896_I180_XG_p1 I1_I1896_G29_22 I1_I1896_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I180_XG_MP0 (VDD I1_I1896_P29_22 XI1_I1896_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I180_XG_MP1 (XI1_I1896_I180_XG_p1 I1_I1896_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I179_XG_MP2 (XI1_I1896_I179_XG_p1 I1_I1896_G28_21 I1_I1896_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I179_XG_MP0 (VDD I1_I1896_P28_21 XI1_I1896_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I179_XG_MP1 (XI1_I1896_I179_XG_p1 I1_I1896_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I123_XG_MP2 (XI1_I1942_I123_XG_p1 I1_I1942_G27_26 I1_I1942_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I123_XG_MP0 (VDD I1_I1942_P27_26 XI1_I1942_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I123_XG_MP1 (XI1_I1942_I123_XG_p1 I1_I1942_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I122_XG_MP2 (XI1_I1942_I122_XG_p1 I1_I1942_G26_25 I1_I1942_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I122_XG_MP0 (VDD I1_I1942_P26_25 XI1_I1942_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I122_XG_MP1 (XI1_I1942_I122_XG_p1 I1_I1942_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I124_XG_MP2 (XI1_I1942_I124_XG_p1 I1_I1942_G28_27 I1_I1942_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I124_XG_MP0 (VDD I1_I1942_P28_27 XI1_I1942_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I124_XG_MP1 (XI1_I1942_I124_XG_p1 I1_I1942_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I123_XG_MP2 (XI1_I1988_I123_XG_p1 I1_I1988_G27_26 I1_I1988_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I123_XG_MP0 (VDD I1_I1988_P27_26 XI1_I1988_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I123_XG_MP1 (XI1_I1988_I123_XG_p1 I1_I1988_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I124_XG_MP2 (XI1_I1988_I124_XG_p1 I1_I1988_G28_27 I1_I1988_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I124_XG_MP0 (VDD I1_I1988_P28_27 XI1_I1988_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I124_XG_MP1 (XI1_I1988_I124_XG_p1 I1_I1988_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I122_XG_MP2 (XI1_I2066_I122_XG_p1 I1_I2066_G26_25 I1_I2066_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I122_XG_MP0 (VDD I1_I2066_P26_25 XI1_I2066_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I122_XG_MP1 (XI1_I2066_I122_XG_p1 I1_I2066_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I181_XG_MP2 (XI1_I2066_I181_XG_p1 I1_I2066_G30_23 I1_I2066_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I181_XG_MP0 (VDD I1_I2066_P30_23 XI1_I2066_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I181_XG_MP1 (XI1_I2066_I181_XG_p1 I1_I2066_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I121_XG_MP2 (XI1_I2066_I121_XG_p1 I1_I2066_G25_24 I1_I2066_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I121_XG_MP0 (VDD I1_I2066_P25_24 XI1_I2066_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I121_XG_MP1 (XI1_I2066_I121_XG_p1 I1_I2066_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I180_XG_MP2 (XI1_I2066_I180_XG_p1 I1_I2066_G29_22 I1_I2066_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I180_XG_MP0 (VDD I1_I2066_P29_22 XI1_I2066_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I180_XG_MP1 (XI1_I2066_I180_XG_p1 I1_I2066_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I174_XG_MP2 (XI1_I2066_I174_XG_p1 I1_I2066_G23_16 I1_I2066_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I174_XG_MP0 (VDD I1_I2066_P23_16 XI1_I2066_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I174_XG_MP1 (XI1_I2066_I174_XG_p1 I1_I2066_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2236_MP2 (XI1_I2236_p1 I1_nrk22 I1_nrkn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2236_MP0 (VDD I1_A_31_b3_9 XI1_I2236_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2236_MP1 (XI1_I2236_p1 I1_ru22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2239_MP2 (XI1_I2239_p1 I1_nrk23 I1_nrkn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2239_MP0 (VDD I1_A_31_b3_9 XI1_I2239_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2239_MP1 (XI1_I2239_p1 I1_ru23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2242_MP2 (XI1_I2242_p1 I1_nrk24 I1_nrkn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2242_MP0 (VDD I1_A_31_b3_9 XI1_I2242_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2242_MP1 (XI1_I2242_p1 I1_ru24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2245_MP2 (XI1_I2245_p1 I1_nrk25 I1_nrkn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2245_MP0 (VDD I1_A_31_b3_9 XI1_I2245_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2245_MP1 (XI1_I2245_p1 I1_ru25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I373_XG_MP2 (XI0_I1660_I373_XG_p1 I0_I1660_G62_55 I0_I1660_G62_47n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I373_XG_MP0 (VDD I0_I1660_P62_55 XI0_I1660_I373_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I373_XG_MP1 (XI0_I1660_I373_XG_p1 I0_I1660_G54_47 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I250_XG_MP2 (XI0_I1660_I250_XG_p1 I0_I1660_G58_57 I0_I1660_G58_55n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I250_XG_MP0 (VDD I0_I1660_P58_57 XI0_I1660_I250_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I250_XG_MP1 (XI0_I1660_I250_XG_p1 I0_I1660_G56_55 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I248_XG_MP2 (XI0_I1660_I248_XG_p1 I0_I1660_G56_55 I0_I1660_G56_53n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I248_XG_MP0 (VDD I0_I1660_P56_55 XI0_I1660_I248_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I248_XG_MP1 (XI0_I1660_I248_XG_p1 I0_I1660_G54_53 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I253_XG_MP2 (XI0_I1660_I253_XG_p1 I0_I1660_G61_60 I0_I1660_G61_58n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I253_XG_MP0 (VDD I0_I1660_P61_60 XI0_I1660_I253_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I253_XG_MP1 (XI0_I1660_I253_XG_p1 I0_I1660_G59_58 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I126_XG_MP2 (XI1_I1850_I126_XG_p1 I1_I1850_G30_29 I1_I1850_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I126_XG_MP0 (VDD I1_I1850_P30_29 XI1_I1850_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I126_XG_MP1 (XI1_I1850_I126_XG_p1 I1_I1850_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I181_XG_MP2 (XI1_I1850_I181_XG_p1 I1_I1850_G30_23 I1_I1850_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I181_XG_MP0 (VDD I1_I1850_P30_23 XI1_I1850_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I181_XG_MP1 (XI1_I1850_I181_XG_p1 I1_I1850_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I125_XG_MP2 (XI1_I1896_I125_XG_p1 I1_I1896_G29_28 I1_I1896_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I125_XG_MP0 (VDD I1_I1896_P29_28 XI1_I1896_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I125_XG_MP1 (XI1_I1896_I125_XG_p1 I1_I1896_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I182_XG_MP2 (XI1_I1896_I182_XG_p1 I1_I1896_G31_24 I1_I1896_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I182_XG_MP0 (VDD I1_I1896_P31_24 XI1_I1896_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I182_XG_MP1 (XI1_I1896_I182_XG_p1 I1_I1896_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I124_XG_MP2 (XI1_I1896_I124_XG_p1 I1_I1896_G28_27 I1_I1896_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I124_XG_MP0 (VDD I1_I1896_P28_27 XI1_I1896_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I124_XG_MP1 (XI1_I1896_I124_XG_p1 I1_I1896_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I122_XG_MP2 (XI1_I1896_I122_XG_p1 I1_I1896_G26_25 I1_I1896_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I122_XG_MP0 (VDD I1_I1896_P26_25 XI1_I1896_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I122_XG_MP1 (XI1_I1896_I122_XG_p1 I1_I1896_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I181_XG_MP2 (XI1_I1896_I181_XG_p1 I1_I1896_G30_23 I1_I1896_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I181_XG_MP0 (VDD I1_I1896_P30_23 XI1_I1896_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I181_XG_MP1 (XI1_I1896_I181_XG_p1 I1_I1896_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I125_XG_MP2 (XI1_I1942_I125_XG_p1 I1_I1942_G29_28 I1_I1942_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I125_XG_MP0 (VDD I1_I1942_P29_28 XI1_I1942_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I125_XG_MP1 (XI1_I1942_I125_XG_p1 I1_I1942_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I127_XG_MP2 (XI1_I1942_I127_XG_p1 I1_I1942_G31_30 I1_I1942_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I127_XG_MP0 (VDD I1_I1942_P31_30 XI1_I1942_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I127_XG_MP1 (XI1_I1942_I127_XG_p1 I1_I1942_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I126_XG_MP2 (XI1_I1942_I126_XG_p1 I1_I1942_G30_29 I1_I1942_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I126_XG_MP0 (VDD I1_I1942_P30_29 XI1_I1942_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I126_XG_MP1 (XI1_I1942_I126_XG_p1 I1_I1942_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I125_XG_MP2 (XI1_I1988_I125_XG_p1 I1_I1988_G29_28 I1_I1988_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I125_XG_MP0 (VDD I1_I1988_P29_28 XI1_I1988_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I125_XG_MP1 (XI1_I1988_I125_XG_p1 I1_I1988_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I127_XG_MP2 (XI1_I1988_I127_XG_p1 I1_I1988_G31_30 I1_I1988_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I127_XG_MP0 (VDD I1_I1988_P31_30 XI1_I1988_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I127_XG_MP1 (XI1_I1988_I127_XG_p1 I1_I1988_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I126_XG_MP2 (XI1_I1988_I126_XG_p1 I1_I1988_G30_29 I1_I1988_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I126_XG_MP0 (VDD I1_I1988_P30_29 XI1_I1988_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I126_XG_MP1 (XI1_I1988_I126_XG_p1 I1_I1988_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I124_XG_MP2 (XI1_I2066_I124_XG_p1 I1_I2066_G28_27 I1_I2066_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I124_XG_MP0 (VDD I1_I2066_P28_27 XI1_I2066_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I124_XG_MP1 (XI1_I2066_I124_XG_p1 I1_I2066_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I125_XG_MP2 (XI1_I2066_I125_XG_p1 I1_I2066_G29_28 I1_I2066_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I125_XG_MP0 (VDD I1_I2066_P29_28 XI1_I2066_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I125_XG_MP1 (XI1_I2066_I125_XG_p1 I1_I2066_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I123_XG_MP2 (XI1_I2066_I123_XG_p1 I1_I2066_G27_26 I1_I2066_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I123_XG_MP0 (VDD I1_I2066_P27_26 XI1_I2066_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I123_XG_MP1 (XI1_I2066_I123_XG_p1 I1_I2066_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I182_XG_MP2 (XI1_I2066_I182_XG_p1 I1_I2066_G31_24 I1_I2066_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I182_XG_MP0 (VDD I1_I2066_P31_24 XI1_I2066_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I182_XG_MP1 (XI1_I2066_I182_XG_p1 I1_I2066_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2248_MP2 (XI1_I2248_p1 I1_nrk26 I1_nrkn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2248_MP0 (VDD I1_A_31_b3_10 XI1_I2248_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2248_MP1 (XI1_I2248_p1 I1_ru26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I254_XG_MP2 (XI0_I1660_I254_XG_p1 I0_I1660_G62_61 I0_I1660_G62_59n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I254_XG_MP0 (VDD I0_I1660_P62_61 XI0_I1660_I254_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I254_XG_MP1 (XI0_I1660_I254_XG_p1 I0_I1660_G60_59 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I252_XG_MP2 (XI0_I1660_I252_XG_p1 I0_I1660_G60_59 I0_I1660_G60_57n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I252_XG_MP0 (VDD I0_I1660_P60_59 XI0_I1660_I252_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I252_XG_MP1 (XI0_I1660_I252_XG_p1 I0_I1660_G58_57 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I255_XG_MP2 (XI0_I1660_I255_XG_p1 I0_I1660_G63_62 I0_I1660_G63_60n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I255_XG_MP0 (VDD I0_I1660_P63_62 XI0_I1660_I255_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I255_XG_MP1 (XI0_I1660_I255_XG_p1 I0_I1660_G61_60 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I127_XG_MP2 (XI1_I1896_I127_XG_p1 I1_I1896_G31_30 I1_I1896_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I127_XG_MP0 (VDD I1_I1896_P31_30 XI1_I1896_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I127_XG_MP1 (XI1_I1896_I127_XG_p1 I1_I1896_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I126_XG_MP2 (XI1_I1896_I126_XG_p1 I1_I1896_G30_29 I1_I1896_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I126_XG_MP0 (VDD I1_I1896_P30_29 XI1_I1896_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I126_XG_MP1 (XI1_I1896_I126_XG_p1 I1_I1896_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I126_XG_MP2 (XI1_I2066_I126_XG_p1 I1_I2066_G30_29 I1_I2066_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I126_XG_MP0 (VDD I1_I2066_P30_29 XI1_I2066_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I126_XG_MP1 (XI1_I2066_I126_XG_p1 I1_I2066_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I127_XG_MP2 (XI1_I2066_I127_XG_p1 I1_I2066_G31_30 I1_I2066_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I127_XG_MP0 (VDD I1_I2066_P31_30 XI1_I2066_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I127_XG_MP1 (XI1_I2066_I127_XG_p1 I1_I2066_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2260_MP2 (XI1_I2260_p1 I1_nrk30 I1_nrkn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2260_MP0 (VDD I1_A_31_b3_10 XI1_I2260_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2260_MP1 (XI1_I2260_p1 I1_ru30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2257_MP2 (XI1_I2257_p1 I1_nrk29 I1_nrkn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2257_MP0 (VDD I1_A_31_b3_10 XI1_I2257_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2257_MP1 (XI1_I2257_p1 I1_ru29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2254_MP2 (XI1_I2254_p1 I1_nrk28 I1_nrkn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2254_MP0 (VDD I1_A_31_b3_10 XI1_I2254_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2254_MP1 (XI1_I2254_p1 I1_ru28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2251_MP2 (XI1_I2251_p1 I1_nrk27 I1_nrkn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2251_MP0 (VDD I1_A_31_b3_10 XI1_I2251_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2251_MP1 (XI1_I2251_p1 I1_ru27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1501_MP24 (XI0_I1501_sn I0_fa9_0 XI0_I1501_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1501_MP26 (VDD XI0_I1501_sn I0_fa140_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1501_MP17 (XI0_I1501_con I0_fa9_0 XI0_I1501_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1501_MP14 (XI0_I1501_p1 I0_cm8_0 XI0_I1501_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1501_MP13 (VDD I0_cm7_1 XI0_I1501_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1501_MP15 (XI0_I1501_p2 I0_cm7_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1501_MP16 (VDD I0_cm8_0 XI0_I1501_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1501_MP28 (I0_fa140_1 XI0_I1501_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1501_MP22 (XI0_I1501_p4 I0_cm7_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1501_MP23 (XI0_I1501_p5 I0_cm8_0 XI0_I1501_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1501_MP23_1 (XI0_I1501_p4 I0_cm8_0 XI0_I1501_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1501_MP22_1 (VDD I0_cm7_1 XI0_I1501_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1501_MP19 (XI0_I1501_p3 I0_cm8_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1501_MP18 (VDD I0_cm7_1 XI0_I1501_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1501_MP20 (XI0_I1501_p3 I0_fa9_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1501_MP21 (XI0_I1501_sn XI0_I1501_con XI0_I1501_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1501_MP24_1 (XI0_I1501_p5 I0_fa9_0 XI0_I1501_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1370_MP24 (XI0_I1370_sn I0_B_11_b3_5 XI0_I1370_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1370_MP26 (VDD XI0_I1370_sn I0_fa9_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1370_MP17 (XI0_I1370_con I0_B_11_b3_5 XI0_I1370_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1370_MP14 (XI0_I1370_p1 I0_pp5_0 XI0_I1370_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1370_MP13 (VDD I0_pp4_2 XI0_I1370_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1370_MP15 (XI0_I1370_p2 I0_pp4_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1370_MP16 (VDD I0_pp5_0 XI0_I1370_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1370_MP28 (I0_fa9_1 XI0_I1370_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1370_MP22 (XI0_I1370_p4 I0_pp4_2 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1370_MP23 (XI0_I1370_p5 I0_pp5_0 XI0_I1370_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1370_MP23_1 (XI0_I1370_p4 I0_pp5_0 XI0_I1370_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1370_MP22_1 (VDD I0_pp4_2 XI0_I1370_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1370_MP19 (XI0_I1370_p3 I0_pp5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1370_MP18 (VDD I0_pp4_2 XI0_I1370_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1370_MP20 (XI0_I1370_p3 I0_B_11_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1370_MP21 (XI0_I1370_sn XI0_I1370_con XI0_I1370_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1370_MP24_1 (XI0_I1370_p5 I0_B_11_b3_5 XI0_I1370_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1521_MP24 (XI0_I1521_sn I0_fa49_0 XI0_I1521_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1521_MP26 (VDD XI0_I1521_sn I0_fa160_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1521_MP17 (XI0_I1521_con I0_fa49_0 XI0_I1521_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1521_MP14 (XI0_I1521_p1 I0_cm48_0 XI0_I1521_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1521_MP13 (VDD I0_cm47_0 XI0_I1521_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1521_MP15 (XI0_I1521_p2 I0_cm47_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1521_MP16 (VDD I0_cm48_0 XI0_I1521_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1521_MP28 (I0_fa160_1 XI0_I1521_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1521_MP22 (XI0_I1521_p4 I0_cm47_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1521_MP23 (XI0_I1521_p5 I0_cm48_0 XI0_I1521_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1521_MP23_1 (XI0_I1521_p4 I0_cm48_0 XI0_I1521_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1521_MP22_1 (VDD I0_cm47_0 XI0_I1521_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1521_MP19 (XI0_I1521_p3 I0_cm48_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1521_MP18 (VDD I0_cm47_0 XI0_I1521_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1521_MP20 (XI0_I1521_p3 I0_fa49_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1521_MP21 (XI0_I1521_sn XI0_I1521_con XI0_I1521_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1521_MP24_1 (XI0_I1521_p5 I0_fa49_0 XI0_I1521_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1499_MP24 (XI0_I1499_sn I0_pp4_0 XI0_I1499_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1499_MP26 (VDD XI0_I1499_sn I0_fa138_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1499_MP17 (XI0_I1499_con I0_pp4_0 XI0_I1499_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1499_MP14 (XI0_I1499_p1 I0_cm6_0 XI0_I1499_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1499_MP13 (VDD I0_cm5_1 XI0_I1499_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1499_MP15 (XI0_I1499_p2 I0_cm5_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1499_MP16 (VDD I0_cm6_0 XI0_I1499_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1499_MP28 (I0_fa138_1 XI0_I1499_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1499_MP22 (XI0_I1499_p4 I0_cm5_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1499_MP23 (XI0_I1499_p5 I0_cm6_0 XI0_I1499_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1499_MP23_1 (XI0_I1499_p4 I0_cm6_0 XI0_I1499_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1499_MP22_1 (VDD I0_cm5_1 XI0_I1499_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1499_MP19 (XI0_I1499_p3 I0_cm6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1499_MP18 (VDD I0_cm5_1 XI0_I1499_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1499_MP20 (XI0_I1499_p3 I0_pp4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1499_MP21 (XI0_I1499_sn XI0_I1499_con XI0_I1499_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1499_MP24_1 (XI0_I1499_p5 I0_pp4_0 XI0_I1499_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1373_MP24 (XI0_I1373_sn I0_pp6_0 XI0_I1373_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1373_MP26 (VDD XI0_I1373_sn I0_fa12_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1373_MP17 (XI0_I1373_con I0_pp6_0 XI0_I1373_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1373_MP14 (XI0_I1373_p1 I0_pp5_2 XI0_I1373_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1373_MP13 (VDD I0_pp4_4 XI0_I1373_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1373_MP15 (XI0_I1373_p2 I0_pp4_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1373_MP16 (VDD I0_pp5_2 XI0_I1373_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1373_MP28 (I0_fa12_1 XI0_I1373_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1373_MP22 (XI0_I1373_p4 I0_pp4_4 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1373_MP23 (XI0_I1373_p5 I0_pp5_2 XI0_I1373_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1373_MP23_1 (XI0_I1373_p4 I0_pp5_2 XI0_I1373_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1373_MP22_1 (VDD I0_pp4_4 XI0_I1373_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1373_MP19 (XI0_I1373_p3 I0_pp5_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1373_MP18 (VDD I0_pp4_4 XI0_I1373_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1373_MP20 (XI0_I1373_p3 I0_pp6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1373_MP21 (XI0_I1373_sn XI0_I1373_con XI0_I1373_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1373_MP24_1 (XI0_I1373_p5 I0_pp6_0 XI0_I1373_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1375_MP24 (XI0_I1375_sn I0_pp6_1 XI0_I1375_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1375_MP26 (VDD XI0_I1375_sn I0_fa14_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1375_MP17 (XI0_I1375_con I0_pp6_1 XI0_I1375_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1375_MP14 (XI0_I1375_p1 I0_pp5_3 XI0_I1375_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1375_MP13 (VDD I0_pp4_5 XI0_I1375_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1375_MP15 (XI0_I1375_p2 I0_pp4_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1375_MP16 (VDD I0_pp5_3 XI0_I1375_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1375_MP28 (I0_fa14_1 XI0_I1375_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1375_MP22 (XI0_I1375_p4 I0_pp4_5 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1375_MP23 (XI0_I1375_p5 I0_pp5_3 XI0_I1375_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1375_MP23_1 (XI0_I1375_p4 I0_pp5_3 XI0_I1375_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1375_MP22_1 (VDD I0_pp4_5 XI0_I1375_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1375_MP19 (XI0_I1375_p3 I0_pp5_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1375_MP18 (VDD I0_pp4_5 XI0_I1375_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1375_MP20 (XI0_I1375_p3 I0_pp6_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1375_MP21 (XI0_I1375_sn XI0_I1375_con XI0_I1375_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1375_MP24_1 (XI0_I1375_p5 I0_pp6_1 XI0_I1375_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1519_MP24 (XI0_I1519_sn I0_pp12_1 XI0_I1519_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1519_MP26 (VDD XI0_I1519_sn I0_fa158_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1519_MP17 (XI0_I1519_con I0_pp12_1 XI0_I1519_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1519_MP14 (XI0_I1519_p1 I0_cm45_0 XI0_I1519_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1519_MP13 (VDD I0_cm44_0 XI0_I1519_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1519_MP15 (XI0_I1519_p2 I0_cm44_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1519_MP16 (VDD I0_cm45_0 XI0_I1519_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1519_MP28 (I0_fa158_1 XI0_I1519_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1519_MP22 (XI0_I1519_p4 I0_cm44_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1519_MP23 (XI0_I1519_p5 I0_cm45_0 XI0_I1519_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1519_MP23_1 (XI0_I1519_p4 I0_cm45_0 XI0_I1519_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1519_MP22_1 (VDD I0_cm44_0 XI0_I1519_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1519_MP19 (XI0_I1519_p3 I0_cm45_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1519_MP18 (VDD I0_cm44_0 XI0_I1519_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1519_MP20 (XI0_I1519_p3 I0_pp12_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1519_MP21 (XI0_I1519_sn XI0_I1519_con XI0_I1519_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1519_MP24_1 (XI0_I1519_p5 I0_pp12_1 XI0_I1519_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1363_MP24 (XI0_I1363_sn I0_pp2_0 XI0_I1363_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1363_MP26 (VDD XI0_I1363_sn I0_fa2_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1363_MP17 (XI0_I1363_con I0_pp2_0 XI0_I1363_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1363_MP14 (XI0_I1363_p1 I0_pp1_2 XI0_I1363_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1363_MP13 (VDD I0_pp0_4 XI0_I1363_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1363_MP15 (XI0_I1363_p2 I0_pp0_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1363_MP16 (VDD I0_pp1_2 XI0_I1363_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1363_MP28 (I0_fa2_1 XI0_I1363_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1363_MP22 (XI0_I1363_p4 I0_pp0_4 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1363_MP23 (XI0_I1363_p5 I0_pp1_2 XI0_I1363_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1363_MP23_1 (XI0_I1363_p4 I0_pp1_2 XI0_I1363_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1363_MP22_1 (VDD I0_pp0_4 XI0_I1363_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1363_MP19 (XI0_I1363_p3 I0_pp1_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1363_MP18 (VDD I0_pp0_4 XI0_I1363_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1363_MP20 (XI0_I1363_p3 I0_pp2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1363_MP21 (XI0_I1363_sn XI0_I1363_con XI0_I1363_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1363_MP24_1 (XI0_I1363_p5 I0_pp2_0 XI0_I1363_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1517_MP24 (XI0_I1517_sn I0_pp12_0 XI0_I1517_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1517_MP26 (VDD XI0_I1517_sn I0_fa156_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1517_MP17 (XI0_I1517_con I0_pp12_0 XI0_I1517_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1517_MP14 (XI0_I1517_p1 I0_cm42_0 XI0_I1517_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1517_MP13 (VDD I0_cm41_0 XI0_I1517_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1517_MP15 (XI0_I1517_p2 I0_cm41_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1517_MP16 (VDD I0_cm42_0 XI0_I1517_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1517_MP28 (I0_fa156_1 XI0_I1517_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1517_MP22 (XI0_I1517_p4 I0_cm41_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1517_MP23 (XI0_I1517_p5 I0_cm42_0 XI0_I1517_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1517_MP23_1 (XI0_I1517_p4 I0_cm42_0 XI0_I1517_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1517_MP22_1 (VDD I0_cm41_0 XI0_I1517_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1517_MP19 (XI0_I1517_p3 I0_cm42_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1517_MP18 (VDD I0_cm41_0 XI0_I1517_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1517_MP20 (XI0_I1517_p3 I0_pp12_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1517_MP21 (XI0_I1517_sn XI0_I1517_con XI0_I1517_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1517_MP24_1 (XI0_I1517_p5 I0_pp12_0 XI0_I1517_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1394_MP24 (XI0_I1394_sn I0_pp10_1 XI0_I1394_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1394_MP26 (VDD XI0_I1394_sn I0_fa33_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1394_MP17 (XI0_I1394_con I0_pp10_1 XI0_I1394_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1394_MP14 (XI0_I1394_p1 I0_pp9_3 XI0_I1394_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1394_MP13 (VDD I0_pp8_5 XI0_I1394_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1394_MP15 (XI0_I1394_p2 I0_pp8_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1394_MP16 (VDD I0_pp9_3 XI0_I1394_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1394_MP28 (I0_fa33_1 XI0_I1394_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1394_MP22 (XI0_I1394_p4 I0_pp8_5 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1394_MP23 (XI0_I1394_p5 I0_pp9_3 XI0_I1394_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1394_MP23_1 (XI0_I1394_p4 I0_pp9_3 XI0_I1394_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1394_MP22_1 (VDD I0_pp8_5 XI0_I1394_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1394_MP19 (XI0_I1394_p3 I0_pp9_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1394_MP18 (VDD I0_pp8_5 XI0_I1394_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1394_MP20 (XI0_I1394_p3 I0_pp10_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1394_MP21 (XI0_I1394_sn XI0_I1394_con XI0_I1394_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1394_MP24_1 (XI0_I1394_p5 I0_pp10_1 XI0_I1394_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1641_MP24 (XI0_I1641_sn I0_cm84_2 XI0_I1641_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1641_MP26 (VDD XI0_I1641_sn I0_fa280_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1641_MP17 (XI0_I1641_con I0_cm84_2 XI0_I1641_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1641_MP14 (XI0_I1641_p1 I0_cm230_0 XI0_I1641_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1641_MP13 (VDD I0_cm229_1 XI0_I1641_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1641_MP15 (XI0_I1641_p2 I0_cm229_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1641_MP16 (VDD I0_cm230_0 XI0_I1641_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1641_MP28 (I0_fa280_1 XI0_I1641_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1641_MP22 (XI0_I1641_p4 I0_cm229_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1641_MP23 (XI0_I1641_p5 I0_cm230_0 XI0_I1641_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1641_MP23_1 (XI0_I1641_p4 I0_cm230_0 XI0_I1641_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1641_MP22_1 (VDD I0_cm229_1 XI0_I1641_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1641_MP19 (XI0_I1641_p3 I0_cm230_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1641_MP18 (VDD I0_cm229_1 XI0_I1641_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1641_MP20 (XI0_I1641_p3 I0_cm84_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1641_MP21 (XI0_I1641_sn XI0_I1641_con XI0_I1641_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1641_MP24_1 (XI0_I1641_p5 I0_cm84_2 XI0_I1641_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1498_MP24 (XI0_I1498_sn I0_pp1_1 XI0_I1498_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1498_MP26 (VDD XI0_I1498_sn I0_fa137_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1498_MP17 (XI0_I1498_con I0_pp1_1 XI0_I1498_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1498_MP14 (XI0_I1498_p1 I0_pp0_3 XI0_I1498_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1498_MP13 (VDD I0_fa1_1 XI0_I1498_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1498_MP15 (XI0_I1498_p2 I0_fa1_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1498_MP16 (VDD I0_pp0_3 XI0_I1498_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1498_MP28 (I0_fa137_1 XI0_I1498_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1498_MP22 (XI0_I1498_p4 I0_fa1_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1498_MP23 (XI0_I1498_p5 I0_pp0_3 XI0_I1498_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1498_MP23_1 (XI0_I1498_p4 I0_pp0_3 XI0_I1498_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1498_MP22_1 (VDD I0_fa1_1 XI0_I1498_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1498_MP19 (XI0_I1498_p3 I0_pp0_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1498_MP18 (VDD I0_fa1_1 XI0_I1498_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1498_MP20 (XI0_I1498_p3 I0_pp1_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1498_MP21 (XI0_I1498_sn XI0_I1498_con XI0_I1498_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1498_MP24_1 (XI0_I1498_p5 I0_pp1_1 XI0_I1498_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1362_MP24 (XI0_I1362_sn I0_B_3_b3_5 XI0_I1362_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1362_MP26 (VDD XI0_I1362_sn I0_fa1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1362_MP17 (XI0_I1362_con I0_B_3_b3_5 XI0_I1362_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1362_MP14 (XI0_I1362_p1 I0_pp1_0 XI0_I1362_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1362_MP13 (VDD I0_pp0_2 XI0_I1362_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1362_MP15 (XI0_I1362_p2 I0_pp0_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1362_MP16 (VDD I0_pp1_0 XI0_I1362_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1362_MP28 (I0_fa1_1 XI0_I1362_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1362_MP22 (XI0_I1362_p4 I0_pp0_2 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1362_MP23 (XI0_I1362_p5 I0_pp1_0 XI0_I1362_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1362_MP23_1 (XI0_I1362_p4 I0_pp1_0 XI0_I1362_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1362_MP22_1 (VDD I0_pp0_2 XI0_I1362_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1362_MP19 (XI0_I1362_p3 I0_pp1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1362_MP18 (VDD I0_pp0_2 XI0_I1362_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1362_MP20 (XI0_I1362_p3 I0_B_3_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1362_MP21 (XI0_I1362_sn XI0_I1362_con XI0_I1362_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1362_MP24_1 (XI0_I1362_p5 I0_B_3_b3_5 XI0_I1362_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1500_MP24 (XI0_I1500_sn I0_pp4_1 XI0_I1500_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1500_MP26 (VDD XI0_I1500_sn I0_fa139_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1500_MP17 (XI0_I1500_con I0_pp4_1 XI0_I1500_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1500_MP14 (XI0_I1500_p1 I0_cm7_0 XI0_I1500_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1500_MP13 (VDD I0_cm6_1 XI0_I1500_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1500_MP15 (XI0_I1500_p2 I0_cm6_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1500_MP16 (VDD I0_cm7_0 XI0_I1500_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1500_MP28 (I0_fa139_1 XI0_I1500_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1500_MP22 (XI0_I1500_p4 I0_cm6_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1500_MP23 (XI0_I1500_p5 I0_cm7_0 XI0_I1500_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1500_MP23_1 (XI0_I1500_p4 I0_cm7_0 XI0_I1500_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1500_MP22_1 (VDD I0_cm6_1 XI0_I1500_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1500_MP19 (XI0_I1500_p3 I0_cm7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1500_MP18 (VDD I0_cm6_1 XI0_I1500_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1500_MP20 (XI0_I1500_p3 I0_pp4_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1500_MP21 (XI0_I1500_sn XI0_I1500_con XI0_I1500_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1500_MP24_1 (XI0_I1500_p5 I0_pp4_1 XI0_I1500_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1391_MP24 (XI0_I1391_sn I0_pp10_0 XI0_I1391_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1391_MP26 (VDD XI0_I1391_sn I0_fa30_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1391_MP17 (XI0_I1391_con I0_pp10_0 XI0_I1391_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1391_MP14 (XI0_I1391_p1 I0_pp9_2 XI0_I1391_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1391_MP13 (VDD I0_pp8_4 XI0_I1391_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1391_MP15 (XI0_I1391_p2 I0_pp8_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1391_MP16 (VDD I0_pp9_2 XI0_I1391_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1391_MP28 (I0_fa30_1 XI0_I1391_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1391_MP22 (XI0_I1391_p4 I0_pp8_4 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1391_MP23 (XI0_I1391_p5 I0_pp9_2 XI0_I1391_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1391_MP23_1 (XI0_I1391_p4 I0_pp9_2 XI0_I1391_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1391_MP22_1 (VDD I0_pp8_4 XI0_I1391_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1391_MP19 (XI0_I1391_p3 I0_pp9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1391_MP18 (VDD I0_pp8_4 XI0_I1391_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1391_MP20 (XI0_I1391_p3 I0_pp10_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1391_MP21 (XI0_I1391_sn XI0_I1391_con XI0_I1391_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1391_MP24_1 (XI0_I1391_p5 I0_pp10_0 XI0_I1391_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1570_MP24 (XI0_I1570_sn I0_B_5_b3_5 XI0_I1570_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1570_MP26 (VDD XI0_I1570_sn I0_fa209_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1570_MP17 (XI0_I1570_con I0_B_5_b3_5 XI0_I1570_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1570_MP14 (XI0_I1570_p1 I0_fa2_0 XI0_I1570_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1570_MP13 (VDD I0_fa137_1 XI0_I1570_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1570_MP15 (XI0_I1570_p2 I0_fa137_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1570_MP16 (VDD I0_fa2_0 XI0_I1570_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1570_MP28 (I0_fa209_1 XI0_I1570_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1570_MP22 (XI0_I1570_p4 I0_fa137_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1570_MP23 (XI0_I1570_p5 I0_fa2_0 XI0_I1570_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1570_MP23_1 (XI0_I1570_p4 I0_fa2_0 XI0_I1570_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1570_MP22_1 (VDD I0_fa137_1 XI0_I1570_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1570_MP19 (XI0_I1570_p3 I0_fa2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1570_MP18 (VDD I0_fa137_1 XI0_I1570_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1570_MP20 (XI0_I1570_p3 I0_B_5_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1570_MP21 (XI0_I1570_sn XI0_I1570_con XI0_I1570_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1570_MP24_1 (XI0_I1570_p5 I0_B_5_b3_5 XI0_I1570_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1364_MP24 (XI0_I1364_sn I0_pp2_1 XI0_I1364_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1364_MP26 (VDD XI0_I1364_sn I0_fa3_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1364_MP17 (XI0_I1364_con I0_pp2_1 XI0_I1364_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1364_MP14 (XI0_I1364_p1 I0_pp1_3 XI0_I1364_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1364_MP13 (VDD I0_pp0_5 XI0_I1364_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1364_MP15 (XI0_I1364_p2 I0_pp0_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1364_MP16 (VDD I0_pp1_3 XI0_I1364_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1364_MP28 (I0_fa3_1 XI0_I1364_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1364_MP22 (XI0_I1364_p4 I0_pp0_5 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1364_MP23 (XI0_I1364_p5 I0_pp1_3 XI0_I1364_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1364_MP23_1 (XI0_I1364_p4 I0_pp1_3 XI0_I1364_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1364_MP22_1 (VDD I0_pp0_5 XI0_I1364_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1364_MP19 (XI0_I1364_p3 I0_pp1_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1364_MP18 (VDD I0_pp0_5 XI0_I1364_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1364_MP20 (XI0_I1364_p3 I0_pp2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1364_MP21 (XI0_I1364_sn XI0_I1364_con XI0_I1364_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1364_MP24_1 (XI0_I1364_p5 I0_pp2_1 XI0_I1364_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1571_MP24 (XI0_I1571_sn I0_pp8_0 XI0_I1571_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1571_MP26 (VDD XI0_I1571_sn I0_fa210_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1571_MP17 (XI0_I1571_con I0_pp8_0 XI0_I1571_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1571_MP14 (XI0_I1571_p1 I0_cm146_0 XI0_I1571_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1571_MP13 (VDD I0_cm145_1 XI0_I1571_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1571_MP15 (XI0_I1571_p2 I0_cm145_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1571_MP16 (VDD I0_cm146_0 XI0_I1571_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1571_MP28 (I0_fa210_1 XI0_I1571_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1571_MP22 (XI0_I1571_p4 I0_cm145_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1571_MP23 (XI0_I1571_p5 I0_cm146_0 XI0_I1571_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1571_MP23_1 (XI0_I1571_p4 I0_cm146_0 XI0_I1571_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1571_MP22_1 (VDD I0_cm145_1 XI0_I1571_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1571_MP19 (XI0_I1571_p3 I0_cm146_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1571_MP18 (VDD I0_cm145_1 XI0_I1571_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1571_MP20 (XI0_I1571_p3 I0_pp8_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1571_MP21 (XI0_I1571_sn XI0_I1571_con XI0_I1571_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1571_MP24_1 (XI0_I1571_p5 I0_pp8_0 XI0_I1571_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1573_MP24 (XI0_I1573_sn I0_fa25_0 XI0_I1573_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1573_MP26 (VDD XI0_I1573_sn I0_fa212_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1573_MP17 (XI0_I1573_con I0_fa25_0 XI0_I1573_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1573_MP14 (XI0_I1573_p1 I0_cm148_0 XI0_I1573_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1573_MP13 (VDD I0_cm147_1 XI0_I1573_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1573_MP15 (XI0_I1573_p2 I0_cm147_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1573_MP16 (VDD I0_cm148_0 XI0_I1573_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1573_MP28 (I0_fa212_1 XI0_I1573_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1573_MP22 (XI0_I1573_p4 I0_cm147_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1573_MP23 (XI0_I1573_p5 I0_cm148_0 XI0_I1573_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1573_MP23_1 (XI0_I1573_p4 I0_cm148_0 XI0_I1573_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1573_MP22_1 (VDD I0_cm147_1 XI0_I1573_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1573_MP19 (XI0_I1573_p3 I0_cm148_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1573_MP18 (VDD I0_cm147_1 XI0_I1573_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1573_MP20 (XI0_I1573_p3 I0_fa25_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1573_MP21 (XI0_I1573_sn XI0_I1573_con XI0_I1573_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1573_MP24_1 (XI0_I1573_p5 I0_fa25_0 XI0_I1573_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1572_MP24 (XI0_I1572_sn I0_pp8_1 XI0_I1572_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1572_MP26 (VDD XI0_I1572_sn I0_fa211_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1572_MP17 (XI0_I1572_con I0_pp8_1 XI0_I1572_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1572_MP14 (XI0_I1572_p1 I0_cm147_0 XI0_I1572_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1572_MP13 (VDD I0_cm146_1 XI0_I1572_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1572_MP15 (XI0_I1572_p2 I0_cm146_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1572_MP16 (VDD I0_cm147_0 XI0_I1572_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1572_MP28 (I0_fa211_1 XI0_I1572_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1572_MP22 (XI0_I1572_p4 I0_cm146_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1572_MP23 (XI0_I1572_p5 I0_cm147_0 XI0_I1572_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1572_MP23_1 (XI0_I1572_p4 I0_cm147_0 XI0_I1572_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1572_MP22_1 (VDD I0_cm146_1 XI0_I1572_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1572_MP19 (XI0_I1572_p3 I0_cm147_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1572_MP18 (VDD I0_cm146_1 XI0_I1572_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1572_MP20 (XI0_I1572_p3 I0_pp8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1572_MP21 (XI0_I1572_sn XI0_I1572_con XI0_I1572_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1572_MP24_1 (XI0_I1572_p5 I0_pp8_1 XI0_I1572_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1511_MP24 (XI0_I1511_sn I0_pp9_1 XI0_I1511_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1511_MP26 (VDD XI0_I1511_sn I0_fa150_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1511_MP17 (XI0_I1511_con I0_pp9_1 XI0_I1511_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1511_MP14 (XI0_I1511_p1 I0_pp8_3 XI0_I1511_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1511_MP13 (VDD I0_cm27_0 XI0_I1511_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1511_MP15 (XI0_I1511_p2 I0_cm27_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1511_MP16 (VDD I0_pp8_3 XI0_I1511_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1511_MP28 (I0_fa150_1 XI0_I1511_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1511_MP22 (XI0_I1511_p4 I0_cm27_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1511_MP23 (XI0_I1511_p5 I0_pp8_3 XI0_I1511_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1511_MP23_1 (XI0_I1511_p4 I0_pp8_3 XI0_I1511_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1511_MP22_1 (VDD I0_cm27_0 XI0_I1511_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1511_MP19 (XI0_I1511_p3 I0_pp8_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1511_MP18 (VDD I0_cm27_0 XI0_I1511_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1511_MP20 (XI0_I1511_p3 I0_pp9_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1511_MP21 (XI0_I1511_sn XI0_I1511_con XI0_I1511_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1511_MP24_1 (XI0_I1511_p5 I0_pp9_1 XI0_I1511_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1386_MP24 (XI0_I1386_sn I0_B_19_b3_5 XI0_I1386_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1386_MP26 (VDD XI0_I1386_sn I0_fa25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1386_MP17 (XI0_I1386_con I0_B_19_b3_5 XI0_I1386_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1386_MP14 (XI0_I1386_p1 I0_pp9_0 XI0_I1386_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1386_MP13 (VDD I0_pp8_2 XI0_I1386_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1386_MP15 (XI0_I1386_p2 I0_pp8_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1386_MP16 (VDD I0_pp9_0 XI0_I1386_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1386_MP28 (I0_fa25_1 XI0_I1386_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1386_MP22 (XI0_I1386_p4 I0_pp8_2 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1386_MP23 (XI0_I1386_p5 I0_pp9_0 XI0_I1386_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1386_MP23_1 (XI0_I1386_p4 I0_pp9_0 XI0_I1386_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1386_MP22_1 (VDD I0_pp8_2 XI0_I1386_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1386_MP19 (XI0_I1386_p3 I0_pp9_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1386_MP18 (VDD I0_pp8_2 XI0_I1386_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1386_MP20 (XI0_I1386_p3 I0_B_19_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1386_MP21 (XI0_I1386_sn XI0_I1386_con XI0_I1386_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1386_MP24_1 (XI0_I1386_p5 I0_B_19_b3_5 XI0_I1386_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1644_MP24 (XI0_I1644_sn I0_cm184_2 XI0_I1644_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1644_MP26 (VDD XI0_I1644_sn I0_fa283_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1644_MP17 (XI0_I1644_con I0_cm184_2 XI0_I1644_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1644_MP14 (XI0_I1644_p1 I0_cm233_0 XI0_I1644_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1644_MP13 (VDD I0_cm232_1 XI0_I1644_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1644_MP15 (XI0_I1644_p2 I0_cm232_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1644_MP16 (VDD I0_cm233_0 XI0_I1644_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1644_MP28 (I0_fa283_1 XI0_I1644_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1644_MP22 (XI0_I1644_p4 I0_cm232_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1644_MP23 (XI0_I1644_p5 I0_cm233_0 XI0_I1644_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1644_MP23_1 (XI0_I1644_p4 I0_cm233_0 XI0_I1644_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1644_MP22_1 (VDD I0_cm232_1 XI0_I1644_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1644_MP19 (XI0_I1644_p3 I0_cm233_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1644_MP18 (VDD I0_cm232_1 XI0_I1644_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1644_MP20 (XI0_I1644_p3 I0_cm184_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1644_MP21 (XI0_I1644_sn XI0_I1644_con XI0_I1644_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1644_MP24_1 (XI0_I1644_p5 I0_cm184_2 XI0_I1644_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1610_MP24 (XI0_I1610_sn I0_fa3_0 XI0_I1610_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1610_MP26 (VDD XI0_I1610_sn I0_fa249_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1610_MP17 (XI0_I1610_con I0_fa3_0 XI0_I1610_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1610_MP14 (XI0_I1610_p1 I0_fa2_1 XI0_I1610_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1610_MP13 (VDD I0_fa209_1 XI0_I1610_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1610_MP15 (XI0_I1610_p2 I0_fa209_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1610_MP16 (VDD I0_fa2_1 XI0_I1610_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1610_MP28 (I0_fa249_1 XI0_I1610_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1610_MP22 (XI0_I1610_p4 I0_fa209_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1610_MP23 (XI0_I1610_p5 I0_fa2_1 XI0_I1610_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1610_MP23_1 (XI0_I1610_p4 I0_fa2_1 XI0_I1610_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1610_MP22_1 (VDD I0_fa209_1 XI0_I1610_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1610_MP19 (XI0_I1610_p3 I0_fa2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1610_MP18 (VDD I0_fa209_1 XI0_I1610_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1610_MP20 (XI0_I1610_p3 I0_fa3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1610_MP21 (XI0_I1610_sn XI0_I1610_con XI0_I1610_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1610_MP24_1 (XI0_I1610_p5 I0_fa3_0 XI0_I1610_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1574_MP24 (XI0_I1574_sn I0_fa150_0 XI0_I1574_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1574_MP26 (VDD XI0_I1574_sn I0_fa213_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1574_MP17 (XI0_I1574_con I0_fa150_0 XI0_I1574_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1574_MP14 (XI0_I1574_p1 I0_cm149_0 XI0_I1574_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1574_MP13 (VDD I0_cm148_1 XI0_I1574_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1574_MP15 (XI0_I1574_p2 I0_cm148_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1574_MP16 (VDD I0_cm149_0 XI0_I1574_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1574_MP28 (I0_fa213_1 XI0_I1574_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1574_MP22 (XI0_I1574_p4 I0_cm148_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1574_MP23 (XI0_I1574_p5 I0_cm149_0 XI0_I1574_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1574_MP23_1 (XI0_I1574_p4 I0_cm149_0 XI0_I1574_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1574_MP22_1 (VDD I0_cm148_1 XI0_I1574_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1574_MP19 (XI0_I1574_p3 I0_cm149_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1574_MP18 (VDD I0_cm148_1 XI0_I1574_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1574_MP20 (XI0_I1574_p3 I0_fa150_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1574_MP21 (XI0_I1574_sn XI0_I1574_con XI0_I1574_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1574_MP24_1 (XI0_I1574_p5 I0_fa150_0 XI0_I1574_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1449_MP24 (XI0_I1449_sn I0_pp15_6 XI0_I1449_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1449_MP26 (VDD XI0_I1449_sn I0_fa88_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1449_MP17 (XI0_I1449_con I0_pp15_6 XI0_I1449_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1449_MP14 (XI0_I1449_p1 I0_pp14_8 XI0_I1449_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1449_MP13 (VDD I0_pp13_10 XI0_I1449_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1449_MP15 (XI0_I1449_p2 I0_pp13_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1449_MP16 (VDD I0_pp14_8 XI0_I1449_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1449_MP28 (I0_fa88_1 XI0_I1449_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1449_MP22 (XI0_I1449_p4 I0_pp13_10 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1449_MP23 (XI0_I1449_p5 I0_pp14_8 XI0_I1449_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1449_MP23_1 (XI0_I1449_p4 I0_pp14_8 XI0_I1449_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1449_MP22_1 (VDD I0_pp13_10 XI0_I1449_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1449_MP19 (XI0_I1449_p3 I0_pp14_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
