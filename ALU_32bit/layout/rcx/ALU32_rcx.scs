    I_MXI1_I1574_I115_XG_MN1 (VSS I1_I1574_G17_16 XI1_I1574_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I113_XG_MN2 (I1_I1574_G17_14n I1_I1574_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I113_XG_MN0 (XI1_I1574_I113_XG_n1 I1_I1574_P17_16 I1_I1574_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I113_XG_MN1 (VSS I1_I1574_G15_14 XI1_I1574_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I172_XG_MN2 (I1_I1574_G21_6n I1_I1574_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I172_XG_MN0 (XI1_I1574_I172_XG_n1 I1_I1574_P21_14 I1_I1574_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I172_XG_MN1 (VSS I1_I1574_G13_6 XI1_I1574_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I164_XG_MN2 (I1_I1574_G13_0n I1_I1574_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I164_XG_MN0 (XI1_I1574_I164_XG_n1 I1_I1574_P13_6 I1_I1574_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I164_XG_MN1 (VSS I1_I1574_G5_0 XI1_I1574_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I168_XG_MN2 (I1_I1574_G17_2n I1_I1574_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I168_XG_MN0 (XI1_I1574_I168_XG_n1 I1_I1574_P17_10 I1_I1574_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I168_XG_MN1 (VSS I1_I1574_G9_2 XI1_I1574_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I101_XG_MN2 (I1_I1574_G5_2n I1_I1574_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I101_XG_MN0 (XI1_I1574_I101_XG_n1 I1_I1574_P5_4 I1_I1574_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I101_XG_MN1 (VSS I1_I1574_G3_2 XI1_I1574_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I69_MN2 (I1_nakn12 I1_nak11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I69_MN0 (XI1_I69_n1 I1_A_31_b3_1 I1_nakn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I69_MN1 (VSS A_11 XI1_I69_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I66_MN2 (I1_nakn11 I1_nak10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I66_MN0 (XI1_I66_n1 I1_A_31_b3_1 I1_nakn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I66_MN1 (VSS A_10 XI1_I66_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I112_XG_MN2 (I2_I1_I42_G16_13n I2_I1_I42_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I112_XG_MN0 (XI2_I1_I42_I112_XG_n1 I2_I1_I42_P16_15 I2_I1_I42_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I112_XG_MN1 (VSS I2_I1_I42_G14_13 XI2_I1_I42_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I114_XG_MN2 (I2_I1_I42_G18_15n I2_I1_I42_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I114_XG_MN0 (XI2_I1_I42_I114_XG_n1 I2_I1_I42_P18_17 I2_I1_I42_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I114_XG_MN1 (VSS I2_I1_I42_G16_15 XI2_I1_I42_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I116_XG_MN2 (I2_I1_I42_G20_17n I2_I1_I42_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I116_XG_MN0 (XI2_I1_I42_I116_XG_n1 I2_I1_I42_P20_19 I2_I1_I42_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I116_XG_MN1 (VSS I2_I1_I42_G18_17 XI2_I1_I42_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I118_XG_MN2 (I2_I1_I42_G22_19n I2_I1_I42_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I118_XG_MN0 (XI2_I1_I42_I118_XG_n1 I2_I1_I42_P22_21 I2_I1_I42_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I118_XG_MN1 (VSS I2_I1_I42_G20_19 XI2_I1_I42_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I284_MN2 (I2_I3_q16_2 I2_I3_o16_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I284_MN0 (XI2_I3_I284_n1 I2_I3_SEL_AS_b3_3 I2_I3_q16_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I284_MN1 (VSS I2_S_16 XI2_I3_I284_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I176_XG_MN2 (I1_I562_G25_10n I1_I562_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I176_XG_MN0 (XI1_I562_I176_XG_n1 I1_I562_P25_18 I1_I562_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I176_XG_MN1 (VSS I1_I562_G17_10 XI1_I562_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I172_XG_MN2 (I1_I562_G21_6n I1_I562_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I172_XG_MN0 (XI1_I562_I172_XG_n1 I1_I562_P21_14 I1_I562_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I172_XG_MN1 (VSS I1_I562_G13_6 XI1_I562_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I180_XG_MN2 (I1_I562_G29_14n I1_I562_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I180_XG_MN0 (XI1_I562_I180_XG_n1 I1_I562_P29_22 I1_I562_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I180_XG_MN1 (VSS I1_I562_G21_14 XI1_I562_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I123_XG_MN2 (I1_I562_G27_24n I1_I562_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I123_XG_MN0 (XI1_I562_I123_XG_n1 I1_I562_P27_26 I1_I562_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I123_XG_MN1 (VSS I1_I562_G25_24 XI1_I562_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I125_XG_MN2 (I1_I562_G29_26n I1_I562_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I125_XG_MN0 (XI1_I562_I125_XG_n1 I1_I562_P29_28 I1_I562_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I125_XG_MN1 (VSS I1_I562_G27_26 XI1_I562_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I127_XG_MN2 (I1_I562_G31_28n I1_I562_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I127_XG_MN0 (XI1_I562_I127_XG_n1 I1_I562_P31_30 I1_I562_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I127_XG_MN1 (VSS I1_I562_G29_28 XI1_I562_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I121_XG_MN2 (I1_I1712_G25_22n I1_I1712_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I121_XG_MN0 (XI1_I1712_I121_XG_n1 I1_I1712_P25_24 I1_I1712_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I121_XG_MN1 (VSS I1_I1712_G23_22 XI1_I1712_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I180_XG_MN2 (I1_I1712_G29_14n I1_I1712_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I180_XG_MN0 (XI1_I1712_I180_XG_n1 I1_I1712_P29_22 I1_I1712_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I180_XG_MN1 (VSS I1_I1712_G21_14 XI1_I1712_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I119_XG_MN2 (I1_I1712_G23_20n I1_I1712_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I119_XG_MN0 (XI1_I1712_I119_XG_n1 I1_I1712_P23_22 I1_I1712_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I119_XG_MN1 (VSS I1_I1712_G21_20 XI1_I1712_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I172_XG_MN2 (I1_I1712_G21_6n I1_I1712_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I172_XG_MN0 (XI1_I1712_I172_XG_n1 I1_I1712_P21_14 I1_I1712_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I172_XG_MN1 (VSS I1_I1712_G13_6 XI1_I1712_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I164_XG_MN2 (I1_I1712_G13_0n I1_I1712_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I164_XG_MN0 (XI1_I1712_I164_XG_n1 I1_I1712_P13_6 I1_I1712_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I164_XG_MN1 (VSS I1_I1712_G5_0 XI1_I1712_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I109_XG_MN2 (I1_I1712_G13_10n I1_I1712_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I109_XG_MN0 (XI1_I1712_I109_XG_n1 I1_I1712_P13_12 I1_I1712_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I109_XG_MN1 (VSS I1_I1712_G11_10 XI1_I1712_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I168_XG_MN2 (I1_I1712_G17_2n I1_I1712_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I168_XG_MN0 (XI1_I1712_I168_XG_n1 I1_I1712_P17_10 I1_I1712_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I168_XG_MN1 (VSS I1_I1712_G9_2 XI1_I1712_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I158_XG_MN2 (I1_I1712_G9_0n I1_I1712_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I158_XG_MN0 (XI1_I1712_I158_XG_n1 I1_I1712_P9_2 I1_I1712_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I158_XG_MN1 (VSS I1_I1712_G1_0 XI1_I1712_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I107_XG_MN2 (I1_I1712_G11_8n I1_I1712_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I107_XG_MN0 (XI1_I1712_I107_XG_n1 I1_I1712_P11_10 I1_I1712_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I107_XG_MN1 (VSS I1_I1712_G9_8 XI1_I1712_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I105_XG_MN2 (I1_I1712_G9_6n I1_I1712_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I105_XG_MN0 (XI1_I1712_I105_XG_n1 I1_I1712_P9_8 I1_I1712_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I105_XG_MN1 (VSS I1_I1712_G7_6 XI1_I1712_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I103_XG_MN2 (I1_I1712_G7_4n I1_I1712_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I103_XG_MN0 (XI1_I1712_I103_XG_n1 I1_I1712_P7_6 I1_I1712_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I103_XG_MN1 (VSS I1_I1712_G5_4 XI1_I1712_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I101_XG_MN2 (I1_I1712_G5_2n I1_I1712_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I101_XG_MN0 (XI1_I1712_I101_XG_n1 I1_I1712_P5_4 I1_I1712_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I101_XG_MN1 (VSS I1_I1712_G3_2 XI1_I1712_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I99_XG_MN2 (I1_I1712_G3_0n I1_I1712_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I99_XG_MN0 (XI1_I1712_I99_XG_n1 I1_I1712_P3_2 I1_I1712_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I99_XG_MN1 (VSS I1_I1712_G1_0 XI1_I1712_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I125_XG_MN2 (I1_I1574_G29_26n I1_I1574_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I125_XG_MN0 (XI1_I1574_I125_XG_n1 I1_I1574_P29_28 I1_I1574_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I125_XG_MN1 (VSS I1_I1574_G27_26 XI1_I1574_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I121_XG_MN2 (I1_I1574_G25_22n I1_I1574_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I121_XG_MN0 (XI1_I1574_I121_XG_n1 I1_I1574_P25_24 I1_I1574_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I121_XG_MN1 (VSS I1_I1574_G23_22 XI1_I1574_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I180_XG_MN2 (I1_I1574_G29_14n I1_I1574_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I180_XG_MN0 (XI1_I1574_I180_XG_n1 I1_I1574_P29_22 I1_I1574_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I180_XG_MN1 (VSS I1_I1574_G21_14 XI1_I1574_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I117_XG_MN2 (I1_I1574_G21_18n I1_I1574_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I117_XG_MN0 (XI1_I1574_I117_XG_n1 I1_I1574_P21_20 I1_I1574_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I117_XG_MN1 (VSS I1_I1574_G19_18 XI1_I1574_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I176_XG_MN2 (I1_I1574_G25_10n I1_I1574_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I176_XG_MN0 (XI1_I1574_I176_XG_n1 I1_I1574_P25_18 I1_I1574_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I176_XG_MN1 (VSS I1_I1574_G17_10 XI1_I1574_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I158_XG_MN2 (I1_I1574_G9_0n I1_I1574_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I158_XG_MN0 (XI1_I1574_I158_XG_n1 I1_I1574_P9_2 I1_I1574_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I158_XG_MN1 (VSS I1_I1574_G1_0 XI1_I1574_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I99_XG_MN2 (I1_I1574_G3_0n I1_I1574_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I99_XG_MN0 (XI1_I1574_I99_XG_n1 I1_I1574_P3_2 I1_I1574_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I99_XG_MN1 (VSS I1_I1574_G1_0 XI1_I1574_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I248_MN2 (I2_I3_q13_2 I2_I3_o13_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I248_MN0 (XI2_I3_I248_n1 I2_I3_SEL_AS_b3_2 I2_I3_q13_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I248_MN1 (VSS I2_S_13 XI2_I3_I248_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I163_XG_MN2 (I2_I1_I42_G12_0n I2_I1_I42_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I163_XG_MN0 (XI2_I1_I42_I163_XG_n1 I2_I1_I42_P12_5 I2_I1_I42_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I163_XG_MN1 (VSS I2_I1_I42_G4_0 XI2_I1_I42_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I110_XG_MN2 (I2_I1_I42_G14_11n I2_I1_I42_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I110_XG_MN0 (XI2_I1_I42_I110_XG_n1 I2_I1_I42_P14_13 I2_I1_I42_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I110_XG_MN1 (VSS I2_I1_I42_G12_11 XI2_I1_I42_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I171_XG_MN2 (I2_I1_I42_G20_5n I2_I1_I42_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I171_XG_MN0 (XI2_I1_I42_I171_XG_n1 I2_I1_I42_P20_13 I2_I1_I42_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I171_XG_MN1 (VSS I2_I1_I42_G12_5 XI2_I1_I42_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I179_XG_MN2 (I2_I1_I42_G28_13n I2_I1_I42_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I179_XG_MN0 (XI2_I1_I42_I179_XG_n1 I2_I1_I42_P28_21 I2_I1_I42_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I179_XG_MN1 (VSS I2_I1_I42_G20_13 XI2_I1_I42_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I120_XG_MN2 (I2_I1_I42_G24_21n I2_I1_I42_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I120_XG_MN0 (XI2_I1_I42_I120_XG_n1 I2_I1_I42_P24_23 I2_I1_I42_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I120_XG_MN1 (VSS I2_I1_I42_G22_21 XI2_I1_I42_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I122_XG_MN2 (I2_I1_I42_G26_23n I2_I1_I42_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I122_XG_MN0 (XI2_I1_I42_I122_XG_n1 I2_I1_I42_P26_25 I2_I1_I42_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I122_XG_MN1 (VSS I2_I1_I42_G24_23 XI2_I1_I42_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I124_XG_MN2 (I2_I1_I42_G28_25n I2_I1_I42_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I124_XG_MN0 (XI2_I1_I42_I124_XG_n1 I2_I1_I42_P28_27 I2_I1_I42_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I124_XG_MN1 (VSS I2_I1_I42_G26_25 XI2_I1_I42_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I392_MN2 (I2_I3_q25_2 I2_I3_o25_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I392_MN0 (XI2_I3_I392_n1 I2_I3_SEL_AS_b3_4 I2_I3_q25_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I392_MN1 (VSS I2_S_25 XI2_I3_I392_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I440_MN2 (I2_I3_q29_2 I2_I3_o29_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I440_MN0 (XI2_I3_I440_n1 I2_I3_SEL_AS_b3_5 I2_I3_q29_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I440_MN1 (VSS I2_S_29 XI2_I3_I440_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I162_XG_MN2 (I1_I562_G11_0n I1_I562_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I162_XG_MN0 (XI1_I562_I162_XG_n1 I1_I562_P11_4 I1_I562_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I162_XG_MN1 (VSS I1_I562_G3_0np XI1_I562_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I170_XG_MN2 (I1_I562_G19_4n I1_I562_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I170_XG_MN0 (XI1_I562_I170_XG_n1 I1_I562_P19_12 I1_I562_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I170_XG_MN1 (VSS I1_I562_G11_4 XI1_I562_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I166_XG_MN2 (I1_I562_G15_0n I1_I562_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I166_XG_MN0 (XI1_I562_I166_XG_n1 I1_I562_P15_8 I1_I562_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I166_XG_MN1 (VSS I1_I562_G7_0 XI1_I562_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I178_XG_MN2 (I1_I562_G27_12n I1_I562_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I178_XG_MN0 (XI1_I562_I178_XG_n1 I1_I562_P27_20 I1_I562_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I178_XG_MN1 (VSS I1_I562_G19_12 XI1_I562_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I174_XG_MN2 (I1_I562_G23_8n I1_I562_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I174_XG_MN0 (XI1_I562_I174_XG_n1 I1_I562_P23_16 I1_I562_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I174_XG_MN1 (VSS I1_I562_G15_8 XI1_I562_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I182_XG_MN2 (I1_I562_G31_16n I1_I562_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I182_XG_MN0 (XI1_I562_I182_XG_n1 I1_I562_P31_24 I1_I562_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I182_XG_MN1 (VSS I1_I562_G23_16 XI1_I562_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I117_XG_MN2 (I1_I1712_G21_18n I1_I1712_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I117_XG_MN0 (XI1_I1712_I117_XG_n1 I1_I1712_P21_20 I1_I1712_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I117_XG_MN1 (VSS I1_I1712_G19_18 XI1_I1712_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I179_XG_MN2 (I1_I1712_G28_13n I1_I1712_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I179_XG_MN0 (XI1_I1712_I179_XG_n1 I1_I1712_P28_21 I1_I1712_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I179_XG_MN1 (VSS I1_I1712_G20_13 XI1_I1712_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I115_XG_MN2 (I1_I1712_G19_16n I1_I1712_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I115_XG_MN0 (XI1_I1712_I115_XG_n1 I1_I1712_P19_18 I1_I1712_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I115_XG_MN1 (VSS I1_I1712_G17_16 XI1_I1712_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I171_XG_MN2 (I1_I1712_G20_5n I1_I1712_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I171_XG_MN0 (XI1_I1712_I171_XG_n1 I1_I1712_P20_13 I1_I1712_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I171_XG_MN1 (VSS I1_I1712_G12_5 XI1_I1712_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I113_XG_MN2 (I1_I1712_G17_14n I1_I1712_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I113_XG_MN0 (XI1_I1712_I113_XG_n1 I1_I1712_P17_16 I1_I1712_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I113_XG_MN1 (VSS I1_I1712_G15_14 XI1_I1712_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I111_XG_MN2 (I1_I1712_G15_12n I1_I1712_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I111_XG_MN0 (XI1_I1712_I111_XG_n1 I1_I1712_P15_14 I1_I1712_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I111_XG_MN1 (VSS I1_I1712_G13_12 XI1_I1712_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I163_XG_MN2 (I1_I1712_G12_0n I1_I1712_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I163_XG_MN0 (XI1_I1712_I163_XG_n1 I1_I1712_P12_5 I1_I1712_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I163_XG_MN1 (VSS I1_I1712_G4_0 XI1_I1712_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I123_XG_MN2 (I1_I1574_G27_24n I1_I1574_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I123_XG_MN0 (XI1_I1574_I123_XG_n1 I1_I1574_P27_26 I1_I1574_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I123_XG_MN1 (VSS I1_I1574_G25_24 XI1_I1574_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I119_XG_MN2 (I1_I1574_G23_20n I1_I1574_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I119_XG_MN0 (XI1_I1574_I119_XG_n1 I1_I1574_P23_22 I1_I1574_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I119_XG_MN1 (VSS I1_I1574_G21_20 XI1_I1574_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I112_XG_MN2 (I1_I1574_G16_13n I1_I1574_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I112_XG_MN0 (XI1_I1574_I112_XG_n1 I1_I1574_P16_15 I1_I1574_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I112_XG_MN1 (VSS I1_I1574_G14_13 XI1_I1574_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I110_XG_MN2 (I1_I1574_G14_11n I1_I1574_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I110_XG_MN0 (XI1_I1574_I110_XG_n1 I1_I1574_P14_13 I1_I1574_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I110_XG_MN1 (VSS I1_I1574_G12_11 XI1_I1574_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I108_XG_MN2 (I1_I1574_G12_9n I1_I1574_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I108_XG_MN0 (XI1_I1574_I108_XG_n1 I1_I1574_P12_11 I1_I1574_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I108_XG_MN1 (VSS I1_I1574_G10_9 XI1_I1574_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I106_XG_MN2 (I1_I1574_G10_7n I1_I1574_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I106_XG_MN0 (XI1_I1574_I106_XG_n1 I1_I1574_P10_9 I1_I1574_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I106_XG_MN1 (VSS I1_I1574_G8_7 XI1_I1574_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I104_XG_MN2 (I1_I1574_G8_5n I1_I1574_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I104_XG_MN0 (XI1_I1574_I104_XG_n1 I1_I1574_P8_7 I1_I1574_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I104_XG_MN1 (VSS I1_I1574_G6_5 XI1_I1574_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I102_XG_MN2 (I1_I1574_G6_3n I1_I1574_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I102_XG_MN0 (XI1_I1574_I102_XG_n1 I1_I1574_P6_5 I1_I1574_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I102_XG_MN1 (VSS I1_I1574_G4_3 XI1_I1574_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I260_MN2 (I2_I3_q14_2 I2_I3_o14_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I260_MN0 (XI2_I3_I260_n1 I2_I3_SEL_AS_b3_2 I2_I3_q14_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I260_MN1 (VSS I2_S_14 XI2_I3_I260_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I272_MN2 (I2_I3_q15_2 I2_I3_o15_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I272_MN0 (XI2_I3_I272_n1 I2_I3_SEL_AS_b3_2 I2_I3_q15_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I272_MN1 (VSS I2_S_15 XI2_I3_I272_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I165_XG_MN2 (I2_I1_I42_G14_0n I2_I1_I42_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I165_XG_MN0 (XI2_I1_I42_I165_XG_n1 I2_I1_I42_P14_7 I2_I1_I42_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I165_XG_MN1 (VSS I2_I1_I42_G6_0 XI2_I1_I42_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I113_XG_MN2 (I2_I1_I42_G17_14n I2_I1_I42_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I113_XG_MN0 (XI2_I1_I42_I113_XG_n1 I2_I1_I42_P17_16 I2_I1_I42_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I113_XG_MN1 (VSS I2_I1_I42_G15_14 XI2_I1_I42_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I173_XG_MN2 (I2_I1_I42_G22_7n I2_I1_I42_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I173_XG_MN0 (XI2_I1_I42_I173_XG_n1 I2_I1_I42_P22_15 I2_I1_I42_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I173_XG_MN1 (VSS I2_I1_I42_G14_7 XI2_I1_I42_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I177_XG_MN2 (I2_I1_I42_G26_11n I2_I1_I42_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I177_XG_MN0 (XI2_I1_I42_I177_XG_n1 I2_I1_I42_P26_19 I2_I1_I42_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I177_XG_MN1 (VSS I2_I1_I42_G18_11 XI2_I1_I42_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I115_XG_MN2 (I2_I1_I42_G19_16n I2_I1_I42_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I115_XG_MN0 (XI2_I1_I42_I115_XG_n1 I2_I1_I42_P19_18 I2_I1_I42_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I115_XG_MN1 (VSS I2_I1_I42_G17_16 XI2_I1_I42_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I117_XG_MN2 (I2_I1_I42_G21_18n I2_I1_I42_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I117_XG_MN0 (XI2_I1_I42_I117_XG_n1 I2_I1_I42_P21_20 I2_I1_I42_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I117_XG_MN1 (VSS I2_I1_I42_G19_18 XI2_I1_I42_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I181_XG_MN2 (I2_I1_I42_G30_15n I2_I1_I42_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I181_XG_MN0 (XI2_I1_I42_I181_XG_n1 I2_I1_I42_P30_23 I2_I1_I42_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I181_XG_MN1 (VSS I2_I1_I42_G22_15 XI2_I1_I42_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I119_XG_MN2 (I2_I1_I42_G23_20n I2_I1_I42_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I119_XG_MN0 (XI2_I1_I42_I119_XG_n1 I2_I1_I42_P23_22 I2_I1_I42_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I119_XG_MN1 (VSS I2_I1_I42_G21_20 XI2_I1_I42_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I126_XG_MN2 (I2_I1_I42_G30_27n I2_I1_I42_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I126_XG_MN0 (XI2_I1_I42_I126_XG_n1 I2_I1_I42_P30_29 I2_I1_I42_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I126_XG_MN1 (VSS I2_I1_I42_G28_27 XI2_I1_I42_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I380_MN2 (I2_I3_q24_2 I2_I3_o24_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I380_MN0 (XI2_I3_I380_n1 I2_I3_SEL_AS_b3_4 I2_I3_q24_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I380_MN1 (VSS I2_S_24 XI2_I3_I380_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I404_MN2 (I2_I3_q26_2 I2_I3_o26_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I404_MN0 (XI2_I3_I404_n1 I2_I3_SEL_AS_b3_4 I2_I3_q26_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I404_MN1 (VSS I2_S_26 XI2_I3_I404_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I416_MN2 (I2_I3_q27_2 I2_I3_o27_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I416_MN0 (XI2_I3_I416_n1 I2_I3_SEL_AS_b3_5 I2_I3_q27_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I416_MN1 (VSS I2_S_27 XI2_I3_I416_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I428_MN2 (I2_I3_q28_2 I2_I3_o28_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I428_MN0 (XI2_I3_I428_n1 I2_I3_SEL_AS_b3_5 I2_I3_q28_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I428_MN1 (VSS I2_S_28 XI2_I3_I428_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I126_XG_MN2 (I1_I1712_G30_27n I1_I1712_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I126_XG_MN0 (XI1_I1712_I126_XG_n1 I1_I1712_P30_29 I1_I1712_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I126_XG_MN1 (VSS I1_I1712_G28_27 XI1_I1712_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I124_XG_MN2 (I1_I1712_G28_25n I1_I1712_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I124_XG_MN0 (XI1_I1712_I124_XG_n1 I1_I1712_P28_27 I1_I1712_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I124_XG_MN1 (VSS I1_I1712_G26_25 XI1_I1712_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I122_XG_MN2 (I1_I1712_G26_23n I1_I1712_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I122_XG_MN0 (XI1_I1712_I122_XG_n1 I1_I1712_P26_25 I1_I1712_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I122_XG_MN1 (VSS I1_I1712_G24_23 XI1_I1712_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I120_XG_MN2 (I1_I1712_G24_21n I1_I1712_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I120_XG_MN0 (XI1_I1712_I120_XG_n1 I1_I1712_P24_23 I1_I1712_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I120_XG_MN1 (VSS I1_I1712_G22_21 XI1_I1712_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I175_XG_MN2 (I1_I1712_G24_9n I1_I1712_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I175_XG_MN0 (XI1_I1712_I175_XG_n1 I1_I1712_P24_17 I1_I1712_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I175_XG_MN1 (VSS I1_I1712_G16_9 XI1_I1712_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I167_XG_MN2 (I1_I1712_G16_1n I1_I1712_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I167_XG_MN0 (XI1_I1712_I167_XG_n1 I1_I1712_P16_9 I1_I1712_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I167_XG_MN1 (VSS I1_I1712_G8_1 XI1_I1712_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I157_XG_MN2 (I1_I1712_G8_0n I1_I1712_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I157_XG_MN0 (XI1_I1712_I157_XG_n1 I1_I1712_P8_1 I1_I1712_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I157_XG_MN1 (VSS I1_I1712_G0_0 XI1_I1712_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I100_XG_MN2 (I1_I1712_G4_1n I1_I1712_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I100_XG_MN0 (XI1_I1712_I100_XG_n1 I1_I1712_P4_3 I1_I1712_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I100_XG_MN1 (VSS I1_I1712_G2_1 XI1_I1712_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I98_XG_MN2 (I1_I1712_G2_0n I1_I1712_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I98_XG_MN0 (XI1_I1712_I98_XG_n1 I1_I1712_P2_1 I1_I1712_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I98_XG_MN1 (VSS I1_I1712_G0_0 XI1_I1712_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I126_XG_MN2 (I1_I1574_G30_27n I1_I1574_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I126_XG_MN0 (XI1_I1574_I126_XG_n1 I1_I1574_P30_29 I1_I1574_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I126_XG_MN1 (VSS I1_I1574_G28_27 XI1_I1574_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I124_XG_MN2 (I1_I1574_G28_25n I1_I1574_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I124_XG_MN0 (XI1_I1574_I124_XG_n1 I1_I1574_P28_27 I1_I1574_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I124_XG_MN1 (VSS I1_I1574_G26_25 XI1_I1574_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I179_XG_MN2 (I1_I1574_G28_13n I1_I1574_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I179_XG_MN0 (XI1_I1574_I179_XG_n1 I1_I1574_P28_21 I1_I1574_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I179_XG_MN1 (VSS I1_I1574_G20_13 XI1_I1574_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I171_XG_MN2 (I1_I1574_G20_5n I1_I1574_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I171_XG_MN0 (XI1_I1574_I171_XG_n1 I1_I1574_P20_13 I1_I1574_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I171_XG_MN1 (VSS I1_I1574_G12_5 XI1_I1574_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I163_XG_MN2 (I1_I1574_G12_0n I1_I1574_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I163_XG_MN0 (XI1_I1574_I163_XG_n1 I1_I1574_P12_5 I1_I1574_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I163_XG_MN1 (VSS I1_I1574_G4_0 XI1_I1574_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I175_XG_MN2 (I1_I1574_G24_9n I1_I1574_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I175_XG_MN0 (XI1_I1574_I175_XG_n1 I1_I1574_P24_17 I1_I1574_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I175_XG_MN1 (VSS I1_I1574_G16_9 XI1_I1574_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I167_XG_MN2 (I1_I1574_G16_1n I1_I1574_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I167_XG_MN0 (XI1_I1574_I167_XG_n1 I1_I1574_P16_9 I1_I1574_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I167_XG_MN1 (VSS I1_I1574_G8_1 XI1_I1574_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I100_XG_MN2 (I1_I1574_G4_1n I1_I1574_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I100_XG_MN0 (XI1_I1574_I100_XG_n1 I1_I1574_P4_3 I1_I1574_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I100_XG_MN1 (VSS I1_I1574_G2_1 XI1_I1574_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I236_MN2 (I2_I3_q12_2 I2_I3_o12_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I236_MN0 (XI2_I3_I236_n1 I2_I3_SEL_AS_b3_2 I2_I3_q12_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I236_MN1 (VSS I2_S_12 XI2_I3_I236_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I108_XG_MN2 (I2_I1_I42_G12_9n I2_I1_I42_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I108_XG_MN0 (XI2_I1_I42_I108_XG_n1 I2_I1_I42_P12_11 I2_I1_I42_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I108_XG_MN1 (VSS I2_I1_I42_G10_9 XI2_I1_I42_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I175_XG_MN2 (I2_I1_I42_G24_9n I2_I1_I42_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I175_XG_MN0 (XI2_I1_I42_I175_XG_n1 I2_I1_I42_P24_17 I2_I1_I42_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I175_XG_MN1 (VSS I2_I1_I42_G16_9 XI2_I1_I42_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I169_XG_MN2 (I2_I1_I42_G18_3n I2_I1_I42_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I169_XG_MN0 (XI2_I1_I42_I169_XG_n1 I2_I1_I42_P18_11 I2_I1_I42_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I169_XG_MN1 (VSS I2_I1_I42_G10_3 XI2_I1_I42_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I111_XG_MN2 (I2_I1_I42_G15_12n I2_I1_I42_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I111_XG_MN0 (XI2_I1_I42_I111_XG_n1 I2_I1_I42_P15_14 I2_I1_I42_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I111_XG_MN1 (VSS I2_I1_I42_G13_12 XI2_I1_I42_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I178_XG_MN2 (I2_I1_I42_G27_12n I2_I1_I42_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I178_XG_MN0 (XI2_I1_I42_I178_XG_n1 I2_I1_I42_P27_20 I2_I1_I42_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I178_XG_MN1 (VSS I2_I1_I42_G19_12 XI2_I1_I42_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I121_XG_MN2 (I2_I1_I42_G25_22n I2_I1_I42_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I121_XG_MN0 (XI2_I1_I42_I121_XG_n1 I2_I1_I42_P25_24 I2_I1_I42_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I121_XG_MN1 (VSS I2_I1_I42_G23_22 XI2_I1_I42_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I123_XG_MN2 (I2_I1_I42_G27_24n I2_I1_I42_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I123_XG_MN0 (XI2_I1_I42_I123_XG_n1 I2_I1_I42_P27_26 I2_I1_I42_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I123_XG_MN1 (VSS I2_I1_I42_G25_24 XI2_I1_I42_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I125_XG_MN2 (I2_I1_I42_G29_26n I2_I1_I42_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I125_XG_MN0 (XI2_I1_I42_I125_XG_n1 I2_I1_I42_P29_28 I2_I1_I42_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I125_XG_MN1 (VSS I2_I1_I42_G27_26 XI2_I1_I42_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I127_XG_MN2 (I2_I1_I42_G31_28n I2_I1_I42_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I127_XG_MN0 (XI2_I1_I42_I127_XG_n1 I2_I1_I42_P31_30 I2_I1_I42_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I127_XG_MN1 (VSS I2_I1_I42_G29_28 XI2_I1_I42_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I452_MN2 (I2_I3_q30_2 I2_I3_o30_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I452_MN0 (XI2_I3_I452_n1 I2_I3_SEL_AS_b3_5 I2_I3_q30_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I452_MN1 (VSS I2_S_30 XI2_I3_I452_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I464_MN2 (I2_I3_q31_2 I2_I3_o31_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I464_MN0 (XI2_I3_I464_n1 I2_I3_SEL_AS_b3_5 I2_I3_q31_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I464_MN1 (VSS I2_S_31 XI2_I3_I464_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I181_XG_MN2 (I1_I1712_G30_15n I1_I1712_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I181_XG_MN0 (XI1_I1712_I181_XG_n1 I1_I1712_P30_23 I1_I1712_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I181_XG_MN1 (VSS I1_I1712_G22_15 XI1_I1712_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I118_XG_MN2 (I1_I1712_G22_19n I1_I1712_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I118_XG_MN0 (XI1_I1712_I118_XG_n1 I1_I1712_P22_21 I1_I1712_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I118_XG_MN1 (VSS I1_I1712_G20_19 XI1_I1712_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I177_XG_MN2 (I1_I1712_G26_11n I1_I1712_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I177_XG_MN0 (XI1_I1712_I177_XG_n1 I1_I1712_P26_19 I1_I1712_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I177_XG_MN1 (VSS I1_I1712_G18_11 XI1_I1712_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I173_XG_MN2 (I1_I1712_G22_7n I1_I1712_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I173_XG_MN0 (XI1_I1712_I173_XG_n1 I1_I1712_P22_15 I1_I1712_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I173_XG_MN1 (VSS I1_I1712_G14_7 XI1_I1712_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I165_XG_MN2 (I1_I1712_G14_0n I1_I1712_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I165_XG_MN0 (XI1_I1712_I165_XG_n1 I1_I1712_P14_7 I1_I1712_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I165_XG_MN1 (VSS I1_I1712_G6_0 XI1_I1712_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I169_XG_MN2 (I1_I1712_G18_3n I1_I1712_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I169_XG_MN0 (XI1_I1712_I169_XG_n1 I1_I1712_P18_11 I1_I1712_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I169_XG_MN1 (VSS I1_I1712_G10_3 XI1_I1712_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I160_XG_MN2 (I1_I1712_G10_0n I1_I1712_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I160_XG_MN0 (XI1_I1712_I160_XG_n1 I1_I1712_P10_3 I1_I1712_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I160_XG_MN1 (VSS I1_I1712_G2_0np XI1_I1712_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I104_XG_MN2 (I1_I1712_G8_5n I1_I1712_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I104_XG_MN0 (XI1_I1712_I104_XG_n1 I1_I1712_P8_7 I1_I1712_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I104_XG_MN1 (VSS I1_I1712_G6_5 XI1_I1712_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I102_XG_MN2 (I1_I1712_G6_3n I1_I1712_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I102_XG_MN0 (XI1_I1712_I102_XG_n1 I1_I1712_P6_5 I1_I1712_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I102_XG_MN1 (VSS I1_I1712_G4_3 XI1_I1712_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I122_XG_MN2 (I1_I1574_G26_23n I1_I1574_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I122_XG_MN0 (XI1_I1574_I122_XG_n1 I1_I1574_P26_25 I1_I1574_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I122_XG_MN1 (VSS I1_I1574_G24_23 XI1_I1574_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I120_XG_MN2 (I1_I1574_G24_21n I1_I1574_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I120_XG_MN0 (XI1_I1574_I120_XG_n1 I1_I1574_P24_23 I1_I1574_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I120_XG_MN1 (VSS I1_I1574_G22_21 XI1_I1574_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I116_XG_MN2 (I1_I1574_G20_17n I1_I1574_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I116_XG_MN0 (XI1_I1574_I116_XG_n1 I1_I1574_P20_19 I1_I1574_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I116_XG_MN1 (VSS I1_I1574_G18_17 XI1_I1574_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I114_XG_MN2 (I1_I1574_G18_15n I1_I1574_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I114_XG_MN0 (XI1_I1574_I114_XG_n1 I1_I1574_P18_17 I1_I1574_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I114_XG_MN1 (VSS I1_I1574_G16_15 XI1_I1574_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I157_XG_MN2 (I1_I1574_G8_0n I1_I1574_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I157_XG_MN0 (XI1_I1574_I157_XG_n1 I1_I1574_P8_1 I1_I1574_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I157_XG_MN1 (VSS I1_I1574_G0_0 XI1_I1574_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I98_XG_MN2 (I1_I1574_G2_0n I1_I1574_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I98_XG_MN0 (XI1_I1574_I98_XG_n1 I1_I1574_P2_1 I1_I1574_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I98_XG_MN1 (VSS I1_I1574_G0_0 XI1_I1574_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I224_MN2 (I2_I3_q11_2 I2_I3_o11_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I224_MN0 (XI2_I3_I224_n1 I2_I3_SEL_AS_b3_2 I2_I3_q11_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I224_MN1 (VSS I2_S_11 XI2_I3_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I106_XG_MN2 (I2_I1_I42_G10_7n I2_I1_I42_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I106_XG_MN0 (XI2_I1_I42_I106_XG_n1 I2_I1_I42_P10_9 I2_I1_I42_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I106_XG_MN1 (VSS I2_I1_I42_G8_7 XI2_I1_I42_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I160_XG_MN2 (I2_I1_I42_G10_0n I2_I1_I42_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I160_XG_MN0 (XI2_I1_I42_I160_XG_n1 I2_I1_I42_P10_3 I2_I1_I42_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I160_XG_MN1 (VSS I2_I1_I42_G2_0np XI2_I1_I42_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I109_XG_MN2 (I2_I1_I42_G13_10n I2_I1_I42_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I109_XG_MN0 (XI2_I1_I42_I109_XG_n1 I2_I1_I42_P13_12 I2_I1_I42_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I109_XG_MN1 (VSS I2_I1_I42_G11_10 XI2_I1_I42_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I164_XG_MN2 (I2_I1_I42_G13_0n I2_I1_I42_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I164_XG_MN0 (XI2_I1_I42_I164_XG_n1 I2_I1_I42_P13_6 I2_I1_I42_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I164_XG_MN1 (VSS I2_I1_I42_G5_0 XI2_I1_I42_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I172_XG_MN2 (I2_I1_I42_G21_6n I2_I1_I42_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I172_XG_MN0 (XI2_I1_I42_I172_XG_n1 I2_I1_I42_P21_14 I2_I1_I42_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I172_XG_MN1 (VSS I2_I1_I42_G13_6 XI2_I1_I42_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I166_XG_MN2 (I2_I1_I42_G15_0n I2_I1_I42_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I166_XG_MN0 (XI2_I1_I42_I166_XG_n1 I2_I1_I42_P15_8 I2_I1_I42_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I166_XG_MN1 (VSS I2_I1_I42_G7_0 XI2_I1_I42_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I174_XG_MN2 (I2_I1_I42_G23_8n I2_I1_I42_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I174_XG_MN0 (XI2_I1_I42_I174_XG_n1 I2_I1_I42_P23_16 I2_I1_I42_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I174_XG_MN1 (VSS I2_I1_I42_G15_8 XI2_I1_I42_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I180_XG_MN2 (I2_I1_I42_G29_14n I2_I1_I42_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I180_XG_MN0 (XI2_I1_I42_I180_XG_n1 I2_I1_I42_P29_22 I2_I1_I42_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I180_XG_MN1 (VSS I2_I1_I42_G21_14 XI2_I1_I42_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I182_XG_MN2 (I2_I1_I42_G31_16n I2_I1_I42_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I182_XG_MN0 (XI2_I1_I42_I182_XG_n1 I2_I1_I42_P31_24 I2_I1_I42_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I182_XG_MN1 (VSS I2_I1_I42_G23_16 XI2_I1_I42_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I116_XG_MN2 (I1_I1712_G20_17n I1_I1712_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I116_XG_MN0 (XI1_I1712_I116_XG_n1 I1_I1712_P20_19 I1_I1712_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I116_XG_MN1 (VSS I1_I1712_G18_17 XI1_I1712_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I108_XG_MN2 (I1_I1712_G12_9n I1_I1712_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I108_XG_MN0 (XI1_I1712_I108_XG_n1 I1_I1712_P12_11 I1_I1712_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I108_XG_MN1 (VSS I1_I1712_G10_9 XI1_I1712_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I106_XG_MN2 (I1_I1712_G10_7n I1_I1712_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I106_XG_MN0 (XI1_I1712_I106_XG_n1 I1_I1712_P10_9 I1_I1712_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I106_XG_MN1 (VSS I1_I1712_G8_7 XI1_I1712_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I118_XG_MN2 (I1_I1574_G22_19n I1_I1574_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I118_XG_MN0 (XI1_I1574_I118_XG_n1 I1_I1574_P22_21 I1_I1574_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I118_XG_MN1 (VSS I1_I1574_G20_19 XI1_I1574_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I177_XG_MN2 (I1_I1574_G26_11n I1_I1574_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I177_XG_MN0 (XI1_I1574_I177_XG_n1 I1_I1574_P26_19 I1_I1574_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I177_XG_MN1 (VSS I1_I1574_G18_11 XI1_I1574_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I169_XG_MN2 (I1_I1574_G18_3n I1_I1574_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I169_XG_MN0 (XI1_I1574_I169_XG_n1 I1_I1574_P18_11 I1_I1574_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I169_XG_MN1 (VSS I1_I1574_G10_3 XI1_I1574_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I160_XG_MN2 (I1_I1574_G10_0n I1_I1574_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I160_XG_MN0 (XI1_I1574_I160_XG_n1 I1_I1574_P10_3 I1_I1574_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I160_XG_MN1 (VSS I1_I1574_G2_0np XI1_I1574_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I63_MN2 (I1_nakn10 I1_nak9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I63_MN0 (XI1_I63_n1 I1_A_31_b3_1 I1_nakn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I63_MN1 (VSS A_9 XI1_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I167_XG_MN2 (I2_I1_I42_G16_1n I2_I1_I42_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I167_XG_MN0 (XI2_I1_I42_I167_XG_n1 I2_I1_I42_P16_9 I2_I1_I42_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I167_XG_MN1 (VSS I2_I1_I42_G8_1 XI2_I1_I42_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I107_XG_MN2 (I2_I1_I42_G11_8n I2_I1_I42_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I107_XG_MN0 (XI2_I1_I42_I107_XG_n1 I2_I1_I42_P11_10 I2_I1_I42_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I107_XG_MN1 (VSS I2_I1_I42_G9_8 XI2_I1_I42_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I162_XG_MN2 (I2_I1_I42_G11_0n I2_I1_I42_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I162_XG_MN0 (XI2_I1_I42_I162_XG_n1 I2_I1_I42_P11_4 I2_I1_I42_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I162_XG_MN1 (VSS I2_I1_I42_G3_0np XI2_I1_I42_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I168_XG_MN2 (I2_I1_I42_G17_2n I2_I1_I42_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I168_XG_MN0 (XI2_I1_I42_I168_XG_n1 I2_I1_I42_P17_10 I2_I1_I42_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I168_XG_MN1 (VSS I2_I1_I42_G9_2 XI2_I1_I42_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I170_XG_MN2 (I2_I1_I42_G19_4n I2_I1_I42_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I170_XG_MN0 (XI2_I1_I42_I170_XG_n1 I2_I1_I42_P19_12 I2_I1_I42_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I170_XG_MN1 (VSS I2_I1_I42_G11_4 XI2_I1_I42_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I176_XG_MN2 (I2_I1_I42_G25_10n I2_I1_I42_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I176_XG_MN0 (XI2_I1_I42_I176_XG_n1 I2_I1_I42_P25_18 I2_I1_I42_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I176_XG_MN1 (VSS I2_I1_I42_G17_10 XI2_I1_I42_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I98_XG_MN2 (I1_I1666_G2_0n I1_I1666_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I98_XG_MN0 (XI1_I1666_I98_XG_n1 I1_I1666_P2_1 I1_I1666_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I98_XG_MN1 (VSS I1_I1666_G0_0 XI1_I1666_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I181_XG_MN2 (I1_I1574_G30_15n I1_I1574_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I181_XG_MN0 (XI1_I1574_I181_XG_n1 I1_I1574_P30_23 I1_I1574_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I181_XG_MN1 (VSS I1_I1574_G22_15 XI1_I1574_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I173_XG_MN2 (I1_I1574_G22_7n I1_I1574_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I173_XG_MN0 (XI1_I1574_I173_XG_n1 I1_I1574_P22_15 I1_I1574_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I173_XG_MN1 (VSS I1_I1574_G14_7 XI1_I1574_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I165_XG_MN2 (I1_I1574_G14_0n I1_I1574_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I165_XG_MN0 (XI1_I1574_I165_XG_n1 I1_I1574_P14_7 I1_I1574_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I165_XG_MN1 (VSS I1_I1574_G6_0 XI1_I1574_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I60_MN2 (I1_nakn9 I1_nak8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I60_MN0 (XI1_I60_n1 I1_A_31_b3_1 I1_nakn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I60_MN1 (VSS A_8 XI1_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I104_XG_MN2 (I2_I1_I42_G8_5n I2_I1_I42_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I104_XG_MN0 (XI2_I1_I42_I104_XG_n1 I2_I1_I42_P8_7 I2_I1_I42_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I104_XG_MN1 (VSS I2_I1_I42_G6_5 XI2_I1_I42_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I157_XG_MN2 (I2_I1_I42_G8_0n I2_I1_I42_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I157_XG_MN0 (XI2_I1_I42_I157_XG_n1 I2_I1_I42_P8_1 I2_I1_I42_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I157_XG_MN1 (VSS I2_I1_I42_G0_0 XI2_I1_I42_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I105_XG_MN2 (I2_I1_I42_G9_6n I2_I1_I42_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I105_XG_MN0 (XI2_I1_I42_I105_XG_n1 I2_I1_I42_P9_8 I2_I1_I42_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I105_XG_MN1 (VSS I2_I1_I42_G7_6 XI2_I1_I42_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I103_XG_MN2 (I2_I1_I42_G7_4n I2_I1_I42_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I103_XG_MN0 (XI2_I1_I42_I103_XG_n1 I2_I1_I42_P7_6 I2_I1_I42_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I103_XG_MN1 (VSS I2_I1_I42_G5_4 XI2_I1_I42_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I158_XG_MN2 (I2_I1_I42_G9_0n I2_I1_I42_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I158_XG_MN0 (XI2_I1_I42_I158_XG_n1 I2_I1_I42_P9_2 I2_I1_I42_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I158_XG_MN1 (VSS I2_I1_I42_G1_0 XI2_I1_I42_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I100_XG_MN2 (I1_I1666_G4_1n I1_I1666_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I100_XG_MN0 (XI1_I1666_I100_XG_n1 I1_I1666_P4_3 I1_I1666_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I100_XG_MN1 (VSS I1_I1666_G2_1 XI1_I1666_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I99_XG_MN2 (I1_I1666_G3_0n I1_I1666_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I99_XG_MN0 (XI1_I1666_I99_XG_n1 I1_I1666_P3_2 I1_I1666_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I99_XG_MN1 (VSS I1_I1666_G1_0 XI1_I1666_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I101_XG_MN2 (I1_I1666_G5_2n I1_I1666_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I101_XG_MN0 (XI1_I1666_I101_XG_n1 I1_I1666_P5_4 I1_I1666_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I101_XG_MN1 (VSS I1_I1666_G3_2 XI1_I1666_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I54_MN2 (I1_nakn7 I1_nak6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I54_MN0 (XI1_I54_n1 I1_A_31_b3_1 I1_nakn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I54_MN1 (VSS A_6 XI1_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I57_MN2 (I1_nakn8 I1_nak7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I57_MN0 (XI1_I57_n1 I1_A_31_b3_1 I1_nakn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I57_MN1 (VSS A_7 XI1_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I102_XG_MN2 (I2_I1_I42_G6_3n I2_I1_I42_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I102_XG_MN0 (XI2_I1_I42_I102_XG_n1 I2_I1_I42_P6_5 I2_I1_I42_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I102_XG_MN1 (VSS I2_I1_I42_G4_3 XI2_I1_I42_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I101_XG_MN2 (I2_I1_I42_G5_2n I2_I1_I42_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I101_XG_MN0 (XI2_I1_I42_I101_XG_n1 I2_I1_I42_P5_4 I2_I1_I42_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I101_XG_MN1 (VSS I2_I1_I42_G3_2 XI2_I1_I42_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I167_XG_MN2 (I1_I1666_G16_1n I1_I1666_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I167_XG_MN0 (XI1_I1666_I167_XG_n1 I1_I1666_P16_9 I1_I1666_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I167_XG_MN1 (VSS I1_I1666_G8_1 XI1_I1666_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I157_XG_MN2 (I1_I1666_G8_0n I1_I1666_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I157_XG_MN0 (XI1_I1666_I157_XG_n1 I1_I1666_P8_1 I1_I1666_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I157_XG_MN1 (VSS I1_I1666_G0_0 XI1_I1666_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I104_XG_MN2 (I1_I1666_G8_5n I1_I1666_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I104_XG_MN0 (XI1_I1666_I104_XG_n1 I1_I1666_P8_7 I1_I1666_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I104_XG_MN1 (VSS I1_I1666_G6_5 XI1_I1666_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I102_XG_MN2 (I1_I1666_G6_3n I1_I1666_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I102_XG_MN0 (XI1_I1666_I102_XG_n1 I1_I1666_P6_5 I1_I1666_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I102_XG_MN1 (VSS I1_I1666_G4_3 XI1_I1666_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I103_XG_MN2 (I1_I1666_G7_4n I1_I1666_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I103_XG_MN0 (XI1_I1666_I103_XG_n1 I1_I1666_P7_6 I1_I1666_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I103_XG_MN1 (VSS I1_I1666_G5_4 XI1_I1666_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I100_XG_MN2 (I2_I1_I42_G4_1n I2_I1_I42_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I100_XG_MN0 (XI2_I1_I42_I100_XG_n1 I2_I1_I42_P4_3 I2_I1_I42_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I100_XG_MN1 (VSS I2_I1_I42_G2_1 XI2_I1_I42_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I99_XG_MN2 (I2_I1_I42_G3_0n I2_I1_I42_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I99_XG_MN0 (XI2_I1_I42_I99_XG_n1 I2_I1_I42_P3_2 I2_I1_I42_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I99_XG_MN1 (VSS I2_I1_I42_G1_0 XI2_I1_I42_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I160_XG_MN2 (I1_I1666_G10_0n I1_I1666_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I160_XG_MN0 (XI1_I1666_I160_XG_n1 I1_I1666_P10_3 I1_I1666_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I160_XG_MN1 (VSS I1_I1666_G2_0np XI1_I1666_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I169_XG_MN2 (I1_I1666_G18_3n I1_I1666_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I169_XG_MN0 (XI1_I1666_I169_XG_n1 I1_I1666_P18_11 I1_I1666_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I169_XG_MN1 (VSS I1_I1666_G10_3 XI1_I1666_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I106_XG_MN2 (I1_I1666_G10_7n I1_I1666_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I106_XG_MN0 (XI1_I1666_I106_XG_n1 I1_I1666_P10_9 I1_I1666_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I106_XG_MN1 (VSS I1_I1666_G8_7 XI1_I1666_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I158_XG_MN2 (I1_I1666_G9_0n I1_I1666_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I158_XG_MN0 (XI1_I1666_I158_XG_n1 I1_I1666_P9_2 I1_I1666_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I158_XG_MN1 (VSS I1_I1666_G1_0 XI1_I1666_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I168_XG_MN2 (I1_I1666_G17_2n I1_I1666_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I168_XG_MN0 (XI1_I1666_I168_XG_n1 I1_I1666_P17_10 I1_I1666_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I168_XG_MN1 (VSS I1_I1666_G9_2 XI1_I1666_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I105_XG_MN2 (I1_I1666_G9_6n I1_I1666_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I105_XG_MN0 (XI1_I1666_I105_XG_n1 I1_I1666_P9_8 I1_I1666_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I105_XG_MN1 (VSS I1_I1666_G7_6 XI1_I1666_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I98_XG_MN2 (I2_I1_I42_G2_0n I2_I1_I42_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I98_XG_MN0 (XI2_I1_I42_I98_XG_n1 I2_I1_I42_P2_1 I2_I1_I42_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I98_XG_MN1 (VSS I2_I1_I42_G0_0 XI2_I1_I42_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I163_XG_MN2 (I1_I1666_G12_0n I1_I1666_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I163_XG_MN0 (XI1_I1666_I163_XG_n1 I1_I1666_P12_5 I1_I1666_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I163_XG_MN1 (VSS I1_I1666_G4_0 XI1_I1666_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I171_XG_MN2 (I1_I1666_G20_5n I1_I1666_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I171_XG_MN0 (XI1_I1666_I171_XG_n1 I1_I1666_P20_13 I1_I1666_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I171_XG_MN1 (VSS I1_I1666_G12_5 XI1_I1666_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I108_XG_MN2 (I1_I1666_G12_9n I1_I1666_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I108_XG_MN0 (XI1_I1666_I108_XG_n1 I1_I1666_P12_11 I1_I1666_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I108_XG_MN1 (VSS I1_I1666_G10_9 XI1_I1666_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I162_XG_MN2 (I1_I1666_G11_0n I1_I1666_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I162_XG_MN0 (XI1_I1666_I162_XG_n1 I1_I1666_P11_4 I1_I1666_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I162_XG_MN1 (VSS I1_I1666_G3_0np XI1_I1666_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I170_XG_MN2 (I1_I1666_G19_4n I1_I1666_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I170_XG_MN0 (XI1_I1666_I170_XG_n1 I1_I1666_P19_12 I1_I1666_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I170_XG_MN1 (VSS I1_I1666_G11_4 XI1_I1666_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I107_XG_MN2 (I1_I1666_G11_8n I1_I1666_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I107_XG_MN0 (XI1_I1666_I107_XG_n1 I1_I1666_P11_10 I1_I1666_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I107_XG_MN1 (VSS I1_I1666_G9_8 XI1_I1666_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I98_XG_MN2 (I1_I1620_G2_0n I1_I1620_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I98_XG_MN0 (XI1_I1620_I98_XG_n1 I1_I1620_P2_1 I1_I1620_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I98_XG_MN1 (VSS I1_I1620_G0_0 XI1_I1620_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I177_XG_MN2 (I1_I1666_G26_11n I1_I1666_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I177_XG_MN0 (XI1_I1666_I177_XG_n1 I1_I1666_P26_19 I1_I1666_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I177_XG_MN1 (VSS I1_I1666_G18_11 XI1_I1666_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I175_XG_MN2 (I1_I1666_G24_9n I1_I1666_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I175_XG_MN0 (XI1_I1666_I175_XG_n1 I1_I1666_P24_17 I1_I1666_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I175_XG_MN1 (VSS I1_I1666_G16_9 XI1_I1666_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I110_XG_MN2 (I1_I1666_G14_11n I1_I1666_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I110_XG_MN0 (XI1_I1666_I110_XG_n1 I1_I1666_P14_13 I1_I1666_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I110_XG_MN1 (VSS I1_I1666_G12_11 XI1_I1666_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I164_XG_MN2 (I1_I1666_G13_0n I1_I1666_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I164_XG_MN0 (XI1_I1666_I164_XG_n1 I1_I1666_P13_6 I1_I1666_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I164_XG_MN1 (VSS I1_I1666_G5_0 XI1_I1666_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I176_XG_MN2 (I1_I1666_G25_10n I1_I1666_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I176_XG_MN0 (XI1_I1666_I176_XG_n1 I1_I1666_P25_18 I1_I1666_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I176_XG_MN1 (VSS I1_I1666_G17_10 XI1_I1666_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I109_XG_MN2 (I1_I1666_G13_10n I1_I1666_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I109_XG_MN0 (XI1_I1666_I109_XG_n1 I1_I1666_P13_12 I1_I1666_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I109_XG_MN1 (VSS I1_I1666_G11_10 XI1_I1666_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I106_XG_MN2 (I1_I1620_G10_7n I1_I1620_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I106_XG_MN0 (XI1_I1620_I106_XG_n1 I1_I1620_P10_9 I1_I1620_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I106_XG_MN1 (VSS I1_I1620_G8_7 XI1_I1620_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I102_XG_MN2 (I1_I1620_G6_3n I1_I1620_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I102_XG_MN0 (XI1_I1620_I102_XG_n1 I1_I1620_P6_5 I1_I1620_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I102_XG_MN1 (VSS I1_I1620_G4_3 XI1_I1620_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I99_XG_MN2 (I1_I1620_G3_0n I1_I1620_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I99_XG_MN0 (XI1_I1620_I99_XG_n1 I1_I1620_P3_2 I1_I1620_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I99_XG_MN1 (VSS I1_I1620_G1_0 XI1_I1620_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I100_XG_MN2 (I1_I1620_G4_1n I1_I1620_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I100_XG_MN0 (XI1_I1620_I100_XG_n1 I1_I1620_P4_3 I1_I1620_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I100_XG_MN1 (VSS I1_I1620_G2_1 XI1_I1620_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I127_XG_MN2 (I1_I1758_G31_28n I1_I1758_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I127_XG_MN0 (XI1_I1758_I127_XG_n1 I1_I1758_P31_30 I1_I1758_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I127_XG_MN1 (VSS I1_I1758_G29_28 XI1_I1758_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I125_XG_MN2 (I1_I1758_G29_26n I1_I1758_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I125_XG_MN0 (XI1_I1758_I125_XG_n1 I1_I1758_P29_28 I1_I1758_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I125_XG_MN1 (VSS I1_I1758_G27_26 XI1_I1758_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I123_XG_MN2 (I1_I1758_G27_24n I1_I1758_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I123_XG_MN0 (XI1_I1758_I123_XG_n1 I1_I1758_P27_26 I1_I1758_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I123_XG_MN1 (VSS I1_I1758_G25_24 XI1_I1758_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I121_XG_MN2 (I1_I1758_G25_22n I1_I1758_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I121_XG_MN0 (XI1_I1758_I121_XG_n1 I1_I1758_P25_24 I1_I1758_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I121_XG_MN1 (VSS I1_I1758_G23_22 XI1_I1758_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I119_XG_MN2 (I1_I1758_G23_20n I1_I1758_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I119_XG_MN0 (XI1_I1758_I119_XG_n1 I1_I1758_P23_22 I1_I1758_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I119_XG_MN1 (VSS I1_I1758_G21_20 XI1_I1758_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I117_XG_MN2 (I1_I1758_G21_18n I1_I1758_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I117_XG_MN0 (XI1_I1758_I117_XG_n1 I1_I1758_P21_20 I1_I1758_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I117_XG_MN1 (VSS I1_I1758_G19_18 XI1_I1758_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I115_XG_MN2 (I1_I1758_G19_16n I1_I1758_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I115_XG_MN0 (XI1_I1758_I115_XG_n1 I1_I1758_P19_18 I1_I1758_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I115_XG_MN1 (VSS I1_I1758_G17_16 XI1_I1758_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I113_XG_MN2 (I1_I1758_G17_14n I1_I1758_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I113_XG_MN0 (XI1_I1758_I113_XG_n1 I1_I1758_P17_16 I1_I1758_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I113_XG_MN1 (VSS I1_I1758_G15_14 XI1_I1758_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I111_XG_MN2 (I1_I1758_G15_12n I1_I1758_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I111_XG_MN0 (XI1_I1758_I111_XG_n1 I1_I1758_P15_14 I1_I1758_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I111_XG_MN1 (VSS I1_I1758_G13_12 XI1_I1758_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I165_XG_MN2 (I1_I1666_G14_0n I1_I1666_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I165_XG_MN0 (XI1_I1666_I165_XG_n1 I1_I1666_P14_7 I1_I1666_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I165_XG_MN1 (VSS I1_I1666_G6_0 XI1_I1666_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I179_XG_MN2 (I1_I1666_G28_13n I1_I1666_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I179_XG_MN0 (XI1_I1666_I179_XG_n1 I1_I1666_P28_21 I1_I1666_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I179_XG_MN1 (VSS I1_I1666_G20_13 XI1_I1666_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I112_XG_MN2 (I1_I1666_G16_13n I1_I1666_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I112_XG_MN0 (XI1_I1666_I112_XG_n1 I1_I1666_P16_15 I1_I1666_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I112_XG_MN1 (VSS I1_I1666_G14_13 XI1_I1666_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I172_XG_MN2 (I1_I1666_G21_6n I1_I1666_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I172_XG_MN0 (XI1_I1666_I172_XG_n1 I1_I1666_P21_14 I1_I1666_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I172_XG_MN1 (VSS I1_I1666_G13_6 XI1_I1666_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I111_XG_MN2 (I1_I1666_G15_12n I1_I1666_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I111_XG_MN0 (XI1_I1666_I111_XG_n1 I1_I1666_P15_14 I1_I1666_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I111_XG_MN1 (VSS I1_I1666_G13_12 XI1_I1666_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I160_XG_MN2 (I1_I1620_G10_0n I1_I1620_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I160_XG_MN0 (XI1_I1620_I160_XG_n1 I1_I1620_P10_3 I1_I1620_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I160_XG_MN1 (VSS I1_I1620_G2_0np XI1_I1620_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I110_XG_MN2 (I1_I1620_G14_11n I1_I1620_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I110_XG_MN0 (XI1_I1620_I110_XG_n1 I1_I1620_P14_13 I1_I1620_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I110_XG_MN1 (VSS I1_I1620_G12_11 XI1_I1620_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I108_XG_MN2 (I1_I1620_G12_9n I1_I1620_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I108_XG_MN0 (XI1_I1620_I108_XG_n1 I1_I1620_P12_11 I1_I1620_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I108_XG_MN1 (VSS I1_I1620_G10_9 XI1_I1620_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I104_XG_MN2 (I1_I1620_G8_5n I1_I1620_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I104_XG_MN0 (XI1_I1620_I104_XG_n1 I1_I1620_P8_7 I1_I1620_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I104_XG_MN1 (VSS I1_I1620_G6_5 XI1_I1620_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I107_XG_MN2 (I1_I1620_G11_8n I1_I1620_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I107_XG_MN0 (XI1_I1620_I107_XG_n1 I1_I1620_P11_10 I1_I1620_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I107_XG_MN1 (VSS I1_I1620_G9_8 XI1_I1620_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I105_XG_MN2 (I1_I1620_G9_6n I1_I1620_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I105_XG_MN0 (XI1_I1620_I105_XG_n1 I1_I1620_P9_8 I1_I1620_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I105_XG_MN1 (VSS I1_I1620_G7_6 XI1_I1620_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I103_XG_MN2 (I1_I1620_G7_4n I1_I1620_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I103_XG_MN0 (XI1_I1620_I103_XG_n1 I1_I1620_P7_6 I1_I1620_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I103_XG_MN1 (VSS I1_I1620_G5_4 XI1_I1620_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I101_XG_MN2 (I1_I1620_G5_2n I1_I1620_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I101_XG_MN0 (XI1_I1620_I101_XG_n1 I1_I1620_P5_4 I1_I1620_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I101_XG_MN1 (VSS I1_I1620_G3_2 XI1_I1620_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I167_XG_MN2 (I1_I1620_G16_1n I1_I1620_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I167_XG_MN0 (XI1_I1620_I167_XG_n1 I1_I1620_P16_9 I1_I1620_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I167_XG_MN1 (VSS I1_I1620_G8_1 XI1_I1620_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I157_XG_MN2 (I1_I1620_G8_0n I1_I1620_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I157_XG_MN0 (XI1_I1620_I157_XG_n1 I1_I1620_P8_1 I1_I1620_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I157_XG_MN1 (VSS I1_I1620_G0_0 XI1_I1620_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I182_XG_MN2 (I1_I1758_G31_16n I1_I1758_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I182_XG_MN0 (XI1_I1758_I182_XG_n1 I1_I1758_P31_24 I1_I1758_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I182_XG_MN1 (VSS I1_I1758_G23_16 XI1_I1758_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I180_XG_MN2 (I1_I1758_G29_14n I1_I1758_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I180_XG_MN0 (XI1_I1758_I180_XG_n1 I1_I1758_P29_22 I1_I1758_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I180_XG_MN1 (VSS I1_I1758_G21_14 XI1_I1758_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I174_XG_MN2 (I1_I1758_G23_8n I1_I1758_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I174_XG_MN0 (XI1_I1758_I174_XG_n1 I1_I1758_P23_16 I1_I1758_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I174_XG_MN1 (VSS I1_I1758_G15_8 XI1_I1758_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I178_XG_MN2 (I1_I1758_G27_12n I1_I1758_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I178_XG_MN0 (XI1_I1758_I178_XG_n1 I1_I1758_P27_20 I1_I1758_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I178_XG_MN1 (VSS I1_I1758_G19_12 XI1_I1758_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I176_XG_MN2 (I1_I1758_G25_10n I1_I1758_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I176_XG_MN0 (XI1_I1758_I176_XG_n1 I1_I1758_P25_18 I1_I1758_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I176_XG_MN1 (VSS I1_I1758_G17_10 XI1_I1758_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I109_XG_MN2 (I1_I1758_G13_10n I1_I1758_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I109_XG_MN0 (XI1_I1758_I109_XG_n1 I1_I1758_P13_12 I1_I1758_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I109_XG_MN1 (VSS I1_I1758_G11_10 XI1_I1758_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I107_XG_MN2 (I1_I1758_G11_8n I1_I1758_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I107_XG_MN0 (XI1_I1758_I107_XG_n1 I1_I1758_P11_10 I1_I1758_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I107_XG_MN1 (VSS I1_I1758_G9_8 XI1_I1758_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I173_XG_MN2 (I1_I1666_G22_7n I1_I1666_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I173_XG_MN0 (XI1_I1666_I173_XG_n1 I1_I1666_P22_15 I1_I1666_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I173_XG_MN1 (VSS I1_I1666_G14_7 XI1_I1666_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I116_XG_MN2 (I1_I1666_G20_17n I1_I1666_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I116_XG_MN0 (XI1_I1666_I116_XG_n1 I1_I1666_P20_19 I1_I1666_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I116_XG_MN1 (VSS I1_I1666_G18_17 XI1_I1666_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I114_XG_MN2 (I1_I1666_G18_15n I1_I1666_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I114_XG_MN0 (XI1_I1666_I114_XG_n1 I1_I1666_P18_17 I1_I1666_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I114_XG_MN1 (VSS I1_I1666_G16_15 XI1_I1666_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I166_XG_MN2 (I1_I1666_G15_0n I1_I1666_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I166_XG_MN0 (XI1_I1666_I166_XG_n1 I1_I1666_P15_8 I1_I1666_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I166_XG_MN1 (VSS I1_I1666_G7_0 XI1_I1666_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I178_XG_MN2 (I1_I1666_G27_12n I1_I1666_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I178_XG_MN0 (XI1_I1666_I178_XG_n1 I1_I1666_P27_20 I1_I1666_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I178_XG_MN1 (VSS I1_I1666_G19_12 XI1_I1666_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I115_XG_MN2 (I1_I1666_G19_16n I1_I1666_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I115_XG_MN0 (XI1_I1666_I115_XG_n1 I1_I1666_P19_18 I1_I1666_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I115_XG_MN1 (VSS I1_I1666_G17_16 XI1_I1666_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I113_XG_MN2 (I1_I1666_G17_14n I1_I1666_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I113_XG_MN0 (XI1_I1666_I113_XG_n1 I1_I1666_P17_16 I1_I1666_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I113_XG_MN1 (VSS I1_I1666_G15_14 XI1_I1666_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I165_XG_MN2 (I1_I1620_G14_0n I1_I1620_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I165_XG_MN0 (XI1_I1620_I165_XG_n1 I1_I1620_P14_7 I1_I1620_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I165_XG_MN1 (VSS I1_I1620_G6_0 XI1_I1620_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I169_XG_MN2 (I1_I1620_G18_3n I1_I1620_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I169_XG_MN0 (XI1_I1620_I169_XG_n1 I1_I1620_P18_11 I1_I1620_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I169_XG_MN1 (VSS I1_I1620_G10_3 XI1_I1620_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I114_XG_MN2 (I1_I1620_G18_15n I1_I1620_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I114_XG_MN0 (XI1_I1620_I114_XG_n1 I1_I1620_P18_17 I1_I1620_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I114_XG_MN1 (VSS I1_I1620_G16_15 XI1_I1620_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I112_XG_MN2 (I1_I1620_G16_13n I1_I1620_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I112_XG_MN0 (XI1_I1620_I112_XG_n1 I1_I1620_P16_15 I1_I1620_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I112_XG_MN1 (VSS I1_I1620_G14_13 XI1_I1620_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I163_XG_MN2 (I1_I1620_G12_0n I1_I1620_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I163_XG_MN0 (XI1_I1620_I163_XG_n1 I1_I1620_P12_5 I1_I1620_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I163_XG_MN1 (VSS I1_I1620_G4_0 XI1_I1620_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I109_XG_MN2 (I1_I1620_G13_10n I1_I1620_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I109_XG_MN0 (XI1_I1620_I109_XG_n1 I1_I1620_P13_12 I1_I1620_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I109_XG_MN1 (VSS I1_I1620_G11_10 XI1_I1620_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2108_MN2 (I1_nqkn11 I1_nqk10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2108_MN0 (XI1_I2108_n1 I1_sq_b3_1 I1_nqkn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2108_MN1 (VSS I1_qu10_b3_5 XI1_I2108_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I176_MN2 (I2_I3_q7_2 I2_I3_o7_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I176_MN0 (XI2_I3_I176_n1 I2_I3_SEL_AS_b3_1 I2_I3_q7_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I176_MN1 (VSS I2_S_7 XI2_I3_I176_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I212_MN2 (I2_I3_q10_2 I2_I3_o10_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I212_MN0 (XI2_I3_I212_n1 I2_I3_SEL_AS_b3_1 I2_I3_q10_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I212_MN1 (VSS I2_S_10 XI2_I3_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I166_XG_MN2 (I1_I1758_G15_0n I1_I1758_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I166_XG_MN0 (XI1_I1758_I166_XG_n1 I1_I1758_P15_8 I1_I1758_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I166_XG_MN1 (VSS I1_I1758_G7_0 XI1_I1758_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I172_XG_MN2 (I1_I1758_G21_6n I1_I1758_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I172_XG_MN0 (XI1_I1758_I172_XG_n1 I1_I1758_P21_14 I1_I1758_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I172_XG_MN1 (VSS I1_I1758_G13_6 XI1_I1758_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I164_XG_MN2 (I1_I1758_G13_0n I1_I1758_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I164_XG_MN0 (XI1_I1758_I164_XG_n1 I1_I1758_P13_6 I1_I1758_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I164_XG_MN1 (VSS I1_I1758_G5_0 XI1_I1758_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I170_XG_MN2 (I1_I1758_G19_4n I1_I1758_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I170_XG_MN0 (XI1_I1758_I170_XG_n1 I1_I1758_P19_12 I1_I1758_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I170_XG_MN1 (VSS I1_I1758_G11_4 XI1_I1758_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I162_XG_MN2 (I1_I1758_G11_0n I1_I1758_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I162_XG_MN0 (XI1_I1758_I162_XG_n1 I1_I1758_P11_4 I1_I1758_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I162_XG_MN1 (VSS I1_I1758_G3_0np XI1_I1758_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I105_XG_MN2 (I1_I1758_G9_6n I1_I1758_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I105_XG_MN0 (XI1_I1758_I105_XG_n1 I1_I1758_P9_8 I1_I1758_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I105_XG_MN1 (VSS I1_I1758_G7_6 XI1_I1758_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I103_XG_MN2 (I1_I1758_G7_4n I1_I1758_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I103_XG_MN0 (XI1_I1758_I103_XG_n1 I1_I1758_P7_6 I1_I1758_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I103_XG_MN1 (VSS I1_I1758_G5_4 XI1_I1758_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I118_XG_MN2 (I1_I1666_G22_19n I1_I1666_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I118_XG_MN0 (XI1_I1666_I118_XG_n1 I1_I1666_P22_21 I1_I1666_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I118_XG_MN1 (VSS I1_I1666_G20_19 XI1_I1666_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I174_XG_MN2 (I1_I1666_G23_8n I1_I1666_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I174_XG_MN0 (XI1_I1666_I174_XG_n1 I1_I1666_P23_16 I1_I1666_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I174_XG_MN1 (VSS I1_I1666_G15_8 XI1_I1666_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I180_XG_MN2 (I1_I1666_G29_14n I1_I1666_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I180_XG_MN0 (XI1_I1666_I180_XG_n1 I1_I1666_P29_22 I1_I1666_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I180_XG_MN1 (VSS I1_I1666_G21_14 XI1_I1666_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I117_XG_MN2 (I1_I1666_G21_18n I1_I1666_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I117_XG_MN0 (XI1_I1666_I117_XG_n1 I1_I1666_P21_20 I1_I1666_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I117_XG_MN1 (VSS I1_I1666_G19_18 XI1_I1666_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I173_XG_MN2 (I1_I1620_G22_7n I1_I1620_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I173_XG_MN0 (XI1_I1620_I173_XG_n1 I1_I1620_P22_15 I1_I1620_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I173_XG_MN1 (VSS I1_I1620_G14_7 XI1_I1620_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I177_XG_MN2 (I1_I1620_G26_11n I1_I1620_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I177_XG_MN0 (XI1_I1620_I177_XG_n1 I1_I1620_P26_19 I1_I1620_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I177_XG_MN1 (VSS I1_I1620_G18_11 XI1_I1620_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I113_XG_MN2 (I1_I1620_G17_14n I1_I1620_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I113_XG_MN0 (XI1_I1620_I113_XG_n1 I1_I1620_P17_16 I1_I1620_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I113_XG_MN1 (VSS I1_I1620_G15_14 XI1_I1620_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I111_XG_MN2 (I1_I1620_G15_12n I1_I1620_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I111_XG_MN0 (XI1_I1620_I111_XG_n1 I1_I1620_P15_14 I1_I1620_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I111_XG_MN1 (VSS I1_I1620_G13_12 XI1_I1620_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I168_XG_MN2 (I1_I1620_G17_2n I1_I1620_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I168_XG_MN0 (XI1_I1620_I168_XG_n1 I1_I1620_P17_10 I1_I1620_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I168_XG_MN1 (VSS I1_I1620_G9_2 XI1_I1620_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I158_XG_MN2 (I1_I1620_G9_0n I1_I1620_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I158_XG_MN0 (XI1_I1620_I158_XG_n1 I1_I1620_P9_2 I1_I1620_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I158_XG_MN1 (VSS I1_I1620_G1_0 XI1_I1620_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2102_MN2 (I1_nqkn9 I1_nqk8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2102_MN0 (XI1_I2102_n1 I1_sq_b3_1 I1_nqkn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2102_MN1 (VSS I1_qu8_b3_5 XI1_I2102_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2105_MN2 (I1_nqkn10 I1_nqk9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2105_MN0 (XI1_I2105_n1 I1_sq_b3_1 I1_nqkn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2105_MN1 (VSS I1_qu9_b3_5 XI1_I2105_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I200_MN2 (I2_I3_q9_2 I2_I3_o9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I200_MN0 (XI2_I3_I200_n1 I2_I3_SEL_AS_b3_1 I2_I3_q9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I200_MN1 (VSS I2_S_9 XI2_I3_I200_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I164_MN2 (I2_I3_q6_2 I2_I3_o6_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I164_MN0 (XI2_I3_I164_n1 I2_I3_SEL_AS_b3_1 I2_I3_q6_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I164_MN1 (VSS I2_S_6 XI2_I3_I164_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I188_MN2 (I2_I3_q8_2 I2_I3_o8_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I188_MN0 (XI2_I3_I188_n1 I2_I3_SEL_AS_b3_1 I2_I3_q8_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I188_MN1 (VSS I2_S_8 XI2_I3_I188_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I126_XG_MN2 (I1_I1758_G30_27n I1_I1758_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I126_XG_MN0 (XI1_I1758_I126_XG_n1 I1_I1758_P30_29 I1_I1758_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I126_XG_MN1 (VSS I1_I1758_G28_27 XI1_I1758_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I124_XG_MN2 (I1_I1758_G28_25n I1_I1758_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I124_XG_MN0 (XI1_I1758_I124_XG_n1 I1_I1758_P28_27 I1_I1758_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I124_XG_MN1 (VSS I1_I1758_G26_25 XI1_I1758_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I122_XG_MN2 (I1_I1758_G26_23n I1_I1758_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I122_XG_MN0 (XI1_I1758_I122_XG_n1 I1_I1758_P26_25 I1_I1758_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I122_XG_MN1 (VSS I1_I1758_G24_23 XI1_I1758_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I120_XG_MN2 (I1_I1758_G24_21n I1_I1758_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I120_XG_MN0 (XI1_I1758_I120_XG_n1 I1_I1758_P24_23 I1_I1758_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I120_XG_MN1 (VSS I1_I1758_G22_21 XI1_I1758_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I118_XG_MN2 (I1_I1758_G22_19n I1_I1758_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I118_XG_MN0 (XI1_I1758_I118_XG_n1 I1_I1758_P22_21 I1_I1758_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I118_XG_MN1 (VSS I1_I1758_G20_19 XI1_I1758_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I168_XG_MN2 (I1_I1758_G17_2n I1_I1758_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I168_XG_MN0 (XI1_I1758_I168_XG_n1 I1_I1758_P17_10 I1_I1758_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I168_XG_MN1 (VSS I1_I1758_G9_2 XI1_I1758_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I158_XG_MN2 (I1_I1758_G9_0n I1_I1758_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I158_XG_MN0 (XI1_I1758_I158_XG_n1 I1_I1758_P9_2 I1_I1758_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I158_XG_MN1 (VSS I1_I1758_G1_0 XI1_I1758_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I181_XG_MN2 (I1_I1666_G30_15n I1_I1666_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I181_XG_MN0 (XI1_I1666_I181_XG_n1 I1_I1666_P30_23 I1_I1666_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I181_XG_MN1 (VSS I1_I1666_G22_15 XI1_I1666_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I182_XG_MN2 (I1_I1666_G31_16n I1_I1666_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I182_XG_MN0 (XI1_I1666_I182_XG_n1 I1_I1666_P31_24 I1_I1666_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I182_XG_MN1 (VSS I1_I1666_G23_16 XI1_I1666_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I119_XG_MN2 (I1_I1666_G23_20n I1_I1666_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I119_XG_MN0 (XI1_I1666_I119_XG_n1 I1_I1666_P23_22 I1_I1666_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I119_XG_MN1 (VSS I1_I1666_G21_20 XI1_I1666_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I175_XG_MN2 (I1_I1620_G24_9n I1_I1620_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I175_XG_MN0 (XI1_I1620_I175_XG_n1 I1_I1620_P24_17 I1_I1620_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I175_XG_MN1 (VSS I1_I1620_G16_9 XI1_I1620_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I171_XG_MN2 (I1_I1620_G20_5n I1_I1620_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I171_XG_MN0 (XI1_I1620_I171_XG_n1 I1_I1620_P20_13 I1_I1620_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I171_XG_MN1 (VSS I1_I1620_G12_5 XI1_I1620_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I162_XG_MN2 (I1_I1620_G11_0n I1_I1620_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I162_XG_MN0 (XI1_I1620_I162_XG_n1 I1_I1620_P11_4 I1_I1620_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I162_XG_MN1 (VSS I1_I1620_G3_0np XI1_I1620_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I164_XG_MN2 (I1_I1620_G13_0n I1_I1620_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I164_XG_MN0 (XI1_I1620_I164_XG_n1 I1_I1620_P13_6 I1_I1620_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I164_XG_MN1 (VSS I1_I1620_G5_0 XI1_I1620_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I181_XG_MN2 (I1_I1758_G30_15n I1_I1758_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I181_XG_MN0 (XI1_I1758_I181_XG_n1 I1_I1758_P30_23 I1_I1758_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I181_XG_MN1 (VSS I1_I1758_G22_15 XI1_I1758_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I116_XG_MN2 (I1_I1758_G20_17n I1_I1758_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I116_XG_MN0 (XI1_I1758_I116_XG_n1 I1_I1758_P20_19 I1_I1758_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I116_XG_MN1 (VSS I1_I1758_G18_17 XI1_I1758_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I114_XG_MN2 (I1_I1758_G18_15n I1_I1758_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I114_XG_MN0 (XI1_I1758_I114_XG_n1 I1_I1758_P18_17 I1_I1758_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I114_XG_MN1 (VSS I1_I1758_G16_15 XI1_I1758_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I112_XG_MN2 (I1_I1758_G16_13n I1_I1758_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I112_XG_MN0 (XI1_I1758_I112_XG_n1 I1_I1758_P16_15 I1_I1758_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I112_XG_MN1 (VSS I1_I1758_G14_13 XI1_I1758_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I110_XG_MN2 (I1_I1758_G14_11n I1_I1758_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I110_XG_MN0 (XI1_I1758_I110_XG_n1 I1_I1758_P14_13 I1_I1758_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I110_XG_MN1 (VSS I1_I1758_G12_11 XI1_I1758_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I108_XG_MN2 (I1_I1758_G12_9n I1_I1758_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I108_XG_MN0 (XI1_I1758_I108_XG_n1 I1_I1758_P12_11 I1_I1758_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I108_XG_MN1 (VSS I1_I1758_G10_9 XI1_I1758_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I101_XG_MN2 (I1_I1758_G5_2n I1_I1758_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I101_XG_MN0 (XI1_I1758_I101_XG_n1 I1_I1758_P5_4 I1_I1758_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I101_XG_MN1 (VSS I1_I1758_G3_2 XI1_I1758_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I122_XG_MN2 (I1_I1666_G26_23n I1_I1666_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I122_XG_MN0 (XI1_I1666_I122_XG_n1 I1_I1666_P26_25 I1_I1666_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I122_XG_MN1 (VSS I1_I1666_G24_23 XI1_I1666_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I120_XG_MN2 (I1_I1666_G24_21n I1_I1666_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I120_XG_MN0 (XI1_I1666_I120_XG_n1 I1_I1666_P24_23 I1_I1666_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I120_XG_MN1 (VSS I1_I1666_G22_21 XI1_I1666_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I121_XG_MN2 (I1_I1666_G25_22n I1_I1666_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I121_XG_MN0 (XI1_I1666_I121_XG_n1 I1_I1666_P25_24 I1_I1666_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I121_XG_MN1 (VSS I1_I1666_G23_22 XI1_I1666_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I118_XG_MN2 (I1_I1620_G22_19n I1_I1620_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I118_XG_MN0 (XI1_I1620_I118_XG_n1 I1_I1620_P22_21 I1_I1620_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I118_XG_MN1 (VSS I1_I1620_G20_19 XI1_I1620_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I116_XG_MN2 (I1_I1620_G20_17n I1_I1620_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I116_XG_MN0 (XI1_I1620_I116_XG_n1 I1_I1620_P20_19 I1_I1620_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I116_XG_MN1 (VSS I1_I1620_G18_17 XI1_I1620_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I115_XG_MN2 (I1_I1620_G19_16n I1_I1620_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I115_XG_MN0 (XI1_I1620_I115_XG_n1 I1_I1620_P19_18 I1_I1620_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I115_XG_MN1 (VSS I1_I1620_G17_16 XI1_I1620_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I170_XG_MN2 (I1_I1620_G19_4n I1_I1620_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I170_XG_MN0 (XI1_I1620_I170_XG_n1 I1_I1620_P19_12 I1_I1620_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I170_XG_MN1 (VSS I1_I1620_G11_4 XI1_I1620_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2096_MN2 (I1_nqkn7 I1_nqk6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2096_MN0 (XI1_I2096_n1 I1_sq_b3_1 I1_nqkn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2096_MN1 (VSS I1_qu6_b3_5 XI1_I2096_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2099_MN2 (I1_nqkn8 I1_nqk7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2099_MN0 (XI1_I2099_n1 I1_sq_b3_1 I1_nqkn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2099_MN1 (VSS I1_qu7_b3_5 XI1_I2099_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I179_XG_MN2 (I1_I1758_G28_13n I1_I1758_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I179_XG_MN0 (XI1_I1758_I179_XG_n1 I1_I1758_P28_21 I1_I1758_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I179_XG_MN1 (VSS I1_I1758_G20_13 XI1_I1758_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I177_XG_MN2 (I1_I1758_G26_11n I1_I1758_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I177_XG_MN0 (XI1_I1758_I177_XG_n1 I1_I1758_P26_19 I1_I1758_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I177_XG_MN1 (VSS I1_I1758_G18_11 XI1_I1758_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I173_XG_MN2 (I1_I1758_G22_7n I1_I1758_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I173_XG_MN0 (XI1_I1758_I173_XG_n1 I1_I1758_P22_15 I1_I1758_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I173_XG_MN1 (VSS I1_I1758_G14_7 XI1_I1758_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I165_XG_MN2 (I1_I1758_G14_0n I1_I1758_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I165_XG_MN0 (XI1_I1758_I165_XG_n1 I1_I1758_P14_7 I1_I1758_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I165_XG_MN1 (VSS I1_I1758_G6_0 XI1_I1758_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I171_XG_MN2 (I1_I1758_G20_5n I1_I1758_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I171_XG_MN0 (XI1_I1758_I171_XG_n1 I1_I1758_P20_13 I1_I1758_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I171_XG_MN1 (VSS I1_I1758_G12_5 XI1_I1758_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I106_XG_MN2 (I1_I1758_G10_7n I1_I1758_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I106_XG_MN0 (XI1_I1758_I106_XG_n1 I1_I1758_P10_9 I1_I1758_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I106_XG_MN1 (VSS I1_I1758_G8_7 XI1_I1758_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I104_XG_MN2 (I1_I1758_G8_5n I1_I1758_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I104_XG_MN0 (XI1_I1758_I104_XG_n1 I1_I1758_P8_7 I1_I1758_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I104_XG_MN1 (VSS I1_I1758_G6_5 XI1_I1758_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I102_XG_MN2 (I1_I1758_G6_3n I1_I1758_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I102_XG_MN0 (XI1_I1758_I102_XG_n1 I1_I1758_P6_5 I1_I1758_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I102_XG_MN1 (VSS I1_I1758_G4_3 XI1_I1758_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I99_XG_MN2 (I1_I1758_G3_0n I1_I1758_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I99_XG_MN0 (XI1_I1758_I99_XG_n1 I1_I1758_P3_2 I1_I1758_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I99_XG_MN1 (VSS I1_I1758_G1_0 XI1_I1758_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I124_XG_MN2 (I1_I1666_G28_25n I1_I1666_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I124_XG_MN0 (XI1_I1666_I124_XG_n1 I1_I1666_P28_27 I1_I1666_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I124_XG_MN1 (VSS I1_I1666_G26_25 XI1_I1666_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I127_XG_MN2 (I1_I1666_G31_28n I1_I1666_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I127_XG_MN0 (XI1_I1666_I127_XG_n1 I1_I1666_P31_30 I1_I1666_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I127_XG_MN1 (VSS I1_I1666_G29_28 XI1_I1666_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I125_XG_MN2 (I1_I1666_G29_26n I1_I1666_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I125_XG_MN0 (XI1_I1666_I125_XG_n1 I1_I1666_P29_28 I1_I1666_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I125_XG_MN1 (VSS I1_I1666_G27_26 XI1_I1666_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I123_XG_MN2 (I1_I1666_G27_24n I1_I1666_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I123_XG_MN0 (XI1_I1666_I123_XG_n1 I1_I1666_P27_26 I1_I1666_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I123_XG_MN1 (VSS I1_I1666_G25_24 XI1_I1666_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I181_XG_MN2 (I1_I1620_G30_15n I1_I1620_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I181_XG_MN0 (XI1_I1620_I181_XG_n1 I1_I1620_P30_23 I1_I1620_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I181_XG_MN1 (VSS I1_I1620_G22_15 XI1_I1620_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I120_XG_MN2 (I1_I1620_G24_21n I1_I1620_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I120_XG_MN0 (XI1_I1620_I120_XG_n1 I1_I1620_P24_23 I1_I1620_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I120_XG_MN1 (VSS I1_I1620_G22_21 XI1_I1620_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I179_XG_MN2 (I1_I1620_G28_13n I1_I1620_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I179_XG_MN0 (XI1_I1620_I179_XG_n1 I1_I1620_P28_21 I1_I1620_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I179_XG_MN1 (VSS I1_I1620_G20_13 XI1_I1620_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I117_XG_MN2 (I1_I1620_G21_18n I1_I1620_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I117_XG_MN0 (XI1_I1620_I117_XG_n1 I1_I1620_P21_20 I1_I1620_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I117_XG_MN1 (VSS I1_I1620_G19_18 XI1_I1620_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I174_XG_MN2 (I1_I1620_G23_8n I1_I1620_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I174_XG_MN0 (XI1_I1620_I174_XG_n1 I1_I1620_P23_16 I1_I1620_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I174_XG_MN1 (VSS I1_I1620_G15_8 XI1_I1620_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I166_XG_MN2 (I1_I1620_G15_0n I1_I1620_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I166_XG_MN0 (XI1_I1620_I166_XG_n1 I1_I1620_P15_8 I1_I1620_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I166_XG_MN1 (VSS I1_I1620_G7_0 XI1_I1620_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I172_XG_MN2 (I1_I1620_G21_6n I1_I1620_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I172_XG_MN0 (XI1_I1620_I172_XG_n1 I1_I1620_P21_14 I1_I1620_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I172_XG_MN1 (VSS I1_I1620_G13_6 XI1_I1620_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I51_MN2 (I1_nakn6 I1_nak5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I51_MN0 (XI1_I51_n1 I1_A_31_b3_0 I1_nakn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I51_MN1 (VSS A_5 XI1_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I175_XG_MN2 (I1_I1758_G24_9n I1_I1758_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I175_XG_MN0 (XI1_I1758_I175_XG_n1 I1_I1758_P24_17 I1_I1758_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I175_XG_MN1 (VSS I1_I1758_G16_9 XI1_I1758_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I169_XG_MN2 (I1_I1758_G18_3n I1_I1758_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I169_XG_MN0 (XI1_I1758_I169_XG_n1 I1_I1758_P18_11 I1_I1758_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I169_XG_MN1 (VSS I1_I1758_G10_3 XI1_I1758_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I163_XG_MN2 (I1_I1758_G12_0n I1_I1758_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I163_XG_MN0 (XI1_I1758_I163_XG_n1 I1_I1758_P12_5 I1_I1758_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I163_XG_MN1 (VSS I1_I1758_G4_0 XI1_I1758_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I160_XG_MN2 (I1_I1758_G10_0n I1_I1758_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I160_XG_MN0 (XI1_I1758_I160_XG_n1 I1_I1758_P10_3 I1_I1758_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I160_XG_MN1 (VSS I1_I1758_G2_0np XI1_I1758_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I167_XG_MN2 (I1_I1758_G16_1n I1_I1758_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I167_XG_MN0 (XI1_I1758_I167_XG_n1 I1_I1758_P16_9 I1_I1758_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I167_XG_MN1 (VSS I1_I1758_G8_1 XI1_I1758_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I100_XG_MN2 (I1_I1758_G4_1n I1_I1758_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I100_XG_MN0 (XI1_I1758_I100_XG_n1 I1_I1758_P4_3 I1_I1758_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I100_XG_MN1 (VSS I1_I1758_G2_1 XI1_I1758_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1666_I126_XG_MN2 (I1_I1666_G30_27n I1_I1666_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1666_I126_XG_MN0 (XI1_I1666_I126_XG_n1 I1_I1666_P30_29 I1_I1666_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1666_I126_XG_MN1 (VSS I1_I1666_G28_27 XI1_I1666_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I122_XG_MN2 (I1_I1620_G26_23n I1_I1620_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I122_XG_MN0 (XI1_I1620_I122_XG_n1 I1_I1620_P26_25 I1_I1620_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I122_XG_MN1 (VSS I1_I1620_G24_23 XI1_I1620_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I119_XG_MN2 (I1_I1620_G23_20n I1_I1620_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I119_XG_MN0 (XI1_I1620_I119_XG_n1 I1_I1620_P23_22 I1_I1620_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I119_XG_MN1 (VSS I1_I1620_G21_20 XI1_I1620_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I182_XG_MN2 (I1_I1620_G31_16n I1_I1620_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I182_XG_MN0 (XI1_I1620_I182_XG_n1 I1_I1620_P31_24 I1_I1620_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I182_XG_MN1 (VSS I1_I1620_G23_16 XI1_I1620_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I176_XG_MN2 (I1_I1620_G25_10n I1_I1620_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I176_XG_MN0 (XI1_I1620_I176_XG_n1 I1_I1620_P25_18 I1_I1620_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I176_XG_MN1 (VSS I1_I1620_G17_10 XI1_I1620_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I92_MN2 (I2_I3_q0_2 I2_I3_o0_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I92_MN0 (XI2_I3_I92_n1 I2_I3_SEL_AS_b3_0 I2_I3_q0_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I92_MN1 (VSS I2_S_0 XI2_I3_I92_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I152_MN2 (I2_I3_q5_2 I2_I3_o5_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I152_MN0 (XI2_I3_I152_n1 I2_I3_SEL_AS_b3_0 I2_I3_q5_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I152_MN1 (VSS I2_S_5 XI2_I3_I152_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I157_XG_MN2 (I1_I1758_G8_0n I1_I1758_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I157_XG_MN0 (XI1_I1758_I157_XG_n1 I1_I1758_P8_1 I1_I1758_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I157_XG_MN1 (VSS I1_I1758_G0_0 XI1_I1758_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1758_I98_XG_MN2 (I1_I1758_G2_0n I1_I1758_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1758_I98_XG_MN0 (XI1_I1758_I98_XG_n1 I1_I1758_P2_1 I1_I1758_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1758_I98_XG_MN1 (VSS I1_I1758_G0_0 XI1_I1758_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I126_XG_MN2 (I1_I1620_G30_27n I1_I1620_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I126_XG_MN0 (XI1_I1620_I126_XG_n1 I1_I1620_P30_29 I1_I1620_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I126_XG_MN1 (VSS I1_I1620_G28_27 XI1_I1620_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I124_XG_MN2 (I1_I1620_G28_25n I1_I1620_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I124_XG_MN0 (XI1_I1620_I124_XG_n1 I1_I1620_P28_27 I1_I1620_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I124_XG_MN1 (VSS I1_I1620_G26_25 XI1_I1620_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I121_XG_MN2 (I1_I1620_G25_22n I1_I1620_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I121_XG_MN0 (XI1_I1620_I121_XG_n1 I1_I1620_P25_24 I1_I1620_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I121_XG_MN1 (VSS I1_I1620_G23_22 XI1_I1620_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I178_XG_MN2 (I1_I1620_G27_12n I1_I1620_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I178_XG_MN0 (XI1_I1620_I178_XG_n1 I1_I1620_P27_20 I1_I1620_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I178_XG_MN1 (VSS I1_I1620_G19_12 XI1_I1620_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I180_XG_MN2 (I1_I1620_G29_14n I1_I1620_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I180_XG_MN0 (XI1_I1620_I180_XG_n1 I1_I1620_P29_22 I1_I1620_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I180_XG_MN1 (VSS I1_I1620_G21_14 XI1_I1620_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I45_MN2 (I1_nakn4 I1_nak3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I45_MN0 (XI1_I45_n1 I1_A_31_b3_0 I1_nakn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I45_MN1 (VSS A_3 XI1_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I48_MN2 (I1_nakn5 I1_nak4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I48_MN0 (XI1_I48_n1 I1_A_31_b3_0 I1_nakn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I48_MN1 (VSS A_4 XI1_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2093_MN2 (I1_nqkn6 I1_nqk5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2093_MN0 (XI1_I2093_n1 I1_sq_b3_0 I1_nqkn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2093_MN1 (VSS I1_qu5_b3_5 XI1_I2093_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I140_MN2 (I2_I3_q4_2 I2_I3_o4_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I140_MN0 (XI2_I3_I140_n1 I2_I3_SEL_AS_b3_0 I2_I3_q4_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I140_MN1 (VSS I2_S_4 XI2_I3_I140_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I127_XG_MN2 (I1_I1620_G31_28n I1_I1620_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I127_XG_MN0 (XI1_I1620_I127_XG_n1 I1_I1620_P31_30 I1_I1620_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I127_XG_MN1 (VSS I1_I1620_G29_28 XI1_I1620_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I123_XG_MN2 (I1_I1620_G27_24n I1_I1620_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I123_XG_MN0 (XI1_I1620_I123_XG_n1 I1_I1620_P27_26 I1_I1620_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I123_XG_MN1 (VSS I1_I1620_G25_24 XI1_I1620_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I42_MN2 (I1_nakn3 I1_nak2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I42_MN0 (XI1_I42_n1 I1_A_31_b3_0 I1_nakn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I42_MN1 (VSS A_2 XI1_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I39_MN2 (I1_nakn2 I1_nak1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I39_MN0 (XI1_I39_n1 I1_A_31_b3_0 I1_nakn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I39_MN1 (VSS A_1 XI1_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2090_MN2 (I1_nqkn5 I1_nqk4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2090_MN0 (XI1_I2090_n1 I1_sq_b3_0 I1_nqkn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2090_MN1 (VSS I1_qu4_b3_5 XI1_I2090_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I104_MN2 (I2_I3_q1_2 I2_I3_o1_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I104_MN0 (XI2_I3_I104_n1 I2_I3_SEL_AS_b3_0 I2_I3_q1_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I104_MN1 (VSS I2_S_1 XI2_I3_I104_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I116_XG_MN2 (I1_I1804_G20_17n I1_I1804_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I116_XG_MN0 (XI1_I1804_I116_XG_n1 I1_I1804_P20_19 I1_I1804_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I116_XG_MN1 (VSS I1_I1804_G18_17 XI1_I1804_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I114_XG_MN2 (I1_I1804_G18_15n I1_I1804_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I114_XG_MN0 (XI1_I1804_I114_XG_n1 I1_I1804_P18_17 I1_I1804_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I114_XG_MN1 (VSS I1_I1804_G16_15 XI1_I1804_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I110_XG_MN2 (I1_I1804_G14_11n I1_I1804_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I110_XG_MN0 (XI1_I1804_I110_XG_n1 I1_I1804_P14_13 I1_I1804_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I110_XG_MN1 (VSS I1_I1804_G12_11 XI1_I1804_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I106_XG_MN2 (I1_I1804_G10_7n I1_I1804_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I106_XG_MN0 (XI1_I1804_I106_XG_n1 I1_I1804_P10_9 I1_I1804_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I106_XG_MN1 (VSS I1_I1804_G8_7 XI1_I1804_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1620_I125_XG_MN2 (I1_I1620_G29_26n I1_I1620_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1620_I125_XG_MN0 (XI1_I1620_I125_XG_n1 I1_I1620_P29_28 I1_I1620_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1620_I125_XG_MN1 (VSS I1_I1620_G27_26 XI1_I1620_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2087_MN2 (I1_nqkn4 I1_nqk3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2087_MN0 (XI1_I2087_n1 I1_sq_b3_0 I1_nqkn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2087_MN1 (VSS I1_qu3_b3_5 XI1_I2087_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2084_MN2 (I1_nqkn3 I1_nqk2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2084_MN0 (XI1_I2084_n1 I1_sq_b3_0 I1_nqkn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2084_MN1 (VSS I1_qu2_b3_5 XI1_I2084_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2081_MN2 (I1_nqkn2 I1_nqk1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2081_MN0 (XI1_I2081_n1 I1_sq_b3_0 I1_nqkn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2081_MN1 (VSS I1_qu1_b3_5 XI1_I2081_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I122_XG_MN2 (I1_I1804_G26_23n I1_I1804_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I122_XG_MN0 (XI1_I1804_I122_XG_n1 I1_I1804_P26_25 I1_I1804_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I122_XG_MN1 (VSS I1_I1804_G24_23 XI1_I1804_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I120_XG_MN2 (I1_I1804_G24_21n I1_I1804_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I120_XG_MN0 (XI1_I1804_I120_XG_n1 I1_I1804_P24_23 I1_I1804_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I120_XG_MN1 (VSS I1_I1804_G22_21 XI1_I1804_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I118_XG_MN2 (I1_I1804_G22_19n I1_I1804_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I118_XG_MN0 (XI1_I1804_I118_XG_n1 I1_I1804_P22_21 I1_I1804_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I118_XG_MN1 (VSS I1_I1804_G20_19 XI1_I1804_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I112_XG_MN2 (I1_I1804_G16_13n I1_I1804_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I112_XG_MN0 (XI1_I1804_I112_XG_n1 I1_I1804_P16_15 I1_I1804_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I112_XG_MN1 (VSS I1_I1804_G14_13 XI1_I1804_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I175_XG_MN2 (I1_I1804_G24_9n I1_I1804_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I175_XG_MN0 (XI1_I1804_I175_XG_n1 I1_I1804_P24_17 I1_I1804_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I175_XG_MN1 (VSS I1_I1804_G16_9 XI1_I1804_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I108_XG_MN2 (I1_I1804_G12_9n I1_I1804_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I108_XG_MN0 (XI1_I1804_I108_XG_n1 I1_I1804_P12_11 I1_I1804_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I108_XG_MN1 (VSS I1_I1804_G10_9 XI1_I1804_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I167_XG_MN2 (I1_I1804_G16_1n I1_I1804_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I167_XG_MN0 (XI1_I1804_I167_XG_n1 I1_I1804_P16_9 I1_I1804_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I167_XG_MN1 (VSS I1_I1804_G8_1 XI1_I1804_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I104_XG_MN2 (I1_I1804_G8_5n I1_I1804_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I104_XG_MN0 (XI1_I1804_I104_XG_n1 I1_I1804_P8_7 I1_I1804_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I104_XG_MN1 (VSS I1_I1804_G6_5 XI1_I1804_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I102_XG_MN2 (I1_I1804_G6_3n I1_I1804_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I102_XG_MN0 (XI1_I1804_I102_XG_n1 I1_I1804_P6_5 I1_I1804_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I102_XG_MN1 (VSS I1_I1804_G4_3 XI1_I1804_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I100_XG_MN2 (I1_I1804_G4_1n I1_I1804_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I100_XG_MN0 (XI1_I1804_I100_XG_n1 I1_I1804_P4_3 I1_I1804_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I100_XG_MN1 (VSS I1_I1804_G2_1 XI1_I1804_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I124_XG_MN2 (I1_I1804_G28_25n I1_I1804_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I124_XG_MN0 (XI1_I1804_I124_XG_n1 I1_I1804_P28_27 I1_I1804_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I124_XG_MN1 (VSS I1_I1804_G26_25 XI1_I1804_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I179_XG_MN2 (I1_I1804_G28_13n I1_I1804_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I179_XG_MN0 (XI1_I1804_I179_XG_n1 I1_I1804_P28_21 I1_I1804_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I179_XG_MN1 (VSS I1_I1804_G20_13 XI1_I1804_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I177_XG_MN2 (I1_I1804_G26_11n I1_I1804_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I177_XG_MN0 (XI1_I1804_I177_XG_n1 I1_I1804_P26_19 I1_I1804_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I177_XG_MN1 (VSS I1_I1804_G18_11 XI1_I1804_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I171_XG_MN2 (I1_I1804_G20_5n I1_I1804_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I171_XG_MN0 (XI1_I1804_I171_XG_n1 I1_I1804_P20_13 I1_I1804_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I171_XG_MN1 (VSS I1_I1804_G12_5 XI1_I1804_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I163_XG_MN2 (I1_I1804_G12_0n I1_I1804_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I163_XG_MN0 (XI1_I1804_I163_XG_n1 I1_I1804_P12_5 I1_I1804_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I163_XG_MN1 (VSS I1_I1804_G4_0 XI1_I1804_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I169_XG_MN2 (I1_I1804_G18_3n I1_I1804_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I169_XG_MN0 (XI1_I1804_I169_XG_n1 I1_I1804_P18_11 I1_I1804_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I169_XG_MN1 (VSS I1_I1804_G10_3 XI1_I1804_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I157_XG_MN2 (I1_I1804_G8_0n I1_I1804_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I157_XG_MN0 (XI1_I1804_I157_XG_n1 I1_I1804_P8_1 I1_I1804_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I157_XG_MN1 (VSS I1_I1804_G0_0 XI1_I1804_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I98_XG_MN2 (I1_I1804_G2_0n I1_I1804_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I98_XG_MN0 (XI1_I1804_I98_XG_n1 I1_I1804_P2_1 I1_I1804_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I98_XG_MN1 (VSS I1_I1804_G0_0 XI1_I1804_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I99_XG_MN2 (I1_I1942_G3_0n I1_I1942_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I99_XG_MN0 (XI1_I1942_I99_XG_n1 I1_I1942_P3_2 I1_I1942_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I99_XG_MN1 (VSS I1_I1942_G1_0 XI1_I1942_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I100_XG_MN2 (I1_I1942_G4_1n I1_I1942_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I100_XG_MN0 (XI1_I1942_I100_XG_n1 I1_I1942_P4_3 I1_I1942_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I100_XG_MN1 (VSS I1_I1942_G2_1 XI1_I1942_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I98_XG_MN2 (I1_I1942_G2_0n I1_I1942_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I98_XG_MN0 (XI1_I1942_I98_XG_n1 I1_I1942_P2_1 I1_I1942_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I98_XG_MN1 (VSS I1_I1942_G0_0 XI1_I1942_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I126_XG_MN2 (I1_I1804_G30_27n I1_I1804_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I126_XG_MN0 (XI1_I1804_I126_XG_n1 I1_I1804_P30_29 I1_I1804_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I126_XG_MN1 (VSS I1_I1804_G28_27 XI1_I1804_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I181_XG_MN2 (I1_I1804_G30_15n I1_I1804_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I181_XG_MN0 (XI1_I1804_I181_XG_n1 I1_I1804_P30_23 I1_I1804_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I181_XG_MN1 (VSS I1_I1804_G22_15 XI1_I1804_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I173_XG_MN2 (I1_I1804_G22_7n I1_I1804_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I173_XG_MN0 (XI1_I1804_I173_XG_n1 I1_I1804_P22_15 I1_I1804_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I173_XG_MN1 (VSS I1_I1804_G14_7 XI1_I1804_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I165_XG_MN2 (I1_I1804_G14_0n I1_I1804_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I165_XG_MN0 (XI1_I1804_I165_XG_n1 I1_I1804_P14_7 I1_I1804_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I165_XG_MN1 (VSS I1_I1804_G6_0 XI1_I1804_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I160_XG_MN2 (I1_I1804_G10_0n I1_I1804_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I160_XG_MN0 (XI1_I1804_I160_XG_n1 I1_I1804_P10_3 I1_I1804_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I160_XG_MN1 (VSS I1_I1804_G2_0np XI1_I1804_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I101_XG_MN2 (I1_I1804_G5_2n I1_I1804_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I101_XG_MN0 (XI1_I1804_I101_XG_n1 I1_I1804_P5_4 I1_I1804_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I101_XG_MN1 (VSS I1_I1804_G3_2 XI1_I1804_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I99_XG_MN2 (I1_I1804_G3_0n I1_I1804_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I99_XG_MN0 (XI1_I1804_I99_XG_n1 I1_I1804_P3_2 I1_I1804_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I99_XG_MN1 (VSS I1_I1804_G1_0 XI1_I1804_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I98_XG_MN2 (I1_I1896_G2_0n I1_I1896_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I98_XG_MN0 (XI1_I1896_I98_XG_n1 I1_I1896_P2_1 I1_I1896_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I98_XG_MN1 (VSS I1_I1896_G0_0 XI1_I1896_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I101_XG_MN2 (I1_I1942_G5_2n I1_I1942_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I101_XG_MN0 (XI1_I1942_I101_XG_n1 I1_I1942_P5_4 I1_I1942_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I101_XG_MN1 (VSS I1_I1942_G3_2 XI1_I1942_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I102_XG_MN2 (I1_I1942_G6_3n I1_I1942_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I102_XG_MN0 (XI1_I1942_I102_XG_n1 I1_I1942_P6_5 I1_I1942_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I102_XG_MN1 (VSS I1_I1942_G4_3 XI1_I1942_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I101_XG_MN2 (I1_I1988_G5_2n I1_I1988_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I101_XG_MN0 (XI1_I1988_I101_XG_n1 I1_I1988_P5_4 I1_I1988_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I101_XG_MN1 (VSS I1_I1988_G3_2 XI1_I1988_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I99_XG_MN2 (I1_I1988_G3_0n I1_I1988_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I99_XG_MN0 (XI1_I1988_I99_XG_n1 I1_I1988_P3_2 I1_I1988_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I99_XG_MN1 (VSS I1_I1988_G1_0 XI1_I1988_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I100_XG_MN2 (I1_I1988_G4_1n I1_I1988_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I100_XG_MN0 (XI1_I1988_I100_XG_n1 I1_I1988_P4_3 I1_I1988_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I100_XG_MN1 (VSS I1_I1988_G2_1 XI1_I1988_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I98_XG_MN2 (I1_I1988_G2_0n I1_I1988_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I98_XG_MN0 (XI1_I1988_I98_XG_n1 I1_I1988_P2_1 I1_I1988_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I98_XG_MN1 (VSS I1_I1988_G0_0 XI1_I1988_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I199_XG_MN2 (I0_I1660_G7_4n I0_I1660_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I199_XG_MN0 (XI0_I1660_I199_XG_n1 I0_I1660_P7_6 I0_I1660_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I199_XG_MN1 (VSS I0_I1660_G5_4 XI0_I1660_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I203_XG_MN2 (I0_I1660_G11_8n I0_I1660_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I203_XG_MN0 (XI0_I1660_I203_XG_n1 I0_I1660_P11_10 I0_I1660_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I203_XG_MN1 (VSS I0_I1660_G9_8 XI0_I1660_I203_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I205_XG_MN2 (I0_I1660_G13_10n I0_I1660_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I205_XG_MN0 (XI0_I1660_I205_XG_n1 I0_I1660_P13_12 I0_I1660_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I205_XG_MN1 (VSS I0_I1660_G11_10 XI0_I1660_I205_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I207_XG_MN2 (I0_I1660_G15_12n I0_I1660_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I207_XG_MN0 (XI0_I1660_I207_XG_n1 I0_I1660_P15_14 I0_I1660_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I207_XG_MN1 (VSS I0_I1660_G13_12 XI0_I1660_I207_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I209_XG_MN2 (I0_I1660_G17_14n I0_I1660_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I209_XG_MN0 (XI0_I1660_I209_XG_n1 I0_I1660_P17_16 I0_I1660_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I209_XG_MN1 (VSS I0_I1660_G15_14 XI0_I1660_I209_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I211_XG_MN2 (I0_I1660_G19_16n I0_I1660_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I211_XG_MN0 (XI0_I1660_I211_XG_n1 I0_I1660_P19_18 I0_I1660_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I211_XG_MN1 (VSS I0_I1660_G17_16 XI0_I1660_I211_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I213_XG_MN2 (I0_I1660_G21_18n I0_I1660_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I213_XG_MN0 (XI0_I1660_I213_XG_n1 I0_I1660_P21_20 I0_I1660_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I213_XG_MN1 (VSS I0_I1660_G19_18 XI0_I1660_I213_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I215_XG_MN2 (I0_I1660_G23_20n I0_I1660_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I215_XG_MN0 (XI0_I1660_I215_XG_n1 I0_I1660_P23_22 I0_I1660_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I215_XG_MN1 (VSS I0_I1660_G21_20 XI0_I1660_I215_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I125_XG_MN2 (I1_I1804_G29_26n I1_I1804_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I125_XG_MN0 (XI1_I1804_I125_XG_n1 I1_I1804_P29_28 I1_I1804_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I125_XG_MN1 (VSS I1_I1804_G27_26 XI1_I1804_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I123_XG_MN2 (I1_I1804_G27_24n I1_I1804_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I123_XG_MN0 (XI1_I1804_I123_XG_n1 I1_I1804_P27_26 I1_I1804_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I123_XG_MN1 (VSS I1_I1804_G25_24 XI1_I1804_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I121_XG_MN2 (I1_I1804_G25_22n I1_I1804_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I121_XG_MN0 (XI1_I1804_I121_XG_n1 I1_I1804_P25_24 I1_I1804_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I121_XG_MN1 (VSS I1_I1804_G23_22 XI1_I1804_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I119_XG_MN2 (I1_I1804_G23_20n I1_I1804_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I119_XG_MN0 (XI1_I1804_I119_XG_n1 I1_I1804_P23_22 I1_I1804_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I119_XG_MN1 (VSS I1_I1804_G21_20 XI1_I1804_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I117_XG_MN2 (I1_I1804_G21_18n I1_I1804_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I117_XG_MN0 (XI1_I1804_I117_XG_n1 I1_I1804_P21_20 I1_I1804_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I117_XG_MN1 (VSS I1_I1804_G19_18 XI1_I1804_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I113_XG_MN2 (I1_I1804_G17_14n I1_I1804_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I113_XG_MN0 (XI1_I1804_I113_XG_n1 I1_I1804_P17_16 I1_I1804_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I113_XG_MN1 (VSS I1_I1804_G15_14 XI1_I1804_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I111_XG_MN2 (I1_I1804_G15_12n I1_I1804_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I111_XG_MN0 (XI1_I1804_I111_XG_n1 I1_I1804_P15_14 I1_I1804_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I111_XG_MN1 (VSS I1_I1804_G13_12 XI1_I1804_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I109_XG_MN2 (I1_I1804_G13_10n I1_I1804_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I109_XG_MN0 (XI1_I1804_I109_XG_n1 I1_I1804_P13_12 I1_I1804_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I109_XG_MN1 (VSS I1_I1804_G11_10 XI1_I1804_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I107_XG_MN2 (I1_I1804_G11_8n I1_I1804_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I107_XG_MN0 (XI1_I1804_I107_XG_n1 I1_I1804_P11_10 I1_I1804_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I107_XG_MN1 (VSS I1_I1804_G9_8 XI1_I1804_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I105_XG_MN2 (I1_I1804_G9_6n I1_I1804_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I105_XG_MN0 (XI1_I1804_I105_XG_n1 I1_I1804_P9_8 I1_I1804_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I105_XG_MN1 (VSS I1_I1804_G7_6 XI1_I1804_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I103_XG_MN2 (I1_I1804_G7_4n I1_I1804_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I103_XG_MN0 (XI1_I1804_I103_XG_n1 I1_I1804_P7_6 I1_I1804_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I103_XG_MN1 (VSS I1_I1804_G5_4 XI1_I1804_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I99_XG_MN2 (I1_I1850_G3_0n I1_I1850_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I99_XG_MN0 (XI1_I1850_I99_XG_n1 I1_I1850_P3_2 I1_I1850_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I99_XG_MN1 (VSS I1_I1850_G1_0 XI1_I1850_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I101_XG_MN2 (I1_I1896_G5_2n I1_I1896_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I101_XG_MN0 (XI1_I1896_I101_XG_n1 I1_I1896_P5_4 I1_I1896_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I101_XG_MN1 (VSS I1_I1896_G3_2 XI1_I1896_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I99_XG_MN2 (I1_I1896_G3_0n I1_I1896_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I99_XG_MN0 (XI1_I1896_I99_XG_n1 I1_I1896_P3_2 I1_I1896_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I99_XG_MN1 (VSS I1_I1896_G1_0 XI1_I1896_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I100_XG_MN2 (I1_I1896_G4_1n I1_I1896_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I100_XG_MN0 (XI1_I1896_I100_XG_n1 I1_I1896_P4_3 I1_I1896_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I100_XG_MN1 (VSS I1_I1896_G2_1 XI1_I1896_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I103_XG_MN2 (I1_I1942_G7_4n I1_I1942_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I103_XG_MN0 (XI1_I1942_I103_XG_n1 I1_I1942_P7_6 I1_I1942_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I103_XG_MN1 (VSS I1_I1942_G5_4 XI1_I1942_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I104_XG_MN2 (I1_I1942_G8_5n I1_I1942_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I104_XG_MN0 (XI1_I1942_I104_XG_n1 I1_I1942_P8_7 I1_I1942_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I104_XG_MN1 (VSS I1_I1942_G6_5 XI1_I1942_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I167_XG_MN2 (I1_I1942_G16_1n I1_I1942_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I167_XG_MN0 (XI1_I1942_I167_XG_n1 I1_I1942_P16_9 I1_I1942_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I167_XG_MN1 (VSS I1_I1942_G8_1 XI1_I1942_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I157_XG_MN2 (I1_I1942_G8_0n I1_I1942_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I157_XG_MN0 (XI1_I1942_I157_XG_n1 I1_I1942_P8_1 I1_I1942_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I157_XG_MN1 (VSS I1_I1942_G0_0 XI1_I1942_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I103_XG_MN2 (I1_I1988_G7_4n I1_I1988_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I103_XG_MN0 (XI1_I1988_I103_XG_n1 I1_I1988_P7_6 I1_I1988_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I103_XG_MN1 (VSS I1_I1988_G5_4 XI1_I1988_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I102_XG_MN2 (I1_I1988_G6_3n I1_I1988_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I102_XG_MN0 (XI1_I1988_I102_XG_n1 I1_I1988_P6_5 I1_I1988_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I102_XG_MN1 (VSS I1_I1988_G4_3 XI1_I1988_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I157_XG_MN2 (I1_I1988_G8_0n I1_I1988_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I157_XG_MN0 (XI1_I1988_I157_XG_n1 I1_I1988_P8_1 I1_I1988_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I157_XG_MN1 (VSS I1_I1988_G0_0 XI1_I1988_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I197_XG_MN2 (I0_I1660_G5_2n I0_I1660_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I197_XG_MN0 (XI0_I1660_I197_XG_n1 I0_I1660_P5_4 I0_I1660_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I197_XG_MN1 (VSS I0_I1660_G3_2 XI0_I1660_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I201_XG_MN2 (I0_I1660_G9_6n I0_I1660_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I201_XG_MN0 (XI0_I1660_I201_XG_n1 I0_I1660_P9_8 I0_I1660_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I201_XG_MN1 (VSS I0_I1660_G7_6 XI0_I1660_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I324_XG_MN2 (I0_I1660_G13_0n I0_I1660_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I324_XG_MN0 (XI0_I1660_I324_XG_n1 I0_I1660_P13_6 I0_I1660_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I324_XG_MN1 (VSS I0_I1660_G5_0 XI0_I1660_I324_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I328_XG_MN2 (I0_I1660_G17_2n I0_I1660_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I328_XG_MN0 (XI0_I1660_I328_XG_n1 I0_I1660_P17_10 I0_I1660_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I328_XG_MN1 (VSS I0_I1660_G9_2 XI0_I1660_I328_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I210_XG_MN2 (I0_I1660_G18_15n I0_I1660_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I210_XG_MN0 (XI0_I1660_I210_XG_n1 I0_I1660_P18_17 I0_I1660_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I210_XG_MN1 (VSS I0_I1660_G16_15 XI0_I1660_I210_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I322_XG_MN2 (I0_I1660_G11_0n I0_I1660_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I322_XG_MN0 (XI0_I1660_I322_XG_n1 I0_I1660_P11_4 I0_I1660_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I322_XG_MN1 (VSS I0_I1660_G3_0np XI0_I1660_I322_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I212_XG_MN2 (I0_I1660_G20_17n I0_I1660_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I212_XG_MN0 (XI0_I1660_I212_XG_n1 I0_I1660_P20_19 I0_I1660_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I212_XG_MN1 (VSS I0_I1660_G18_17 XI0_I1660_I212_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I330_XG_MN2 (I0_I1660_G19_4n I0_I1660_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I330_XG_MN0 (XI0_I1660_I330_XG_n1 I0_I1660_P19_12 I0_I1660_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I330_XG_MN1 (VSS I0_I1660_G11_4 XI0_I1660_I330_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I214_XG_MN2 (I0_I1660_G22_19n I0_I1660_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I214_XG_MN0 (XI0_I1660_I214_XG_n1 I0_I1660_P22_21 I0_I1660_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I214_XG_MN1 (VSS I0_I1660_G20_19 XI0_I1660_I214_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I216_XG_MN2 (I0_I1660_G24_21n I0_I1660_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I216_XG_MN0 (XI0_I1660_I216_XG_n1 I0_I1660_P24_23 I0_I1660_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I216_XG_MN1 (VSS I0_I1660_G22_21 XI0_I1660_I216_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I326_XG_MN2 (I0_I1660_G15_0n I0_I1660_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I326_XG_MN0 (XI0_I1660_I326_XG_n1 I0_I1660_P15_8 I0_I1660_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I326_XG_MN1 (VSS I0_I1660_G7_0 XI0_I1660_I326_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I218_XG_MN2 (I0_I1660_G26_23n I0_I1660_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I218_XG_MN0 (XI0_I1660_I218_XG_n1 I0_I1660_P26_25 I0_I1660_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I218_XG_MN1 (VSS I0_I1660_G24_23 XI0_I1660_I218_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I334_XG_MN2 (I0_I1660_G23_8n I0_I1660_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I334_XG_MN0 (XI0_I1660_I334_XG_n1 I0_I1660_P23_16 I0_I1660_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I334_XG_MN1 (VSS I0_I1660_G15_8 XI0_I1660_I334_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I217_XG_MN2 (I0_I1660_G25_22n I0_I1660_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I217_XG_MN0 (XI0_I1660_I217_XG_n1 I0_I1660_P25_24 I0_I1660_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I217_XG_MN1 (VSS I0_I1660_G23_22 XI0_I1660_I217_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I219_XG_MN2 (I0_I1660_G27_24n I0_I1660_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I219_XG_MN0 (XI0_I1660_I219_XG_n1 I0_I1660_P27_26 I0_I1660_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I219_XG_MN1 (VSS I0_I1660_G25_24 XI0_I1660_I219_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I221_XG_MN2 (I0_I1660_G29_26n I0_I1660_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I221_XG_MN0 (XI0_I1660_I221_XG_n1 I0_I1660_P29_28 I0_I1660_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I221_XG_MN1 (VSS I0_I1660_G27_26 XI0_I1660_I221_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I127_XG_MN2 (I1_I1804_G31_28n I1_I1804_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I127_XG_MN0 (XI1_I1804_I127_XG_n1 I1_I1804_P31_30 I1_I1804_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I127_XG_MN1 (VSS I1_I1804_G29_28 XI1_I1804_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I115_XG_MN2 (I1_I1804_G19_16n I1_I1804_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I115_XG_MN0 (XI1_I1804_I115_XG_n1 I1_I1804_P19_18 I1_I1804_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I115_XG_MN1 (VSS I1_I1804_G17_16 XI1_I1804_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I176_XG_MN2 (I1_I1804_G25_10n I1_I1804_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I176_XG_MN0 (XI1_I1804_I176_XG_n1 I1_I1804_P25_18 I1_I1804_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I176_XG_MN1 (VSS I1_I1804_G17_10 XI1_I1804_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I168_XG_MN2 (I1_I1804_G17_2n I1_I1804_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I168_XG_MN0 (XI1_I1804_I168_XG_n1 I1_I1804_P17_10 I1_I1804_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I168_XG_MN1 (VSS I1_I1804_G9_2 XI1_I1804_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I158_XG_MN2 (I1_I1804_G9_0n I1_I1804_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I158_XG_MN0 (XI1_I1804_I158_XG_n1 I1_I1804_P9_2 I1_I1804_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I158_XG_MN1 (VSS I1_I1804_G1_0 XI1_I1804_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I103_XG_MN2 (I1_I1896_G7_4n I1_I1896_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I103_XG_MN0 (XI1_I1896_I103_XG_n1 I1_I1896_P7_6 I1_I1896_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I103_XG_MN1 (VSS I1_I1896_G5_4 XI1_I1896_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I102_XG_MN2 (I1_I1896_G6_3n I1_I1896_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I102_XG_MN0 (XI1_I1896_I102_XG_n1 I1_I1896_P6_5 I1_I1896_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I102_XG_MN1 (VSS I1_I1896_G4_3 XI1_I1896_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I105_XG_MN2 (I1_I1942_G9_6n I1_I1942_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I105_XG_MN0 (XI1_I1942_I105_XG_n1 I1_I1942_P9_8 I1_I1942_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I105_XG_MN1 (VSS I1_I1942_G7_6 XI1_I1942_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I158_XG_MN2 (I1_I1942_G9_0n I1_I1942_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I158_XG_MN0 (XI1_I1942_I158_XG_n1 I1_I1942_P9_2 I1_I1942_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I158_XG_MN1 (VSS I1_I1942_G1_0 XI1_I1942_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I168_XG_MN2 (I1_I1988_G17_2n I1_I1988_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I168_XG_MN0 (XI1_I1988_I168_XG_n1 I1_I1988_P17_10 I1_I1988_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I168_XG_MN1 (VSS I1_I1988_G9_2 XI1_I1988_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I105_XG_MN2 (I1_I1988_G9_6n I1_I1988_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I105_XG_MN0 (XI1_I1988_I105_XG_n1 I1_I1988_P9_8 I1_I1988_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I105_XG_MN1 (VSS I1_I1988_G7_6 XI1_I1988_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I158_XG_MN2 (I1_I1988_G9_0n I1_I1988_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I158_XG_MN0 (XI1_I1988_I158_XG_n1 I1_I1988_P9_2 I1_I1988_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I158_XG_MN1 (VSS I1_I1988_G1_0 XI1_I1988_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I104_XG_MN2 (I1_I1988_G8_5n I1_I1988_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I104_XG_MN0 (XI1_I1988_I104_XG_n1 I1_I1988_P8_7 I1_I1988_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I104_XG_MN1 (VSS I1_I1988_G6_5 XI1_I1988_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I167_XG_MN2 (I1_I1988_G16_1n I1_I1988_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I167_XG_MN0 (XI1_I1988_I167_XG_n1 I1_I1988_P16_9 I1_I1988_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I167_XG_MN1 (VSS I1_I1988_G8_1 XI1_I1988_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I194_XG_MN2 (I0_I1660_G2_0n I0_I1660_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I194_XG_MN0 (XI0_I1660_I194_XG_n1 I0_I1660_P2_1 I0_I1660_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I194_XG_MN1 (VSS I0_I1660_G0_0 XI0_I1660_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I196_XG_MN2 (I0_I1660_G4_1n I0_I1660_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I196_XG_MN0 (XI0_I1660_I196_XG_n1 I0_I1660_P4_3 I0_I1660_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I196_XG_MN1 (VSS I0_I1660_G2_1 XI0_I1660_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I195_XG_MN2 (I0_I1660_G3_0n I0_I1660_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I195_XG_MN0 (XI0_I1660_I195_XG_n1 I0_I1660_P3_2 I0_I1660_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I195_XG_MN1 (VSS I0_I1660_G1_0 XI0_I1660_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I198_XG_MN2 (I0_I1660_G6_3n I0_I1660_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I198_XG_MN0 (XI0_I1660_I198_XG_n1 I0_I1660_P6_5 I0_I1660_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I198_XG_MN1 (VSS I0_I1660_G4_3 XI0_I1660_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I200_XG_MN2 (I0_I1660_G8_5n I0_I1660_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I200_XG_MN0 (XI0_I1660_I200_XG_n1 I0_I1660_P8_7 I0_I1660_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I200_XG_MN1 (VSS I0_I1660_G6_5 XI0_I1660_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I202_XG_MN2 (I0_I1660_G10_7n I0_I1660_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I202_XG_MN0 (XI0_I1660_I202_XG_n1 I0_I1660_P10_9 I0_I1660_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I202_XG_MN1 (VSS I0_I1660_G8_7 XI0_I1660_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I204_XG_MN2 (I0_I1660_G12_9n I0_I1660_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I204_XG_MN0 (XI0_I1660_I204_XG_n1 I0_I1660_P12_11 I0_I1660_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I204_XG_MN1 (VSS I0_I1660_G10_9 XI0_I1660_I204_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I318_XG_MN2 (I0_I1660_G9_0n I0_I1660_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I318_XG_MN0 (XI0_I1660_I318_XG_n1 I0_I1660_P9_2 I0_I1660_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I318_XG_MN1 (VSS I0_I1660_G1_0 XI0_I1660_I318_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I206_XG_MN2 (I0_I1660_G14_11n I0_I1660_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I206_XG_MN0 (XI0_I1660_I206_XG_n1 I0_I1660_P14_13 I0_I1660_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I206_XG_MN1 (VSS I0_I1660_G12_11 XI0_I1660_I206_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I208_XG_MN2 (I0_I1660_G16_13n I0_I1660_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I208_XG_MN0 (XI0_I1660_I208_XG_n1 I0_I1660_P16_15 I0_I1660_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I208_XG_MN1 (VSS I0_I1660_G14_13 XI0_I1660_I208_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I332_XG_MN2 (I0_I1660_G21_6n I0_I1660_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I332_XG_MN0 (XI0_I1660_I332_XG_n1 I0_I1660_P21_14 I0_I1660_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I332_XG_MN1 (VSS I0_I1660_G13_6 XI0_I1660_I332_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I220_XG_MN2 (I0_I1660_G28_25n I0_I1660_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I220_XG_MN0 (XI0_I1660_I220_XG_n1 I0_I1660_P28_27 I0_I1660_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I220_XG_MN1 (VSS I0_I1660_G26_25 XI0_I1660_I220_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I222_XG_MN2 (I0_I1660_G30_27n I0_I1660_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I222_XG_MN0 (XI0_I1660_I222_XG_n1 I0_I1660_P30_29 I0_I1660_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I222_XG_MN1 (VSS I0_I1660_G28_27 XI0_I1660_I222_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I336_XG_MN2 (I0_I1660_G25_10n I0_I1660_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I336_XG_MN0 (XI0_I1660_I336_XG_n1 I0_I1660_P25_18 I0_I1660_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I336_XG_MN1 (VSS I0_I1660_G17_10 XI0_I1660_I336_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I344_XG_MN2 (I0_I1660_G33_18n I0_I1660_G33_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I344_XG_MN0 (XI0_I1660_I344_XG_n1 I0_I1660_P33_26 I0_I1660_G33_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I344_XG_MN1 (VSS I0_I1660_G25_18 XI0_I1660_I344_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I338_XG_MN2 (I0_I1660_G27_12n I0_I1660_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I338_XG_MN0 (XI0_I1660_I338_XG_n1 I0_I1660_P27_20 I0_I1660_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I338_XG_MN1 (VSS I0_I1660_G19_12 XI0_I1660_I338_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I342_XG_MN2 (I0_I1660_G31_16n I0_I1660_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I342_XG_MN0 (XI0_I1660_I342_XG_n1 I0_I1660_P31_24 I0_I1660_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I342_XG_MN1 (VSS I0_I1660_G23_16 XI0_I1660_I342_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I223_XG_MN2 (I0_I1660_G31_28n I0_I1660_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I223_XG_MN0 (XI0_I1660_I223_XG_n1 I0_I1660_P31_30 I0_I1660_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I223_XG_MN1 (VSS I0_I1660_G29_28 XI0_I1660_I223_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I225_XG_MN2 (I0_I1660_G33_30n I0_I1660_G33_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I225_XG_MN0 (XI0_I1660_I225_XG_n1 I0_I1660_P33_32 I0_I1660_G33_30n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I225_XG_MN1 (VSS I0_I1660_G31_30 XI0_I1660_I225_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I180_XG_MN2 (I1_I1804_G29_14n I1_I1804_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I180_XG_MN0 (XI1_I1804_I180_XG_n1 I1_I1804_P29_22 I1_I1804_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I180_XG_MN1 (VSS I1_I1804_G21_14 XI1_I1804_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I172_XG_MN2 (I1_I1804_G21_6n I1_I1804_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I172_XG_MN0 (XI1_I1804_I172_XG_n1 I1_I1804_P21_14 I1_I1804_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I172_XG_MN1 (VSS I1_I1804_G13_6 XI1_I1804_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I164_XG_MN2 (I1_I1804_G13_0n I1_I1804_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I164_XG_MN0 (XI1_I1804_I164_XG_n1 I1_I1804_P13_6 I1_I1804_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I164_XG_MN1 (VSS I1_I1804_G5_0 XI1_I1804_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I101_XG_MN2 (I1_I1850_G5_2n I1_I1850_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I101_XG_MN0 (XI1_I1850_I101_XG_n1 I1_I1850_P5_4 I1_I1850_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I101_XG_MN1 (VSS I1_I1850_G3_2 XI1_I1850_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I98_XG_MN2 (I1_I1850_G2_0n I1_I1850_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I98_XG_MN0 (XI1_I1850_I98_XG_n1 I1_I1850_P2_1 I1_I1850_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I98_XG_MN1 (VSS I1_I1850_G0_0 XI1_I1850_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I104_XG_MN2 (I1_I1896_G8_5n I1_I1896_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I104_XG_MN0 (XI1_I1896_I104_XG_n1 I1_I1896_P8_7 I1_I1896_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I104_XG_MN1 (VSS I1_I1896_G6_5 XI1_I1896_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I157_XG_MN2 (I1_I1896_G8_0n I1_I1896_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I157_XG_MN0 (XI1_I1896_I157_XG_n1 I1_I1896_P8_1 I1_I1896_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I157_XG_MN1 (VSS I1_I1896_G0_0 XI1_I1896_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I168_XG_MN2 (I1_I1942_G17_2n I1_I1942_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I168_XG_MN0 (XI1_I1942_I168_XG_n1 I1_I1942_P17_10 I1_I1942_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I168_XG_MN1 (VSS I1_I1942_G9_2 XI1_I1942_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I106_XG_MN2 (I1_I1942_G10_7n I1_I1942_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I106_XG_MN0 (XI1_I1942_I106_XG_n1 I1_I1942_P10_9 I1_I1942_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I106_XG_MN1 (VSS I1_I1942_G8_7 XI1_I1942_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I169_XG_MN2 (I1_I1942_G18_3n I1_I1942_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I169_XG_MN0 (XI1_I1942_I169_XG_n1 I1_I1942_P18_11 I1_I1942_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I169_XG_MN1 (VSS I1_I1942_G10_3 XI1_I1942_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I160_XG_MN2 (I1_I1942_G10_0n I1_I1942_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I160_XG_MN0 (XI1_I1942_I160_XG_n1 I1_I1942_P10_3 I1_I1942_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I160_XG_MN1 (VSS I1_I1942_G2_0np XI1_I1942_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I107_XG_MN2 (I1_I1988_G11_8n I1_I1988_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I107_XG_MN0 (XI1_I1988_I107_XG_n1 I1_I1988_P11_10 I1_I1988_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I107_XG_MN1 (VSS I1_I1988_G9_8 XI1_I1988_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I106_XG_MN2 (I1_I1988_G10_7n I1_I1988_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I106_XG_MN0 (XI1_I1988_I106_XG_n1 I1_I1988_P10_9 I1_I1988_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I106_XG_MN1 (VSS I1_I1988_G8_7 XI1_I1988_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I160_XG_MN2 (I1_I1988_G10_0n I1_I1988_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I160_XG_MN0 (XI1_I1988_I160_XG_n1 I1_I1988_P10_3 I1_I1988_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I160_XG_MN1 (VSS I1_I1988_G2_0np XI1_I1988_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2066_I102_XG_MN2 (I1_I2066_G6_3n I1_I2066_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2066_I102_XG_MN0 (XI1_I2066_I102_XG_n1 I1_I2066_P6_5 I1_I2066_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2066_I102_XG_MN1 (VSS I1_I2066_G4_3 XI1_I2066_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2066_I100_XG_MN2 (I1_I2066_G4_1n I1_I2066_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2066_I100_XG_MN0 (XI1_I2066_I100_XG_n1 I1_I2066_P4_3 I1_I2066_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2066_I100_XG_MN1 (VSS I1_I2066_G2_1 XI1_I2066_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2066_I98_XG_MN2 (I1_I2066_G2_0n I1_I2066_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2066_I98_XG_MN0 (XI1_I2066_I98_XG_n1 I1_I2066_P2_1 I1_I2066_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2066_I98_XG_MN1 (VSS I1_I2066_G0_0 XI1_I2066_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2173_MN2 (I1_nrkn2 I1_nrk1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2173_MN0 (XI1_I2173_n1 I1_A_31_b3_5 I1_nrkn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2173_MN1 (VSS I1_ru1 XI1_I2173_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I323_XG_MN2 (I0_I1660_G12_0n I0_I1660_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I323_XG_MN0 (XI0_I1660_I323_XG_n1 I0_I1660_P12_5 I0_I1660_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I323_XG_MN1 (VSS I0_I1660_G4_0 XI0_I1660_I323_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I428_XG_MN2 (I0_I1660_G33_0n I0_I1660_G33_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I428_XG_MN0 (XI0_I1660_I428_XG_n1 I0_I1660_P33_2 I0_I1660_G33_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I428_XG_MN1 (VSS I0_I1660_G1_0 XI0_I1660_I428_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I331_XG_MN2 (I0_I1660_G20_5n I0_I1660_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I331_XG_MN0 (XI0_I1660_I331_XG_n1 I0_I1660_P20_13 I0_I1660_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I331_XG_MN1 (VSS I0_I1660_G12_5 XI0_I1660_I331_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I335_XG_MN2 (I0_I1660_G24_9n I0_I1660_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I335_XG_MN0 (XI0_I1660_I335_XG_n1 I0_I1660_P24_17 I0_I1660_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I335_XG_MN1 (VSS I0_I1660_G16_9 XI0_I1660_I335_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I430_XG_MN2 (I0_I1660_G35_0n I0_I1660_G35_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I430_XG_MN0 (XI0_I1660_I430_XG_n1 I0_I1660_P35_4 I0_I1660_G35_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I430_XG_MN1 (VSS I0_I1660_G3_0np XI0_I1660_I430_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I432_XG_MN2 (I0_I1660_G37_0n I0_I1660_G37_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I432_XG_MN0 (XI0_I1660_I432_XG_n1 I0_I1660_P37_6 I0_I1660_G37_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I432_XG_MN1 (VSS I0_I1660_G5_0 XI0_I1660_I432_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I224_XG_MN2 (I0_I1660_G32_29n I0_I1660_G32_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I224_XG_MN0 (XI0_I1660_I224_XG_n1 I0_I1660_P32_31 I0_I1660_G32_29n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I224_XG_MN1 (VSS I0_I1660_G30_29 XI0_I1660_I224_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I452_XG_MN2 (I0_I1660_G49_0n I0_I1660_G49_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I452_XG_MN0 (XI0_I1660_I452_XG_n1 I0_I1660_P49_18 I0_I1660_G49_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I452_XG_MN1 (VSS I0_I1660_G17_0 XI0_I1660_I452_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I434_XG_MN2 (I0_I1660_G39_0n I0_I1660_G39_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I434_XG_MN0 (XI0_I1660_I434_XG_n1 I0_I1660_P39_8 I0_I1660_G39_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I434_XG_MN1 (VSS I0_I1660_G7_0 XI0_I1660_I434_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I340_XG_MN2 (I0_I1660_G29_14n I0_I1660_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I340_XG_MN0 (XI0_I1660_I340_XG_n1 I0_I1660_P29_22 I0_I1660_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I340_XG_MN1 (VSS I0_I1660_G21_14 XI0_I1660_I340_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I346_XG_MN2 (I0_I1660_G35_20n I0_I1660_G35_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I346_XG_MN0 (XI0_I1660_I346_XG_n1 I0_I1660_P35_28 I0_I1660_G35_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I346_XG_MN1 (VSS I0_I1660_G27_20 XI0_I1660_I346_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I350_XG_MN2 (I0_I1660_G39_24n I0_I1660_G39_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I350_XG_MN0 (XI0_I1660_I350_XG_n1 I0_I1660_P39_32 I0_I1660_G39_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I350_XG_MN1 (VSS I0_I1660_G31_24 XI0_I1660_I350_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I227_XG_MN2 (I0_I1660_G35_32n I0_I1660_G35_34 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I227_XG_MN0 (XI0_I1660_I227_XG_n1 I0_I1660_P35_34 I0_I1660_G35_32n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I227_XG_MN1 (VSS I0_I1660_G33_32 XI0_I1660_I227_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I182_XG_MN2 (I1_I1804_G31_16n I1_I1804_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I182_XG_MN0 (XI1_I1804_I182_XG_n1 I1_I1804_P31_24 I1_I1804_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I182_XG_MN1 (VSS I1_I1804_G23_16 XI1_I1804_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I178_XG_MN2 (I1_I1804_G27_12n I1_I1804_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I178_XG_MN0 (XI1_I1804_I178_XG_n1 I1_I1804_P27_20 I1_I1804_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I178_XG_MN1 (VSS I1_I1804_G19_12 XI1_I1804_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I174_XG_MN2 (I1_I1804_G23_8n I1_I1804_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I174_XG_MN0 (XI1_I1804_I174_XG_n1 I1_I1804_P23_16 I1_I1804_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I174_XG_MN1 (VSS I1_I1804_G15_8 XI1_I1804_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I166_XG_MN2 (I1_I1804_G15_0n I1_I1804_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I166_XG_MN0 (XI1_I1804_I166_XG_n1 I1_I1804_P15_8 I1_I1804_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I166_XG_MN1 (VSS I1_I1804_G7_0 XI1_I1804_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I170_XG_MN2 (I1_I1804_G19_4n I1_I1804_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I170_XG_MN0 (XI1_I1804_I170_XG_n1 I1_I1804_P19_12 I1_I1804_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I170_XG_MN1 (VSS I1_I1804_G11_4 XI1_I1804_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1804_I162_XG_MN2 (I1_I1804_G11_0n I1_I1804_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1804_I162_XG_MN0 (XI1_I1804_I162_XG_n1 I1_I1804_P11_4 I1_I1804_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1804_I162_XG_MN1 (VSS I1_I1804_G3_0np XI1_I1804_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I100_XG_MN2 (I1_I1850_G4_1n I1_I1850_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I100_XG_MN0 (XI1_I1850_I100_XG_n1 I1_I1850_P4_3 I1_I1850_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I100_XG_MN1 (VSS I1_I1850_G2_1 XI1_I1850_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I105_XG_MN2 (I1_I1896_G9_6n I1_I1896_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I105_XG_MN0 (XI1_I1896_I105_XG_n1 I1_I1896_P9_8 I1_I1896_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I105_XG_MN1 (VSS I1_I1896_G7_6 XI1_I1896_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I158_XG_MN2 (I1_I1896_G9_0n I1_I1896_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I158_XG_MN0 (XI1_I1896_I158_XG_n1 I1_I1896_P9_2 I1_I1896_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I158_XG_MN1 (VSS I1_I1896_G1_0 XI1_I1896_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I167_XG_MN2 (I1_I1896_G16_1n I1_I1896_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I167_XG_MN0 (XI1_I1896_I167_XG_n1 I1_I1896_P16_9 I1_I1896_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I167_XG_MN1 (VSS I1_I1896_G8_1 XI1_I1896_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I107_XG_MN2 (I1_I1942_G11_8n I1_I1942_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I107_XG_MN0 (XI1_I1942_I107_XG_n1 I1_I1942_P11_10 I1_I1942_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I107_XG_MN1 (VSS I1_I1942_G9_8 XI1_I1942_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I170_XG_MN2 (I1_I1942_G19_4n I1_I1942_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I170_XG_MN0 (XI1_I1942_I170_XG_n1 I1_I1942_P19_12 I1_I1942_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I170_XG_MN1 (VSS I1_I1942_G11_4 XI1_I1942_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I162_XG_MN2 (I1_I1942_G11_0n I1_I1942_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I162_XG_MN0 (XI1_I1942_I162_XG_n1 I1_I1942_P11_4 I1_I1942_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I162_XG_MN1 (VSS I1_I1942_G3_0np XI1_I1942_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I108_XG_MN2 (I1_I1942_G12_9n I1_I1942_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I108_XG_MN0 (XI1_I1942_I108_XG_n1 I1_I1942_P12_11 I1_I1942_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I108_XG_MN1 (VSS I1_I1942_G10_9 XI1_I1942_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I109_XG_MN2 (I1_I1988_G13_10n I1_I1988_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I109_XG_MN0 (XI1_I1988_I109_XG_n1 I1_I1988_P13_12 I1_I1988_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I109_XG_MN1 (VSS I1_I1988_G11_10 XI1_I1988_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I162_XG_MN2 (I1_I1988_G11_0n I1_I1988_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I162_XG_MN0 (XI1_I1988_I162_XG_n1 I1_I1988_P11_4 I1_I1988_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I162_XG_MN1 (VSS I1_I1988_G3_0np XI1_I1988_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I108_XG_MN2 (I1_I1988_G12_9n I1_I1988_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I108_XG_MN0 (XI1_I1988_I108_XG_n1 I1_I1988_P12_11 I1_I1988_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I108_XG_MN1 (VSS I1_I1988_G10_9 XI1_I1988_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I175_XG_MN2 (I1_I1988_G24_9n I1_I1988_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I175_XG_MN0 (XI1_I1988_I175_XG_n1 I1_I1988_P24_17 I1_I1988_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I175_XG_MN1 (VSS I1_I1988_G16_9 XI1_I1988_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2066_I104_XG_MN2 (I1_I2066_G8_5n I1_I2066_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2066_I104_XG_MN0 (XI1_I2066_I104_XG_n1 I1_I2066_P8_7 I1_I2066_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2066_I104_XG_MN1 (VSS I1_I2066_G6_5 XI1_I2066_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2066_I101_XG_MN2 (I1_I2066_G5_2n I1_I2066_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2066_I101_XG_MN0 (XI1_I2066_I101_XG_n1 I1_I2066_P5_4 I1_I2066_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2066_I101_XG_MN1 (VSS I1_I2066_G3_2 XI1_I2066_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2066_I99_XG_MN2 (I1_I2066_G3_0n I1_I2066_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2066_I99_XG_MN0 (XI1_I2066_I99_XG_n1 I1_I2066_P3_2 I1_I2066_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2066_I99_XG_MN1 (VSS I1_I2066_G1_0 XI1_I2066_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I317_XG_MN2 (I0_I1660_G8_0n I0_I1660_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I317_XG_MN0 (XI0_I1660_I317_XG_n1 I0_I1660_P8_1 I0_I1660_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I317_XG_MN1 (VSS I0_I1660_G0_0 XI0_I1660_I317_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I427_XG_MN2 (I0_I1660_G32_0n I0_I1660_G32_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I427_XG_MN0 (XI0_I1660_I427_XG_n1 I0_I1660_P32_1 I0_I1660_G32_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I427_XG_MN1 (VSS I0_I1660_G0_0 XI0_I1660_I427_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I327_XG_MN2 (I0_I1660_G16_1n I0_I1660_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I327_XG_MN0 (XI0_I1660_I327_XG_n1 I0_I1660_P16_9 I0_I1660_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I327_XG_MN1 (VSS I0_I1660_G8_1 XI0_I1660_I327_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I343_XG_MN2 (I0_I1660_G32_17n I0_I1660_G32_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I343_XG_MN0 (XI0_I1660_I343_XG_n1 I0_I1660_P32_25 I0_I1660_G32_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I343_XG_MN1 (VSS I0_I1660_G24_17 XI0_I1660_I343_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I339_XG_MN2 (I0_I1660_G28_13n I0_I1660_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I339_XG_MN0 (XI0_I1660_I339_XG_n1 I0_I1660_P28_21 I0_I1660_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I339_XG_MN1 (VSS I0_I1660_G20_13 XI0_I1660_I339_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I226_XG_MN2 (I0_I1660_G34_31n I0_I1660_G34_33 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I226_XG_MN0 (XI0_I1660_I226_XG_n1 I0_I1660_P34_33 I0_I1660_G34_31n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I226_XG_MN1 (VSS I0_I1660_G32_31 XI0_I1660_I226_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I228_XG_MN2 (I0_I1660_G36_33n I0_I1660_G36_35 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I228_XG_MN0 (XI0_I1660_I228_XG_n1 I0_I1660_P36_35 I0_I1660_G36_33n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I228_XG_MN1 (VSS I0_I1660_G34_33 XI0_I1660_I228_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I348_XG_MN2 (I0_I1660_G37_22n I0_I1660_G37_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I348_XG_MN0 (XI0_I1660_I348_XG_n1 I0_I1660_P37_30 I0_I1660_G37_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I348_XG_MN1 (VSS I0_I1660_G29_22 XI0_I1660_I348_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I442_XG_MN2 (I0_I1660_G43_0n I0_I1660_G43_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I442_XG_MN0 (XI0_I1660_I442_XG_n1 I0_I1660_P43_12 I0_I1660_G43_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I442_XG_MN1 (VSS I0_I1660_G11_0np XI0_I1660_I442_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I354_XG_MN2 (I0_I1660_G43_28n I0_I1660_G43_36 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I354_XG_MN0 (XI0_I1660_I354_XG_n1 I0_I1660_P43_36 I0_I1660_G43_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I354_XG_MN1 (VSS I0_I1660_G35_28 XI0_I1660_I354_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I229_XG_MN2 (I0_I1660_G37_34n I0_I1660_G37_36 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I229_XG_MN0 (XI0_I1660_I229_XG_n1 I0_I1660_P37_36 I0_I1660_G37_34n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I229_XG_MN1 (VSS I0_I1660_G35_34 XI0_I1660_I229_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I105_XG_MN2 (I1_I1850_G9_6n I1_I1850_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I105_XG_MN0 (XI1_I1850_I105_XG_n1 I1_I1850_P9_8 I1_I1850_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I105_XG_MN1 (VSS I1_I1850_G7_6 XI1_I1850_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I107_XG_MN2 (I1_I1850_G11_8n I1_I1850_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I107_XG_MN0 (XI1_I1850_I107_XG_n1 I1_I1850_P11_10 I1_I1850_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I107_XG_MN1 (VSS I1_I1850_G9_8 XI1_I1850_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I103_XG_MN2 (I1_I1850_G7_4n I1_I1850_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I103_XG_MN0 (XI1_I1850_I103_XG_n1 I1_I1850_P7_6 I1_I1850_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I103_XG_MN1 (VSS I1_I1850_G5_4 XI1_I1850_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I102_XG_MN2 (I1_I1850_G6_3n I1_I1850_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I102_XG_MN0 (XI1_I1850_I102_XG_n1 I1_I1850_P6_5 I1_I1850_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I102_XG_MN1 (VSS I1_I1850_G4_3 XI1_I1850_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I107_XG_MN2 (I1_I1896_G11_8n I1_I1896_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I107_XG_MN0 (XI1_I1896_I107_XG_n1 I1_I1896_P11_10 I1_I1896_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I107_XG_MN1 (VSS I1_I1896_G9_8 XI1_I1896_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I168_XG_MN2 (I1_I1896_G17_2n I1_I1896_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I168_XG_MN0 (XI1_I1896_I168_XG_n1 I1_I1896_P17_10 I1_I1896_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I168_XG_MN1 (VSS I1_I1896_G9_2 XI1_I1896_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I106_XG_MN2 (I1_I1896_G10_7n I1_I1896_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I106_XG_MN0 (XI1_I1896_I106_XG_n1 I1_I1896_P10_9 I1_I1896_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I106_XG_MN1 (VSS I1_I1896_G8_7 XI1_I1896_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I160_XG_MN2 (I1_I1896_G10_0n I1_I1896_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I160_XG_MN0 (XI1_I1896_I160_XG_n1 I1_I1896_P10_3 I1_I1896_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I160_XG_MN1 (VSS I1_I1896_G2_0np XI1_I1896_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I109_XG_MN2 (I1_I1942_G13_10n I1_I1942_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I109_XG_MN0 (XI1_I1942_I109_XG_n1 I1_I1942_P13_12 I1_I1942_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I109_XG_MN1 (VSS I1_I1942_G11_10 XI1_I1942_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I176_XG_MN2 (I1_I1942_G25_10n I1_I1942_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I176_XG_MN0 (XI1_I1942_I176_XG_n1 I1_I1942_P25_18 I1_I1942_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I176_XG_MN1 (VSS I1_I1942_G17_10 XI1_I1942_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I110_XG_MN2 (I1_I1942_G14_11n I1_I1942_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I110_XG_MN0 (XI1_I1942_I110_XG_n1 I1_I1942_P14_13 I1_I1942_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I110_XG_MN1 (VSS I1_I1942_G12_11 XI1_I1942_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I163_XG_MN2 (I1_I1942_G12_0n I1_I1942_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I163_XG_MN0 (XI1_I1942_I163_XG_n1 I1_I1942_P12_5 I1_I1942_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I163_XG_MN1 (VSS I1_I1942_G4_0 XI1_I1942_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I175_XG_MN2 (I1_I1942_G24_9n I1_I1942_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I175_XG_MN0 (XI1_I1942_I175_XG_n1 I1_I1942_P24_17 I1_I1942_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I175_XG_MN1 (VSS I1_I1942_G16_9 XI1_I1942_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I176_XG_MN2 (I1_I1988_G25_10n I1_I1988_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I176_XG_MN0 (XI1_I1988_I176_XG_n1 I1_I1988_P25_18 I1_I1988_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I176_XG_MN1 (VSS I1_I1988_G17_10 XI1_I1988_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I110_XG_MN2 (I1_I1988_G14_11n I1_I1988_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I110_XG_MN0 (XI1_I1988_I110_XG_n1 I1_I1988_P14_13 I1_I1988_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I110_XG_MN1 (VSS I1_I1988_G12_11 XI1_I1988_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I169_XG_MN2 (I1_I1988_G18_3n I1_I1988_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I169_XG_MN0 (XI1_I1988_I169_XG_n1 I1_I1988_P18_11 I1_I1988_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I169_XG_MN1 (VSS I1_I1988_G10_3 XI1_I1988_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2066_I106_XG_MN2 (I1_I2066_G10_7n I1_I2066_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2066_I106_XG_MN0 (XI1_I2066_I106_XG_n1 I1_I2066_P10_9 I1_I2066_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2066_I106_XG_MN1 (VSS I1_I2066_G8_7 XI1_I2066_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2066_I157_XG_MN2 (I1_I2066_G8_0n I1_I2066_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2066_I157_XG_MN0 (XI1_I2066_I157_XG_n1 I1_I2066_P8_1 I1_I2066_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2066_I157_XG_MN1 (VSS I1_I2066_G0_0 XI1_I2066_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2066_I103_XG_MN2 (I1_I2066_G7_4n I1_I2066_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2066_I103_XG_MN0 (XI1_I2066_I103_XG_n1 I1_I2066_P7_6 I1_I2066_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2066_I103_XG_MN1 (VSS I1_I2066_G5_4 XI1_I2066_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2176_MN2 (I1_nrkn3 I1_nrk2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2176_MN0 (XI1_I2176_n1 I1_A_31_b3_6 I1_nrkn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2176_MN1 (VSS I1_ru2 XI1_I2176_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2179_MN2 (I1_nrkn4 I1_nrk3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2179_MN0 (XI1_I2179_n1 I1_A_31_b3_6 I1_nrkn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2179_MN1 (VSS I1_ru3 XI1_I2179_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2182_MN2 (I1_nrkn5 I1_nrk4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2182_MN0 (XI1_I2182_n1 I1_A_31_b3_6 I1_nrkn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2182_MN1 (VSS I1_ru4 XI1_I2182_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I320_XG_MN2 (I0_I1660_G10_0n I0_I1660_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I320_XG_MN0 (XI0_I1660_I320_XG_n1 I0_I1660_P10_3 I0_I1660_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I320_XG_MN1 (VSS I0_I1660_G2_0np XI0_I1660_I320_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I329_XG_MN2 (I0_I1660_G18_3n I0_I1660_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I329_XG_MN0 (XI0_I1660_I329_XG_n1 I0_I1660_P18_11 I0_I1660_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I329_XG_MN1 (VSS I0_I1660_G10_3 XI0_I1660_I329_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I325_XG_MN2 (I0_I1660_G14_0n I0_I1660_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I325_XG_MN0 (XI0_I1660_I325_XG_n1 I0_I1660_P14_7 I0_I1660_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I325_XG_MN1 (VSS I0_I1660_G6_0 XI0_I1660_I325_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I431_XG_MN2 (I0_I1660_G36_0n I0_I1660_G36_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I431_XG_MN0 (XI0_I1660_I431_XG_n1 I0_I1660_P36_5 I0_I1660_G36_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I431_XG_MN1 (VSS I0_I1660_G4_0 XI0_I1660_I431_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I451_XG_MN2 (I0_I1660_G48_0n I0_I1660_G48_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I451_XG_MN0 (XI0_I1660_I451_XG_n1 I0_I1660_P48_17 I0_I1660_G48_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I451_XG_MN1 (VSS I0_I1660_G16_0 XI0_I1660_I451_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I436_XG_MN2 (I0_I1660_G40_0n I0_I1660_G40_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I436_XG_MN0 (XI0_I1660_I436_XG_n1 I0_I1660_P40_9 I0_I1660_G40_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I436_XG_MN1 (VSS I0_I1660_G8_0np XI0_I1660_I436_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I347_XG_MN2 (I0_I1660_G36_21n I0_I1660_G36_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I347_XG_MN0 (XI0_I1660_I347_XG_n1 I0_I1660_P36_29 I0_I1660_G36_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I347_XG_MN1 (VSS I0_I1660_G28_21 XI0_I1660_I347_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I351_XG_MN2 (I0_I1660_G40_25n I0_I1660_G40_33 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I351_XG_MN0 (XI0_I1660_I351_XG_n1 I0_I1660_P40_33 I0_I1660_G40_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I351_XG_MN1 (VSS I0_I1660_G32_25 XI0_I1660_I351_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I438_XG_MN2 (I0_I1660_G41_0n I0_I1660_G41_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I438_XG_MN0 (XI0_I1660_I438_XG_n1 I0_I1660_P41_10 I0_I1660_G41_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I438_XG_MN1 (VSS I0_I1660_G9_0np XI0_I1660_I438_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I454_XG_MN2 (I0_I1660_G51_0n I0_I1660_G51_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I454_XG_MN0 (XI0_I1660_I454_XG_n1 I0_I1660_P51_20 I0_I1660_G51_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I454_XG_MN1 (VSS I0_I1660_G19_0 XI0_I1660_I454_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I352_XG_MN2 (I0_I1660_G41_26n I0_I1660_G41_34 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I352_XG_MN0 (XI0_I1660_I352_XG_n1 I0_I1660_P41_34 I0_I1660_G41_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I352_XG_MN1 (VSS I0_I1660_G33_26 XI0_I1660_I352_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I450_XG_MN2 (I0_I1660_G47_0n I0_I1660_G47_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I450_XG_MN0 (XI0_I1660_I450_XG_n1 I0_I1660_P47_16 I0_I1660_G47_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I450_XG_MN1 (VSS I0_I1660_G15_0np XI0_I1660_I450_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I360_XG_MN2 (I0_I1660_G49_34n I0_I1660_G49_42 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I360_XG_MN0 (XI0_I1660_I360_XG_n1 I0_I1660_P49_42 I0_I1660_G49_34n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I360_XG_MN1 (VSS I0_I1660_G41_34 XI0_I1660_I360_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I362_XG_MN2 (I0_I1660_G51_36n I0_I1660_G51_44 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I362_XG_MN0 (XI0_I1660_I362_XG_n1 I0_I1660_P51_44 I0_I1660_G51_36n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I362_XG_MN1 (VSS I0_I1660_G43_36 XI0_I1660_I362_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I358_XG_MN2 (I0_I1660_G47_32n I0_I1660_G47_40 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I358_XG_MN0 (XI0_I1660_I358_XG_n1 I0_I1660_P47_40 I0_I1660_G47_32n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I358_XG_MN1 (VSS I0_I1660_G39_32 XI0_I1660_I358_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I231_XG_MN2 (I0_I1660_G39_36n I0_I1660_G39_38 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I231_XG_MN0 (XI0_I1660_I231_XG_n1 I0_I1660_P39_38 I0_I1660_G39_36n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I231_XG_MN1 (VSS I0_I1660_G37_36 XI0_I1660_I231_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I233_XG_MN2 (I0_I1660_G41_38n I0_I1660_G41_40 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I233_XG_MN0 (XI0_I1660_I233_XG_n1 I0_I1660_P41_40 I0_I1660_G41_38n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I233_XG_MN1 (VSS I0_I1660_G39_38 XI0_I1660_I233_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I162_XG_MN2 (I1_I1850_G11_0n I1_I1850_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I162_XG_MN0 (XI1_I1850_I162_XG_n1 I1_I1850_P11_4 I1_I1850_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I162_XG_MN1 (VSS I1_I1850_G3_0np XI1_I1850_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I109_XG_MN2 (I1_I1850_G13_10n I1_I1850_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I109_XG_MN0 (XI1_I1850_I109_XG_n1 I1_I1850_P13_12 I1_I1850_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I109_XG_MN1 (VSS I1_I1850_G11_10 XI1_I1850_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I158_XG_MN2 (I1_I1850_G9_0n I1_I1850_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I158_XG_MN0 (XI1_I1850_I158_XG_n1 I1_I1850_P9_2 I1_I1850_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I158_XG_MN1 (VSS I1_I1850_G1_0 XI1_I1850_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I106_XG_MN2 (I1_I1850_G10_7n I1_I1850_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I106_XG_MN0 (XI1_I1850_I106_XG_n1 I1_I1850_P10_9 I1_I1850_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I106_XG_MN1 (VSS I1_I1850_G8_7 XI1_I1850_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I104_XG_MN2 (I1_I1850_G8_5n I1_I1850_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I104_XG_MN0 (XI1_I1850_I104_XG_n1 I1_I1850_P8_7 I1_I1850_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I104_XG_MN1 (VSS I1_I1850_G6_5 XI1_I1850_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I109_XG_MN2 (I1_I1896_G13_10n I1_I1896_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I109_XG_MN0 (XI1_I1896_I109_XG_n1 I1_I1896_P13_12 I1_I1896_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I109_XG_MN1 (VSS I1_I1896_G11_10 XI1_I1896_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I162_XG_MN2 (I1_I1896_G11_0n I1_I1896_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I162_XG_MN0 (XI1_I1896_I162_XG_n1 I1_I1896_P11_4 I1_I1896_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I162_XG_MN1 (VSS I1_I1896_G3_0np XI1_I1896_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I108_XG_MN2 (I1_I1896_G12_9n I1_I1896_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I108_XG_MN0 (XI1_I1896_I108_XG_n1 I1_I1896_P12_11 I1_I1896_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I108_XG_MN1 (VSS I1_I1896_G10_9 XI1_I1896_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I169_XG_MN2 (I1_I1896_G18_3n I1_I1896_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I169_XG_MN0 (XI1_I1896_I169_XG_n1 I1_I1896_P18_11 I1_I1896_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I169_XG_MN1 (VSS I1_I1896_G10_3 XI1_I1896_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I111_XG_MN2 (I1_I1942_G15_12n I1_I1942_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I111_XG_MN0 (XI1_I1942_I111_XG_n1 I1_I1942_P15_14 I1_I1942_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I111_XG_MN1 (VSS I1_I1942_G13_12 XI1_I1942_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I164_XG_MN2 (I1_I1942_G13_0n I1_I1942_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I164_XG_MN0 (XI1_I1942_I164_XG_n1 I1_I1942_P13_6 I1_I1942_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I164_XG_MN1 (VSS I1_I1942_G5_0 XI1_I1942_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I112_XG_MN2 (I1_I1942_G16_13n I1_I1942_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I112_XG_MN0 (XI1_I1942_I112_XG_n1 I1_I1942_P16_15 I1_I1942_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I112_XG_MN1 (VSS I1_I1942_G14_13 XI1_I1942_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I171_XG_MN2 (I1_I1942_G20_5n I1_I1942_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I171_XG_MN0 (XI1_I1942_I171_XG_n1 I1_I1942_P20_13 I1_I1942_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I171_XG_MN1 (VSS I1_I1942_G12_5 XI1_I1942_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I111_XG_MN2 (I1_I1988_G15_12n I1_I1988_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I111_XG_MN0 (XI1_I1988_I111_XG_n1 I1_I1988_P15_14 I1_I1988_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I111_XG_MN1 (VSS I1_I1988_G13_12 XI1_I1988_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I170_XG_MN2 (I1_I1988_G19_4n I1_I1988_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I170_XG_MN0 (XI1_I1988_I170_XG_n1 I1_I1988_P19_12 I1_I1988_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I170_XG_MN1 (VSS I1_I1988_G11_4 XI1_I1988_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I164_XG_MN2 (I1_I1988_G13_0n I1_I1988_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I164_XG_MN0 (XI1_I1988_I164_XG_n1 I1_I1988_P13_6 I1_I1988_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I164_XG_MN1 (VSS I1_I1988_G5_0 XI1_I1988_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I112_XG_MN2 (I1_I1988_G16_13n I1_I1988_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I112_XG_MN0 (XI1_I1988_I112_XG_n1 I1_I1988_P16_15 I1_I1988_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I112_XG_MN1 (VSS I1_I1988_G14_13 XI1_I1988_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I163_XG_MN2 (I1_I1988_G12_0n I1_I1988_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I163_XG_MN0 (XI1_I1988_I163_XG_n1 I1_I1988_P12_5 I1_I1988_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I163_XG_MN1 (VSS I1_I1988_G4_0 XI1_I1988_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2066_I108_XG_MN2 (I1_I2066_G12_9n I1_I2066_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2066_I108_XG_MN0 (XI1_I2066_I108_XG_n1 I1_I2066_P12_11 I1_I2066_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2066_I108_XG_MN1 (VSS I1_I2066_G10_9 XI1_I2066_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2066_I167_XG_MN2 (I1_I2066_G16_1n I1_I2066_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2066_I167_XG_MN0 (XI1_I2066_I167_XG_n1 I1_I2066_P16_9 I1_I2066_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2066_I167_XG_MN1 (VSS I1_I2066_G8_1 XI1_I2066_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2066_I105_XG_MN2 (I1_I2066_G9_6n I1_I2066_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2066_I105_XG_MN0 (XI1_I2066_I105_XG_n1 I1_I2066_P9_8 I1_I2066_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2066_I105_XG_MN1 (VSS I1_I2066_G7_6 XI1_I2066_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2066_I158_XG_MN2 (I1_I2066_G9_0n I1_I2066_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2066_I158_XG_MN0 (XI1_I2066_I158_XG_n1 I1_I2066_P9_2 I1_I2066_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2066_I158_XG_MN1 (VSS I1_I2066_G1_0 XI1_I2066_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2188_MN2 (I1_nrkn7 I1_nrk6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2188_MN0 (XI1_I2188_n1 I1_A_31_b3_6 I1_nrkn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2188_MN1 (VSS I1_ru6 XI1_I2188_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2185_MN2 (I1_nrkn6 I1_nrk5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2185_MN0 (XI1_I2185_n1 I1_A_31_b3_6 I1_nrkn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2185_MN1 (VSS I1_ru5 XI1_I2185_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I429_XG_MN2 (I0_I1660_G34_0n I0_I1660_G34_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I429_XG_MN0 (XI0_I1660_I429_XG_n1 I0_I1660_P34_3 I0_I1660_G34_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I429_XG_MN1 (VSS I0_I1660_G2_0np XI0_I1660_I429_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I333_XG_MN2 (I0_I1660_G22_7n I0_I1660_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I333_XG_MN0 (XI0_I1660_I333_XG_n1 I0_I1660_P22_15 I0_I1660_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I333_XG_MN1 (VSS I0_I1660_G14_7 XI0_I1660_I333_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I337_XG_MN2 (I0_I1660_G26_11n I0_I1660_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I337_XG_MN0 (XI0_I1660_I337_XG_n1 I0_I1660_P26_19 I0_I1660_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I337_XG_MN1 (VSS I0_I1660_G18_11 XI0_I1660_I337_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I359_XG_MN2 (I0_I1660_G48_33n I0_I1660_G48_41 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I359_XG_MN0 (XI0_I1660_I359_XG_n1 I0_I1660_P48_41 I0_I1660_G48_33n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I359_XG_MN1 (VSS I0_I1660_G40_33 XI0_I1660_I359_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I230_XG_MN2 (I0_I1660_G38_35n I0_I1660_G38_37 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I230_XG_MN0 (XI0_I1660_I230_XG_n1 I0_I1660_P38_37 I0_I1660_G38_35n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I230_XG_MN1 (VSS I0_I1660_G36_35 XI0_I1660_I230_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I232_XG_MN2 (I0_I1660_G40_37n I0_I1660_G40_39 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I232_XG_MN0 (XI0_I1660_I232_XG_n1 I0_I1660_P40_39 I0_I1660_G40_37n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I232_XG_MN1 (VSS I0_I1660_G38_37 XI0_I1660_I232_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I456_XG_MN2 (I0_I1660_G53_0n I0_I1660_G53_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I456_XG_MN0 (XI0_I1660_I456_XG_n1 I0_I1660_P53_22 I0_I1660_G53_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I456_XG_MN1 (VSS I0_I1660_G21_0 XI0_I1660_I456_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I458_XG_MN2 (I0_I1660_G55_0n I0_I1660_G55_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I458_XG_MN0 (XI0_I1660_I458_XG_n1 I0_I1660_P55_24 I0_I1660_G55_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I458_XG_MN1 (VSS I0_I1660_G23_0 XI0_I1660_I458_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I466_XG_MN2 (I0_I1660_G63_0n I0_I1660_G63_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I466_XG_MN0 (XI0_I1660_I466_XG_n1 I0_I1660_P63_32 I0_I1660_G63_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I466_XG_MN1 (VSS I0_I1660_G31_0 XI0_I1660_I466_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I366_XG_MN2 (I0_I1660_G55_40n I0_I1660_G55_48 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I366_XG_MN0 (XI0_I1660_I366_XG_n1 I0_I1660_P55_48 I0_I1660_G55_40n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I366_XG_MN1 (VSS I0_I1660_G47_40 XI0_I1660_I366_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I235_XG_MN2 (I0_I1660_G43_40n I0_I1660_G43_42 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I235_XG_MN0 (XI0_I1660_I235_XG_n1 I0_I1660_P43_42 I0_I1660_G43_40n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I235_XG_MN1 (VSS I0_I1660_G41_40 XI0_I1660_I235_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I170_XG_MN2 (I1_I1850_G19_4n I1_I1850_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I170_XG_MN0 (XI1_I1850_I170_XG_n1 I1_I1850_P19_12 I1_I1850_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I170_XG_MN1 (VSS I1_I1850_G11_4 XI1_I1850_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I111_XG_MN2 (I1_I1850_G15_12n I1_I1850_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I111_XG_MN0 (XI1_I1850_I111_XG_n1 I1_I1850_P15_14 I1_I1850_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I111_XG_MN1 (VSS I1_I1850_G13_12 XI1_I1850_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I164_XG_MN2 (I1_I1850_G13_0n I1_I1850_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I164_XG_MN0 (XI1_I1850_I164_XG_n1 I1_I1850_P13_6 I1_I1850_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I164_XG_MN1 (VSS I1_I1850_G5_0 XI1_I1850_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I168_XG_MN2 (I1_I1850_G17_2n I1_I1850_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I168_XG_MN0 (XI1_I1850_I168_XG_n1 I1_I1850_P17_10 I1_I1850_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I168_XG_MN1 (VSS I1_I1850_G9_2 XI1_I1850_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I108_XG_MN2 (I1_I1850_G12_9n I1_I1850_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I108_XG_MN0 (XI1_I1850_I108_XG_n1 I1_I1850_P12_11 I1_I1850_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I108_XG_MN1 (VSS I1_I1850_G10_9 XI1_I1850_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I157_XG_MN2 (I1_I1850_G8_0n I1_I1850_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I157_XG_MN0 (XI1_I1850_I157_XG_n1 I1_I1850_P8_1 I1_I1850_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I157_XG_MN1 (VSS I1_I1850_G0_0 XI1_I1850_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I170_XG_MN2 (I1_I1896_G19_4n I1_I1896_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I170_XG_MN0 (XI1_I1896_I170_XG_n1 I1_I1896_P19_12 I1_I1896_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I170_XG_MN1 (VSS I1_I1896_G11_4 XI1_I1896_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I110_XG_MN2 (I1_I1896_G14_11n I1_I1896_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I110_XG_MN0 (XI1_I1896_I110_XG_n1 I1_I1896_P14_13 I1_I1896_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I110_XG_MN1 (VSS I1_I1896_G12_11 XI1_I1896_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I163_XG_MN2 (I1_I1896_G12_0n I1_I1896_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I163_XG_MN0 (XI1_I1896_I163_XG_n1 I1_I1896_P12_5 I1_I1896_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I163_XG_MN1 (VSS I1_I1896_G4_0 XI1_I1896_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I113_XG_MN2 (I1_I1942_G17_14n I1_I1942_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I113_XG_MN0 (XI1_I1942_I113_XG_n1 I1_I1942_P17_16 I1_I1942_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I113_XG_MN1 (VSS I1_I1942_G15_14 XI1_I1942_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I172_XG_MN2 (I1_I1942_G21_6n I1_I1942_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I172_XG_MN0 (XI1_I1942_I172_XG_n1 I1_I1942_P21_14 I1_I1942_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I172_XG_MN1 (VSS I1_I1942_G13_6 XI1_I1942_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I114_XG_MN2 (I1_I1942_G18_15n I1_I1942_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I114_XG_MN0 (XI1_I1942_I114_XG_n1 I1_I1942_P18_17 I1_I1942_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I114_XG_MN1 (VSS I1_I1942_G16_15 XI1_I1942_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I113_XG_MN2 (I1_I1988_G17_14n I1_I1988_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I113_XG_MN0 (XI1_I1988_I113_XG_n1 I1_I1988_P17_16 I1_I1988_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I113_XG_MN1 (VSS I1_I1988_G15_14 XI1_I1988_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I172_XG_MN2 (I1_I1988_G21_6n I1_I1988_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I172_XG_MN0 (XI1_I1988_I172_XG_n1 I1_I1988_P21_14 I1_I1988_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I172_XG_MN1 (VSS I1_I1988_G13_6 XI1_I1988_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I116_XG_MN2 (I1_I1988_G20_17n I1_I1988_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I116_XG_MN0 (XI1_I1988_I116_XG_n1 I1_I1988_P20_19 I1_I1988_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I116_XG_MN1 (VSS I1_I1988_G18_17 XI1_I1988_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I114_XG_MN2 (I1_I1988_G18_15n I1_I1988_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I114_XG_MN0 (XI1_I1988_I114_XG_n1 I1_I1988_P18_17 I1_I1988_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I114_XG_MN1 (VSS I1_I1988_G16_15 XI1_I1988_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I171_XG_MN2 (I1_I1988_G20_5n I1_I1988_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I171_XG_MN0 (XI1_I1988_I171_XG_n1 I1_I1988_P20_13 I1_I1988_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I171_XG_MN1 (VSS I1_I1988_G12_5 XI1_I1988_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I165_XG_MN2 (I1_I1988_G14_0n I1_I1988_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I165_XG_MN0 (XI1_I1988_I165_XG_n1 I1_I1988_P14_7 I1_I1988_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I165_XG_MN1 (VSS I1_I1988_G6_0 XI1_I1988_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2066_I110_XG_MN2 (I1_I2066_G14_11n I1_I2066_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2066_I110_XG_MN0 (XI1_I2066_I110_XG_n1 I1_I2066_P14_13 I1_I2066_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2066_I110_XG_MN1 (VSS I1_I2066_G12_11 XI1_I2066_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2066_I175_XG_MN2 (I1_I2066_G24_9n I1_I2066_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2066_I175_XG_MN0 (XI1_I2066_I175_XG_n1 I1_I2066_P24_17 I1_I2066_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2066_I175_XG_MN1 (VSS I1_I2066_G16_9 XI1_I2066_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2066_I160_XG_MN2 (I1_I2066_G10_0n I1_I2066_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2066_I160_XG_MN0 (XI1_I2066_I160_XG_n1 I1_I2066_P10_3 I1_I2066_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2066_I160_XG_MN1 (VSS I1_I2066_G2_0np XI1_I2066_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2066_I107_XG_MN2 (I1_I2066_G11_8n I1_I2066_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2066_I107_XG_MN0 (XI1_I2066_I107_XG_n1 I1_I2066_P11_10 I1_I2066_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2066_I107_XG_MN1 (VSS I1_I2066_G9_8 XI1_I2066_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2066_I168_XG_MN2 (I1_I2066_G17_2n I1_I2066_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2066_I168_XG_MN0 (XI1_I2066_I168_XG_n1 I1_I2066_P17_10 I1_I2066_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2066_I168_XG_MN1 (VSS I1_I2066_G9_2 XI1_I2066_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2191_MN2 (I1_nrkn8 I1_nrk7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2191_MN0 (XI1_I2191_n1 I1_A_31_b3_6 I1_nrkn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2191_MN1 (VSS I1_ru7 XI1_I2191_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I345_XG_MN2 (I0_I1660_G34_19n I0_I1660_G34_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I345_XG_MN0 (XI0_I1660_I345_XG_n1 I0_I1660_P34_27 I0_I1660_G34_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I345_XG_MN1 (VSS I0_I1660_G26_19 XI0_I1660_I345_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I444_XG_MN2 (I0_I1660_G44_0n I0_I1660_G44_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I444_XG_MN0 (XI0_I1660_I444_XG_n1 I0_I1660_P44_13 I0_I1660_G44_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I444_XG_MN1 (VSS I0_I1660_G12_0np XI0_I1660_I444_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I363_XG_MN2 (I0_I1660_G52_37n I0_I1660_G52_45 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I363_XG_MN0 (XI0_I1660_I363_XG_n1 I0_I1660_P52_45 I0_I1660_G52_37n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I363_XG_MN1 (VSS I0_I1660_G44_37 XI0_I1660_I363_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I355_XG_MN2 (I0_I1660_G44_29n I0_I1660_G44_37 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I355_XG_MN0 (XI0_I1660_I355_XG_n1 I0_I1660_P44_37 I0_I1660_G44_29n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I355_XG_MN1 (VSS I0_I1660_G36_29 XI0_I1660_I355_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I234_XG_MN2 (I0_I1660_G42_39n I0_I1660_G42_41 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I234_XG_MN0 (XI0_I1660_I234_XG_n1 I0_I1660_P42_41 I0_I1660_G42_39n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I234_XG_MN1 (VSS I0_I1660_G40_39 XI0_I1660_I234_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I446_XG_MN2 (I0_I1660_G45_0n I0_I1660_G45_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I446_XG_MN0 (XI0_I1660_I446_XG_n1 I0_I1660_P45_14 I0_I1660_G45_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I446_XG_MN1 (VSS I0_I1660_G13_0np XI0_I1660_I446_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I364_XG_MN2 (I0_I1660_G53_38n I0_I1660_G53_46 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I364_XG_MN0 (XI0_I1660_I364_XG_n1 I0_I1660_P53_46 I0_I1660_G53_38n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I364_XG_MN1 (VSS I0_I1660_G45_38 XI0_I1660_I364_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I356_XG_MN2 (I0_I1660_G45_30n I0_I1660_G45_38 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I356_XG_MN0 (XI0_I1660_I356_XG_n1 I0_I1660_P45_38 I0_I1660_G45_30n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I356_XG_MN1 (VSS I0_I1660_G37_30 XI0_I1660_I356_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I237_XG_MN2 (I0_I1660_G45_42n I0_I1660_G45_44 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I237_XG_MN0 (XI0_I1660_I237_XG_n1 I0_I1660_P45_44 I0_I1660_G45_42n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I237_XG_MN1 (VSS I0_I1660_G43_42 XI0_I1660_I237_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I166_XG_MN2 (I1_I1850_G15_0n I1_I1850_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I166_XG_MN0 (XI1_I1850_I166_XG_n1 I1_I1850_P15_8 I1_I1850_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I166_XG_MN1 (VSS I1_I1850_G7_0 XI1_I1850_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I115_XG_MN2 (I1_I1850_G19_16n I1_I1850_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I115_XG_MN0 (XI1_I1850_I115_XG_n1 I1_I1850_P19_18 I1_I1850_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I115_XG_MN1 (VSS I1_I1850_G17_16 XI1_I1850_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I113_XG_MN2 (I1_I1850_G17_14n I1_I1850_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I113_XG_MN0 (XI1_I1850_I113_XG_n1 I1_I1850_P17_16 I1_I1850_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I113_XG_MN1 (VSS I1_I1850_G15_14 XI1_I1850_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I112_XG_MN2 (I1_I1850_G16_13n I1_I1850_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I112_XG_MN0 (XI1_I1850_I112_XG_n1 I1_I1850_P16_15 I1_I1850_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I112_XG_MN1 (VSS I1_I1850_G14_13 XI1_I1850_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I110_XG_MN2 (I1_I1850_G14_11n I1_I1850_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I110_XG_MN0 (XI1_I1850_I110_XG_n1 I1_I1850_P14_13 I1_I1850_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I110_XG_MN1 (VSS I1_I1850_G12_11 XI1_I1850_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I167_XG_MN2 (I1_I1850_G16_1n I1_I1850_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I167_XG_MN0 (XI1_I1850_I167_XG_n1 I1_I1850_P16_9 I1_I1850_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I167_XG_MN1 (VSS I1_I1850_G8_1 XI1_I1850_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I111_XG_MN2 (I1_I1896_G15_12n I1_I1896_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I111_XG_MN0 (XI1_I1896_I111_XG_n1 I1_I1896_P15_14 I1_I1896_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I111_XG_MN1 (VSS I1_I1896_G13_12 XI1_I1896_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I112_XG_MN2 (I1_I1896_G16_13n I1_I1896_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I112_XG_MN0 (XI1_I1896_I112_XG_n1 I1_I1896_P16_15 I1_I1896_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I112_XG_MN1 (VSS I1_I1896_G14_13 XI1_I1896_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I115_XG_MN2 (I1_I1942_G19_16n I1_I1942_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I115_XG_MN0 (XI1_I1942_I115_XG_n1 I1_I1942_P19_18 I1_I1942_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I115_XG_MN1 (VSS I1_I1942_G17_16 XI1_I1942_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I166_XG_MN2 (I1_I1942_G15_0n I1_I1942_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I166_XG_MN0 (XI1_I1942_I166_XG_n1 I1_I1942_P15_8 I1_I1942_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I166_XG_MN1 (VSS I1_I1942_G7_0 XI1_I1942_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I116_XG_MN2 (I1_I1942_G20_17n I1_I1942_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I116_XG_MN0 (XI1_I1942_I116_XG_n1 I1_I1942_P20_19 I1_I1942_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I116_XG_MN1 (VSS I1_I1942_G18_17 XI1_I1942_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I165_XG_MN2 (I1_I1942_G14_0n I1_I1942_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I165_XG_MN0 (XI1_I1942_I165_XG_n1 I1_I1942_P14_7 I1_I1942_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I165_XG_MN1 (VSS I1_I1942_G6_0 XI1_I1942_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I115_XG_MN2 (I1_I1988_G19_16n I1_I1988_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I115_XG_MN0 (XI1_I1988_I115_XG_n1 I1_I1988_P19_18 I1_I1988_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I115_XG_MN1 (VSS I1_I1988_G17_16 XI1_I1988_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I117_XG_MN2 (I1_I1988_G21_18n I1_I1988_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I117_XG_MN0 (XI1_I1988_I117_XG_n1 I1_I1988_P21_20 I1_I1988_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I117_XG_MN1 (VSS I1_I1988_G19_18 XI1_I1988_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I178_XG_MN2 (I1_I1988_G27_12n I1_I1988_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I178_XG_MN0 (XI1_I1988_I178_XG_n1 I1_I1988_P27_20 I1_I1988_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I178_XG_MN1 (VSS I1_I1988_G19_12 XI1_I1988_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I177_XG_MN2 (I1_I1988_G26_11n I1_I1988_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I177_XG_MN0 (XI1_I1988_I177_XG_n1 I1_I1988_P26_19 I1_I1988_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I177_XG_MN1 (VSS I1_I1988_G18_11 XI1_I1988_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2066_I112_XG_MN2 (I1_I2066_G16_13n I1_I2066_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2066_I112_XG_MN0 (XI1_I2066_I112_XG_n1 I1_I2066_P16_15 I1_I2066_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2066_I112_XG_MN1 (VSS I1_I2066_G14_13 XI1_I2066_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2066_I169_XG_MN2 (I1_I2066_G18_3n I1_I2066_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2066_I169_XG_MN0 (XI1_I2066_I169_XG_n1 I1_I2066_P18_11 I1_I2066_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2066_I169_XG_MN1 (VSS I1_I2066_G10_3 XI1_I2066_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2066_I111_XG_MN2 (I1_I2066_G15_12n I1_I2066_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2066_I111_XG_MN0 (XI1_I2066_I111_XG_n1 I1_I2066_P15_14 I1_I2066_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2066_I111_XG_MN1 (VSS I1_I2066_G13_12 XI1_I2066_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2066_I109_XG_MN2 (I1_I2066_G13_10n I1_I2066_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2066_I109_XG_MN0 (XI1_I2066_I109_XG_n1 I1_I2066_P13_12 I1_I2066_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2066_I109_XG_MN1 (VSS I1_I2066_G11_10 XI1_I2066_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2194_MN2 (I1_nrkn9 I1_nrk8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2194_MN0 (XI1_I2194_n1 I1_A_31_b3_7 I1_nrkn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2194_MN1 (VSS I1_ru8 XI1_I2194_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2200_MN2 (I1_nrkn11 I1_nrk10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2200_MN0 (XI1_I2200_n1 I1_A_31_b3_7 I1_nrkn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2200_MN1 (VSS I1_ru10 XI1_I2200_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2197_MN2 (I1_nrkn10 I1_nrk9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2197_MN0 (XI1_I2197_n1 I1_A_31_b3_7 I1_nrkn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2197_MN1 (VSS I1_ru9 XI1_I2197_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I433_XG_MN2 (I0_I1660_G38_0n I0_I1660_G38_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I433_XG_MN0 (XI0_I1660_I433_XG_n1 I0_I1660_P38_7 I0_I1660_G38_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I433_XG_MN1 (VSS I0_I1660_G6_0 XI0_I1660_I433_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I440_XG_MN2 (I0_I1660_G42_0n I0_I1660_G42_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I440_XG_MN0 (XI0_I1660_I440_XG_n1 I0_I1660_P42_11 I0_I1660_G42_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I440_XG_MN1 (VSS I0_I1660_G10_0np XI0_I1660_I440_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I341_XG_MN2 (I0_I1660_G30_15n I0_I1660_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I341_XG_MN0 (XI0_I1660_I341_XG_n1 I0_I1660_P30_23 I0_I1660_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I341_XG_MN1 (VSS I0_I1660_G22_15 XI0_I1660_I341_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I455_XG_MN2 (I0_I1660_G52_0n I0_I1660_G52_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I455_XG_MN0 (XI0_I1660_I455_XG_n1 I0_I1660_P52_21 I0_I1660_G52_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I455_XG_MN1 (VSS I0_I1660_G20_0 XI0_I1660_I455_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I459_XG_MN2 (I0_I1660_G56_0n I0_I1660_G56_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I459_XG_MN0 (XI0_I1660_I459_XG_n1 I0_I1660_P56_25 I0_I1660_G56_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I459_XG_MN1 (VSS I0_I1660_G24_0 XI0_I1660_I459_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I236_XG_MN2 (I0_I1660_G44_41n I0_I1660_G44_43 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I236_XG_MN0 (XI0_I1660_I236_XG_n1 I0_I1660_P44_43 I0_I1660_G44_41n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I236_XG_MN1 (VSS I0_I1660_G42_41 XI0_I1660_I236_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I460_XG_MN2 (I0_I1660_G57_0n I0_I1660_G57_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I460_XG_MN0 (XI0_I1660_I460_XG_n1 I0_I1660_P57_26 I0_I1660_G57_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I460_XG_MN1 (VSS I0_I1660_G25_0 XI0_I1660_I460_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I368_XG_MN2 (I0_I1660_G57_42n I0_I1660_G57_50 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I368_XG_MN0 (XI0_I1660_I368_XG_n1 I0_I1660_P57_50 I0_I1660_G57_42n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I368_XG_MN1 (VSS I0_I1660_G49_42 XI0_I1660_I368_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I462_XG_MN2 (I0_I1660_G59_0n I0_I1660_G59_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I462_XG_MN0 (XI0_I1660_I462_XG_n1 I0_I1660_P59_28 I0_I1660_G59_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I462_XG_MN1 (VSS I0_I1660_G27_0 XI0_I1660_I462_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I370_XG_MN2 (I0_I1660_G59_44n I0_I1660_G59_52 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I370_XG_MN0 (XI0_I1660_I370_XG_n1 I0_I1660_P59_52 I0_I1660_G59_44n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I370_XG_MN1 (VSS I0_I1660_G51_44 XI0_I1660_I370_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI0_I1660_I239_XG_MN2 (I0_I1660_G47_44n I0_I1660_G47_46 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI0_I1660_I239_XG_MN0 (XI0_I1660_I239_XG_n1 I0_I1660_P47_46 I0_I1660_G47_44n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI0_I1660_I239_XG_MN1 (VSS I0_I1660_G45_44 XI0_I1660_I239_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I182_XG_MN2 (I1_I1850_G31_16n I1_I1850_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I182_XG_MN0 (XI1_I1850_I182_XG_n1 I1_I1850_P31_24 I1_I1850_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I182_XG_MN1 (VSS I1_I1850_G23_16 XI1_I1850_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I174_XG_MN2 (I1_I1850_G23_8n I1_I1850_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I174_XG_MN0 (XI1_I1850_I174_XG_n1 I1_I1850_P23_16 I1_I1850_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I174_XG_MN1 (VSS I1_I1850_G15_8 XI1_I1850_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I172_XG_MN2 (I1_I1850_G21_6n I1_I1850_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I172_XG_MN0 (XI1_I1850_I172_XG_n1 I1_I1850_P21_14 I1_I1850_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I172_XG_MN1 (VSS I1_I1850_G13_6 XI1_I1850_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I176_XG_MN2 (I1_I1850_G25_10n I1_I1850_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I176_XG_MN0 (XI1_I1850_I176_XG_n1 I1_I1850_P25_18 I1_I1850_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I176_XG_MN1 (VSS I1_I1850_G17_10 XI1_I1850_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I114_XG_MN2 (I1_I1850_G18_15n I1_I1850_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I114_XG_MN0 (XI1_I1850_I114_XG_n1 I1_I1850_P18_17 I1_I1850_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I114_XG_MN1 (VSS I1_I1850_G16_15 XI1_I1850_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I163_XG_MN2 (I1_I1850_G12_0n I1_I1850_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I163_XG_MN0 (XI1_I1850_I163_XG_n1 I1_I1850_P12_5 I1_I1850_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I163_XG_MN1 (VSS I1_I1850_G4_0 XI1_I1850_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1850_I160_XG_MN2 (I1_I1850_G10_0n I1_I1850_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1850_I160_XG_MN0 (XI1_I1850_I160_XG_n1 I1_I1850_P10_3 I1_I1850_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1850_I160_XG_MN1 (VSS I1_I1850_G2_0np XI1_I1850_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I113_XG_MN2 (I1_I1896_G17_14n I1_I1896_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I113_XG_MN0 (XI1_I1896_I113_XG_n1 I1_I1896_P17_16 I1_I1896_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I113_XG_MN1 (VSS I1_I1896_G15_14 XI1_I1896_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I172_XG_MN2 (I1_I1896_G21_6n I1_I1896_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I172_XG_MN0 (XI1_I1896_I172_XG_n1 I1_I1896_P21_14 I1_I1896_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I172_XG_MN1 (VSS I1_I1896_G13_6 XI1_I1896_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I164_XG_MN2 (I1_I1896_G13_0n I1_I1896_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I164_XG_MN0 (XI1_I1896_I164_XG_n1 I1_I1896_P13_6 I1_I1896_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I164_XG_MN1 (VSS I1_I1896_G5_0 XI1_I1896_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I114_XG_MN2 (I1_I1896_G18_15n I1_I1896_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I114_XG_MN0 (XI1_I1896_I114_XG_n1 I1_I1896_P18_17 I1_I1896_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I114_XG_MN1 (VSS I1_I1896_G16_15 XI1_I1896_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1896_I171_XG_MN2 (I1_I1896_G20_5n I1_I1896_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1896_I171_XG_MN0 (XI1_I1896_I171_XG_n1 I1_I1896_P20_13 I1_I1896_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1896_I171_XG_MN1 (VSS I1_I1896_G12_5 XI1_I1896_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I117_XG_MN2 (I1_I1942_G21_18n I1_I1942_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I117_XG_MN0 (XI1_I1942_I117_XG_n1 I1_I1942_P21_20 I1_I1942_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I117_XG_MN1 (VSS I1_I1942_G19_18 XI1_I1942_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I178_XG_MN2 (I1_I1942_G27_12n I1_I1942_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I178_XG_MN0 (XI1_I1942_I178_XG_n1 I1_I1942_P27_20 I1_I1942_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I178_XG_MN1 (VSS I1_I1942_G19_12 XI1_I1942_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I177_XG_MN2 (I1_I1942_G26_11n I1_I1942_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I177_XG_MN0 (XI1_I1942_I177_XG_n1 I1_I1942_P26_19 I1_I1942_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I177_XG_MN1 (VSS I1_I1942_G18_11 XI1_I1942_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1942_I173_XG_MN2 (I1_I1942_G22_7n I1_I1942_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1942_I173_XG_MN0 (XI1_I1942_I173_XG_n1 I1_I1942_P22_15 I1_I1942_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1942_I173_XG_MN1 (VSS I1_I1942_G14_7 XI1_I1942_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I166_XG_MN2 (I1_I1988_G15_0n I1_I1988_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I166_XG_MN0 (XI1_I1988_I166_XG_n1 I1_I1988_P15_8 I1_I1988_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I166_XG_MN1 (VSS I1_I1988_G7_0 XI1_I1988_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I118_XG_MN2 (I1_I1988_G22_19n I1_I1988_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I118_XG_MN0 (XI1_I1988_I118_XG_n1 I1_I1988_P22_21 I1_I1988_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I118_XG_MN1 (VSS I1_I1988_G20_19 XI1_I1988_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1988_I173_XG_MN2 (I1_I1988_G22_7n I1_I1988_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1988_I173_XG_MN0 (XI1_I1988_I173_XG_n1 I1_I1988_P22_15 I1_I1988_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1988_I173_XG_MN1 (VSS I1_I1988_G14_7 XI1_I1988_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2066_I114_XG_MN2 (I1_I2066_G18_15n I1_I2066_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2066_I114_XG_MN0 (XI1_I2066_I114_XG_n1 I1_I2066_P18_17 I1_I2066_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2066_I114_XG_MN1 (VSS I1_I2066_G16_15 XI1_I2066_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I163_XG_MN2 (I1_I2066_G12_0n I1_I2066_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I163_XG_MN0 (XI1_I2066_I163_XG_n1 I1_I2066_P12_5 I1_I2066_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I163_XG_MN1 (VSS I1_I2066_G4_0 XI1_I2066_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I113_XG_MN2 (I1_I2066_G17_14n I1_I2066_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I113_XG_MN0 (XI1_I2066_I113_XG_n1 I1_I2066_P17_16 I1_I2066_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I113_XG_MN1 (VSS I1_I2066_G15_14 XI1_I2066_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I176_XG_MN2 (I1_I2066_G25_10n I1_I2066_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I176_XG_MN0 (XI1_I2066_I176_XG_n1 I1_I2066_P25_18 I1_I2066_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I176_XG_MN1 (VSS I1_I2066_G17_10 XI1_I2066_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I162_XG_MN2 (I1_I2066_G11_0n I1_I2066_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I162_XG_MN0 (XI1_I2066_I162_XG_n1 I1_I2066_P11_4 I1_I2066_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I162_XG_MN1 (VSS I1_I2066_G3_0np XI1_I2066_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2203_MN2 (I1_nrkn12 I1_nrk11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2203_MN0 (XI1_I2203_n1 I1_A_31_b3_7 I1_nrkn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2203_MN1 (VSS I1_ru11 XI1_I2203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2209_MN2 (I1_nrkn14 I1_nrk13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2209_MN0 (XI1_I2209_n1 I1_A_31_b3_7 I1_nrkn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2209_MN1 (VSS I1_ru13 XI1_I2209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2206_MN2 (I1_nrkn13 I1_nrk12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2206_MN0 (XI1_I2206_n1 I1_A_31_b3_7 I1_nrkn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2206_MN1 (VSS I1_ru12 XI1_I2206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I349_XG_MN2 (I0_I1660_G38_23n I0_I1660_G38_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I349_XG_MN0 (XI0_I1660_I349_XG_n1 I0_I1660_P38_31 I0_I1660_G38_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I349_XG_MN1 (VSS I0_I1660_G30_23 XI0_I1660_I349_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I361_XG_MN2 (I0_I1660_G50_35n I0_I1660_G50_43 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I361_XG_MN0 (XI0_I1660_I361_XG_n1 I0_I1660_P50_43 I0_I1660_G50_35n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I361_XG_MN1 (VSS I0_I1660_G42_35 XI0_I1660_I361_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I353_XG_MN2 (I0_I1660_G42_27n I0_I1660_G42_35 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I353_XG_MN0 (XI0_I1660_I353_XG_n1 I0_I1660_P42_35 I0_I1660_G42_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I353_XG_MN1 (VSS I0_I1660_G34_27 XI0_I1660_I353_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I463_XG_MN2 (I0_I1660_G60_0n I0_I1660_G60_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I463_XG_MN0 (XI0_I1660_I463_XG_n1 I0_I1660_P60_29 I0_I1660_G60_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I463_XG_MN1 (VSS I0_I1660_G28_0 XI0_I1660_I463_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I367_XG_MN2 (I0_I1660_G56_41n I0_I1660_G56_49 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I367_XG_MN0 (XI0_I1660_I367_XG_n1 I0_I1660_P56_49 I0_I1660_G56_41n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I367_XG_MN1 (VSS I0_I1660_G48_41 XI0_I1660_I367_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I238_XG_MN2 (I0_I1660_G46_43n I0_I1660_G46_45 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I238_XG_MN0 (XI0_I1660_I238_XG_n1 I0_I1660_P46_45 I0_I1660_G46_43n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I238_XG_MN1 (VSS I0_I1660_G44_43 XI0_I1660_I238_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I464_XG_MN2 (I0_I1660_G61_0n I0_I1660_G61_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I464_XG_MN0 (XI0_I1660_I464_XG_n1 I0_I1660_P61_30 I0_I1660_G61_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I464_XG_MN1 (VSS I0_I1660_G29_0 XI0_I1660_I464_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I372_XG_MN2 (I0_I1660_G61_46n I0_I1660_G61_54 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I372_XG_MN0 (XI0_I1660_I372_XG_n1 I0_I1660_P61_54 I0_I1660_G61_46n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I372_XG_MN1 (VSS I0_I1660_G53_46 XI0_I1660_I372_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I374_XG_MN2 (I0_I1660_G63_48n I0_I1660_G63_56 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I374_XG_MN0 (XI0_I1660_I374_XG_n1 I0_I1660_P63_56 I0_I1660_G63_48n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I374_XG_MN1 (VSS I0_I1660_G55_48 XI0_I1660_I374_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I241_XG_MN2 (I0_I1660_G49_46n I0_I1660_G49_48 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I241_XG_MN0 (XI0_I1660_I241_XG_n1 I0_I1660_P49_48 I0_I1660_G49_46n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I241_XG_MN1 (VSS I0_I1660_G47_46 XI0_I1660_I241_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1850_I178_XG_MN2 (I1_I1850_G27_12n I1_I1850_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1850_I178_XG_MN0 (XI1_I1850_I178_XG_n1 I1_I1850_P27_20 I1_I1850_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1850_I178_XG_MN1 (VSS I1_I1850_G19_12 XI1_I1850_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1850_I180_XG_MN2 (I1_I1850_G29_14n I1_I1850_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1850_I180_XG_MN0 (XI1_I1850_I180_XG_n1 I1_I1850_P29_22 I1_I1850_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1850_I180_XG_MN1 (VSS I1_I1850_G21_14 XI1_I1850_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1850_I117_XG_MN2 (I1_I1850_G21_18n I1_I1850_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1850_I117_XG_MN0 (XI1_I1850_I117_XG_n1 I1_I1850_P21_20 I1_I1850_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1850_I117_XG_MN1 (VSS I1_I1850_G19_18 XI1_I1850_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1850_I171_XG_MN2 (I1_I1850_G20_5n I1_I1850_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1850_I171_XG_MN0 (XI1_I1850_I171_XG_n1 I1_I1850_P20_13 I1_I1850_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1850_I171_XG_MN1 (VSS I1_I1850_G12_5 XI1_I1850_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1850_I169_XG_MN2 (I1_I1850_G18_3n I1_I1850_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1850_I169_XG_MN0 (XI1_I1850_I169_XG_n1 I1_I1850_P18_11 I1_I1850_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1850_I169_XG_MN1 (VSS I1_I1850_G10_3 XI1_I1850_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1896_I117_XG_MN2 (I1_I1896_G21_18n I1_I1896_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1896_I117_XG_MN0 (XI1_I1896_I117_XG_n1 I1_I1896_P21_20 I1_I1896_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1896_I117_XG_MN1 (VSS I1_I1896_G19_18 XI1_I1896_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1896_I115_XG_MN2 (I1_I1896_G19_16n I1_I1896_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1896_I115_XG_MN0 (XI1_I1896_I115_XG_n1 I1_I1896_P19_18 I1_I1896_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1896_I115_XG_MN1 (VSS I1_I1896_G17_16 XI1_I1896_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1896_I178_XG_MN2 (I1_I1896_G27_12n I1_I1896_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1896_I178_XG_MN0 (XI1_I1896_I178_XG_n1 I1_I1896_P27_20 I1_I1896_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1896_I178_XG_MN1 (VSS I1_I1896_G19_12 XI1_I1896_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1896_I176_XG_MN2 (I1_I1896_G25_10n I1_I1896_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1896_I176_XG_MN0 (XI1_I1896_I176_XG_n1 I1_I1896_P25_18 I1_I1896_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1896_I176_XG_MN1 (VSS I1_I1896_G17_10 XI1_I1896_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1896_I116_XG_MN2 (I1_I1896_G20_17n I1_I1896_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1896_I116_XG_MN0 (XI1_I1896_I116_XG_n1 I1_I1896_P20_19 I1_I1896_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1896_I116_XG_MN1 (VSS I1_I1896_G18_17 XI1_I1896_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1896_I177_XG_MN2 (I1_I1896_G26_11n I1_I1896_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1896_I177_XG_MN0 (XI1_I1896_I177_XG_n1 I1_I1896_P26_19 I1_I1896_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1896_I177_XG_MN1 (VSS I1_I1896_G18_11 XI1_I1896_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1896_I175_XG_MN2 (I1_I1896_G24_9n I1_I1896_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1896_I175_XG_MN0 (XI1_I1896_I175_XG_n1 I1_I1896_P24_17 I1_I1896_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1896_I175_XG_MN1 (VSS I1_I1896_G16_9 XI1_I1896_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1942_I119_XG_MN2 (I1_I1942_G23_20n I1_I1942_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1942_I119_XG_MN0 (XI1_I1942_I119_XG_n1 I1_I1942_P23_22 I1_I1942_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1942_I119_XG_MN1 (VSS I1_I1942_G21_20 XI1_I1942_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1942_I174_XG_MN2 (I1_I1942_G23_8n I1_I1942_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1942_I174_XG_MN0 (XI1_I1942_I174_XG_n1 I1_I1942_P23_16 I1_I1942_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1942_I174_XG_MN1 (VSS I1_I1942_G15_8 XI1_I1942_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1942_I118_XG_MN2 (I1_I1942_G22_19n I1_I1942_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1942_I118_XG_MN0 (XI1_I1942_I118_XG_n1 I1_I1942_P22_21 I1_I1942_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1942_I118_XG_MN1 (VSS I1_I1942_G20_19 XI1_I1942_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1988_I119_XG_MN2 (I1_I1988_G23_20n I1_I1988_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1988_I119_XG_MN0 (XI1_I1988_I119_XG_n1 I1_I1988_P23_22 I1_I1988_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1988_I119_XG_MN1 (VSS I1_I1988_G21_20 XI1_I1988_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1988_I174_XG_MN2 (I1_I1988_G23_8n I1_I1988_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1988_I174_XG_MN0 (XI1_I1988_I174_XG_n1 I1_I1988_P23_16 I1_I1988_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1988_I174_XG_MN1 (VSS I1_I1988_G15_8 XI1_I1988_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1988_I179_XG_MN2 (I1_I1988_G28_13n I1_I1988_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1988_I179_XG_MN0 (XI1_I1988_I179_XG_n1 I1_I1988_P28_21 I1_I1988_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1988_I179_XG_MN1 (VSS I1_I1988_G20_13 XI1_I1988_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I116_XG_MN2 (I1_I2066_G20_17n I1_I2066_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I116_XG_MN0 (XI1_I2066_I116_XG_n1 I1_I2066_P20_19 I1_I2066_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I116_XG_MN1 (VSS I1_I2066_G18_17 XI1_I2066_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I179_XG_MN2 (I1_I2066_G28_13n I1_I2066_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I179_XG_MN0 (XI1_I2066_I179_XG_n1 I1_I2066_P28_21 I1_I2066_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I179_XG_MN1 (VSS I1_I2066_G20_13 XI1_I2066_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I171_XG_MN2 (I1_I2066_G20_5n I1_I2066_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I171_XG_MN0 (XI1_I2066_I171_XG_n1 I1_I2066_P20_13 I1_I2066_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I171_XG_MN1 (VSS I1_I2066_G12_5 XI1_I2066_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I115_XG_MN2 (I1_I2066_G19_16n I1_I2066_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I115_XG_MN0 (XI1_I2066_I115_XG_n1 I1_I2066_P19_18 I1_I2066_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I115_XG_MN1 (VSS I1_I2066_G17_16 XI1_I2066_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I164_XG_MN2 (I1_I2066_G13_0n I1_I2066_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I164_XG_MN0 (XI1_I2066_I164_XG_n1 I1_I2066_P13_6 I1_I2066_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I164_XG_MN1 (VSS I1_I2066_G5_0 XI1_I2066_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I170_XG_MN2 (I1_I2066_G19_4n I1_I2066_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I170_XG_MN0 (XI1_I2066_I170_XG_n1 I1_I2066_P19_12 I1_I2066_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I170_XG_MN1 (VSS I1_I2066_G11_4 XI1_I2066_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2224_MN2 (I1_nrkn19 I1_nrk18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2224_MN0 (XI1_I2224_n1 I1_A_31_b3_8 I1_nrkn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2224_MN1 (VSS I1_ru18 XI1_I2224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2221_MN2 (I1_nrkn18 I1_nrk17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2221_MN0 (XI1_I2221_n1 I1_A_31_b3_8 I1_nrkn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2221_MN1 (VSS I1_ru17 XI1_I2221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I453_XG_MN2 (I0_I1660_G50_0n I0_I1660_G50_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I453_XG_MN0 (XI0_I1660_I453_XG_n1 I0_I1660_P50_19 I0_I1660_G50_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I453_XG_MN1 (VSS I0_I1660_G18_0 XI0_I1660_I453_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I448_XG_MN2 (I0_I1660_G46_0n I0_I1660_G46_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I448_XG_MN0 (XI0_I1660_I448_XG_n1 I0_I1660_P46_15 I0_I1660_G46_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I448_XG_MN1 (VSS I0_I1660_G14_0np XI0_I1660_I448_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I357_XG_MN2 (I0_I1660_G46_31n I0_I1660_G46_39 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I357_XG_MN0 (XI0_I1660_I357_XG_n1 I0_I1660_P46_39 I0_I1660_G46_31n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I357_XG_MN1 (VSS I0_I1660_G38_31 XI0_I1660_I357_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I371_XG_MN2 (I0_I1660_G60_45n I0_I1660_G60_53 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I371_XG_MN0 (XI0_I1660_I371_XG_n1 I0_I1660_P60_53 I0_I1660_G60_45n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I371_XG_MN1 (VSS I0_I1660_G52_45 XI0_I1660_I371_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I240_XG_MN2 (I0_I1660_G48_45n I0_I1660_G48_47 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I240_XG_MN0 (XI0_I1660_I240_XG_n1 I0_I1660_P48_47 I0_I1660_G48_45n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I240_XG_MN1 (VSS I0_I1660_G46_45 XI0_I1660_I240_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I242_XG_MN2 (I0_I1660_G50_47n I0_I1660_G50_49 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I242_XG_MN0 (XI0_I1660_I242_XG_n1 I0_I1660_P50_49 I0_I1660_G50_47n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I242_XG_MN1 (VSS I0_I1660_G48_47 XI0_I1660_I242_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I243_XG_MN2 (I0_I1660_G51_48n I0_I1660_G51_50 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I243_XG_MN0 (XI0_I1660_I243_XG_n1 I0_I1660_P51_50 I0_I1660_G51_48n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I243_XG_MN1 (VSS I0_I1660_G49_48 XI0_I1660_I243_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1850_I119_XG_MN2 (I1_I1850_G23_20n I1_I1850_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1850_I119_XG_MN0 (XI1_I1850_I119_XG_n1 I1_I1850_P23_22 I1_I1850_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1850_I119_XG_MN1 (VSS I1_I1850_G21_20 XI1_I1850_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1850_I121_XG_MN2 (I1_I1850_G25_22n I1_I1850_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1850_I121_XG_MN0 (XI1_I1850_I121_XG_n1 I1_I1850_P25_24 I1_I1850_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1850_I121_XG_MN1 (VSS I1_I1850_G23_22 XI1_I1850_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1850_I116_XG_MN2 (I1_I1850_G20_17n I1_I1850_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1850_I116_XG_MN0 (XI1_I1850_I116_XG_n1 I1_I1850_P20_19 I1_I1850_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1850_I116_XG_MN1 (VSS I1_I1850_G18_17 XI1_I1850_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1850_I165_XG_MN2 (I1_I1850_G14_0n I1_I1850_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1850_I165_XG_MN0 (XI1_I1850_I165_XG_n1 I1_I1850_P14_7 I1_I1850_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1850_I165_XG_MN1 (VSS I1_I1850_G6_0 XI1_I1850_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1850_I175_XG_MN2 (I1_I1850_G24_9n I1_I1850_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1850_I175_XG_MN0 (XI1_I1850_I175_XG_n1 I1_I1850_P24_17 I1_I1850_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1850_I175_XG_MN1 (VSS I1_I1850_G16_9 XI1_I1850_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1896_I119_XG_MN2 (I1_I1896_G23_20n I1_I1896_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1896_I119_XG_MN0 (XI1_I1896_I119_XG_n1 I1_I1896_P23_22 I1_I1896_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1896_I119_XG_MN1 (VSS I1_I1896_G21_20 XI1_I1896_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1896_I166_XG_MN2 (I1_I1896_G15_0n I1_I1896_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1896_I166_XG_MN0 (XI1_I1896_I166_XG_n1 I1_I1896_P15_8 I1_I1896_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1896_I166_XG_MN1 (VSS I1_I1896_G7_0 XI1_I1896_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1896_I165_XG_MN2 (I1_I1896_G14_0n I1_I1896_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1896_I165_XG_MN0 (XI1_I1896_I165_XG_n1 I1_I1896_P14_7 I1_I1896_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1896_I165_XG_MN1 (VSS I1_I1896_G6_0 XI1_I1896_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1942_I121_XG_MN2 (I1_I1942_G25_22n I1_I1942_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1942_I121_XG_MN0 (XI1_I1942_I121_XG_n1 I1_I1942_P25_24 I1_I1942_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1942_I121_XG_MN1 (VSS I1_I1942_G23_22 XI1_I1942_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1942_I180_XG_MN2 (I1_I1942_G29_14n I1_I1942_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1942_I180_XG_MN0 (XI1_I1942_I180_XG_n1 I1_I1942_P29_22 I1_I1942_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1942_I180_XG_MN1 (VSS I1_I1942_G21_14 XI1_I1942_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1942_I120_XG_MN2 (I1_I1942_G24_21n I1_I1942_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1942_I120_XG_MN0 (XI1_I1942_I120_XG_n1 I1_I1942_P24_23 I1_I1942_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1942_I120_XG_MN1 (VSS I1_I1942_G22_21 XI1_I1942_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1942_I179_XG_MN2 (I1_I1942_G28_13n I1_I1942_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1942_I179_XG_MN0 (XI1_I1942_I179_XG_n1 I1_I1942_P28_21 I1_I1942_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1942_I179_XG_MN1 (VSS I1_I1942_G20_13 XI1_I1942_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1988_I121_XG_MN2 (I1_I1988_G25_22n I1_I1988_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1988_I121_XG_MN0 (XI1_I1988_I121_XG_n1 I1_I1988_P25_24 I1_I1988_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1988_I121_XG_MN1 (VSS I1_I1988_G23_22 XI1_I1988_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1988_I180_XG_MN2 (I1_I1988_G29_14n I1_I1988_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1988_I180_XG_MN0 (XI1_I1988_I180_XG_n1 I1_I1988_P29_22 I1_I1988_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1988_I180_XG_MN1 (VSS I1_I1988_G21_14 XI1_I1988_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1988_I120_XG_MN2 (I1_I1988_G24_21n I1_I1988_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1988_I120_XG_MN0 (XI1_I1988_I120_XG_n1 I1_I1988_P24_23 I1_I1988_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1988_I120_XG_MN1 (VSS I1_I1988_G22_21 XI1_I1988_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I177_XG_MN2 (I1_I2066_G26_11n I1_I2066_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I177_XG_MN0 (XI1_I2066_I177_XG_n1 I1_I2066_P26_19 I1_I2066_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I177_XG_MN1 (VSS I1_I2066_G18_11 XI1_I2066_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I165_XG_MN2 (I1_I2066_G14_0n I1_I2066_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I165_XG_MN0 (XI1_I2066_I165_XG_n1 I1_I2066_P14_7 I1_I2066_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I165_XG_MN1 (VSS I1_I2066_G6_0 XI1_I2066_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I117_XG_MN2 (I1_I2066_G21_18n I1_I2066_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I117_XG_MN0 (XI1_I2066_I117_XG_n1 I1_I2066_P21_20 I1_I2066_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I117_XG_MN1 (VSS I1_I2066_G19_18 XI1_I2066_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I172_XG_MN2 (I1_I2066_G21_6n I1_I2066_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I172_XG_MN0 (XI1_I2066_I172_XG_n1 I1_I2066_P21_14 I1_I2066_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I172_XG_MN1 (VSS I1_I2066_G13_6 XI1_I2066_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I166_XG_MN2 (I1_I2066_G15_0n I1_I2066_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I166_XG_MN0 (XI1_I2066_I166_XG_n1 I1_I2066_P15_8 I1_I2066_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I166_XG_MN1 (VSS I1_I2066_G7_0 XI1_I2066_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2212_MN2 (I1_nrkn15 I1_nrk14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2212_MN0 (XI1_I2212_n1 I1_A_31_b3_8 I1_nrkn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2212_MN1 (VSS I1_ru14 XI1_I2212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2227_MN2 (I1_nrkn20 I1_nrk19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2227_MN0 (XI1_I2227_n1 I1_A_31_b3_8 I1_nrkn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2227_MN1 (VSS I1_ru19 XI1_I2227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2215_MN2 (I1_nrkn16 I1_nrk15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2215_MN0 (XI1_I2215_n1 I1_A_31_b3_8 I1_nrkn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2215_MN1 (VSS I1_ru15 XI1_I2215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2218_MN2 (I1_nrkn17 I1_nrk16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2218_MN0 (XI1_I2218_n1 I1_A_31_b3_8 I1_nrkn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2218_MN1 (VSS I1_ru16 XI1_I2218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I461_XG_MN2 (I0_I1660_G58_0n I0_I1660_G58_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I461_XG_MN0 (XI0_I1660_I461_XG_n1 I0_I1660_P58_27 I0_I1660_G58_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I461_XG_MN1 (VSS I0_I1660_G26_0 XI0_I1660_I461_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I369_XG_MN2 (I0_I1660_G58_43n I0_I1660_G58_51 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I369_XG_MN0 (XI0_I1660_I369_XG_n1 I0_I1660_P58_51 I0_I1660_G58_43n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I369_XG_MN1 (VSS I0_I1660_G50_43 XI0_I1660_I369_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I244_XG_MN2 (I0_I1660_G52_49n I0_I1660_G52_51 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I244_XG_MN0 (XI0_I1660_I244_XG_n1 I0_I1660_P52_51 I0_I1660_G52_49n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I244_XG_MN1 (VSS I0_I1660_G50_49 XI0_I1660_I244_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I247_XG_MN2 (I0_I1660_G55_52n I0_I1660_G55_54 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I247_XG_MN0 (XI0_I1660_I247_XG_n1 I0_I1660_P55_54 I0_I1660_G55_52n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I247_XG_MN1 (VSS I0_I1660_G53_52 XI0_I1660_I247_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I245_XG_MN2 (I0_I1660_G53_50n I0_I1660_G53_52 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I245_XG_MN0 (XI0_I1660_I245_XG_n1 I0_I1660_P53_52 I0_I1660_G53_50n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I245_XG_MN1 (VSS I0_I1660_G51_50 XI0_I1660_I245_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1850_I127_XG_MN2 (I1_I1850_G31_28n I1_I1850_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1850_I127_XG_MN0 (XI1_I1850_I127_XG_n1 I1_I1850_P31_30 I1_I1850_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1850_I127_XG_MN1 (VSS I1_I1850_G29_28 XI1_I1850_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1850_I120_XG_MN2 (I1_I1850_G24_21n I1_I1850_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1850_I120_XG_MN0 (XI1_I1850_I120_XG_n1 I1_I1850_P24_23 I1_I1850_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1850_I120_XG_MN1 (VSS I1_I1850_G22_21 XI1_I1850_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1850_I118_XG_MN2 (I1_I1850_G22_19n I1_I1850_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1850_I118_XG_MN0 (XI1_I1850_I118_XG_n1 I1_I1850_P22_21 I1_I1850_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1850_I118_XG_MN1 (VSS I1_I1850_G20_19 XI1_I1850_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1850_I177_XG_MN2 (I1_I1850_G26_11n I1_I1850_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1850_I177_XG_MN0 (XI1_I1850_I177_XG_n1 I1_I1850_P26_19 I1_I1850_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1850_I177_XG_MN1 (VSS I1_I1850_G18_11 XI1_I1850_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1850_I173_XG_MN2 (I1_I1850_G22_7n I1_I1850_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1850_I173_XG_MN0 (XI1_I1850_I173_XG_n1 I1_I1850_P22_15 I1_I1850_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1850_I173_XG_MN1 (VSS I1_I1850_G14_7 XI1_I1850_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1896_I121_XG_MN2 (I1_I1896_G25_22n I1_I1896_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1896_I121_XG_MN0 (XI1_I1896_I121_XG_n1 I1_I1896_P25_24 I1_I1896_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1896_I121_XG_MN1 (VSS I1_I1896_G23_22 XI1_I1896_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1896_I174_XG_MN2 (I1_I1896_G23_8n I1_I1896_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1896_I174_XG_MN0 (XI1_I1896_I174_XG_n1 I1_I1896_P23_16 I1_I1896_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1896_I174_XG_MN1 (VSS I1_I1896_G15_8 XI1_I1896_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1896_I118_XG_MN2 (I1_I1896_G22_19n I1_I1896_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1896_I118_XG_MN0 (XI1_I1896_I118_XG_n1 I1_I1896_P22_21 I1_I1896_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1896_I118_XG_MN1 (VSS I1_I1896_G20_19 XI1_I1896_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1896_I120_XG_MN2 (I1_I1896_G24_21n I1_I1896_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1896_I120_XG_MN0 (XI1_I1896_I120_XG_n1 I1_I1896_P24_23 I1_I1896_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1896_I120_XG_MN1 (VSS I1_I1896_G22_21 XI1_I1896_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1896_I173_XG_MN2 (I1_I1896_G22_7n I1_I1896_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1896_I173_XG_MN0 (XI1_I1896_I173_XG_n1 I1_I1896_P22_15 I1_I1896_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1896_I173_XG_MN1 (VSS I1_I1896_G14_7 XI1_I1896_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1942_I182_XG_MN2 (I1_I1942_G31_16n I1_I1942_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1942_I182_XG_MN0 (XI1_I1942_I182_XG_n1 I1_I1942_P31_24 I1_I1942_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1942_I182_XG_MN1 (VSS I1_I1942_G23_16 XI1_I1942_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1942_I181_XG_MN2 (I1_I1942_G30_15n I1_I1942_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1942_I181_XG_MN0 (XI1_I1942_I181_XG_n1 I1_I1942_P30_23 I1_I1942_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1942_I181_XG_MN1 (VSS I1_I1942_G22_15 XI1_I1942_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1988_I182_XG_MN2 (I1_I1988_G31_16n I1_I1988_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1988_I182_XG_MN0 (XI1_I1988_I182_XG_n1 I1_I1988_P31_24 I1_I1988_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1988_I182_XG_MN1 (VSS I1_I1988_G23_16 XI1_I1988_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1988_I122_XG_MN2 (I1_I1988_G26_23n I1_I1988_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1988_I122_XG_MN0 (XI1_I1988_I122_XG_n1 I1_I1988_P26_25 I1_I1988_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1988_I122_XG_MN1 (VSS I1_I1988_G24_23 XI1_I1988_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1988_I181_XG_MN2 (I1_I1988_G30_15n I1_I1988_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1988_I181_XG_MN0 (XI1_I1988_I181_XG_n1 I1_I1988_P30_23 I1_I1988_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1988_I181_XG_MN1 (VSS I1_I1988_G22_15 XI1_I1988_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I120_XG_MN2 (I1_I2066_G24_21n I1_I2066_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I120_XG_MN0 (XI1_I2066_I120_XG_n1 I1_I2066_P24_23 I1_I2066_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I120_XG_MN1 (VSS I1_I2066_G22_21 XI1_I2066_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I118_XG_MN2 (I1_I2066_G22_19n I1_I2066_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I118_XG_MN0 (XI1_I2066_I118_XG_n1 I1_I2066_P22_21 I1_I2066_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I118_XG_MN1 (VSS I1_I2066_G20_19 XI1_I2066_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I173_XG_MN2 (I1_I2066_G22_7n I1_I2066_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I173_XG_MN0 (XI1_I2066_I173_XG_n1 I1_I2066_P22_15 I1_I2066_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I173_XG_MN1 (VSS I1_I2066_G14_7 XI1_I2066_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I119_XG_MN2 (I1_I2066_G23_20n I1_I2066_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I119_XG_MN0 (XI1_I2066_I119_XG_n1 I1_I2066_P23_22 I1_I2066_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I119_XG_MN1 (VSS I1_I2066_G21_20 XI1_I2066_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I178_XG_MN2 (I1_I2066_G27_12n I1_I2066_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I178_XG_MN0 (XI1_I2066_I178_XG_n1 I1_I2066_P27_20 I1_I2066_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I178_XG_MN1 (VSS I1_I2066_G19_12 XI1_I2066_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2233_MN2 (I1_nrkn22 I1_nrk21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2233_MN0 (XI1_I2233_n1 I1_A_31_b3_9 I1_nrkn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2233_MN1 (VSS I1_ru21 XI1_I2233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2230_MN2 (I1_nrkn21 I1_nrk20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2230_MN0 (XI1_I2230_n1 I1_A_31_b3_9 I1_nrkn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2230_MN1 (VSS I1_ru20 XI1_I2230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I457_XG_MN2 (I0_I1660_G54_0n I0_I1660_G54_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I457_XG_MN0 (XI0_I1660_I457_XG_n1 I0_I1660_P54_23 I0_I1660_G54_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I457_XG_MN1 (VSS I0_I1660_G22_0 XI0_I1660_I457_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I465_XG_MN2 (I0_I1660_G62_0n I0_I1660_G62_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I465_XG_MN0 (XI0_I1660_I465_XG_n1 I0_I1660_P62_31 I0_I1660_G62_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I465_XG_MN1 (VSS I0_I1660_G30_0 XI0_I1660_I465_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I365_XG_MN2 (I0_I1660_G54_39n I0_I1660_G54_47 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I365_XG_MN0 (XI0_I1660_I365_XG_n1 I0_I1660_P54_47 I0_I1660_G54_39n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I365_XG_MN1 (VSS I0_I1660_G46_39 XI0_I1660_I365_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I246_XG_MN2 (I0_I1660_G54_51n I0_I1660_G54_53 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I246_XG_MN0 (XI0_I1660_I246_XG_n1 I0_I1660_P54_53 I0_I1660_G54_51n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I246_XG_MN1 (VSS I0_I1660_G52_51 XI0_I1660_I246_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I251_XG_MN2 (I0_I1660_G59_56n I0_I1660_G59_58 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I251_XG_MN0 (XI0_I1660_I251_XG_n1 I0_I1660_P59_58 I0_I1660_G59_56n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I251_XG_MN1 (VSS I0_I1660_G57_56 XI0_I1660_I251_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I249_XG_MN2 (I0_I1660_G57_54n I0_I1660_G57_56 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I249_XG_MN0 (XI0_I1660_I249_XG_n1 I0_I1660_P57_56 I0_I1660_G57_54n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I249_XG_MN1 (VSS I0_I1660_G55_54 XI0_I1660_I249_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1850_I124_XG_MN2 (I1_I1850_G28_25n I1_I1850_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1850_I124_XG_MN0 (XI1_I1850_I124_XG_n1 I1_I1850_P28_27 I1_I1850_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1850_I124_XG_MN1 (VSS I1_I1850_G26_25 XI1_I1850_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1850_I122_XG_MN2 (I1_I1850_G26_23n I1_I1850_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1850_I122_XG_MN0 (XI1_I1850_I122_XG_n1 I1_I1850_P26_25 I1_I1850_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1850_I122_XG_MN1 (VSS I1_I1850_G24_23 XI1_I1850_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1850_I179_XG_MN2 (I1_I1850_G28_13n I1_I1850_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1850_I179_XG_MN0 (XI1_I1850_I179_XG_n1 I1_I1850_P28_21 I1_I1850_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1850_I179_XG_MN1 (VSS I1_I1850_G20_13 XI1_I1850_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1896_I123_XG_MN2 (I1_I1896_G27_24n I1_I1896_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1896_I123_XG_MN0 (XI1_I1896_I123_XG_n1 I1_I1896_P27_26 I1_I1896_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1896_I123_XG_MN1 (VSS I1_I1896_G25_24 XI1_I1896_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1896_I180_XG_MN2 (I1_I1896_G29_14n I1_I1896_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1896_I180_XG_MN0 (XI1_I1896_I180_XG_n1 I1_I1896_P29_22 I1_I1896_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1896_I180_XG_MN1 (VSS I1_I1896_G21_14 XI1_I1896_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1896_I179_XG_MN2 (I1_I1896_G28_13n I1_I1896_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1896_I179_XG_MN0 (XI1_I1896_I179_XG_n1 I1_I1896_P28_21 I1_I1896_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1896_I179_XG_MN1 (VSS I1_I1896_G20_13 XI1_I1896_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1942_I123_XG_MN2 (I1_I1942_G27_24n I1_I1942_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1942_I123_XG_MN0 (XI1_I1942_I123_XG_n1 I1_I1942_P27_26 I1_I1942_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1942_I123_XG_MN1 (VSS I1_I1942_G25_24 XI1_I1942_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1942_I122_XG_MN2 (I1_I1942_G26_23n I1_I1942_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1942_I122_XG_MN0 (XI1_I1942_I122_XG_n1 I1_I1942_P26_25 I1_I1942_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1942_I122_XG_MN1 (VSS I1_I1942_G24_23 XI1_I1942_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1942_I124_XG_MN2 (I1_I1942_G28_25n I1_I1942_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1942_I124_XG_MN0 (XI1_I1942_I124_XG_n1 I1_I1942_P28_27 I1_I1942_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1942_I124_XG_MN1 (VSS I1_I1942_G26_25 XI1_I1942_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1988_I123_XG_MN2 (I1_I1988_G27_24n I1_I1988_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1988_I123_XG_MN0 (XI1_I1988_I123_XG_n1 I1_I1988_P27_26 I1_I1988_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1988_I123_XG_MN1 (VSS I1_I1988_G25_24 XI1_I1988_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1988_I124_XG_MN2 (I1_I1988_G28_25n I1_I1988_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1988_I124_XG_MN0 (XI1_I1988_I124_XG_n1 I1_I1988_P28_27 I1_I1988_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1988_I124_XG_MN1 (VSS I1_I1988_G26_25 XI1_I1988_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I122_XG_MN2 (I1_I2066_G26_23n I1_I2066_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I122_XG_MN0 (XI1_I2066_I122_XG_n1 I1_I2066_P26_25 I1_I2066_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I122_XG_MN1 (VSS I1_I2066_G24_23 XI1_I2066_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I181_XG_MN2 (I1_I2066_G30_15n I1_I2066_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I181_XG_MN0 (XI1_I2066_I181_XG_n1 I1_I2066_P30_23 I1_I2066_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I181_XG_MN1 (VSS I1_I2066_G22_15 XI1_I2066_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I121_XG_MN2 (I1_I2066_G25_22n I1_I2066_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I121_XG_MN0 (XI1_I2066_I121_XG_n1 I1_I2066_P25_24 I1_I2066_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I121_XG_MN1 (VSS I1_I2066_G23_22 XI1_I2066_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I180_XG_MN2 (I1_I2066_G29_14n I1_I2066_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I180_XG_MN0 (XI1_I2066_I180_XG_n1 I1_I2066_P29_22 I1_I2066_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I180_XG_MN1 (VSS I1_I2066_G21_14 XI1_I2066_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I174_XG_MN2 (I1_I2066_G23_8n I1_I2066_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I174_XG_MN0 (XI1_I2066_I174_XG_n1 I1_I2066_P23_16 I1_I2066_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I174_XG_MN1 (VSS I1_I2066_G15_8 XI1_I2066_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2236_MN2 (I1_nrkn23 I1_nrk22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2236_MN0 (XI1_I2236_n1 I1_A_31_b3_9 I1_nrkn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2236_MN1 (VSS I1_ru22 XI1_I2236_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2239_MN2 (I1_nrkn24 I1_nrk23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2239_MN0 (XI1_I2239_n1 I1_A_31_b3_9 I1_nrkn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2239_MN1 (VSS I1_ru23 XI1_I2239_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2242_MN2 (I1_nrkn25 I1_nrk24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2242_MN0 (XI1_I2242_n1 I1_A_31_b3_9 I1_nrkn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2242_MN1 (VSS I1_ru24 XI1_I2242_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2245_MN2 (I1_nrkn26 I1_nrk25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2245_MN0 (XI1_I2245_n1 I1_A_31_b3_9 I1_nrkn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2245_MN1 (VSS I1_ru25 XI1_I2245_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I373_XG_MN2 (I0_I1660_G62_47n I0_I1660_G62_55 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I373_XG_MN0 (XI0_I1660_I373_XG_n1 I0_I1660_P62_55 I0_I1660_G62_47n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I373_XG_MN1 (VSS I0_I1660_G54_47 XI0_I1660_I373_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I250_XG_MN2 (I0_I1660_G58_55n I0_I1660_G58_57 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I250_XG_MN0 (XI0_I1660_I250_XG_n1 I0_I1660_P58_57 I0_I1660_G58_55n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I250_XG_MN1 (VSS I0_I1660_G56_55 XI0_I1660_I250_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I248_XG_MN2 (I0_I1660_G56_53n I0_I1660_G56_55 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I248_XG_MN0 (XI0_I1660_I248_XG_n1 I0_I1660_P56_55 I0_I1660_G56_53n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I248_XG_MN1 (VSS I0_I1660_G54_53 XI0_I1660_I248_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I253_XG_MN2 (I0_I1660_G61_58n I0_I1660_G61_60 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I253_XG_MN0 (XI0_I1660_I253_XG_n1 I0_I1660_P61_60 I0_I1660_G61_58n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I253_XG_MN1 (VSS I0_I1660_G59_58 XI0_I1660_I253_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1850_I126_XG_MN2 (I1_I1850_G30_27n I1_I1850_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1850_I126_XG_MN0 (XI1_I1850_I126_XG_n1 I1_I1850_P30_29 I1_I1850_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1850_I126_XG_MN1 (VSS I1_I1850_G28_27 XI1_I1850_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1850_I181_XG_MN2 (I1_I1850_G30_15n I1_I1850_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1850_I181_XG_MN0 (XI1_I1850_I181_XG_n1 I1_I1850_P30_23 I1_I1850_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1850_I181_XG_MN1 (VSS I1_I1850_G22_15 XI1_I1850_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1896_I125_XG_MN2 (I1_I1896_G29_26n I1_I1896_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1896_I125_XG_MN0 (XI1_I1896_I125_XG_n1 I1_I1896_P29_28 I1_I1896_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1896_I125_XG_MN1 (VSS I1_I1896_G27_26 XI1_I1896_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1896_I182_XG_MN2 (I1_I1896_G31_16n I1_I1896_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1896_I182_XG_MN0 (XI1_I1896_I182_XG_n1 I1_I1896_P31_24 I1_I1896_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1896_I182_XG_MN1 (VSS I1_I1896_G23_16 XI1_I1896_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1896_I124_XG_MN2 (I1_I1896_G28_25n I1_I1896_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1896_I124_XG_MN0 (XI1_I1896_I124_XG_n1 I1_I1896_P28_27 I1_I1896_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1896_I124_XG_MN1 (VSS I1_I1896_G26_25 XI1_I1896_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1896_I122_XG_MN2 (I1_I1896_G26_23n I1_I1896_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1896_I122_XG_MN0 (XI1_I1896_I122_XG_n1 I1_I1896_P26_25 I1_I1896_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1896_I122_XG_MN1 (VSS I1_I1896_G24_23 XI1_I1896_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1896_I181_XG_MN2 (I1_I1896_G30_15n I1_I1896_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1896_I181_XG_MN0 (XI1_I1896_I181_XG_n1 I1_I1896_P30_23 I1_I1896_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1896_I181_XG_MN1 (VSS I1_I1896_G22_15 XI1_I1896_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1942_I125_XG_MN2 (I1_I1942_G29_26n I1_I1942_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1942_I125_XG_MN0 (XI1_I1942_I125_XG_n1 I1_I1942_P29_28 I1_I1942_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1942_I125_XG_MN1 (VSS I1_I1942_G27_26 XI1_I1942_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1942_I127_XG_MN2 (I1_I1942_G31_28n I1_I1942_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1942_I127_XG_MN0 (XI1_I1942_I127_XG_n1 I1_I1942_P31_30 I1_I1942_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1942_I127_XG_MN1 (VSS I1_I1942_G29_28 XI1_I1942_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1942_I126_XG_MN2 (I1_I1942_G30_27n I1_I1942_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1942_I126_XG_MN0 (XI1_I1942_I126_XG_n1 I1_I1942_P30_29 I1_I1942_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1942_I126_XG_MN1 (VSS I1_I1942_G28_27 XI1_I1942_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1988_I125_XG_MN2 (I1_I1988_G29_26n I1_I1988_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1988_I125_XG_MN0 (XI1_I1988_I125_XG_n1 I1_I1988_P29_28 I1_I1988_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1988_I125_XG_MN1 (VSS I1_I1988_G27_26 XI1_I1988_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1988_I127_XG_MN2 (I1_I1988_G31_28n I1_I1988_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1988_I127_XG_MN0 (XI1_I1988_I127_XG_n1 I1_I1988_P31_30 I1_I1988_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1988_I127_XG_MN1 (VSS I1_I1988_G29_28 XI1_I1988_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1988_I126_XG_MN2 (I1_I1988_G30_27n I1_I1988_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1988_I126_XG_MN0 (XI1_I1988_I126_XG_n1 I1_I1988_P30_29 I1_I1988_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1988_I126_XG_MN1 (VSS I1_I1988_G28_27 XI1_I1988_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I124_XG_MN2 (I1_I2066_G28_25n I1_I2066_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I124_XG_MN0 (XI1_I2066_I124_XG_n1 I1_I2066_P28_27 I1_I2066_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I124_XG_MN1 (VSS I1_I2066_G26_25 XI1_I2066_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I125_XG_MN2 (I1_I2066_G29_26n I1_I2066_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I125_XG_MN0 (XI1_I2066_I125_XG_n1 I1_I2066_P29_28 I1_I2066_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I125_XG_MN1 (VSS I1_I2066_G27_26 XI1_I2066_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I123_XG_MN2 (I1_I2066_G27_24n I1_I2066_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I123_XG_MN0 (XI1_I2066_I123_XG_n1 I1_I2066_P27_26 I1_I2066_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I123_XG_MN1 (VSS I1_I2066_G25_24 XI1_I2066_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I182_XG_MN2 (I1_I2066_G31_16n I1_I2066_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I182_XG_MN0 (XI1_I2066_I182_XG_n1 I1_I2066_P31_24 I1_I2066_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I182_XG_MN1 (VSS I1_I2066_G23_16 XI1_I2066_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2248_MN2 (I1_nrkn27 I1_nrk26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2248_MN0 (XI1_I2248_n1 I1_A_31_b3_10 I1_nrkn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2248_MN1 (VSS I1_ru26 XI1_I2248_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I254_XG_MN2 (I0_I1660_G62_59n I0_I1660_G62_61 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I254_XG_MN0 (XI0_I1660_I254_XG_n1 I0_I1660_P62_61 I0_I1660_G62_59n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I254_XG_MN1 (VSS I0_I1660_G60_59 XI0_I1660_I254_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I252_XG_MN2 (I0_I1660_G60_57n I0_I1660_G60_59 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I252_XG_MN0 (XI0_I1660_I252_XG_n1 I0_I1660_P60_59 I0_I1660_G60_57n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I252_XG_MN1 (VSS I0_I1660_G58_57 XI0_I1660_I252_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1660_I255_XG_MN2 (I0_I1660_G63_60n I0_I1660_G63_62 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI0_I1660_I255_XG_MN0 (XI0_I1660_I255_XG_n1 I0_I1660_P63_62 I0_I1660_G63_60n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1660_I255_XG_MN1 (VSS I0_I1660_G61_60 XI0_I1660_I255_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1896_I127_XG_MN2 (I1_I1896_G31_28n I1_I1896_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1896_I127_XG_MN0 (XI1_I1896_I127_XG_n1 I1_I1896_P31_30 I1_I1896_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1896_I127_XG_MN1 (VSS I1_I1896_G29_28 XI1_I1896_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I1896_I126_XG_MN2 (I1_I1896_G30_27n I1_I1896_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I1896_I126_XG_MN0 (XI1_I1896_I126_XG_n1 I1_I1896_P30_29 I1_I1896_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I1896_I126_XG_MN1 (VSS I1_I1896_G28_27 XI1_I1896_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I126_XG_MN2 (I1_I2066_G30_27n I1_I2066_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I126_XG_MN0 (XI1_I2066_I126_XG_n1 I1_I2066_P30_29 I1_I2066_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I126_XG_MN1 (VSS I1_I2066_G28_27 XI1_I2066_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2066_I127_XG_MN2 (I1_I2066_G31_28n I1_I2066_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2066_I127_XG_MN0 (XI1_I2066_I127_XG_n1 I1_I2066_P31_30 I1_I2066_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2066_I127_XG_MN1 (VSS I1_I2066_G29_28 XI1_I2066_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2260_MN2 (I1_nrkn31 I1_nrk30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2260_MN0 (XI1_I2260_n1 I1_A_31_b3_10 I1_nrkn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2260_MN1 (VSS I1_ru30 XI1_I2260_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2257_MN2 (I1_nrkn30 I1_nrk29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2257_MN0 (XI1_I2257_n1 I1_A_31_b3_10 I1_nrkn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2257_MN1 (VSS I1_ru29 XI1_I2257_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2254_MN2 (I1_nrkn29 I1_nrk28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2254_MN0 (XI1_I2254_n1 I1_A_31_b3_10 I1_nrkn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2254_MN1 (VSS I1_ru28 XI1_I2254_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI1_I2251_MN2 (I1_nrkn28 I1_nrk27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.68u ps=1.16u
    I_MXI1_I2251_MN0 (XI1_I2251_n1 I1_A_31_b3_10 I1_nrkn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.68u ps=0.68u
    I_MXI1_I2251_MN1 (VSS I1_ru27 XI1_I2251_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.16u ps=0.68u
    I_MXI0_I1501_MN12 (XI0_I1501_sn I0_fa9_0 XI0_I1501_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1501_MN25 (I0_fa140_0 XI0_I1501_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1501_MN5 (XI0_I1501_con I0_fa9_0 XI0_I1501_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1501_MN2 (XI0_I1501_n1 I0_cm8_0 XI0_I1501_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1501_MN1 (VSS I0_cm7_1 XI0_I1501_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1501_MN3 (XI0_I1501_n2 I0_cm7_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1501_MN4 (VSS I0_cm8_0 XI0_I1501_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1501_MN27 (I0_fa140_1 XI0_I1501_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1501_MN10 (XI0_I1501_n4 I0_cm7_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1501_MN11 (XI0_I1501_n5 I0_cm8_0 XI0_I1501_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1501_MN11_1 (XI0_I1501_n4 I0_cm8_0 XI0_I1501_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1501_MN10_1 (VSS I0_cm7_1 XI0_I1501_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1501_MN6 (XI0_I1501_n3 I0_cm7_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1501_MN7 (VSS I0_cm8_0 XI0_I1501_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1501_MN8 (XI0_I1501_n3 I0_fa9_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1501_MN9 (XI0_I1501_sn XI0_I1501_con XI0_I1501_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1501_MN12_1 (XI0_I1501_n5 I0_fa9_0 XI0_I1501_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1370_MN12 (XI0_I1370_sn I0_B_11_b3_5 XI0_I1370_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1370_MN25 (I0_fa9_0 XI0_I1370_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1370_MN5 (XI0_I1370_con I0_B_11_b3_5 XI0_I1370_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1370_MN2 (XI0_I1370_n1 I0_pp5_0 XI0_I1370_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1370_MN1 (VSS I0_pp4_2 XI0_I1370_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1370_MN3 (XI0_I1370_n2 I0_pp4_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1370_MN4 (VSS I0_pp5_0 XI0_I1370_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1370_MN27 (I0_fa9_1 XI0_I1370_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1370_MN10 (XI0_I1370_n4 I0_pp4_2 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1370_MN11 (XI0_I1370_n5 I0_pp5_0 XI0_I1370_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1370_MN11_1 (XI0_I1370_n4 I0_pp5_0 XI0_I1370_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1370_MN10_1 (VSS I0_pp4_2 XI0_I1370_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1370_MN6 (XI0_I1370_n3 I0_pp4_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1370_MN7 (VSS I0_pp5_0 XI0_I1370_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1370_MN8 (XI0_I1370_n3 I0_B_11_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1370_MN9 (XI0_I1370_sn XI0_I1370_con XI0_I1370_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1370_MN12_1 (XI0_I1370_n5 I0_B_11_b3_5 XI0_I1370_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1521_MN12 (XI0_I1521_sn I0_fa49_0 XI0_I1521_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1521_MN25 (I0_fa160_0 XI0_I1521_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1521_MN5 (XI0_I1521_con I0_fa49_0 XI0_I1521_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1521_MN2 (XI0_I1521_n1 I0_cm48_0 XI0_I1521_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1521_MN1 (VSS I0_cm47_0 XI0_I1521_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1521_MN3 (XI0_I1521_n2 I0_cm47_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1521_MN4 (VSS I0_cm48_0 XI0_I1521_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1521_MN27 (I0_fa160_1 XI0_I1521_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1521_MN10 (XI0_I1521_n4 I0_cm47_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1521_MN11 (XI0_I1521_n5 I0_cm48_0 XI0_I1521_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1521_MN11_1 (XI0_I1521_n4 I0_cm48_0 XI0_I1521_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1521_MN10_1 (VSS I0_cm47_0 XI0_I1521_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1521_MN6 (XI0_I1521_n3 I0_cm47_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1521_MN7 (VSS I0_cm48_0 XI0_I1521_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1521_MN8 (XI0_I1521_n3 I0_fa49_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1521_MN9 (XI0_I1521_sn XI0_I1521_con XI0_I1521_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1521_MN12_1 (XI0_I1521_n5 I0_fa49_0 XI0_I1521_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1499_MN12 (XI0_I1499_sn I0_pp4_0 XI0_I1499_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1499_MN25 (I0_fa138_0 XI0_I1499_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1499_MN5 (XI0_I1499_con I0_pp4_0 XI0_I1499_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1499_MN2 (XI0_I1499_n1 I0_cm6_0 XI0_I1499_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1499_MN1 (VSS I0_cm5_1 XI0_I1499_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1499_MN3 (XI0_I1499_n2 I0_cm5_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1499_MN4 (VSS I0_cm6_0 XI0_I1499_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1499_MN27 (I0_fa138_1 XI0_I1499_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1499_MN10 (XI0_I1499_n4 I0_cm5_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1499_MN11 (XI0_I1499_n5 I0_cm6_0 XI0_I1499_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1499_MN11_1 (XI0_I1499_n4 I0_cm6_0 XI0_I1499_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1499_MN10_1 (VSS I0_cm5_1 XI0_I1499_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1499_MN6 (XI0_I1499_n3 I0_cm5_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1499_MN7 (VSS I0_cm6_0 XI0_I1499_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1499_MN8 (XI0_I1499_n3 I0_pp4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1499_MN9 (XI0_I1499_sn XI0_I1499_con XI0_I1499_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1499_MN12_1 (XI0_I1499_n5 I0_pp4_0 XI0_I1499_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1373_MN12 (XI0_I1373_sn I0_pp6_0 XI0_I1373_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1373_MN25 (I0_fa12_0 XI0_I1373_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1373_MN5 (XI0_I1373_con I0_pp6_0 XI0_I1373_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1373_MN2 (XI0_I1373_n1 I0_pp5_2 XI0_I1373_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1373_MN1 (VSS I0_pp4_4 XI0_I1373_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1373_MN3 (XI0_I1373_n2 I0_pp4_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1373_MN4 (VSS I0_pp5_2 XI0_I1373_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1373_MN27 (I0_fa12_1 XI0_I1373_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1373_MN10 (XI0_I1373_n4 I0_pp4_4 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1373_MN11 (XI0_I1373_n5 I0_pp5_2 XI0_I1373_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1373_MN11_1 (XI0_I1373_n4 I0_pp5_2 XI0_I1373_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1373_MN10_1 (VSS I0_pp4_4 XI0_I1373_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1373_MN6 (XI0_I1373_n3 I0_pp4_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1373_MN7 (VSS I0_pp5_2 XI0_I1373_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1373_MN8 (XI0_I1373_n3 I0_pp6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1373_MN9 (XI0_I1373_sn XI0_I1373_con XI0_I1373_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1373_MN12_1 (XI0_I1373_n5 I0_pp6_0 XI0_I1373_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1375_MN12 (XI0_I1375_sn I0_pp6_1 XI0_I1375_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1375_MN25 (I0_fa14_0 XI0_I1375_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1375_MN5 (XI0_I1375_con I0_pp6_1 XI0_I1375_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1375_MN2 (XI0_I1375_n1 I0_pp5_3 XI0_I1375_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1375_MN1 (VSS I0_pp4_5 XI0_I1375_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1375_MN3 (XI0_I1375_n2 I0_pp4_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1375_MN4 (VSS I0_pp5_3 XI0_I1375_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1375_MN27 (I0_fa14_1 XI0_I1375_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1375_MN10 (XI0_I1375_n4 I0_pp4_5 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1375_MN11 (XI0_I1375_n5 I0_pp5_3 XI0_I1375_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1375_MN11_1 (XI0_I1375_n4 I0_pp5_3 XI0_I1375_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1375_MN10_1 (VSS I0_pp4_5 XI0_I1375_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1375_MN6 (XI0_I1375_n3 I0_pp4_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1375_MN7 (VSS I0_pp5_3 XI0_I1375_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1375_MN8 (XI0_I1375_n3 I0_pp6_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1375_MN9 (XI0_I1375_sn XI0_I1375_con XI0_I1375_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1375_MN12_1 (XI0_I1375_n5 I0_pp6_1 XI0_I1375_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1519_MN12 (XI0_I1519_sn I0_pp12_1 XI0_I1519_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1519_MN25 (I0_fa158_0 XI0_I1519_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1519_MN5 (XI0_I1519_con I0_pp12_1 XI0_I1519_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1519_MN2 (XI0_I1519_n1 I0_cm45_0 XI0_I1519_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1519_MN1 (VSS I0_cm44_0 XI0_I1519_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1519_MN3 (XI0_I1519_n2 I0_cm44_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1519_MN4 (VSS I0_cm45_0 XI0_I1519_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1519_MN27 (I0_fa158_1 XI0_I1519_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1519_MN10 (XI0_I1519_n4 I0_cm44_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1519_MN11 (XI0_I1519_n5 I0_cm45_0 XI0_I1519_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1519_MN11_1 (XI0_I1519_n4 I0_cm45_0 XI0_I1519_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1519_MN10_1 (VSS I0_cm44_0 XI0_I1519_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1519_MN6 (XI0_I1519_n3 I0_cm44_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1519_MN7 (VSS I0_cm45_0 XI0_I1519_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1519_MN8 (XI0_I1519_n3 I0_pp12_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1519_MN9 (XI0_I1519_sn XI0_I1519_con XI0_I1519_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1519_MN12_1 (XI0_I1519_n5 I0_pp12_1 XI0_I1519_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1363_MN12 (XI0_I1363_sn I0_pp2_0 XI0_I1363_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1363_MN25 (I0_fa2_0 XI0_I1363_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1363_MN5 (XI0_I1363_con I0_pp2_0 XI0_I1363_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1363_MN2 (XI0_I1363_n1 I0_pp1_2 XI0_I1363_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1363_MN1 (VSS I0_pp0_4 XI0_I1363_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1363_MN3 (XI0_I1363_n2 I0_pp0_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1363_MN4 (VSS I0_pp1_2 XI0_I1363_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1363_MN27 (I0_fa2_1 XI0_I1363_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1363_MN10 (XI0_I1363_n4 I0_pp0_4 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1363_MN11 (XI0_I1363_n5 I0_pp1_2 XI0_I1363_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1363_MN11_1 (XI0_I1363_n4 I0_pp1_2 XI0_I1363_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1363_MN10_1 (VSS I0_pp0_4 XI0_I1363_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1363_MN6 (XI0_I1363_n3 I0_pp0_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1363_MN7 (VSS I0_pp1_2 XI0_I1363_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1363_MN8 (XI0_I1363_n3 I0_pp2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1363_MN9 (XI0_I1363_sn XI0_I1363_con XI0_I1363_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1363_MN12_1 (XI0_I1363_n5 I0_pp2_0 XI0_I1363_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1517_MN12 (XI0_I1517_sn I0_pp12_0 XI0_I1517_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1517_MN25 (I0_fa156_0 XI0_I1517_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1517_MN5 (XI0_I1517_con I0_pp12_0 XI0_I1517_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1517_MN2 (XI0_I1517_n1 I0_cm42_0 XI0_I1517_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1517_MN1 (VSS I0_cm41_0 XI0_I1517_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1517_MN3 (XI0_I1517_n2 I0_cm41_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1517_MN4 (VSS I0_cm42_0 XI0_I1517_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1517_MN27 (I0_fa156_1 XI0_I1517_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1517_MN10 (XI0_I1517_n4 I0_cm41_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1517_MN11 (XI0_I1517_n5 I0_cm42_0 XI0_I1517_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1517_MN11_1 (XI0_I1517_n4 I0_cm42_0 XI0_I1517_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
