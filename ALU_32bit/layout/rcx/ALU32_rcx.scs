    I_MXI1_I2066_I33_MN4 (I1_I2066_pn1 XI1_I2066_I33_An XI1_I2066_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I33_MN2 (XI1_I2066_I33_n1 I1_p31_1 I1_I2066_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I33_MN3 (VSS XI1_I2066_I33_Bn XI1_I2066_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I33_MN0 (XI1_I2066_I33_An I1_p31_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I66_MN1 (XI0_I1660_I66_Bn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I66_MN5 (XI0_I1660_I66_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I66_MN4 (I0_I1660_pn2 XI0_I1660_I66_An XI0_I1660_I66_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I66_MN2 (XI0_I1660_I66_n1 I0_fa1_0 I0_I1660_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I66_MN3 (VSS XI0_I1660_I66_Bn XI0_I1660_I66_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I66_MN0 (XI0_I1660_I66_An I0_fa1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I485_MN1 (XI0_I1660_I485_Bn I0_I1660_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I485_MN5 (XI0_I1660_I485_n2 I0_I1660_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I485_MN4 (MULP_18 XI0_I1660_I485_An XI0_I1660_I485_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I485_MN2 (XI0_I1660_I485_n1 I0_I1660_pn18 MULP_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I485_MN3 (VSS XI0_I1660_I485_Bn XI0_I1660_I485_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I485_MN0 (XI0_I1660_I485_An I0_I1660_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I488_MN1 (XI0_I1660_I488_Bn I0_I1660_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I488_MN5 (XI0_I1660_I488_n2 I0_I1660_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I488_MN4 (MULP_21 XI0_I1660_I488_An XI0_I1660_I488_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I488_MN2 (XI0_I1660_I488_n1 I0_I1660_pn21 MULP_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I488_MN3 (VSS XI0_I1660_I488_Bn XI0_I1660_I488_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I488_MN0 (XI0_I1660_I488_An I0_I1660_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I489_MN1 (XI0_I1660_I489_Bn I0_I1660_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I489_MN5 (XI0_I1660_I489_n2 I0_I1660_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I489_MN4 (MULP_22 XI0_I1660_I489_An XI0_I1660_I489_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I489_MN2 (XI0_I1660_I489_n1 I0_I1660_pn22 MULP_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I489_MN3 (VSS XI0_I1660_I489_Bn XI0_I1660_I489_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I489_MN0 (XI0_I1660_I489_An I0_I1660_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I492_MN1 (XI0_I1660_I492_Bn I0_I1660_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I492_MN5 (XI0_I1660_I492_n2 I0_I1660_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I492_MN4 (MULP_25 XI0_I1660_I492_An XI0_I1660_I492_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I492_MN2 (XI0_I1660_I492_n1 I0_I1660_pn25 MULP_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I492_MN3 (VSS XI0_I1660_I492_Bn XI0_I1660_I492_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I492_MN0 (XI0_I1660_I492_An I0_I1660_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I493_MN1 (XI0_I1660_I493_Bn I0_I1660_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I493_MN5 (XI0_I1660_I493_n2 I0_I1660_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I493_MN4 (MULP_26 XI0_I1660_I493_An XI0_I1660_I493_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I493_MN2 (XI0_I1660_I493_n1 I0_I1660_pn26 MULP_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I493_MN3 (VSS XI0_I1660_I493_Bn XI0_I1660_I493_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I493_MN0 (XI0_I1660_I493_An I0_I1660_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I494_MN1 (XI0_I1660_I494_Bn I0_I1660_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I494_MN5 (XI0_I1660_I494_n2 I0_I1660_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I494_MN4 (MULP_27 XI0_I1660_I494_An XI0_I1660_I494_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I494_MN2 (XI0_I1660_I494_n1 I0_I1660_pn27 MULP_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I494_MN3 (VSS XI0_I1660_I494_Bn XI0_I1660_I494_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I494_MN0 (XI0_I1660_I494_An I0_I1660_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I496_MN1 (XI0_I1660_I496_Bn I0_I1660_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I496_MN5 (XI0_I1660_I496_n2 I0_I1660_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I496_MN4 (MULP_29 XI0_I1660_I496_An XI0_I1660_I496_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I496_MN2 (XI0_I1660_I496_n1 I0_I1660_pn29 MULP_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I496_MN3 (VSS XI0_I1660_I496_Bn XI0_I1660_I496_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I496_MN0 (XI0_I1660_I496_An I0_I1660_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I495_MN1 (XI0_I1660_I495_Bn I0_I1660_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I495_MN5 (XI0_I1660_I495_n2 I0_I1660_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I495_MN4 (MULP_28 XI0_I1660_I495_An XI0_I1660_I495_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I495_MN2 (XI0_I1660_I495_n1 I0_I1660_pn28 MULP_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I495_MN3 (VSS XI0_I1660_I495_Bn XI0_I1660_I495_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I495_MN0 (XI0_I1660_I495_An I0_I1660_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I92_MN1 (XI0_I1660_I92_Bn I0_ha272_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I92_MN5 (XI0_I1660_I92_n2 I0_ha272_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I92_MN4 (I0_I1660_pn28 XI0_I1660_I92_An XI0_I1660_I92_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I92_MN2 (XI0_I1660_I92_n1 I0_ha271_1 I0_I1660_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I92_MN3 (VSS XI0_I1660_I92_Bn XI0_I1660_I92_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I92_MN0 (XI0_I1660_I92_An I0_ha271_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I93_MN1 (XI0_I1660_I93_Bn I0_ha273_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I93_MN5 (XI0_I1660_I93_n2 I0_ha273_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I93_MN4 (I0_I1660_pn29 XI0_I1660_I93_An XI0_I1660_I93_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I93_MN2 (XI0_I1660_I93_n1 I0_ha272_1 I0_I1660_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I93_MN3 (VSS XI0_I1660_I93_Bn XI0_I1660_I93_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I93_MN0 (XI0_I1660_I93_An I0_ha272_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I234_MN1 (XI1_I1804_I234_Bn I1_c27_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I234_MN5 (XI1_I1804_I234_n2 I1_c27_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I234_MN4 (I1_p27_31 XI1_I1804_I234_An XI1_I1804_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I234_MN2 (XI1_I1804_I234_n1 I1_I1804_pn31 I1_p27_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I234_MN3 (VSS XI1_I1804_I234_Bn XI1_I1804_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I234_MN0 (XI1_I1804_I234_An I1_I1804_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I230_MN1 (XI1_I1804_I230_Bn I1_I1804_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I230_MN5 (XI1_I1804_I230_n2 I1_I1804_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I230_MN4 (I1_p27_27 XI1_I1804_I230_An XI1_I1804_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I230_MN2 (XI1_I1804_I230_n1 I1_I1804_pn27 I1_p27_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I230_MN3 (VSS XI1_I1804_I230_Bn XI1_I1804_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I230_MN0 (XI1_I1804_I230_An I1_I1804_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I226_MN1 (XI1_I1804_I226_Bn I1_I1804_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I226_MN5 (XI1_I1804_I226_n2 I1_I1804_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I226_MN4 (I1_p27_23 XI1_I1804_I226_An XI1_I1804_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I226_MN2 (XI1_I1804_I226_n1 I1_I1804_pn23 I1_p27_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I226_MN3 (VSS XI1_I1804_I226_Bn XI1_I1804_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I226_MN0 (XI1_I1804_I226_An I1_I1804_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I224_MN1 (XI1_I1804_I224_Bn I1_I1804_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I224_MN5 (XI1_I1804_I224_n2 I1_I1804_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I224_MN4 (I1_p27_21 XI1_I1804_I224_An XI1_I1804_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I224_MN2 (XI1_I1804_I224_n1 I1_I1804_pn21 I1_p27_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I224_MN3 (VSS XI1_I1804_I224_Bn XI1_I1804_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I224_MN0 (XI1_I1804_I224_An I1_I1804_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I222_MN1 (XI1_I1804_I222_Bn I1_I1804_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I222_MN5 (XI1_I1804_I222_n2 I1_I1804_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I222_MN4 (I1_p27_19 XI1_I1804_I222_An XI1_I1804_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I222_MN2 (XI1_I1804_I222_n1 I1_I1804_pn19 I1_p27_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I222_MN3 (VSS XI1_I1804_I222_Bn XI1_I1804_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I222_MN0 (XI1_I1804_I222_An I1_I1804_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I228_MN1 (XI1_I1804_I228_Bn I1_I1804_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I228_MN5 (XI1_I1804_I228_n2 I1_I1804_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I228_MN4 (I1_p27_25 XI1_I1804_I228_An XI1_I1804_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I228_MN2 (XI1_I1804_I228_n1 I1_I1804_pn25 I1_p27_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I228_MN3 (VSS XI1_I1804_I228_Bn XI1_I1804_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I228_MN0 (XI1_I1804_I228_An I1_I1804_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I209_MN1 (XI1_I1804_I209_Bn I1_I1804_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I209_MN5 (XI1_I1804_I209_n2 I1_I1804_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I209_MN4 (I1_p27_6 XI1_I1804_I209_An XI1_I1804_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I209_MN2 (XI1_I1804_I209_n1 I1_I1804_pn6 I1_p27_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I209_MN3 (VSS XI1_I1804_I209_Bn XI1_I1804_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I209_MN0 (XI1_I1804_I209_An I1_I1804_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I37_MN1 (XI1_I1850_I37_Bn I1_b28_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I37_MN5 (XI1_I1850_I37_n2 I1_b28_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I37_MN4 (I1_I1850_pn5 XI1_I1850_I37_An XI1_I1850_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I37_MN2 (XI1_I1850_I37_n1 I1_p27_4 I1_I1850_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I37_MN3 (VSS XI1_I1850_I37_Bn XI1_I1850_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I37_MN0 (XI1_I1850_I37_An I1_p27_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I38_MN1 (XI1_I1896_I38_Bn I1_b29_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I38_MN5 (XI1_I1896_I38_n2 I1_b29_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I38_MN4 (I1_I1896_pn6 XI1_I1896_I38_An XI1_I1896_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I38_MN2 (XI1_I1896_I38_n1 I1_p28_5 I1_I1896_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I38_MN3 (VSS XI1_I1896_I38_Bn XI1_I1896_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I38_MN0 (XI1_I1896_I38_An I1_p28_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I37_MN1 (XI1_I1896_I37_Bn I1_b29_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I37_MN5 (XI1_I1896_I37_n2 I1_b29_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I37_MN4 (I1_I1896_pn5 XI1_I1896_I37_An XI1_I1896_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I37_MN2 (XI1_I1896_I37_n1 I1_p28_4 I1_I1896_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I37_MN3 (VSS XI1_I1896_I37_Bn XI1_I1896_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I37_MN0 (XI1_I1896_I37_An I1_p28_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I208_MN1 (XI1_I1896_I208_Bn I1_I1896_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I208_MN5 (XI1_I1896_I208_n2 I1_I1896_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I208_MN4 (I1_p29_5 XI1_I1896_I208_An XI1_I1896_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I208_MN2 (XI1_I1896_I208_n1 I1_I1896_pn5 I1_p29_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I208_MN3 (VSS XI1_I1896_I208_Bn XI1_I1896_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I208_MN0 (XI1_I1896_I208_An I1_I1896_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I39_MN1 (XI1_I1942_I39_Bn I1_b30_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I39_MN5 (XI1_I1942_I39_n2 I1_b30_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I39_MN4 (I1_I1942_pn7 XI1_I1942_I39_An XI1_I1942_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I39_MN2 (XI1_I1942_I39_n1 I1_p29_6 I1_I1942_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I39_MN3 (VSS XI1_I1942_I39_Bn XI1_I1942_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I39_MN0 (XI1_I1942_I39_An I1_p29_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I209_MN1 (XI1_I1942_I209_Bn I1_I1942_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I209_MN5 (XI1_I1942_I209_n2 I1_I1942_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I209_MN4 (I1_p30_6 XI1_I1942_I209_An XI1_I1942_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I209_MN2 (XI1_I1942_I209_n1 I1_I1942_pn6 I1_p30_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I209_MN3 (VSS XI1_I1942_I209_Bn XI1_I1942_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I209_MN0 (XI1_I1942_I209_An I1_I1942_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I40_MN1 (XI1_I1988_I40_Bn I1_b31_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I40_MN5 (XI1_I1988_I40_n2 I1_b31_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I40_MN4 (I1_I1988_pn8 XI1_I1988_I40_An XI1_I1988_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I40_MN2 (XI1_I1988_I40_n1 I1_p30_7 I1_I1988_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I40_MN3 (VSS XI1_I1988_I40_Bn XI1_I1988_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I40_MN0 (XI1_I1988_I40_An I1_p30_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I209_MN1 (XI1_I1988_I209_Bn I1_I1988_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I209_MN5 (XI1_I1988_I209_n2 I1_I1988_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I209_MN4 (I1_p31_6 XI1_I1988_I209_An XI1_I1988_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I209_MN2 (XI1_I1988_I209_n1 I1_I1988_pn6 I1_p31_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I209_MN3 (VSS XI1_I1988_I209_Bn XI1_I1988_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I209_MN0 (XI1_I1988_I209_An I1_I1988_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I208_MN1 (XI1_I1988_I208_Bn I1_I1988_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I208_MN5 (XI1_I1988_I208_n2 I1_I1988_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I208_MN4 (I1_p31_5 XI1_I1988_I208_An XI1_I1988_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I208_MN2 (XI1_I1988_I208_n1 I1_I1988_pn5 I1_p31_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I208_MN3 (VSS XI1_I1988_I208_Bn XI1_I1988_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I208_MN0 (XI1_I1988_I208_An I1_I1988_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I38_MN1 (XI1_I2066_I38_Bn I1_dm6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I38_MN5 (XI1_I2066_I38_n2 I1_dm6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I38_MN4 (I1_I2066_pn6 XI1_I2066_I38_An XI1_I2066_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I38_MN2 (XI1_I2066_I38_n1 I1_p31_6 I1_I2066_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I38_MN3 (VSS XI1_I2066_I38_Bn XI1_I2066_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I38_MN0 (XI1_I2066_I38_An I1_p31_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I37_MN1 (XI1_I2066_I37_Bn I1_dm5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I37_MN5 (XI1_I2066_I37_n2 I1_dm5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I37_MN4 (I1_I2066_pn5 XI1_I2066_I37_An XI1_I2066_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I37_MN2 (XI1_I2066_I37_n1 I1_p31_5 I1_I2066_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I37_MN3 (VSS XI1_I2066_I37_Bn XI1_I2066_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I37_MN0 (XI1_I2066_I37_An I1_p31_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I67_MN1 (XI0_I1660_I67_Bn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I67_MN5 (XI0_I1660_I67_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I67_MN4 (I0_I1660_pn3 XI0_I1660_I67_An XI0_I1660_I67_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I67_MN2 (XI0_I1660_I67_n1 I0_fa137_0 I0_I1660_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I67_MN3 (VSS XI0_I1660_I67_Bn XI0_I1660_I67_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I67_MN0 (XI0_I1660_I67_An I0_fa137_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I203_MN1 (XI1_I2066_I203_Bn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I203_MN5 (XI1_I2066_I203_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I203_MN4 (DIVR_0 XI1_I2066_I203_An XI1_I2066_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I203_MN2 (XI1_I2066_I203_n1 I1_I2066_pn0 DIVR_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I203_MN3 (VSS XI1_I2066_I203_Bn XI1_I2066_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I203_MN0 (XI1_I2066_I203_An I1_I2066_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I469_MN1 (XI0_I1660_I469_Bn I0_I1660_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I469_MN5 (XI0_I1660_I469_n2 I0_I1660_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I469_MN4 (MULP_2 XI0_I1660_I469_An XI0_I1660_I469_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I469_MN2 (XI0_I1660_I469_n1 I0_I1660_pn2 MULP_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I469_MN3 (VSS XI0_I1660_I469_Bn XI0_I1660_I469_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I469_MN0 (XI0_I1660_I469_An I0_I1660_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I472_MN1 (XI0_I1660_I472_Bn I0_I1660_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I472_MN5 (XI0_I1660_I472_n2 I0_I1660_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I472_MN4 (MULP_5 XI0_I1660_I472_An XI0_I1660_I472_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I472_MN2 (XI0_I1660_I472_n1 I0_I1660_pn5 MULP_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I472_MN3 (VSS XI0_I1660_I472_Bn XI0_I1660_I472_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I472_MN0 (XI0_I1660_I472_An I0_I1660_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I94_MN1 (XI0_I1660_I94_Bn I0_ha274_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I94_MN5 (XI0_I1660_I94_n2 I0_ha274_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I94_MN4 (I0_I1660_pn30 XI0_I1660_I94_An XI0_I1660_I94_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I94_MN2 (XI0_I1660_I94_n1 I0_ha273_1 I0_I1660_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I94_MN3 (VSS XI0_I1660_I94_Bn XI0_I1660_I94_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I94_MN0 (XI0_I1660_I94_An I0_ha273_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I39_MN1 (XI1_I1850_I39_Bn I1_b28_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I39_MN5 (XI1_I1850_I39_n2 I1_b28_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I39_MN4 (I1_I1850_pn7 XI1_I1850_I39_An XI1_I1850_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I39_MN2 (XI1_I1850_I39_n1 I1_p27_6 I1_I1850_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I39_MN3 (VSS XI1_I1850_I39_Bn XI1_I1850_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I39_MN0 (XI1_I1850_I39_An I1_p27_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I208_MN1 (XI1_I1850_I208_Bn I1_I1850_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I208_MN5 (XI1_I1850_I208_n2 I1_I1850_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I208_MN4 (I1_p28_5 XI1_I1850_I208_An XI1_I1850_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I208_MN2 (XI1_I1850_I208_n1 I1_I1850_pn5 I1_p28_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I208_MN3 (VSS XI1_I1850_I208_Bn XI1_I1850_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I208_MN0 (XI1_I1850_I208_An I1_I1850_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I39_MN1 (XI1_I1896_I39_Bn I1_b29_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I39_MN5 (XI1_I1896_I39_n2 I1_b29_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I39_MN4 (I1_I1896_pn7 XI1_I1896_I39_An XI1_I1896_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I39_MN2 (XI1_I1896_I39_n1 I1_p28_6 I1_I1896_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I39_MN3 (VSS XI1_I1896_I39_Bn XI1_I1896_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I39_MN0 (XI1_I1896_I39_An I1_p28_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I209_MN1 (XI1_I1896_I209_Bn I1_I1896_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I209_MN5 (XI1_I1896_I209_n2 I1_I1896_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I209_MN4 (I1_p29_6 XI1_I1896_I209_An XI1_I1896_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I209_MN2 (XI1_I1896_I209_n1 I1_I1896_pn6 I1_p29_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I209_MN3 (VSS XI1_I1896_I209_Bn XI1_I1896_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I209_MN0 (XI1_I1896_I209_An I1_I1896_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I210_MN1 (XI1_I1896_I210_Bn I1_I1896_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I210_MN5 (XI1_I1896_I210_n2 I1_I1896_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I210_MN4 (I1_p29_7 XI1_I1896_I210_An XI1_I1896_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I210_MN2 (XI1_I1896_I210_n1 I1_I1896_pn7 I1_p29_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I210_MN3 (VSS XI1_I1896_I210_Bn XI1_I1896_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I210_MN0 (XI1_I1896_I210_An I1_I1896_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I40_MN1 (XI1_I1942_I40_Bn I1_b30_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I40_MN5 (XI1_I1942_I40_n2 I1_b30_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I40_MN4 (I1_I1942_pn8 XI1_I1942_I40_An XI1_I1942_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I40_MN2 (XI1_I1942_I40_n1 I1_p29_7 I1_I1942_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I40_MN3 (VSS XI1_I1942_I40_Bn XI1_I1942_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I40_MN0 (XI1_I1942_I40_An I1_p29_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I41_MN1 (XI1_I1942_I41_Bn I1_b30_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I41_MN5 (XI1_I1942_I41_n2 I1_b30_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I41_MN4 (I1_I1942_pn9 XI1_I1942_I41_An XI1_I1942_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I41_MN2 (XI1_I1942_I41_n1 I1_p29_8 I1_I1942_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I41_MN3 (VSS XI1_I1942_I41_Bn XI1_I1942_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I41_MN0 (XI1_I1942_I41_An I1_p29_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I211_MN1 (XI1_I1942_I211_Bn I1_I1942_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I211_MN5 (XI1_I1942_I211_n2 I1_I1942_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I211_MN4 (I1_p30_8 XI1_I1942_I211_An XI1_I1942_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I211_MN2 (XI1_I1942_I211_n1 I1_I1942_pn8 I1_p30_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I211_MN3 (VSS XI1_I1942_I211_Bn XI1_I1942_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I211_MN0 (XI1_I1942_I211_An I1_I1942_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I210_MN1 (XI1_I1942_I210_Bn I1_I1942_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I210_MN5 (XI1_I1942_I210_n2 I1_I1942_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I210_MN4 (I1_p30_7 XI1_I1942_I210_An XI1_I1942_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I210_MN2 (XI1_I1942_I210_n1 I1_I1942_pn7 I1_p30_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I210_MN3 (VSS XI1_I1942_I210_Bn XI1_I1942_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I210_MN0 (XI1_I1942_I210_An I1_I1942_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I41_MN1 (XI1_I1988_I41_Bn I1_b31_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I41_MN5 (XI1_I1988_I41_n2 I1_b31_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I41_MN4 (I1_I1988_pn9 XI1_I1988_I41_An XI1_I1988_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I41_MN2 (XI1_I1988_I41_n1 I1_p30_8 I1_I1988_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I41_MN3 (VSS XI1_I1988_I41_Bn XI1_I1988_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I41_MN0 (XI1_I1988_I41_An I1_p30_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I211_MN1 (XI1_I1988_I211_Bn I1_I1988_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I211_MN5 (XI1_I1988_I211_n2 I1_I1988_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I211_MN4 (I1_p31_8 XI1_I1988_I211_An XI1_I1988_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I211_MN2 (XI1_I1988_I211_n1 I1_I1988_pn8 I1_p31_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I211_MN3 (VSS XI1_I1988_I211_Bn XI1_I1988_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I211_MN0 (XI1_I1988_I211_An I1_I1988_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I210_MN1 (XI1_I1988_I210_Bn I1_I1988_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I210_MN5 (XI1_I1988_I210_n2 I1_I1988_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I210_MN4 (I1_p31_7 XI1_I1988_I210_An XI1_I1988_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I210_MN2 (XI1_I1988_I210_n1 I1_I1988_pn7 I1_p31_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I210_MN3 (VSS XI1_I1988_I210_Bn XI1_I1988_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I210_MN0 (XI1_I1988_I210_An I1_I1988_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I39_MN1 (XI1_I2066_I39_Bn I1_dm7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I39_MN5 (XI1_I2066_I39_n2 I1_dm7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I39_MN4 (I1_I2066_pn7 XI1_I2066_I39_An XI1_I2066_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I39_MN2 (XI1_I2066_I39_n1 I1_p31_7 I1_I2066_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I39_MN3 (VSS XI1_I2066_I39_Bn XI1_I2066_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I39_MN0 (XI1_I2066_I39_An I1_p31_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I497_MN1 (XI0_I1660_I497_Bn I0_I1660_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I497_MN5 (XI0_I1660_I497_n2 I0_I1660_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I497_MN4 (MULP_30 XI0_I1660_I497_An XI0_I1660_I497_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I497_MN2 (XI0_I1660_I497_n1 I0_I1660_pn30 MULP_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I497_MN3 (VSS XI0_I1660_I497_Bn XI0_I1660_I497_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I497_MN0 (XI0_I1660_I497_An I0_I1660_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I498_MN1 (XI0_I1660_I498_Bn I0_I1660_G30_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I498_MN5 (XI0_I1660_I498_n2 I0_I1660_G30_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I498_MN4 (MULP_31 XI0_I1660_I498_An XI0_I1660_I498_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I498_MN2 (XI0_I1660_I498_n1 I0_I1660_pn31 MULP_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I498_MN3 (VSS XI0_I1660_I498_Bn XI0_I1660_I498_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I498_MN0 (XI0_I1660_I498_An I0_I1660_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I96_MN1 (XI0_I1660_I96_Bn I0_ha276_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I96_MN5 (XI0_I1660_I96_n2 I0_ha276_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I96_MN4 (I0_I1660_pn32 XI0_I1660_I96_An XI0_I1660_I96_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I96_MN2 (XI0_I1660_I96_n1 I0_ha275_1 I0_I1660_pn32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I96_MN3 (VSS XI0_I1660_I96_Bn XI0_I1660_I96_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I96_MN0 (XI0_I1660_I96_An I0_ha275_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I95_MN1 (XI0_I1660_I95_Bn I0_ha275_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I95_MN5 (XI0_I1660_I95_n2 I0_ha275_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I95_MN4 (I0_I1660_pn31 XI0_I1660_I95_An XI0_I1660_I95_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I95_MN2 (XI0_I1660_I95_n1 I0_ha274_1 I0_I1660_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I95_MN3 (VSS XI0_I1660_I95_Bn XI0_I1660_I95_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I95_MN0 (XI0_I1660_I95_An I0_ha274_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I233_MN1 (XI1_I1804_I233_Bn I1_I1804_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I233_MN5 (XI1_I1804_I233_n2 I1_I1804_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I233_MN4 (I1_p27_30 XI1_I1804_I233_An XI1_I1804_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I233_MN2 (XI1_I1804_I233_n1 I1_I1804_pn30 I1_p27_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I233_MN3 (VSS XI1_I1804_I233_Bn XI1_I1804_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I233_MN0 (XI1_I1804_I233_An I1_I1804_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I229_MN1 (XI1_I1804_I229_Bn I1_I1804_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I229_MN5 (XI1_I1804_I229_n2 I1_I1804_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I229_MN4 (I1_p27_26 XI1_I1804_I229_An XI1_I1804_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I229_MN2 (XI1_I1804_I229_n1 I1_I1804_pn26 I1_p27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I229_MN3 (VSS XI1_I1804_I229_Bn XI1_I1804_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I229_MN0 (XI1_I1804_I229_An I1_I1804_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I225_MN1 (XI1_I1804_I225_Bn I1_I1804_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I225_MN5 (XI1_I1804_I225_n2 I1_I1804_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I225_MN4 (I1_p27_22 XI1_I1804_I225_An XI1_I1804_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I225_MN2 (XI1_I1804_I225_n1 I1_I1804_pn22 I1_p27_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I225_MN3 (VSS XI1_I1804_I225_Bn XI1_I1804_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I225_MN0 (XI1_I1804_I225_An I1_I1804_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I221_MN1 (XI1_I1804_I221_Bn I1_I1804_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I221_MN5 (XI1_I1804_I221_n2 I1_I1804_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I221_MN4 (I1_p27_18 XI1_I1804_I221_An XI1_I1804_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I221_MN2 (XI1_I1804_I221_n1 I1_I1804_pn18 I1_p27_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I221_MN3 (VSS XI1_I1804_I221_Bn XI1_I1804_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I221_MN0 (XI1_I1804_I221_An I1_I1804_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I211_MN1 (XI1_I1804_I211_Bn I1_I1804_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I211_MN5 (XI1_I1804_I211_n2 I1_I1804_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I211_MN4 (I1_p27_8 XI1_I1804_I211_An XI1_I1804_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I211_MN2 (XI1_I1804_I211_n1 I1_I1804_pn8 I1_p27_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I211_MN3 (VSS XI1_I1804_I211_Bn XI1_I1804_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I211_MN0 (XI1_I1804_I211_An I1_I1804_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I40_MN1 (XI1_I1850_I40_Bn I1_b28_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I40_MN5 (XI1_I1850_I40_n2 I1_b28_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I40_MN4 (I1_I1850_pn8 XI1_I1850_I40_An XI1_I1850_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I40_MN2 (XI1_I1850_I40_n1 I1_p27_7 I1_I1850_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I40_MN3 (VSS XI1_I1850_I40_Bn XI1_I1850_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I40_MN0 (XI1_I1850_I40_An I1_p27_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I38_MN1 (XI1_I1850_I38_Bn I1_b28_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I38_MN5 (XI1_I1850_I38_n2 I1_b28_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I38_MN4 (I1_I1850_pn6 XI1_I1850_I38_An XI1_I1850_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I38_MN2 (XI1_I1850_I38_n1 I1_p27_5 I1_I1850_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I38_MN3 (VSS XI1_I1850_I38_Bn XI1_I1850_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I38_MN0 (XI1_I1850_I38_An I1_p27_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I40_MN1 (XI1_I1896_I40_Bn I1_b29_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I40_MN5 (XI1_I1896_I40_n2 I1_b29_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I40_MN4 (I1_I1896_pn8 XI1_I1896_I40_An XI1_I1896_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I40_MN2 (XI1_I1896_I40_n1 I1_p28_7 I1_I1896_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I40_MN3 (VSS XI1_I1896_I40_Bn XI1_I1896_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I40_MN0 (XI1_I1896_I40_An I1_p28_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I211_MN1 (XI1_I1896_I211_Bn I1_I1896_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I211_MN5 (XI1_I1896_I211_n2 I1_I1896_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I211_MN4 (I1_p29_8 XI1_I1896_I211_An XI1_I1896_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I211_MN2 (XI1_I1896_I211_n1 I1_I1896_pn8 I1_p29_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I211_MN3 (VSS XI1_I1896_I211_Bn XI1_I1896_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I211_MN0 (XI1_I1896_I211_An I1_I1896_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I42_MN1 (XI1_I1942_I42_Bn I1_b30_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I42_MN5 (XI1_I1942_I42_n2 I1_b30_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I42_MN4 (I1_I1942_pn10 XI1_I1942_I42_An XI1_I1942_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I42_MN2 (XI1_I1942_I42_n1 I1_p29_9 I1_I1942_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I42_MN3 (VSS XI1_I1942_I42_Bn XI1_I1942_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I42_MN0 (XI1_I1942_I42_An I1_p29_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I43_MN1 (XI1_I1988_I43_Bn I1_b31_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I43_MN5 (XI1_I1988_I43_n2 I1_b31_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I43_MN4 (I1_I1988_pn11 XI1_I1988_I43_An XI1_I1988_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I43_MN2 (XI1_I1988_I43_n1 I1_p30_10 I1_I1988_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I43_MN3 (VSS XI1_I1988_I43_Bn XI1_I1988_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I43_MN0 (XI1_I1988_I43_An I1_p30_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I42_MN1 (XI1_I1988_I42_Bn I1_b31_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I42_MN5 (XI1_I1988_I42_n2 I1_b31_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I42_MN4 (I1_I1988_pn10 XI1_I1988_I42_An XI1_I1988_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I42_MN2 (XI1_I1988_I42_n1 I1_p30_9 I1_I1988_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I42_MN3 (VSS XI1_I1988_I42_Bn XI1_I1988_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I42_MN0 (XI1_I1988_I42_An I1_p30_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I41_MN1 (XI1_I2066_I41_Bn I1_dm9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I41_MN5 (XI1_I2066_I41_n2 I1_dm9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I41_MN4 (I1_I2066_pn9 XI1_I2066_I41_An XI1_I2066_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I41_MN2 (XI1_I2066_I41_n1 I1_p31_9 I1_I2066_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I41_MN3 (VSS XI1_I2066_I41_Bn XI1_I2066_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I41_MN0 (XI1_I2066_I41_An I1_p31_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I42_MN1 (XI1_I2066_I42_Bn I1_dm10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I42_MN5 (XI1_I2066_I42_n2 I1_dm10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I42_MN4 (I1_I2066_pn10 XI1_I2066_I42_An XI1_I2066_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I42_MN2 (XI1_I2066_I42_n1 I1_p31_10 I1_I2066_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I42_MN3 (VSS XI1_I2066_I42_Bn XI1_I2066_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I42_MN0 (XI1_I2066_I42_An I1_p31_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I40_MN1 (XI1_I2066_I40_Bn I1_dm8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I40_MN5 (XI1_I2066_I40_n2 I1_dm8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I40_MN4 (I1_I2066_pn8 XI1_I2066_I40_An XI1_I2066_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I40_MN2 (XI1_I2066_I40_n1 I1_p31_8 I1_I2066_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I40_MN3 (VSS XI1_I2066_I40_Bn XI1_I2066_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I40_MN0 (XI1_I2066_I40_An I1_p31_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I204_MN1 (XI1_I2066_I204_Bn I1_I2066_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I204_MN5 (XI1_I2066_I204_n2 I1_I2066_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I204_MN4 (I1_ru1 XI1_I2066_I204_An XI1_I2066_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I204_MN2 (XI1_I2066_I204_n1 I1_I2066_pn1 I1_ru1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I204_MN3 (VSS XI1_I2066_I204_Bn XI1_I2066_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I204_MN0 (XI1_I2066_I204_An I1_I2066_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I499_MN1 (XI0_I1660_I499_Bn I0_I1660_G31_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I499_MN5 (XI0_I1660_I499_n2 I0_I1660_G31_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I499_MN4 (MULP_32 XI0_I1660_I499_An XI0_I1660_I499_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I499_MN2 (XI0_I1660_I499_n1 I0_I1660_pn32 MULP_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I499_MN3 (VSS XI0_I1660_I499_Bn XI0_I1660_I499_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I499_MN0 (XI0_I1660_I499_An I0_I1660_pn32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I97_MN1 (XI0_I1660_I97_Bn I0_ha277_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I97_MN5 (XI0_I1660_I97_n2 I0_ha277_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I97_MN4 (I0_I1660_pn33 XI0_I1660_I97_An XI0_I1660_I97_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I97_MN2 (XI0_I1660_I97_n1 I0_ha276_1 I0_I1660_pn33 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I97_MN3 (VSS XI0_I1660_I97_Bn XI0_I1660_I97_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I97_MN0 (XI0_I1660_I97_An I0_ha276_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I98_MN1 (XI0_I1660_I98_Bn I0_ha278_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I98_MN5 (XI0_I1660_I98_n2 I0_ha278_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I98_MN4 (I0_I1660_pn34 XI0_I1660_I98_An XI0_I1660_I98_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I98_MN2 (XI0_I1660_I98_n1 I0_ha277_1 I0_I1660_pn34 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I98_MN3 (VSS XI0_I1660_I98_Bn XI0_I1660_I98_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I98_MN0 (XI0_I1660_I98_An I0_ha277_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I99_MN1 (XI0_I1660_I99_Bn I0_ha279_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I99_MN5 (XI0_I1660_I99_n2 I0_ha279_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I99_MN4 (I0_I1660_pn35 XI0_I1660_I99_An XI0_I1660_I99_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I99_MN2 (XI0_I1660_I99_n1 I0_ha278_1 I0_I1660_pn35 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I99_MN3 (VSS XI0_I1660_I99_Bn XI0_I1660_I99_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I99_MN0 (XI0_I1660_I99_An I0_ha278_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I223_MN1 (XI1_I1804_I223_Bn I1_I1804_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I223_MN5 (XI1_I1804_I223_n2 I1_I1804_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I223_MN4 (I1_p27_20 XI1_I1804_I223_An XI1_I1804_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I223_MN2 (XI1_I1804_I223_n1 I1_I1804_pn20 I1_p27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I223_MN3 (VSS XI1_I1804_I223_Bn XI1_I1804_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I223_MN0 (XI1_I1804_I223_An I1_I1804_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I43_MN1 (XI1_I1850_I43_Bn I1_b28_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I43_MN5 (XI1_I1850_I43_n2 I1_b28_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I43_MN4 (I1_I1850_pn11 XI1_I1850_I43_An XI1_I1850_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I43_MN2 (XI1_I1850_I43_n1 I1_p27_10 I1_I1850_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I43_MN3 (VSS XI1_I1850_I43_Bn XI1_I1850_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I43_MN0 (XI1_I1850_I43_An I1_p27_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I42_MN1 (XI1_I1850_I42_Bn I1_b28_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I42_MN5 (XI1_I1850_I42_n2 I1_b28_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I42_MN4 (I1_I1850_pn10 XI1_I1850_I42_An XI1_I1850_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I42_MN2 (XI1_I1850_I42_n1 I1_p27_9 I1_I1850_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I42_MN3 (VSS XI1_I1850_I42_Bn XI1_I1850_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I42_MN0 (XI1_I1850_I42_An I1_p27_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I41_MN1 (XI1_I1850_I41_Bn I1_b28_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I41_MN5 (XI1_I1850_I41_n2 I1_b28_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I41_MN4 (I1_I1850_pn9 XI1_I1850_I41_An XI1_I1850_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I41_MN2 (XI1_I1850_I41_n1 I1_p27_8 I1_I1850_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I41_MN3 (VSS XI1_I1850_I41_Bn XI1_I1850_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I41_MN0 (XI1_I1850_I41_An I1_p27_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I210_MN1 (XI1_I1850_I210_Bn I1_I1850_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I210_MN5 (XI1_I1850_I210_n2 I1_I1850_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I210_MN4 (I1_p28_7 XI1_I1850_I210_An XI1_I1850_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I210_MN2 (XI1_I1850_I210_n1 I1_I1850_pn7 I1_p28_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I210_MN3 (VSS XI1_I1850_I210_Bn XI1_I1850_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I210_MN0 (XI1_I1850_I210_An I1_I1850_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I209_MN1 (XI1_I1850_I209_Bn I1_I1850_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I209_MN5 (XI1_I1850_I209_n2 I1_I1850_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I209_MN4 (I1_p28_6 XI1_I1850_I209_An XI1_I1850_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I209_MN2 (XI1_I1850_I209_n1 I1_I1850_pn6 I1_p28_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I209_MN3 (VSS XI1_I1850_I209_Bn XI1_I1850_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I209_MN0 (XI1_I1850_I209_An I1_I1850_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I42_MN1 (XI1_I1896_I42_Bn I1_b29_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I42_MN5 (XI1_I1896_I42_n2 I1_b29_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I42_MN4 (I1_I1896_pn10 XI1_I1896_I42_An XI1_I1896_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I42_MN2 (XI1_I1896_I42_n1 I1_p28_9 I1_I1896_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I42_MN3 (VSS XI1_I1896_I42_Bn XI1_I1896_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I42_MN0 (XI1_I1896_I42_An I1_p28_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I43_MN1 (XI1_I1896_I43_Bn I1_b29_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I43_MN5 (XI1_I1896_I43_n2 I1_b29_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I43_MN4 (I1_I1896_pn11 XI1_I1896_I43_An XI1_I1896_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I43_MN2 (XI1_I1896_I43_n1 I1_p28_10 I1_I1896_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I43_MN3 (VSS XI1_I1896_I43_Bn XI1_I1896_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I43_MN0 (XI1_I1896_I43_An I1_p28_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I41_MN1 (XI1_I1896_I41_Bn I1_b29_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I41_MN5 (XI1_I1896_I41_n2 I1_b29_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I41_MN4 (I1_I1896_pn9 XI1_I1896_I41_An XI1_I1896_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I41_MN2 (XI1_I1896_I41_n1 I1_p28_8 I1_I1896_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I41_MN3 (VSS XI1_I1896_I41_Bn XI1_I1896_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I41_MN0 (XI1_I1896_I41_An I1_p28_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I43_MN1 (XI1_I1942_I43_Bn I1_b30_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I43_MN5 (XI1_I1942_I43_n2 I1_b30_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I43_MN4 (I1_I1942_pn11 XI1_I1942_I43_An XI1_I1942_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I43_MN2 (XI1_I1942_I43_n1 I1_p29_10 I1_I1942_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I43_MN3 (VSS XI1_I1942_I43_Bn XI1_I1942_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I43_MN0 (XI1_I1942_I43_An I1_p29_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I44_MN1 (XI1_I1942_I44_Bn I1_b30_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I44_MN5 (XI1_I1942_I44_n2 I1_b30_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I44_MN4 (I1_I1942_pn12 XI1_I1942_I44_An XI1_I1942_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I44_MN2 (XI1_I1942_I44_n1 I1_p29_11 I1_I1942_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I44_MN3 (VSS XI1_I1942_I44_Bn XI1_I1942_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I44_MN0 (XI1_I1942_I44_An I1_p29_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I45_MN1 (XI1_I1988_I45_Bn I1_b31_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I45_MN5 (XI1_I1988_I45_n2 I1_b31_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I45_MN4 (I1_I1988_pn13 XI1_I1988_I45_An XI1_I1988_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I45_MN2 (XI1_I1988_I45_n1 I1_p30_12 I1_I1988_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I45_MN3 (VSS XI1_I1988_I45_Bn XI1_I1988_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I45_MN0 (XI1_I1988_I45_An I1_p30_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I44_MN1 (XI1_I1988_I44_Bn I1_b31_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I44_MN5 (XI1_I1988_I44_n2 I1_b31_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I44_MN4 (I1_I1988_pn12 XI1_I1988_I44_An XI1_I1988_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I44_MN2 (XI1_I1988_I44_n1 I1_p30_11 I1_I1988_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I44_MN3 (VSS XI1_I1988_I44_Bn XI1_I1988_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I44_MN0 (XI1_I1988_I44_An I1_p30_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I43_MN1 (XI1_I2066_I43_Bn I1_dm11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I43_MN5 (XI1_I2066_I43_n2 I1_dm11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I43_MN4 (I1_I2066_pn11 XI1_I2066_I43_An XI1_I2066_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I43_MN2 (XI1_I2066_I43_n1 I1_p31_11 I1_I2066_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I43_MN3 (VSS XI1_I2066_I43_Bn XI1_I2066_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I43_MN0 (XI1_I2066_I43_An I1_p31_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I205_MN1 (XI1_I2066_I205_Bn I1_I2066_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I205_MN5 (XI1_I2066_I205_n2 I1_I2066_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I205_MN4 (I1_ru2 XI1_I2066_I205_An XI1_I2066_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I205_MN2 (XI1_I2066_I205_n1 I1_I2066_pn2 I1_ru2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I205_MN3 (VSS XI1_I2066_I205_Bn XI1_I2066_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I205_MN0 (XI1_I2066_I205_An I1_I2066_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2171_MN1 (XI1_I2171_Bn I1_nrkn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2171_MN5 (XI1_I2171_n2 I1_nrkn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2171_MN4 (DIVR_1 XI1_I2171_An XI1_I2171_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2171_MN2 (XI1_I2171_n1 I1_ru1 DIVR_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2171_MN3 (VSS XI1_I2171_Bn XI1_I2171_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2171_MN0 (XI1_I2171_An I1_ru1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2174_MN1 (XI1_I2174_Bn I1_nrkn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2174_MN5 (XI1_I2174_n2 I1_nrkn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2174_MN4 (DIVR_2 XI1_I2174_An XI1_I2174_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2174_MN2 (XI1_I2174_n1 I1_ru2 DIVR_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2174_MN3 (VSS XI1_I2174_Bn XI1_I2174_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2174_MN0 (XI1_I2174_An I1_ru2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I102_MN1 (XI0_I1660_I102_Bn I0_ha282_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I102_MN5 (XI0_I1660_I102_n2 I0_ha282_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I102_MN4 (I0_I1660_pn38 XI0_I1660_I102_An XI0_I1660_I102_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I102_MN2 (XI0_I1660_I102_n1 I0_fa281_1 I0_I1660_pn38 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I102_MN3 (VSS XI0_I1660_I102_Bn XI0_I1660_I102_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I102_MN0 (XI0_I1660_I102_An I0_fa281_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I103_MN1 (XI0_I1660_I103_Bn I0_fa283_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I103_MN5 (XI0_I1660_I103_n2 I0_fa283_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I103_MN4 (I0_I1660_pn39 XI0_I1660_I103_An XI0_I1660_I103_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I103_MN2 (XI0_I1660_I103_n1 I0_ha282_1 I0_I1660_pn39 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I103_MN3 (VSS XI0_I1660_I103_Bn XI0_I1660_I103_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I103_MN0 (XI0_I1660_I103_An I0_ha282_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I100_MN1 (XI0_I1660_I100_Bn I0_fa280_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I100_MN5 (XI0_I1660_I100_n2 I0_fa280_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I100_MN4 (I0_I1660_pn36 XI0_I1660_I100_An XI0_I1660_I100_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I100_MN2 (XI0_I1660_I100_n1 I0_ha279_1 I0_I1660_pn36 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I100_MN3 (VSS XI0_I1660_I100_Bn XI0_I1660_I100_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I100_MN0 (XI0_I1660_I100_An I0_ha279_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I101_MN1 (XI0_I1660_I101_Bn I0_fa281_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I101_MN5 (XI0_I1660_I101_n2 I0_fa281_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I101_MN4 (I0_I1660_pn37 XI0_I1660_I101_An XI0_I1660_I101_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I101_MN2 (XI0_I1660_I101_n1 I0_fa280_1 I0_I1660_pn37 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I101_MN3 (VSS XI0_I1660_I101_Bn XI0_I1660_I101_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I101_MN0 (XI0_I1660_I101_An I0_fa280_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I231_MN1 (XI1_I1804_I231_Bn I1_I1804_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I231_MN5 (XI1_I1804_I231_n2 I1_I1804_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I231_MN4 (I1_p27_28 XI1_I1804_I231_An XI1_I1804_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I231_MN2 (XI1_I1804_I231_n1 I1_I1804_pn28 I1_p27_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I231_MN3 (VSS XI1_I1804_I231_Bn XI1_I1804_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I231_MN0 (XI1_I1804_I231_An I1_I1804_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I227_MN1 (XI1_I1804_I227_Bn I1_I1804_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I227_MN5 (XI1_I1804_I227_n2 I1_I1804_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I227_MN4 (I1_p27_24 XI1_I1804_I227_An XI1_I1804_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I227_MN2 (XI1_I1804_I227_n1 I1_I1804_pn24 I1_p27_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I227_MN3 (VSS XI1_I1804_I227_Bn XI1_I1804_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I227_MN0 (XI1_I1804_I227_An I1_I1804_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I45_MN1 (XI1_I1850_I45_Bn I1_b28_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I45_MN5 (XI1_I1850_I45_n2 I1_b28_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I45_MN4 (I1_I1850_pn13 XI1_I1850_I45_An XI1_I1850_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I45_MN2 (XI1_I1850_I45_n1 I1_p27_12 I1_I1850_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I45_MN3 (VSS XI1_I1850_I45_Bn XI1_I1850_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I45_MN0 (XI1_I1850_I45_An I1_p27_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I44_MN1 (XI1_I1850_I44_Bn I1_b28_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I44_MN5 (XI1_I1850_I44_n2 I1_b28_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I44_MN4 (I1_I1850_pn12 XI1_I1850_I44_An XI1_I1850_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I44_MN2 (XI1_I1850_I44_n1 I1_p27_11 I1_I1850_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I44_MN3 (VSS XI1_I1850_I44_Bn XI1_I1850_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I44_MN0 (XI1_I1850_I44_An I1_p27_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I211_MN1 (XI1_I1850_I211_Bn I1_I1850_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I211_MN5 (XI1_I1850_I211_n2 I1_I1850_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I211_MN4 (I1_p28_8 XI1_I1850_I211_An XI1_I1850_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I211_MN2 (XI1_I1850_I211_n1 I1_I1850_pn8 I1_p28_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I211_MN3 (VSS XI1_I1850_I211_Bn XI1_I1850_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I211_MN0 (XI1_I1850_I211_An I1_I1850_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I45_MN1 (XI1_I1942_I45_Bn I1_b30_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I45_MN5 (XI1_I1942_I45_n2 I1_b30_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I45_MN4 (I1_I1942_pn13 XI1_I1942_I45_An XI1_I1942_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I45_MN2 (XI1_I1942_I45_n1 I1_p29_12 I1_I1942_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I45_MN3 (VSS XI1_I1942_I45_Bn XI1_I1942_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I45_MN0 (XI1_I1942_I45_An I1_p29_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I46_MN1 (XI1_I1988_I46_Bn I1_b31_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I46_MN5 (XI1_I1988_I46_n2 I1_b31_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I46_MN4 (I1_I1988_pn14 XI1_I1988_I46_An XI1_I1988_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I46_MN2 (XI1_I1988_I46_n1 I1_p30_13 I1_I1988_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I46_MN3 (VSS XI1_I1988_I46_Bn XI1_I1988_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I46_MN0 (XI1_I1988_I46_An I1_p30_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I44_MN1 (XI1_I2066_I44_Bn I1_dm12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I44_MN5 (XI1_I2066_I44_n2 I1_dm12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I44_MN4 (I1_I2066_pn12 XI1_I2066_I44_An XI1_I2066_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I44_MN2 (XI1_I2066_I44_n1 I1_p31_12 I1_I2066_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I44_MN3 (VSS XI1_I2066_I44_Bn XI1_I2066_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I44_MN0 (XI1_I2066_I44_An I1_p31_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I208_MN1 (XI1_I2066_I208_Bn I1_I2066_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I208_MN5 (XI1_I2066_I208_n2 I1_I2066_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I208_MN4 (I1_ru5 XI1_I2066_I208_An XI1_I2066_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I208_MN2 (XI1_I2066_I208_n1 I1_I2066_pn5 I1_ru5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I208_MN3 (VSS XI1_I2066_I208_Bn XI1_I2066_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I208_MN0 (XI1_I2066_I208_An I1_I2066_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2180_MN1 (XI1_I2180_Bn I1_nrkn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2180_MN5 (XI1_I2180_n2 I1_nrkn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2180_MN4 (DIVR_4 XI1_I2180_An XI1_I2180_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2180_MN2 (XI1_I2180_n1 I1_ru4 DIVR_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2180_MN3 (VSS XI1_I2180_Bn XI1_I2180_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2180_MN0 (XI1_I2180_An I1_ru4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I104_MN1 (XI0_I1660_I104_Bn I0_ha284_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I104_MN5 (XI0_I1660_I104_n2 I0_ha284_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I104_MN4 (I0_I1660_pn40 XI0_I1660_I104_An XI0_I1660_I104_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I104_MN2 (XI0_I1660_I104_n1 I0_fa283_1 I0_I1660_pn40 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I104_MN3 (VSS XI0_I1660_I104_Bn XI0_I1660_I104_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I104_MN0 (XI0_I1660_I104_An I0_fa283_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I105_MN1 (XI0_I1660_I105_Bn I0_fa285_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I105_MN5 (XI0_I1660_I105_n2 I0_fa285_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I105_MN4 (I0_I1660_pn41 XI0_I1660_I105_An XI0_I1660_I105_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I105_MN2 (XI0_I1660_I105_n1 I0_ha284_1 I0_I1660_pn41 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I105_MN3 (VSS XI0_I1660_I105_Bn XI0_I1660_I105_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I105_MN0 (XI0_I1660_I105_An I0_ha284_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I47_MN1 (XI1_I1850_I47_Bn I1_b28_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I47_MN5 (XI1_I1850_I47_n2 I1_b28_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I47_MN4 (I1_I1850_pn15 XI1_I1850_I47_An XI1_I1850_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I47_MN2 (XI1_I1850_I47_n1 I1_p27_14 I1_I1850_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I47_MN3 (VSS XI1_I1850_I47_Bn XI1_I1850_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I47_MN0 (XI1_I1850_I47_An I1_p27_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I44_MN1 (XI1_I1896_I44_Bn I1_b29_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I44_MN5 (XI1_I1896_I44_n2 I1_b29_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I44_MN4 (I1_I1896_pn12 XI1_I1896_I44_An XI1_I1896_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I44_MN2 (XI1_I1896_I44_n1 I1_p28_11 I1_I1896_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I44_MN3 (VSS XI1_I1896_I44_Bn XI1_I1896_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I44_MN0 (XI1_I1896_I44_An I1_p28_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I45_MN1 (XI1_I1896_I45_Bn I1_b29_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I45_MN5 (XI1_I1896_I45_n2 I1_b29_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I45_MN4 (I1_I1896_pn13 XI1_I1896_I45_An XI1_I1896_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I45_MN2 (XI1_I1896_I45_n1 I1_p28_12 I1_I1896_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I45_MN3 (VSS XI1_I1896_I45_Bn XI1_I1896_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I45_MN0 (XI1_I1896_I45_An I1_p28_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I47_MN1 (XI1_I1942_I47_Bn I1_b30_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I47_MN5 (XI1_I1942_I47_n2 I1_b30_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I47_MN4 (I1_I1942_pn15 XI1_I1942_I47_An XI1_I1942_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I47_MN2 (XI1_I1942_I47_n1 I1_p29_14 I1_I1942_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I47_MN3 (VSS XI1_I1942_I47_Bn XI1_I1942_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I47_MN0 (XI1_I1942_I47_An I1_p29_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I46_MN1 (XI1_I1942_I46_Bn I1_b30_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I46_MN5 (XI1_I1942_I46_n2 I1_b30_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I46_MN4 (I1_I1942_pn14 XI1_I1942_I46_An XI1_I1942_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I46_MN2 (XI1_I1942_I46_n1 I1_p29_13 I1_I1942_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I46_MN3 (VSS XI1_I1942_I46_Bn XI1_I1942_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I46_MN0 (XI1_I1942_I46_An I1_p29_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I47_MN1 (XI1_I1988_I47_Bn I1_b31_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I47_MN5 (XI1_I1988_I47_n2 I1_b31_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I47_MN4 (I1_I1988_pn15 XI1_I1988_I47_An XI1_I1988_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I47_MN2 (XI1_I1988_I47_n1 I1_p30_14 I1_I1988_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I47_MN3 (VSS XI1_I1988_I47_Bn XI1_I1988_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I47_MN0 (XI1_I1988_I47_An I1_p30_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I46_MN1 (XI1_I2066_I46_Bn I1_dm14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I46_MN5 (XI1_I2066_I46_n2 I1_dm14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I46_MN4 (I1_I2066_pn14 XI1_I2066_I46_An XI1_I2066_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I46_MN2 (XI1_I2066_I46_n1 I1_p31_14 I1_I2066_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I46_MN3 (VSS XI1_I2066_I46_Bn XI1_I2066_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I46_MN0 (XI1_I2066_I46_An I1_p31_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I45_MN1 (XI1_I2066_I45_Bn I1_dm13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I45_MN5 (XI1_I2066_I45_n2 I1_dm13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I45_MN4 (I1_I2066_pn13 XI1_I2066_I45_An XI1_I2066_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I45_MN2 (XI1_I2066_I45_n1 I1_p31_13 I1_I2066_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I45_MN3 (VSS XI1_I2066_I45_Bn XI1_I2066_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I45_MN0 (XI1_I2066_I45_An I1_p31_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I210_MN1 (XI1_I2066_I210_Bn I1_I2066_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I210_MN5 (XI1_I2066_I210_n2 I1_I2066_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I210_MN4 (I1_ru7 XI1_I2066_I210_An XI1_I2066_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I210_MN2 (XI1_I2066_I210_n1 I1_I2066_pn7 I1_ru7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I210_MN3 (VSS XI1_I2066_I210_Bn XI1_I2066_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I210_MN0 (XI1_I2066_I210_An I1_I2066_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I209_MN1 (XI1_I2066_I209_Bn I1_I2066_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I209_MN5 (XI1_I2066_I209_n2 I1_I2066_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I209_MN4 (I1_ru6 XI1_I2066_I209_An XI1_I2066_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I209_MN2 (XI1_I2066_I209_n1 I1_I2066_pn6 I1_ru6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I209_MN3 (VSS XI1_I2066_I209_Bn XI1_I2066_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I209_MN0 (XI1_I2066_I209_An I1_I2066_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2177_MN1 (XI1_I2177_Bn I1_nrkn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2177_MN5 (XI1_I2177_n2 I1_nrkn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2177_MN4 (DIVR_3 XI1_I2177_An XI1_I2177_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2177_MN2 (XI1_I2177_n1 I1_ru3 DIVR_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2177_MN3 (VSS XI1_I2177_Bn XI1_I2177_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2177_MN0 (XI1_I2177_An I1_ru3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2186_MN1 (XI1_I2186_Bn I1_nrkn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2186_MN5 (XI1_I2186_n2 I1_nrkn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2186_MN4 (DIVR_6 XI1_I2186_An XI1_I2186_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2186_MN2 (XI1_I2186_n1 I1_ru6 DIVR_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2186_MN3 (VSS XI1_I2186_Bn XI1_I2186_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2186_MN0 (XI1_I2186_An I1_ru6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2183_MN1 (XI1_I2183_Bn I1_nrkn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2183_MN5 (XI1_I2183_n2 I1_nrkn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2183_MN4 (DIVR_5 XI1_I2183_An XI1_I2183_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2183_MN2 (XI1_I2183_n1 I1_ru5 DIVR_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2183_MN3 (VSS XI1_I2183_Bn XI1_I2183_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2183_MN0 (XI1_I2183_An I1_ru5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I108_MN1 (XI0_I1660_I108_Bn I0_ha288_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I108_MN5 (XI0_I1660_I108_n2 I0_ha288_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I108_MN4 (I0_I1660_pn44 XI0_I1660_I108_An XI0_I1660_I108_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I108_MN2 (XI0_I1660_I108_n1 I0_fa287_1 I0_I1660_pn44 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I108_MN3 (VSS XI0_I1660_I108_Bn XI0_I1660_I108_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I108_MN0 (XI0_I1660_I108_An I0_fa287_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I107_MN1 (XI0_I1660_I107_Bn I0_fa287_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I107_MN5 (XI0_I1660_I107_n2 I0_fa287_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I107_MN4 (I0_I1660_pn43 XI0_I1660_I107_An XI0_I1660_I107_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I107_MN2 (XI0_I1660_I107_n1 I0_ha286_1 I0_I1660_pn43 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I107_MN3 (VSS XI0_I1660_I107_Bn XI0_I1660_I107_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I107_MN0 (XI0_I1660_I107_An I0_ha286_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I106_MN1 (XI0_I1660_I106_Bn I0_ha286_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I106_MN5 (XI0_I1660_I106_n2 I0_ha286_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I106_MN4 (I0_I1660_pn42 XI0_I1660_I106_An XI0_I1660_I106_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I106_MN2 (XI0_I1660_I106_n1 I0_fa285_1 I0_I1660_pn42 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I106_MN3 (VSS XI0_I1660_I106_Bn XI0_I1660_I106_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I106_MN0 (XI0_I1660_I106_An I0_fa285_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I49_MN1 (XI1_I1850_I49_Bn I1_b28_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I49_MN5 (XI1_I1850_I49_n2 I1_b28_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I49_MN4 (I1_I1850_pn17 XI1_I1850_I49_An XI1_I1850_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I49_MN2 (XI1_I1850_I49_n1 I1_p27_16 I1_I1850_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I49_MN3 (VSS XI1_I1850_I49_Bn XI1_I1850_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I49_MN0 (XI1_I1850_I49_An I1_p27_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I48_MN1 (XI1_I1850_I48_Bn I1_b28_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I48_MN5 (XI1_I1850_I48_n2 I1_b28_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I48_MN4 (I1_I1850_pn16 XI1_I1850_I48_An XI1_I1850_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I48_MN2 (XI1_I1850_I48_n1 I1_p27_15 I1_I1850_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I48_MN3 (VSS XI1_I1850_I48_Bn XI1_I1850_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I48_MN0 (XI1_I1850_I48_An I1_p27_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I46_MN1 (XI1_I1850_I46_Bn I1_b28_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I46_MN5 (XI1_I1850_I46_n2 I1_b28_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I46_MN4 (I1_I1850_pn14 XI1_I1850_I46_An XI1_I1850_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I46_MN2 (XI1_I1850_I46_n1 I1_p27_13 I1_I1850_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I46_MN3 (VSS XI1_I1850_I46_Bn XI1_I1850_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I46_MN0 (XI1_I1850_I46_An I1_p27_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I46_MN1 (XI1_I1896_I46_Bn I1_b29_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I46_MN5 (XI1_I1896_I46_n2 I1_b29_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I46_MN4 (I1_I1896_pn14 XI1_I1896_I46_An XI1_I1896_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I46_MN2 (XI1_I1896_I46_n1 I1_p28_13 I1_I1896_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I46_MN3 (VSS XI1_I1896_I46_Bn XI1_I1896_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I46_MN0 (XI1_I1896_I46_An I1_p28_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I48_MN1 (XI1_I1942_I48_Bn I1_b30_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I48_MN5 (XI1_I1942_I48_n2 I1_b30_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I48_MN4 (I1_I1942_pn16 XI1_I1942_I48_An XI1_I1942_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I48_MN2 (XI1_I1942_I48_n1 I1_p29_15 I1_I1942_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I48_MN3 (VSS XI1_I1942_I48_Bn XI1_I1942_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I48_MN0 (XI1_I1942_I48_An I1_p29_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I220_MN1 (XI1_I1942_I220_Bn I1_I1942_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I220_MN5 (XI1_I1942_I220_n2 I1_I1942_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I220_MN4 (I1_p30_17 XI1_I1942_I220_An XI1_I1942_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I220_MN2 (XI1_I1942_I220_n1 I1_I1942_pn17 I1_p30_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I220_MN3 (VSS XI1_I1942_I220_Bn XI1_I1942_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I220_MN0 (XI1_I1942_I220_An I1_I1942_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I49_MN1 (XI1_I1988_I49_Bn I1_b31_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I49_MN5 (XI1_I1988_I49_n2 I1_b31_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I49_MN4 (I1_I1988_pn17 XI1_I1988_I49_An XI1_I1988_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I49_MN2 (XI1_I1988_I49_n1 I1_p30_16 I1_I1988_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I49_MN3 (VSS XI1_I1988_I49_Bn XI1_I1988_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I49_MN0 (XI1_I1988_I49_An I1_p30_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I48_MN1 (XI1_I1988_I48_Bn I1_b31_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I48_MN5 (XI1_I1988_I48_n2 I1_b31_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I48_MN4 (I1_I1988_pn16 XI1_I1988_I48_An XI1_I1988_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I48_MN2 (XI1_I1988_I48_n1 I1_p30_15 I1_I1988_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I48_MN3 (VSS XI1_I1988_I48_Bn XI1_I1988_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I48_MN0 (XI1_I1988_I48_An I1_p30_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I220_MN1 (XI1_I1988_I220_Bn I1_I1988_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I220_MN5 (XI1_I1988_I220_n2 I1_I1988_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I220_MN4 (I1_p31_17 XI1_I1988_I220_An XI1_I1988_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I220_MN2 (XI1_I1988_I220_n1 I1_I1988_pn17 I1_p31_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I220_MN3 (VSS XI1_I1988_I220_Bn XI1_I1988_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I220_MN0 (XI1_I1988_I220_An I1_I1988_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I47_MN1 (XI1_I2066_I47_Bn I1_dm15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I47_MN5 (XI1_I2066_I47_n2 I1_dm15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I47_MN4 (I1_I2066_pn15 XI1_I2066_I47_An XI1_I2066_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I47_MN2 (XI1_I2066_I47_n1 I1_p31_15 I1_I2066_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I47_MN3 (VSS XI1_I2066_I47_Bn XI1_I2066_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I47_MN0 (XI1_I2066_I47_An I1_p31_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2192_MN1 (XI1_I2192_Bn I1_nrkn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2192_MN5 (XI1_I2192_n2 I1_nrkn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2192_MN4 (DIVR_8 XI1_I2192_An XI1_I2192_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2192_MN2 (XI1_I2192_n1 I1_ru8 DIVR_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2192_MN3 (VSS XI1_I2192_Bn XI1_I2192_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2192_MN0 (XI1_I2192_An I1_ru8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2189_MN1 (XI1_I2189_Bn I1_nrkn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2189_MN5 (XI1_I2189_n2 I1_nrkn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2189_MN4 (DIVR_7 XI1_I2189_An XI1_I2189_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2189_MN2 (XI1_I2189_n1 I1_ru7 DIVR_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2189_MN3 (VSS XI1_I2189_Bn XI1_I2189_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2189_MN0 (XI1_I2189_An I1_ru7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I110_MN1 (XI0_I1660_I110_Bn I0_ha290_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I110_MN5 (XI0_I1660_I110_n2 I0_ha290_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I110_MN4 (I0_I1660_pn46 XI0_I1660_I110_An XI0_I1660_I110_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I110_MN2 (XI0_I1660_I110_n1 I0_fa289_1 I0_I1660_pn46 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I110_MN3 (VSS XI0_I1660_I110_Bn XI0_I1660_I110_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I110_MN0 (XI0_I1660_I110_An I0_fa289_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I109_MN1 (XI0_I1660_I109_Bn I0_fa289_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I109_MN5 (XI0_I1660_I109_n2 I0_fa289_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I109_MN4 (I0_I1660_pn45 XI0_I1660_I109_An XI0_I1660_I109_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I109_MN2 (XI0_I1660_I109_n1 I0_ha288_1 I0_I1660_pn45 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I109_MN3 (VSS XI0_I1660_I109_Bn XI0_I1660_I109_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I109_MN0 (XI0_I1660_I109_An I0_ha288_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I221_MN1 (XI1_I1850_I221_Bn I1_I1850_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I221_MN5 (XI1_I1850_I221_n2 I1_I1850_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I221_MN4 (I1_p28_18 XI1_I1850_I221_An XI1_I1850_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I221_MN2 (XI1_I1850_I221_n1 I1_I1850_pn18 I1_p28_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I221_MN3 (VSS XI1_I1850_I221_Bn XI1_I1850_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I221_MN0 (XI1_I1850_I221_An I1_I1850_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I49_MN1 (XI1_I1896_I49_Bn I1_b29_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I49_MN5 (XI1_I1896_I49_n2 I1_b29_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I49_MN4 (I1_I1896_pn17 XI1_I1896_I49_An XI1_I1896_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I49_MN2 (XI1_I1896_I49_n1 I1_p28_16 I1_I1896_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I49_MN3 (VSS XI1_I1896_I49_Bn XI1_I1896_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I49_MN0 (XI1_I1896_I49_An I1_p28_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I48_MN1 (XI1_I1896_I48_Bn I1_b29_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I48_MN5 (XI1_I1896_I48_n2 I1_b29_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I48_MN4 (I1_I1896_pn16 XI1_I1896_I48_An XI1_I1896_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I48_MN2 (XI1_I1896_I48_n1 I1_p28_15 I1_I1896_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I48_MN3 (VSS XI1_I1896_I48_Bn XI1_I1896_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I48_MN0 (XI1_I1896_I48_An I1_p28_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I47_MN1 (XI1_I1896_I47_Bn I1_b29_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I47_MN5 (XI1_I1896_I47_n2 I1_b29_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I47_MN4 (I1_I1896_pn15 XI1_I1896_I47_An XI1_I1896_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I47_MN2 (XI1_I1896_I47_n1 I1_p28_14 I1_I1896_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I47_MN3 (VSS XI1_I1896_I47_Bn XI1_I1896_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I47_MN0 (XI1_I1896_I47_An I1_p28_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I220_MN1 (XI1_I1896_I220_Bn I1_I1896_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I220_MN5 (XI1_I1896_I220_n2 I1_I1896_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I220_MN4 (I1_p29_17 XI1_I1896_I220_An XI1_I1896_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I220_MN2 (XI1_I1896_I220_n1 I1_I1896_pn17 I1_p29_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I220_MN3 (VSS XI1_I1896_I220_Bn XI1_I1896_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I220_MN0 (XI1_I1896_I220_An I1_I1896_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I49_MN1 (XI1_I1942_I49_Bn I1_b30_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I49_MN5 (XI1_I1942_I49_n2 I1_b30_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I49_MN4 (I1_I1942_pn17 XI1_I1942_I49_An XI1_I1942_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I49_MN2 (XI1_I1942_I49_n1 I1_p29_16 I1_I1942_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I49_MN3 (VSS XI1_I1942_I49_Bn XI1_I1942_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I49_MN0 (XI1_I1942_I49_An I1_p29_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I50_MN1 (XI1_I1942_I50_Bn I1_b30_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I50_MN5 (XI1_I1942_I50_n2 I1_b30_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I50_MN4 (I1_I1942_pn18 XI1_I1942_I50_An XI1_I1942_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I50_MN2 (XI1_I1942_I50_n1 I1_p29_17 I1_I1942_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I50_MN3 (VSS XI1_I1942_I50_Bn XI1_I1942_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I50_MN0 (XI1_I1942_I50_An I1_p29_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I221_MN1 (XI1_I1942_I221_Bn I1_I1942_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I221_MN5 (XI1_I1942_I221_n2 I1_I1942_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I221_MN4 (I1_p30_18 XI1_I1942_I221_An XI1_I1942_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I221_MN2 (XI1_I1942_I221_n1 I1_I1942_pn18 I1_p30_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I221_MN3 (VSS XI1_I1942_I221_Bn XI1_I1942_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I221_MN0 (XI1_I1942_I221_An I1_I1942_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I50_MN1 (XI1_I1988_I50_Bn I1_b31_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I50_MN5 (XI1_I1988_I50_n2 I1_b31_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I50_MN4 (I1_I1988_pn18 XI1_I1988_I50_An XI1_I1988_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I50_MN2 (XI1_I1988_I50_n1 I1_p30_17 I1_I1988_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I50_MN3 (VSS XI1_I1988_I50_Bn XI1_I1988_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I50_MN0 (XI1_I1988_I50_An I1_p30_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I51_MN1 (XI1_I1988_I51_Bn I1_b31_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I51_MN5 (XI1_I1988_I51_n2 I1_b31_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I51_MN4 (I1_I1988_pn19 XI1_I1988_I51_An XI1_I1988_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I51_MN2 (XI1_I1988_I51_n1 I1_p30_18 I1_I1988_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I51_MN3 (VSS XI1_I1988_I51_Bn XI1_I1988_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I51_MN0 (XI1_I1988_I51_An I1_p30_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I221_MN1 (XI1_I1988_I221_Bn I1_I1988_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I221_MN5 (XI1_I1988_I221_n2 I1_I1988_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I221_MN4 (I1_p31_18 XI1_I1988_I221_An XI1_I1988_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I221_MN2 (XI1_I1988_I221_n1 I1_I1988_pn18 I1_p31_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I221_MN3 (VSS XI1_I1988_I221_Bn XI1_I1988_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I221_MN0 (XI1_I1988_I221_An I1_I1988_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I49_MN1 (XI1_I2066_I49_Bn I1_dm17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I49_MN5 (XI1_I2066_I49_n2 I1_dm17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I49_MN4 (I1_I2066_pn17 XI1_I2066_I49_An XI1_I2066_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I49_MN2 (XI1_I2066_I49_n1 I1_p31_17 I1_I2066_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I49_MN3 (VSS XI1_I2066_I49_Bn XI1_I2066_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I49_MN0 (XI1_I2066_I49_An I1_p31_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I48_MN1 (XI1_I2066_I48_Bn I1_dm16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I48_MN5 (XI1_I2066_I48_n2 I1_dm16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I48_MN4 (I1_I2066_pn16 XI1_I2066_I48_An XI1_I2066_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I48_MN2 (XI1_I2066_I48_n1 I1_p31_16 I1_I2066_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I48_MN3 (VSS XI1_I2066_I48_Bn XI1_I2066_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I48_MN0 (XI1_I2066_I48_An I1_p31_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I220_MN1 (XI1_I2066_I220_Bn I1_I2066_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I220_MN5 (XI1_I2066_I220_n2 I1_I2066_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I220_MN4 (I1_ru17 XI1_I2066_I220_An XI1_I2066_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I220_MN2 (XI1_I2066_I220_n1 I1_I2066_pn17 I1_ru17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I220_MN3 (VSS XI1_I2066_I220_Bn XI1_I2066_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I220_MN0 (XI1_I2066_I220_An I1_I2066_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I211_MN1 (XI1_I2066_I211_Bn I1_I2066_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I211_MN5 (XI1_I2066_I211_n2 I1_I2066_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I211_MN4 (I1_ru8 XI1_I2066_I211_An XI1_I2066_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I211_MN2 (XI1_I2066_I211_n1 I1_I2066_pn8 I1_ru8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I211_MN3 (VSS XI1_I2066_I211_Bn XI1_I2066_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I211_MN0 (XI1_I2066_I211_An I1_I2066_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2198_MN1 (XI1_I2198_Bn I1_nrkn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2198_MN5 (XI1_I2198_n2 I1_nrkn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2198_MN4 (DIVR_10 XI1_I2198_An XI1_I2198_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2198_MN2 (XI1_I2198_n1 I1_ru10 DIVR_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2198_MN3 (VSS XI1_I2198_Bn XI1_I2198_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2198_MN0 (XI1_I2198_An I1_ru10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2195_MN1 (XI1_I2195_Bn I1_nrkn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2195_MN5 (XI1_I2195_n2 I1_nrkn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2195_MN4 (DIVR_9 XI1_I2195_An XI1_I2195_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2195_MN2 (XI1_I2195_n1 I1_ru9 DIVR_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2195_MN3 (VSS XI1_I2195_Bn XI1_I2195_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2195_MN0 (XI1_I2195_An I1_ru9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I111_MN1 (XI0_I1660_I111_Bn I0_fa291_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I111_MN5 (XI0_I1660_I111_n2 I0_fa291_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I111_MN4 (I0_I1660_pn47 XI0_I1660_I111_An XI0_I1660_I111_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I111_MN2 (XI0_I1660_I111_n1 I0_ha290_1 I0_I1660_pn47 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I111_MN3 (VSS XI0_I1660_I111_Bn XI0_I1660_I111_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I111_MN0 (XI0_I1660_I111_An I0_ha290_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I50_MN1 (XI1_I1850_I50_Bn I1_b28_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I50_MN5 (XI1_I1850_I50_n2 I1_b28_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I50_MN4 (I1_I1850_pn18 XI1_I1850_I50_An XI1_I1850_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I50_MN2 (XI1_I1850_I50_n1 I1_p27_17 I1_I1850_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I50_MN3 (VSS XI1_I1850_I50_Bn XI1_I1850_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I50_MN0 (XI1_I1850_I50_An I1_p27_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I220_MN1 (XI1_I1850_I220_Bn I1_I1850_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I220_MN5 (XI1_I1850_I220_n2 I1_I1850_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I220_MN4 (I1_p28_17 XI1_I1850_I220_An XI1_I1850_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I220_MN2 (XI1_I1850_I220_n1 I1_I1850_pn17 I1_p28_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I220_MN3 (VSS XI1_I1850_I220_Bn XI1_I1850_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I220_MN0 (XI1_I1850_I220_An I1_I1850_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I51_MN1 (XI1_I1896_I51_Bn I1_b29_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I51_MN5 (XI1_I1896_I51_n2 I1_b29_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I51_MN4 (I1_I1896_pn19 XI1_I1896_I51_An XI1_I1896_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I51_MN2 (XI1_I1896_I51_n1 I1_p28_18 I1_I1896_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I51_MN3 (VSS XI1_I1896_I51_Bn XI1_I1896_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I51_MN0 (XI1_I1896_I51_An I1_p28_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I50_MN1 (XI1_I1896_I50_Bn I1_b29_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I50_MN5 (XI1_I1896_I50_n2 I1_b29_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I50_MN4 (I1_I1896_pn18 XI1_I1896_I50_An XI1_I1896_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I50_MN2 (XI1_I1896_I50_n1 I1_p28_17 I1_I1896_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I50_MN3 (VSS XI1_I1896_I50_Bn XI1_I1896_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I50_MN0 (XI1_I1896_I50_An I1_p28_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I221_MN1 (XI1_I1896_I221_Bn I1_I1896_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I221_MN5 (XI1_I1896_I221_n2 I1_I1896_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I221_MN4 (I1_p29_18 XI1_I1896_I221_An XI1_I1896_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I221_MN2 (XI1_I1896_I221_n1 I1_I1896_pn18 I1_p29_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I221_MN3 (VSS XI1_I1896_I221_Bn XI1_I1896_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I221_MN0 (XI1_I1896_I221_An I1_I1896_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I222_MN1 (XI1_I1896_I222_Bn I1_I1896_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I222_MN5 (XI1_I1896_I222_n2 I1_I1896_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I222_MN4 (I1_p29_19 XI1_I1896_I222_An XI1_I1896_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I222_MN2 (XI1_I1896_I222_n1 I1_I1896_pn19 I1_p29_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I222_MN3 (VSS XI1_I1896_I222_Bn XI1_I1896_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I222_MN0 (XI1_I1896_I222_An I1_I1896_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I51_MN1 (XI1_I1942_I51_Bn I1_b30_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I51_MN5 (XI1_I1942_I51_n2 I1_b30_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I51_MN4 (I1_I1942_pn19 XI1_I1942_I51_An XI1_I1942_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I51_MN2 (XI1_I1942_I51_n1 I1_p29_18 I1_I1942_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I51_MN3 (VSS XI1_I1942_I51_Bn XI1_I1942_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I51_MN0 (XI1_I1942_I51_An I1_p29_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I52_MN1 (XI1_I1942_I52_Bn I1_b30_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I52_MN5 (XI1_I1942_I52_n2 I1_b30_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I52_MN4 (I1_I1942_pn20 XI1_I1942_I52_An XI1_I1942_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I52_MN2 (XI1_I1942_I52_n1 I1_p29_19 I1_I1942_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I52_MN3 (VSS XI1_I1942_I52_Bn XI1_I1942_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I52_MN0 (XI1_I1942_I52_An I1_p29_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I223_MN1 (XI1_I1942_I223_Bn I1_I1942_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I223_MN5 (XI1_I1942_I223_n2 I1_I1942_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I223_MN4 (I1_p30_20 XI1_I1942_I223_An XI1_I1942_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I223_MN2 (XI1_I1942_I223_n1 I1_I1942_pn20 I1_p30_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I223_MN3 (VSS XI1_I1942_I223_Bn XI1_I1942_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I223_MN0 (XI1_I1942_I223_An I1_I1942_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I222_MN1 (XI1_I1942_I222_Bn I1_I1942_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I222_MN5 (XI1_I1942_I222_n2 I1_I1942_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I222_MN4 (I1_p30_19 XI1_I1942_I222_An XI1_I1942_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I222_MN2 (XI1_I1942_I222_n1 I1_I1942_pn19 I1_p30_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I222_MN3 (VSS XI1_I1942_I222_Bn XI1_I1942_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I222_MN0 (XI1_I1942_I222_An I1_I1942_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I53_MN1 (XI1_I1988_I53_Bn I1_b31_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I53_MN5 (XI1_I1988_I53_n2 I1_b31_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I53_MN4 (I1_I1988_pn21 XI1_I1988_I53_An XI1_I1988_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I53_MN2 (XI1_I1988_I53_n1 I1_p30_20 I1_I1988_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I53_MN3 (VSS XI1_I1988_I53_Bn XI1_I1988_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I53_MN0 (XI1_I1988_I53_An I1_p30_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I52_MN1 (XI1_I1988_I52_Bn I1_b31_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I52_MN5 (XI1_I1988_I52_n2 I1_b31_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I52_MN4 (I1_I1988_pn20 XI1_I1988_I52_An XI1_I1988_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I52_MN2 (XI1_I1988_I52_n1 I1_p30_19 I1_I1988_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I52_MN3 (VSS XI1_I1988_I52_Bn XI1_I1988_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I52_MN0 (XI1_I1988_I52_An I1_p30_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I223_MN1 (XI1_I1988_I223_Bn I1_I1988_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I223_MN5 (XI1_I1988_I223_n2 I1_I1988_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I223_MN4 (I1_p31_20 XI1_I1988_I223_An XI1_I1988_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I223_MN2 (XI1_I1988_I223_n1 I1_I1988_pn20 I1_p31_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I223_MN3 (VSS XI1_I1988_I223_Bn XI1_I1988_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I223_MN0 (XI1_I1988_I223_An I1_I1988_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I50_MN1 (XI1_I2066_I50_Bn I1_dm18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I50_MN5 (XI1_I2066_I50_n2 I1_dm18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I50_MN4 (I1_I2066_pn18 XI1_I2066_I50_An XI1_I2066_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I50_MN2 (XI1_I2066_I50_n1 I1_p31_18 I1_I2066_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I50_MN3 (VSS XI1_I2066_I50_Bn XI1_I2066_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I50_MN0 (XI1_I2066_I50_An I1_p31_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I222_MN1 (XI1_I1988_I222_Bn I1_I1988_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I222_MN5 (XI1_I1988_I222_n2 I1_I1988_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I222_MN4 (I1_p31_19 XI1_I1988_I222_An XI1_I1988_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I222_MN2 (XI1_I1988_I222_n1 I1_I1988_pn19 I1_p31_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I222_MN3 (VSS XI1_I1988_I222_Bn XI1_I1988_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I222_MN0 (XI1_I1988_I222_An I1_I1988_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I221_MN1 (XI1_I2066_I221_Bn I1_I2066_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I221_MN5 (XI1_I2066_I221_n2 I1_I2066_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I221_MN4 (I1_ru18 XI1_I2066_I221_An XI1_I2066_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I221_MN2 (XI1_I2066_I221_n1 I1_I2066_pn18 I1_ru18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I221_MN3 (VSS XI1_I2066_I221_Bn XI1_I2066_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I221_MN0 (XI1_I2066_I221_An I1_I2066_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2201_MN1 (XI1_I2201_Bn I1_nrkn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2201_MN5 (XI1_I2201_n2 I1_nrkn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2201_MN4 (DIVR_11 XI1_I2201_An XI1_I2201_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2201_MN2 (XI1_I2201_n1 I1_ru11 DIVR_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2201_MN3 (VSS XI1_I2201_Bn XI1_I2201_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2201_MN0 (XI1_I2201_An I1_ru11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2207_MN1 (XI1_I2207_Bn I1_nrkn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2207_MN5 (XI1_I2207_n2 I1_nrkn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2207_MN4 (DIVR_13 XI1_I2207_An XI1_I2207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2207_MN2 (XI1_I2207_n1 I1_ru13 DIVR_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2207_MN3 (VSS XI1_I2207_Bn XI1_I2207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2207_MN0 (XI1_I2207_An I1_ru13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2204_MN1 (XI1_I2204_Bn I1_nrkn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2204_MN5 (XI1_I2204_n2 I1_nrkn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2204_MN4 (DIVR_12 XI1_I2204_An XI1_I2204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2204_MN2 (XI1_I2204_n1 I1_ru12 DIVR_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2204_MN3 (VSS XI1_I2204_Bn XI1_I2204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2204_MN0 (XI1_I2204_An I1_ru12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I112_MN1 (XI0_I1660_I112_Bn I0_ha292_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I112_MN5 (XI0_I1660_I112_n2 I0_ha292_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I112_MN4 (I0_I1660_pn48 XI0_I1660_I112_An XI0_I1660_I112_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I112_MN2 (XI0_I1660_I112_n1 I0_fa291_1 I0_I1660_pn48 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I112_MN3 (VSS XI0_I1660_I112_Bn XI0_I1660_I112_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I112_MN0 (XI0_I1660_I112_An I0_fa291_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I223_MN1 (XI1_I1850_I223_Bn I1_I1850_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I223_MN5 (XI1_I1850_I223_n2 I1_I1850_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I223_MN4 (I1_p28_20 XI1_I1850_I223_An XI1_I1850_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I223_MN2 (XI1_I1850_I223_n1 I1_I1850_pn20 I1_p28_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I223_MN3 (VSS XI1_I1850_I223_Bn XI1_I1850_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I223_MN0 (XI1_I1850_I223_An I1_I1850_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I53_MN1 (XI1_I1850_I53_Bn I1_b28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I53_MN5 (XI1_I1850_I53_n2 I1_b28_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I53_MN4 (I1_I1850_pn21 XI1_I1850_I53_An XI1_I1850_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I53_MN2 (XI1_I1850_I53_n1 I1_p27_20 I1_I1850_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I53_MN3 (VSS XI1_I1850_I53_Bn XI1_I1850_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I53_MN0 (XI1_I1850_I53_An I1_p27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I52_MN1 (XI1_I1850_I52_Bn I1_b28_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I52_MN5 (XI1_I1850_I52_n2 I1_b28_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I52_MN4 (I1_I1850_pn20 XI1_I1850_I52_An XI1_I1850_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I52_MN2 (XI1_I1850_I52_n1 I1_p27_19 I1_I1850_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I52_MN3 (VSS XI1_I1850_I52_Bn XI1_I1850_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I52_MN0 (XI1_I1850_I52_An I1_p27_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I51_MN1 (XI1_I1850_I51_Bn I1_b28_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I51_MN5 (XI1_I1850_I51_n2 I1_b28_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I51_MN4 (I1_I1850_pn19 XI1_I1850_I51_An XI1_I1850_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I51_MN2 (XI1_I1850_I51_n1 I1_p27_18 I1_I1850_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I51_MN3 (VSS XI1_I1850_I51_Bn XI1_I1850_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I51_MN0 (XI1_I1850_I51_An I1_p27_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I222_MN1 (XI1_I1850_I222_Bn I1_I1850_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I222_MN5 (XI1_I1850_I222_n2 I1_I1850_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I222_MN4 (I1_p28_19 XI1_I1850_I222_An XI1_I1850_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I222_MN2 (XI1_I1850_I222_n1 I1_I1850_pn19 I1_p28_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I222_MN3 (VSS XI1_I1850_I222_Bn XI1_I1850_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I222_MN0 (XI1_I1850_I222_An I1_I1850_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I52_MN1 (XI1_I1896_I52_Bn I1_b29_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I52_MN5 (XI1_I1896_I52_n2 I1_b29_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I52_MN4 (I1_I1896_pn20 XI1_I1896_I52_An XI1_I1896_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I52_MN2 (XI1_I1896_I52_n1 I1_p28_19 I1_I1896_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I52_MN3 (VSS XI1_I1896_I52_Bn XI1_I1896_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I52_MN0 (XI1_I1896_I52_An I1_p28_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I223_MN1 (XI1_I1896_I223_Bn I1_I1896_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I223_MN5 (XI1_I1896_I223_n2 I1_I1896_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I223_MN4 (I1_p29_20 XI1_I1896_I223_An XI1_I1896_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I223_MN2 (XI1_I1896_I223_n1 I1_I1896_pn20 I1_p29_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I223_MN3 (VSS XI1_I1896_I223_Bn XI1_I1896_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I223_MN0 (XI1_I1896_I223_An I1_I1896_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I224_MN1 (XI1_I1896_I224_Bn I1_I1896_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I224_MN5 (XI1_I1896_I224_n2 I1_I1896_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I224_MN4 (I1_p29_21 XI1_I1896_I224_An XI1_I1896_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I224_MN2 (XI1_I1896_I224_n1 I1_I1896_pn21 I1_p29_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I224_MN3 (VSS XI1_I1896_I224_Bn XI1_I1896_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I224_MN0 (XI1_I1896_I224_An I1_I1896_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I53_MN1 (XI1_I1942_I53_Bn I1_b30_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I53_MN5 (XI1_I1942_I53_n2 I1_b30_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I53_MN4 (I1_I1942_pn21 XI1_I1942_I53_An XI1_I1942_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I53_MN2 (XI1_I1942_I53_n1 I1_p29_20 I1_I1942_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I53_MN3 (VSS XI1_I1942_I53_Bn XI1_I1942_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I53_MN0 (XI1_I1942_I53_An I1_p29_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I224_MN1 (XI1_I1942_I224_Bn I1_I1942_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I224_MN5 (XI1_I1942_I224_n2 I1_I1942_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I224_MN4 (I1_p30_21 XI1_I1942_I224_An XI1_I1942_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I224_MN2 (XI1_I1942_I224_n1 I1_I1942_pn21 I1_p30_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I224_MN3 (VSS XI1_I1942_I224_Bn XI1_I1942_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I224_MN0 (XI1_I1942_I224_An I1_I1942_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I54_MN1 (XI1_I1988_I54_Bn I1_b31_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I54_MN5 (XI1_I1988_I54_n2 I1_b31_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I54_MN4 (I1_I1988_pn22 XI1_I1988_I54_An XI1_I1988_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I54_MN2 (XI1_I1988_I54_n1 I1_p30_21 I1_I1988_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I54_MN3 (VSS XI1_I1988_I54_Bn XI1_I1988_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I54_MN0 (XI1_I1988_I54_An I1_p30_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I225_MN1 (XI1_I1988_I225_Bn I1_I1988_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I225_MN5 (XI1_I1988_I225_n2 I1_I1988_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I225_MN4 (I1_p31_22 XI1_I1988_I225_An XI1_I1988_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I225_MN2 (XI1_I1988_I225_n1 I1_I1988_pn22 I1_p31_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I225_MN3 (VSS XI1_I1988_I225_Bn XI1_I1988_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I225_MN0 (XI1_I1988_I225_An I1_I1988_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I224_MN1 (XI1_I1988_I224_Bn I1_I1988_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I224_MN5 (XI1_I1988_I224_n2 I1_I1988_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I224_MN4 (I1_p31_21 XI1_I1988_I224_An XI1_I1988_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I224_MN2 (XI1_I1988_I224_n1 I1_I1988_pn21 I1_p31_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I224_MN3 (VSS XI1_I1988_I224_Bn XI1_I1988_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I224_MN0 (XI1_I1988_I224_An I1_I1988_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I51_MN1 (XI1_I2066_I51_Bn I1_dm19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I51_MN5 (XI1_I2066_I51_n2 I1_dm19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I51_MN4 (I1_I2066_pn19 XI1_I2066_I51_An XI1_I2066_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I51_MN2 (XI1_I2066_I51_n1 I1_p31_19 I1_I2066_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I51_MN3 (VSS XI1_I2066_I51_Bn XI1_I2066_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I51_MN0 (XI1_I2066_I51_An I1_p31_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I222_MN1 (XI1_I2066_I222_Bn I1_I2066_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I222_MN5 (XI1_I2066_I222_n2 I1_I2066_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I222_MN4 (I1_ru19 XI1_I2066_I222_An XI1_I2066_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I222_MN2 (XI1_I2066_I222_n1 I1_I2066_pn19 I1_ru19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I222_MN3 (VSS XI1_I2066_I222_Bn XI1_I2066_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I222_MN0 (XI1_I2066_I222_An I1_I2066_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I223_MN1 (XI1_I2066_I223_Bn I1_I2066_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I223_MN5 (XI1_I2066_I223_n2 I1_I2066_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I223_MN4 (I1_ru20 XI1_I2066_I223_An XI1_I2066_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I223_MN2 (XI1_I2066_I223_n1 I1_I2066_pn20 I1_ru20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I223_MN3 (VSS XI1_I2066_I223_Bn XI1_I2066_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I223_MN0 (XI1_I2066_I223_An I1_I2066_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2210_MN1 (XI1_I2210_Bn I1_nrkn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2210_MN5 (XI1_I2210_n2 I1_nrkn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2210_MN4 (DIVR_14 XI1_I2210_An XI1_I2210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2210_MN2 (XI1_I2210_n1 I1_ru14 DIVR_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2210_MN3 (VSS XI1_I2210_Bn XI1_I2210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2210_MN0 (XI1_I2210_An I1_ru14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2222_MN1 (XI1_I2222_Bn I1_nrkn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2222_MN5 (XI1_I2222_n2 I1_nrkn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2222_MN4 (DIVR_18 XI1_I2222_An XI1_I2222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2222_MN2 (XI1_I2222_n1 I1_ru18 DIVR_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2222_MN3 (VSS XI1_I2222_Bn XI1_I2222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2222_MN0 (XI1_I2222_An I1_ru18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I113_MN1 (XI0_I1660_I113_Bn I0_fa293_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I113_MN5 (XI0_I1660_I113_n2 I0_fa293_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I113_MN4 (I0_I1660_pn49 XI0_I1660_I113_An XI0_I1660_I113_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I113_MN2 (XI0_I1660_I113_n1 I0_ha292_1 I0_I1660_pn49 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I113_MN3 (VSS XI0_I1660_I113_Bn XI0_I1660_I113_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I113_MN0 (XI0_I1660_I113_An I0_ha292_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I55_MN1 (XI1_I1850_I55_Bn I1_b28_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I55_MN5 (XI1_I1850_I55_n2 I1_b28_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I55_MN4 (I1_I1850_pn23 XI1_I1850_I55_An XI1_I1850_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I55_MN2 (XI1_I1850_I55_n1 I1_p27_22 I1_I1850_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I55_MN3 (VSS XI1_I1850_I55_Bn XI1_I1850_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I55_MN0 (XI1_I1850_I55_An I1_p27_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I54_MN1 (XI1_I1850_I54_Bn I1_b28_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I54_MN5 (XI1_I1850_I54_n2 I1_b28_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I54_MN4 (I1_I1850_pn22 XI1_I1850_I54_An XI1_I1850_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I54_MN2 (XI1_I1850_I54_n1 I1_p27_21 I1_I1850_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I54_MN3 (VSS XI1_I1850_I54_Bn XI1_I1850_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I54_MN0 (XI1_I1850_I54_An I1_p27_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I224_MN1 (XI1_I1850_I224_Bn I1_I1850_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I224_MN5 (XI1_I1850_I224_n2 I1_I1850_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I224_MN4 (I1_p28_21 XI1_I1850_I224_An XI1_I1850_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I224_MN2 (XI1_I1850_I224_n1 I1_I1850_pn21 I1_p28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I224_MN3 (VSS XI1_I1850_I224_Bn XI1_I1850_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I224_MN0 (XI1_I1850_I224_An I1_I1850_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I53_MN1 (XI1_I1896_I53_Bn I1_b29_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I53_MN5 (XI1_I1896_I53_n2 I1_b29_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I53_MN4 (I1_I1896_pn21 XI1_I1896_I53_An XI1_I1896_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I53_MN2 (XI1_I1896_I53_n1 I1_p28_20 I1_I1896_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I53_MN3 (VSS XI1_I1896_I53_Bn XI1_I1896_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I53_MN0 (XI1_I1896_I53_An I1_p28_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I54_MN1 (XI1_I1896_I54_Bn I1_b29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I54_MN5 (XI1_I1896_I54_n2 I1_b29_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I54_MN4 (I1_I1896_pn22 XI1_I1896_I54_An XI1_I1896_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I54_MN2 (XI1_I1896_I54_n1 I1_p28_21 I1_I1896_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I54_MN3 (VSS XI1_I1896_I54_Bn XI1_I1896_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I54_MN0 (XI1_I1896_I54_An I1_p28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I225_MN1 (XI1_I1896_I225_Bn I1_I1896_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I225_MN5 (XI1_I1896_I225_n2 I1_I1896_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I225_MN4 (I1_p29_22 XI1_I1896_I225_An XI1_I1896_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I225_MN2 (XI1_I1896_I225_n1 I1_I1896_pn22 I1_p29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I225_MN3 (VSS XI1_I1896_I225_Bn XI1_I1896_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I225_MN0 (XI1_I1896_I225_An I1_I1896_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I54_MN1 (XI1_I1942_I54_Bn I1_b30_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I54_MN5 (XI1_I1942_I54_n2 I1_b30_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I54_MN4 (I1_I1942_pn22 XI1_I1942_I54_An XI1_I1942_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I54_MN2 (XI1_I1942_I54_n1 I1_p29_21 I1_I1942_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I54_MN3 (VSS XI1_I1942_I54_Bn XI1_I1942_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I54_MN0 (XI1_I1942_I54_An I1_p29_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I225_MN1 (XI1_I1942_I225_Bn I1_I1942_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I225_MN5 (XI1_I1942_I225_n2 I1_I1942_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I225_MN4 (I1_p30_22 XI1_I1942_I225_An XI1_I1942_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I225_MN2 (XI1_I1942_I225_n1 I1_I1942_pn22 I1_p30_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I225_MN3 (VSS XI1_I1942_I225_Bn XI1_I1942_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I225_MN0 (XI1_I1942_I225_An I1_I1942_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I226_MN1 (XI1_I1942_I226_Bn I1_I1942_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I226_MN5 (XI1_I1942_I226_n2 I1_I1942_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I226_MN4 (I1_p30_23 XI1_I1942_I226_An XI1_I1942_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I226_MN2 (XI1_I1942_I226_n1 I1_I1942_pn23 I1_p30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I226_MN3 (VSS XI1_I1942_I226_Bn XI1_I1942_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I226_MN0 (XI1_I1942_I226_An I1_I1942_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I55_MN1 (XI1_I1988_I55_Bn I1_b31_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I55_MN5 (XI1_I1988_I55_n2 I1_b31_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I55_MN4 (I1_I1988_pn23 XI1_I1988_I55_An XI1_I1988_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I55_MN2 (XI1_I1988_I55_n1 I1_p30_22 I1_I1988_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I55_MN3 (VSS XI1_I1988_I55_Bn XI1_I1988_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I55_MN0 (XI1_I1988_I55_An I1_p30_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I226_MN1 (XI1_I1988_I226_Bn I1_I1988_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I226_MN5 (XI1_I1988_I226_n2 I1_I1988_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I226_MN4 (I1_p31_23 XI1_I1988_I226_An XI1_I1988_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I226_MN2 (XI1_I1988_I226_n1 I1_I1988_pn23 I1_p31_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I226_MN3 (VSS XI1_I1988_I226_Bn XI1_I1988_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I226_MN0 (XI1_I1988_I226_An I1_I1988_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I52_MN1 (XI1_I2066_I52_Bn I1_dm20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I52_MN5 (XI1_I2066_I52_n2 I1_dm20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I52_MN4 (I1_I2066_pn20 XI1_I2066_I52_An XI1_I2066_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I52_MN2 (XI1_I2066_I52_n1 I1_p31_20 I1_I2066_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I52_MN3 (VSS XI1_I2066_I52_Bn XI1_I2066_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I52_MN0 (XI1_I2066_I52_An I1_p31_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I53_MN1 (XI1_I2066_I53_Bn I1_dm21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I53_MN5 (XI1_I2066_I53_n2 I1_dm21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I53_MN4 (I1_I2066_pn21 XI1_I2066_I53_An XI1_I2066_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I53_MN2 (XI1_I2066_I53_n1 I1_p31_21 I1_I2066_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I53_MN3 (VSS XI1_I2066_I53_Bn XI1_I2066_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I53_MN0 (XI1_I2066_I53_An I1_p31_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I224_MN1 (XI1_I2066_I224_Bn I1_I2066_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I224_MN5 (XI1_I2066_I224_n2 I1_I2066_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I224_MN4 (I1_ru21 XI1_I2066_I224_An XI1_I2066_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I224_MN2 (XI1_I2066_I224_n1 I1_I2066_pn21 I1_ru21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I224_MN3 (VSS XI1_I2066_I224_Bn XI1_I2066_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I224_MN0 (XI1_I2066_I224_An I1_I2066_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I225_MN1 (XI1_I2066_I225_Bn I1_I2066_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I225_MN5 (XI1_I2066_I225_n2 I1_I2066_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I225_MN4 (I1_ru22 XI1_I2066_I225_An XI1_I2066_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I225_MN2 (XI1_I2066_I225_n1 I1_I2066_pn22 I1_ru22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I225_MN3 (VSS XI1_I2066_I225_Bn XI1_I2066_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I225_MN0 (XI1_I2066_I225_An I1_I2066_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2225_MN1 (XI1_I2225_Bn I1_nrkn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2225_MN5 (XI1_I2225_n2 I1_nrkn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2225_MN4 (DIVR_19 XI1_I2225_An XI1_I2225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2225_MN2 (XI1_I2225_n1 I1_ru19 DIVR_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2225_MN3 (VSS XI1_I2225_Bn XI1_I2225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2225_MN0 (XI1_I2225_An I1_ru19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2219_MN1 (XI1_I2219_Bn I1_nrkn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2219_MN5 (XI1_I2219_n2 I1_nrkn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2219_MN4 (DIVR_17 XI1_I2219_An XI1_I2219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2219_MN2 (XI1_I2219_n1 I1_ru17 DIVR_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2219_MN3 (VSS XI1_I2219_Bn XI1_I2219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2219_MN0 (XI1_I2219_An I1_ru17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I122_MN1 (XI0_I1660_I122_Bn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I122_MN5 (XI0_I1660_I122_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I122_MN4 (I0_I1660_pn58 XI0_I1660_I122_An XI0_I1660_I122_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I122_MN2 (XI0_I1660_I122_n1 I0_fa298_0 I0_I1660_pn58 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I122_MN3 (VSS XI0_I1660_I122_Bn XI0_I1660_I122_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I122_MN0 (XI0_I1660_I122_An I0_fa298_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I225_MN1 (XI1_I1850_I225_Bn I1_I1850_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I225_MN5 (XI1_I1850_I225_n2 I1_I1850_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I225_MN4 (I1_p28_22 XI1_I1850_I225_An XI1_I1850_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I225_MN2 (XI1_I1850_I225_n1 I1_I1850_pn22 I1_p28_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I225_MN3 (VSS XI1_I1850_I225_Bn XI1_I1850_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I225_MN0 (XI1_I1850_I225_An I1_I1850_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I226_MN1 (XI1_I1850_I226_Bn I1_I1850_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I226_MN5 (XI1_I1850_I226_n2 I1_I1850_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I226_MN4 (I1_p28_23 XI1_I1850_I226_An XI1_I1850_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I226_MN2 (XI1_I1850_I226_n1 I1_I1850_pn23 I1_p28_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I226_MN3 (VSS XI1_I1850_I226_Bn XI1_I1850_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I226_MN0 (XI1_I1850_I226_An I1_I1850_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I56_MN1 (XI1_I1896_I56_Bn I1_b29_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I56_MN5 (XI1_I1896_I56_n2 I1_b29_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I56_MN4 (I1_I1896_pn24 XI1_I1896_I56_An XI1_I1896_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I56_MN2 (XI1_I1896_I56_n1 I1_p28_23 I1_I1896_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I56_MN3 (VSS XI1_I1896_I56_Bn XI1_I1896_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I56_MN0 (XI1_I1896_I56_An I1_p28_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I55_MN1 (XI1_I1896_I55_Bn I1_b29_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I55_MN5 (XI1_I1896_I55_n2 I1_b29_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I55_MN4 (I1_I1896_pn23 XI1_I1896_I55_An XI1_I1896_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I55_MN2 (XI1_I1896_I55_n1 I1_p28_22 I1_I1896_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I55_MN3 (VSS XI1_I1896_I55_Bn XI1_I1896_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I55_MN0 (XI1_I1896_I55_An I1_p28_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I226_MN1 (XI1_I1896_I226_Bn I1_I1896_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I226_MN5 (XI1_I1896_I226_n2 I1_I1896_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I226_MN4 (I1_p29_23 XI1_I1896_I226_An XI1_I1896_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I226_MN2 (XI1_I1896_I226_n1 I1_I1896_pn23 I1_p29_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I226_MN3 (VSS XI1_I1896_I226_Bn XI1_I1896_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I226_MN0 (XI1_I1896_I226_An I1_I1896_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I55_MN1 (XI1_I1942_I55_Bn I1_b30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I55_MN5 (XI1_I1942_I55_n2 I1_b30_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I55_MN4 (I1_I1942_pn23 XI1_I1942_I55_An XI1_I1942_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I55_MN2 (XI1_I1942_I55_n1 I1_p29_22 I1_I1942_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I55_MN3 (VSS XI1_I1942_I55_Bn XI1_I1942_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I55_MN0 (XI1_I1942_I55_An I1_p29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I56_MN1 (XI1_I1942_I56_Bn I1_b30_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I56_MN5 (XI1_I1942_I56_n2 I1_b30_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I56_MN4 (I1_I1942_pn24 XI1_I1942_I56_An XI1_I1942_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I56_MN2 (XI1_I1942_I56_n1 I1_p29_23 I1_I1942_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I56_MN3 (VSS XI1_I1942_I56_Bn XI1_I1942_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I56_MN0 (XI1_I1942_I56_An I1_p29_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I227_MN1 (XI1_I1942_I227_Bn I1_I1942_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I227_MN5 (XI1_I1942_I227_n2 I1_I1942_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I227_MN4 (I1_p30_24 XI1_I1942_I227_An XI1_I1942_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I227_MN2 (XI1_I1942_I227_n1 I1_I1942_pn24 I1_p30_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I227_MN3 (VSS XI1_I1942_I227_Bn XI1_I1942_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I227_MN0 (XI1_I1942_I227_An I1_I1942_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I234_MN1 (XI1_I1942_I234_Bn I1_c30_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I234_MN5 (XI1_I1942_I234_n2 I1_c30_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I234_MN4 (I1_p30_31 XI1_I1942_I234_An XI1_I1942_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I234_MN2 (XI1_I1942_I234_n1 I1_I1942_pn31 I1_p30_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I234_MN3 (VSS XI1_I1942_I234_Bn XI1_I1942_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I234_MN0 (XI1_I1942_I234_An I1_I1942_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I56_MN1 (XI1_I1988_I56_Bn I1_b31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I56_MN5 (XI1_I1988_I56_n2 I1_b31_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I56_MN4 (I1_I1988_pn24 XI1_I1988_I56_An XI1_I1988_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I56_MN2 (XI1_I1988_I56_n1 I1_p30_23 I1_I1988_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I56_MN3 (VSS XI1_I1988_I56_Bn XI1_I1988_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I56_MN0 (XI1_I1988_I56_An I1_p30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I227_MN1 (XI1_I1988_I227_Bn I1_I1988_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I227_MN5 (XI1_I1988_I227_n2 I1_I1988_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I227_MN4 (I1_p31_24 XI1_I1988_I227_An XI1_I1988_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I227_MN2 (XI1_I1988_I227_n1 I1_I1988_pn24 I1_p31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I227_MN3 (VSS XI1_I1988_I227_Bn XI1_I1988_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I227_MN0 (XI1_I1988_I227_An I1_I1988_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I228_MN1 (XI1_I1988_I228_Bn I1_I1988_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I228_MN5 (XI1_I1988_I228_n2 I1_I1988_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I228_MN4 (I1_p31_25 XI1_I1988_I228_An XI1_I1988_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I228_MN2 (XI1_I1988_I228_n1 I1_I1988_pn25 I1_p31_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I228_MN3 (VSS XI1_I1988_I228_Bn XI1_I1988_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I228_MN0 (XI1_I1988_I228_An I1_I1988_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I54_MN1 (XI1_I2066_I54_Bn I1_dm22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I54_MN5 (XI1_I2066_I54_n2 I1_dm22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I54_MN4 (I1_I2066_pn22 XI1_I2066_I54_An XI1_I2066_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I54_MN2 (XI1_I2066_I54_n1 I1_p31_22 I1_I2066_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I54_MN3 (VSS XI1_I2066_I54_Bn XI1_I2066_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I54_MN0 (XI1_I2066_I54_An I1_p31_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2231_MN1 (XI1_I2231_Bn I1_nrkn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2231_MN5 (XI1_I2231_n2 I1_nrkn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2231_MN4 (DIVR_21 XI1_I2231_An XI1_I2231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2231_MN2 (XI1_I2231_n1 I1_ru21 DIVR_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2231_MN3 (VSS XI1_I2231_Bn XI1_I2231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2231_MN0 (XI1_I2231_An I1_ru21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2228_MN1 (XI1_I2228_Bn I1_nrkn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2228_MN5 (XI1_I2228_n2 I1_nrkn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2228_MN4 (DIVR_20 XI1_I2228_An XI1_I2228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2228_MN2 (XI1_I2228_n1 I1_ru20 DIVR_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2228_MN3 (VSS XI1_I2228_Bn XI1_I2228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2228_MN0 (XI1_I2228_An I1_ru20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2213_MN1 (XI1_I2213_Bn I1_nrkn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2213_MN5 (XI1_I2213_n2 I1_nrkn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2213_MN4 (DIVR_15 XI1_I2213_An XI1_I2213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2213_MN2 (XI1_I2213_n1 I1_ru15 DIVR_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2213_MN3 (VSS XI1_I2213_Bn XI1_I2213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2213_MN0 (XI1_I2213_An I1_ru15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2216_MN1 (XI1_I2216_Bn I1_nrkn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2216_MN5 (XI1_I2216_n2 I1_nrkn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2216_MN4 (DIVR_16 XI1_I2216_An XI1_I2216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2216_MN2 (XI1_I2216_n1 I1_ru16 DIVR_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2216_MN3 (VSS XI1_I2216_Bn XI1_I2216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2216_MN0 (XI1_I2216_An I1_ru16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I120_MN1 (XI0_I1660_I120_Bn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I120_MN5 (XI0_I1660_I120_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I120_MN4 (I0_I1660_pn56 XI0_I1660_I120_An XI0_I1660_I120_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I120_MN2 (XI0_I1660_I120_n1 I0_fa297_0 I0_I1660_pn56 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I120_MN3 (VSS XI0_I1660_I120_Bn XI0_I1660_I120_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I120_MN0 (XI0_I1660_I120_An I0_fa297_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I114_MN1 (XI0_I1660_I114_Bn I0_ha294_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I114_MN5 (XI0_I1660_I114_n2 I0_ha294_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I114_MN4 (I0_I1660_pn50 XI0_I1660_I114_An XI0_I1660_I114_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I114_MN2 (XI0_I1660_I114_n1 I0_fa293_1 I0_I1660_pn50 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I114_MN3 (VSS XI0_I1660_I114_Bn XI0_I1660_I114_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I114_MN0 (XI0_I1660_I114_An I0_fa293_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I123_MN1 (XI0_I1660_I123_Bn I0_fa207_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I123_MN5 (XI0_I1660_I123_n2 I0_fa207_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I123_MN4 (I0_I1660_pn59 XI0_I1660_I123_An XI0_I1660_I123_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I123_MN2 (XI0_I1660_I123_n1 I0_fa298_1 I0_I1660_pn59 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I123_MN3 (VSS XI0_I1660_I123_Bn XI0_I1660_I123_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I123_MN0 (XI0_I1660_I123_An I0_fa298_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I63_MN1 (XI1_I1850_I63_Bn I1_b28_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I63_MN5 (XI1_I1850_I63_n2 I1_b28_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I63_MN4 (I1_I1850_pn31 XI1_I1850_I63_An XI1_I1850_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I63_MN2 (XI1_I1850_I63_n1 I1_p27_30 I1_I1850_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I63_MN3 (VSS XI1_I1850_I63_Bn XI1_I1850_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I63_MN0 (XI1_I1850_I63_An I1_p27_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I62_MN1 (XI1_I1850_I62_Bn I1_b28_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I62_MN5 (XI1_I1850_I62_n2 I1_b28_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I62_MN4 (I1_I1850_pn30 XI1_I1850_I62_An XI1_I1850_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I62_MN2 (XI1_I1850_I62_n1 I1_p27_29 I1_I1850_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I62_MN3 (VSS XI1_I1850_I62_Bn XI1_I1850_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I62_MN0 (XI1_I1850_I62_An I1_p27_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I227_MN1 (XI1_I1850_I227_Bn I1_I1850_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I227_MN5 (XI1_I1850_I227_n2 I1_I1850_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I227_MN4 (I1_p28_24 XI1_I1850_I227_An XI1_I1850_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I227_MN2 (XI1_I1850_I227_n1 I1_I1850_pn24 I1_p28_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I227_MN3 (VSS XI1_I1850_I227_Bn XI1_I1850_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I227_MN0 (XI1_I1850_I227_An I1_I1850_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I57_MN1 (XI1_I1850_I57_Bn I1_b28_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I57_MN5 (XI1_I1850_I57_n2 I1_b28_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I57_MN4 (I1_I1850_pn25 XI1_I1850_I57_An XI1_I1850_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I57_MN2 (XI1_I1850_I57_n1 I1_p27_24 I1_I1850_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I57_MN3 (VSS XI1_I1850_I57_Bn XI1_I1850_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I57_MN0 (XI1_I1850_I57_An I1_p27_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I56_MN1 (XI1_I1850_I56_Bn I1_b28_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I56_MN5 (XI1_I1850_I56_n2 I1_b28_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I56_MN4 (I1_I1850_pn24 XI1_I1850_I56_An XI1_I1850_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I56_MN2 (XI1_I1850_I56_n1 I1_p27_23 I1_I1850_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I56_MN3 (VSS XI1_I1850_I56_Bn XI1_I1850_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I56_MN0 (XI1_I1850_I56_An I1_p27_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I228_MN1 (XI1_I1850_I228_Bn I1_I1850_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I228_MN5 (XI1_I1850_I228_n2 I1_I1850_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I228_MN4 (I1_p28_25 XI1_I1850_I228_An XI1_I1850_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I228_MN2 (XI1_I1850_I228_n1 I1_I1850_pn25 I1_p28_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I228_MN3 (VSS XI1_I1850_I228_Bn XI1_I1850_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I228_MN0 (XI1_I1850_I228_An I1_I1850_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I58_MN1 (XI1_I1896_I58_Bn I1_b29_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I58_MN5 (XI1_I1896_I58_n2 I1_b29_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I58_MN4 (I1_I1896_pn26 XI1_I1896_I58_An XI1_I1896_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I58_MN2 (XI1_I1896_I58_n1 I1_p28_25 I1_I1896_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I58_MN3 (VSS XI1_I1896_I58_Bn XI1_I1896_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I58_MN0 (XI1_I1896_I58_An I1_p28_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I57_MN1 (XI1_I1896_I57_Bn I1_b29_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I57_MN5 (XI1_I1896_I57_n2 I1_b29_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I57_MN4 (I1_I1896_pn25 XI1_I1896_I57_An XI1_I1896_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I57_MN2 (XI1_I1896_I57_n1 I1_p28_24 I1_I1896_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I57_MN3 (VSS XI1_I1896_I57_Bn XI1_I1896_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I57_MN0 (XI1_I1896_I57_An I1_p28_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I227_MN1 (XI1_I1896_I227_Bn I1_I1896_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I227_MN5 (XI1_I1896_I227_n2 I1_I1896_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I227_MN4 (I1_p29_24 XI1_I1896_I227_An XI1_I1896_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I227_MN2 (XI1_I1896_I227_n1 I1_I1896_pn24 I1_p29_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I227_MN3 (VSS XI1_I1896_I227_Bn XI1_I1896_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I227_MN0 (XI1_I1896_I227_An I1_I1896_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I228_MN1 (XI1_I1896_I228_Bn I1_I1896_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I228_MN5 (XI1_I1896_I228_n2 I1_I1896_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I228_MN4 (I1_p29_25 XI1_I1896_I228_An XI1_I1896_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I228_MN2 (XI1_I1896_I228_n1 I1_I1896_pn25 I1_p29_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I228_MN3 (VSS XI1_I1896_I228_Bn XI1_I1896_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I228_MN0 (XI1_I1896_I228_An I1_I1896_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I57_MN1 (XI1_I1942_I57_Bn I1_b30_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I57_MN5 (XI1_I1942_I57_n2 I1_b30_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I57_MN4 (I1_I1942_pn25 XI1_I1942_I57_An XI1_I1942_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I57_MN2 (XI1_I1942_I57_n1 I1_p29_24 I1_I1942_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I57_MN3 (VSS XI1_I1942_I57_Bn XI1_I1942_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I57_MN0 (XI1_I1942_I57_An I1_p29_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I58_MN1 (XI1_I1942_I58_Bn I1_b30_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I58_MN5 (XI1_I1942_I58_n2 I1_b30_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I58_MN4 (I1_I1942_pn26 XI1_I1942_I58_An XI1_I1942_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I58_MN2 (XI1_I1942_I58_n1 I1_p29_25 I1_I1942_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I58_MN3 (VSS XI1_I1942_I58_Bn XI1_I1942_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I58_MN0 (XI1_I1942_I58_An I1_p29_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I229_MN1 (XI1_I1942_I229_Bn I1_I1942_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I229_MN5 (XI1_I1942_I229_n2 I1_I1942_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I229_MN4 (I1_p30_26 XI1_I1942_I229_An XI1_I1942_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I229_MN2 (XI1_I1942_I229_n1 I1_I1942_pn26 I1_p30_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I229_MN3 (VSS XI1_I1942_I229_Bn XI1_I1942_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I229_MN0 (XI1_I1942_I229_An I1_I1942_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I228_MN1 (XI1_I1942_I228_Bn I1_I1942_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I228_MN5 (XI1_I1942_I228_n2 I1_I1942_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I228_MN4 (I1_p30_25 XI1_I1942_I228_An XI1_I1942_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I228_MN2 (XI1_I1942_I228_n1 I1_I1942_pn25 I1_p30_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I228_MN3 (VSS XI1_I1942_I228_Bn XI1_I1942_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I228_MN0 (XI1_I1942_I228_An I1_I1942_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I58_MN1 (XI1_I1988_I58_Bn I1_b31_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I58_MN5 (XI1_I1988_I58_n2 I1_b31_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I58_MN4 (I1_I1988_pn26 XI1_I1988_I58_An XI1_I1988_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I58_MN2 (XI1_I1988_I58_n1 I1_p30_25 I1_I1988_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I58_MN3 (VSS XI1_I1988_I58_Bn XI1_I1988_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I58_MN0 (XI1_I1988_I58_An I1_p30_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I57_MN1 (XI1_I1988_I57_Bn I1_b31_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I57_MN5 (XI1_I1988_I57_n2 I1_b31_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I57_MN4 (I1_I1988_pn25 XI1_I1988_I57_An XI1_I1988_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I57_MN2 (XI1_I1988_I57_n1 I1_p30_24 I1_I1988_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I57_MN3 (VSS XI1_I1988_I57_Bn XI1_I1988_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I57_MN0 (XI1_I1988_I57_An I1_p30_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I59_MN1 (XI1_I1988_I59_Bn I1_b31_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I59_MN5 (XI1_I1988_I59_n2 I1_b31_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I59_MN4 (I1_I1988_pn27 XI1_I1988_I59_An XI1_I1988_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I59_MN2 (XI1_I1988_I59_n1 I1_p30_26 I1_I1988_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I59_MN3 (VSS XI1_I1988_I59_Bn XI1_I1988_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I59_MN0 (XI1_I1988_I59_An I1_p30_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I229_MN1 (XI1_I1988_I229_Bn I1_I1988_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I229_MN5 (XI1_I1988_I229_n2 I1_I1988_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I229_MN4 (I1_p31_26 XI1_I1988_I229_An XI1_I1988_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I229_MN2 (XI1_I1988_I229_n1 I1_I1988_pn26 I1_p31_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I229_MN3 (VSS XI1_I1988_I229_Bn XI1_I1988_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I229_MN0 (XI1_I1988_I229_An I1_I1988_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I56_MN1 (XI1_I2066_I56_Bn I1_dm24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I56_MN5 (XI1_I2066_I56_n2 I1_dm24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I56_MN4 (I1_I2066_pn24 XI1_I2066_I56_An XI1_I2066_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I56_MN2 (XI1_I2066_I56_n1 I1_p31_24 I1_I2066_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I56_MN3 (VSS XI1_I2066_I56_Bn XI1_I2066_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I56_MN0 (XI1_I2066_I56_An I1_p31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I55_MN1 (XI1_I2066_I55_Bn I1_dm23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I55_MN5 (XI1_I2066_I55_n2 I1_dm23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I55_MN4 (I1_I2066_pn23 XI1_I2066_I55_An XI1_I2066_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I55_MN2 (XI1_I2066_I55_n1 I1_p31_23 I1_I2066_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I55_MN3 (VSS XI1_I2066_I55_Bn XI1_I2066_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I55_MN0 (XI1_I2066_I55_An I1_p31_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I57_MN1 (XI1_I2066_I57_Bn I1_dm25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I57_MN5 (XI1_I2066_I57_n2 I1_dm25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I57_MN4 (I1_I2066_pn25 XI1_I2066_I57_An XI1_I2066_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I57_MN2 (XI1_I2066_I57_n1 I1_p31_25 I1_I2066_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I57_MN3 (VSS XI1_I2066_I57_Bn XI1_I2066_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I57_MN0 (XI1_I2066_I57_An I1_p31_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I226_MN1 (XI1_I2066_I226_Bn I1_I2066_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I226_MN5 (XI1_I2066_I226_n2 I1_I2066_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I226_MN4 (I1_ru23 XI1_I2066_I226_An XI1_I2066_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I226_MN2 (XI1_I2066_I226_n1 I1_I2066_pn23 I1_ru23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I226_MN3 (VSS XI1_I2066_I226_Bn XI1_I2066_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I226_MN0 (XI1_I2066_I226_An I1_I2066_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I228_MN1 (XI1_I2066_I228_Bn I1_I2066_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I228_MN5 (XI1_I2066_I228_n2 I1_I2066_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I228_MN4 (I1_ru25 XI1_I2066_I228_An XI1_I2066_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I228_MN2 (XI1_I2066_I228_n1 I1_I2066_pn25 I1_ru25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I228_MN3 (VSS XI1_I2066_I228_Bn XI1_I2066_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I228_MN0 (XI1_I2066_I228_An I1_I2066_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I227_MN1 (XI1_I2066_I227_Bn I1_I2066_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I227_MN5 (XI1_I2066_I227_n2 I1_I2066_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I227_MN4 (I1_ru24 XI1_I2066_I227_An XI1_I2066_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I227_MN2 (XI1_I2066_I227_n1 I1_I2066_pn24 I1_ru24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I227_MN3 (VSS XI1_I2066_I227_Bn XI1_I2066_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I227_MN0 (XI1_I2066_I227_An I1_I2066_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2237_MN1 (XI1_I2237_Bn I1_nrkn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2237_MN5 (XI1_I2237_n2 I1_nrkn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2237_MN4 (DIVR_23 XI1_I2237_An XI1_I2237_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2237_MN2 (XI1_I2237_n1 I1_ru23 DIVR_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2237_MN3 (VSS XI1_I2237_Bn XI1_I2237_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2237_MN0 (XI1_I2237_An I1_ru23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2240_MN1 (XI1_I2240_Bn I1_nrkn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2240_MN5 (XI1_I2240_n2 I1_nrkn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2240_MN4 (DIVR_24 XI1_I2240_An XI1_I2240_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2240_MN2 (XI1_I2240_n1 I1_ru24 DIVR_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2240_MN3 (VSS XI1_I2240_Bn XI1_I2240_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2240_MN0 (XI1_I2240_An I1_ru24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2243_MN1 (XI1_I2243_Bn I1_nrkn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2243_MN5 (XI1_I2243_n2 I1_nrkn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2243_MN4 (DIVR_25 XI1_I2243_An XI1_I2243_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2243_MN2 (XI1_I2243_n1 I1_ru25 DIVR_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2243_MN3 (VSS XI1_I2243_Bn XI1_I2243_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2243_MN0 (XI1_I2243_An I1_ru25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I121_MN1 (XI0_I1660_I121_Bn I0_fa246_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I121_MN5 (XI0_I1660_I121_n2 I0_fa246_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I121_MN4 (I0_I1660_pn57 XI0_I1660_I121_An XI0_I1660_I121_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I121_MN2 (XI0_I1660_I121_n1 I0_fa297_1 I0_I1660_pn57 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I121_MN3 (VSS XI0_I1660_I121_Bn XI0_I1660_I121_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I121_MN0 (XI0_I1660_I121_An I0_fa297_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I233_MN1 (XI1_I1850_I233_Bn I1_I1850_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I233_MN5 (XI1_I1850_I233_n2 I1_I1850_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I233_MN4 (I1_p28_30 XI1_I1850_I233_An XI1_I1850_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I233_MN2 (XI1_I1850_I233_n1 I1_I1850_pn30 I1_p28_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I233_MN3 (VSS XI1_I1850_I233_Bn XI1_I1850_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I233_MN0 (XI1_I1850_I233_An I1_I1850_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I234_MN1 (XI1_I1850_I234_Bn I1_c28_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I234_MN5 (XI1_I1850_I234_n2 I1_c28_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I234_MN4 (I1_p28_31 XI1_I1850_I234_An XI1_I1850_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I234_MN2 (XI1_I1850_I234_n1 I1_I1850_pn31 I1_p28_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I234_MN3 (VSS XI1_I1850_I234_Bn XI1_I1850_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I234_MN0 (XI1_I1850_I234_An I1_I1850_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I63_MN1 (XI1_I1896_I63_Bn I1_b29_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I63_MN5 (XI1_I1896_I63_n2 I1_b29_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I63_MN4 (I1_I1896_pn31 XI1_I1896_I63_An XI1_I1896_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I63_MN2 (XI1_I1896_I63_n1 I1_p28_30 I1_I1896_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I63_MN3 (VSS XI1_I1896_I63_Bn XI1_I1896_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I63_MN0 (XI1_I1896_I63_An I1_p28_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I229_MN1 (XI1_I1896_I229_Bn I1_I1896_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I229_MN5 (XI1_I1896_I229_n2 I1_I1896_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I229_MN4 (I1_p29_26 XI1_I1896_I229_An XI1_I1896_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I229_MN2 (XI1_I1896_I229_n1 I1_I1896_pn26 I1_p29_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I229_MN3 (VSS XI1_I1896_I229_Bn XI1_I1896_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I229_MN0 (XI1_I1896_I229_An I1_I1896_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I59_MN1 (XI1_I1942_I59_Bn I1_b30_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I59_MN5 (XI1_I1942_I59_n2 I1_b30_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I59_MN4 (I1_I1942_pn27 XI1_I1942_I59_An XI1_I1942_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I59_MN2 (XI1_I1942_I59_n1 I1_p29_26 I1_I1942_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I59_MN3 (VSS XI1_I1942_I59_Bn XI1_I1942_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I59_MN0 (XI1_I1942_I59_An I1_p29_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I230_MN1 (XI1_I1942_I230_Bn I1_I1942_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I230_MN5 (XI1_I1942_I230_n2 I1_I1942_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I230_MN4 (I1_p30_27 XI1_I1942_I230_An XI1_I1942_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I230_MN2 (XI1_I1942_I230_n1 I1_I1942_pn27 I1_p30_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I230_MN3 (VSS XI1_I1942_I230_Bn XI1_I1942_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I230_MN0 (XI1_I1942_I230_An I1_I1942_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I60_MN1 (XI1_I1988_I60_Bn I1_b31_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I60_MN5 (XI1_I1988_I60_n2 I1_b31_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I60_MN4 (I1_I1988_pn28 XI1_I1988_I60_An XI1_I1988_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I60_MN2 (XI1_I1988_I60_n1 I1_p30_27 I1_I1988_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I60_MN3 (VSS XI1_I1988_I60_Bn XI1_I1988_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I60_MN0 (XI1_I1988_I60_An I1_p30_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I231_MN1 (XI1_I1988_I231_Bn I1_I1988_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I231_MN5 (XI1_I1988_I231_n2 I1_I1988_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I231_MN4 (I1_p31_28 XI1_I1988_I231_An XI1_I1988_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I231_MN2 (XI1_I1988_I231_n1 I1_I1988_pn28 I1_p31_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I231_MN3 (VSS XI1_I1988_I231_Bn XI1_I1988_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I231_MN0 (XI1_I1988_I231_An I1_I1988_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I230_MN1 (XI1_I1988_I230_Bn I1_I1988_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I230_MN5 (XI1_I1988_I230_n2 I1_I1988_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I230_MN4 (I1_p31_27 XI1_I1988_I230_An XI1_I1988_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I230_MN2 (XI1_I1988_I230_n1 I1_I1988_pn27 I1_p31_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I230_MN3 (VSS XI1_I1988_I230_Bn XI1_I1988_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I230_MN0 (XI1_I1988_I230_An I1_I1988_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I234_MN1 (XI1_I1988_I234_Bn I1_c31_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I234_MN5 (XI1_I1988_I234_n2 I1_c31_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I234_MN4 (I1_p31_31 XI1_I1988_I234_An XI1_I1988_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I234_MN2 (XI1_I1988_I234_n1 I1_I1988_pn31 I1_p31_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I234_MN3 (VSS XI1_I1988_I234_Bn XI1_I1988_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I234_MN0 (XI1_I1988_I234_An I1_I1988_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I232_MN1 (XI1_I1988_I232_Bn I1_I1988_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I232_MN5 (XI1_I1988_I232_n2 I1_I1988_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I232_MN4 (I1_p31_29 XI1_I1988_I232_An XI1_I1988_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I232_MN2 (XI1_I1988_I232_n1 I1_I1988_pn29 I1_p31_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I232_MN3 (VSS XI1_I1988_I232_Bn XI1_I1988_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I232_MN0 (XI1_I1988_I232_An I1_I1988_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I60_MN1 (XI1_I2066_I60_Bn I1_dm28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I60_MN5 (XI1_I2066_I60_n2 I1_dm28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I60_MN4 (I1_I2066_pn28 XI1_I2066_I60_An XI1_I2066_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I60_MN2 (XI1_I2066_I60_n1 I1_p31_28 I1_I2066_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I60_MN3 (VSS XI1_I2066_I60_Bn XI1_I2066_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I60_MN0 (XI1_I2066_I60_An I1_p31_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I58_MN1 (XI1_I2066_I58_Bn I1_dm26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I58_MN5 (XI1_I2066_I58_n2 I1_dm26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I58_MN4 (I1_I2066_pn26 XI1_I2066_I58_An XI1_I2066_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I58_MN2 (XI1_I2066_I58_n1 I1_p31_26 I1_I2066_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I58_MN3 (VSS XI1_I2066_I58_Bn XI1_I2066_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I58_MN0 (XI1_I2066_I58_An I1_p31_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I59_MN1 (XI1_I2066_I59_Bn I1_dm27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I59_MN5 (XI1_I2066_I59_n2 I1_dm27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I59_MN4 (I1_I2066_pn27 XI1_I2066_I59_An XI1_I2066_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I59_MN2 (XI1_I2066_I59_n1 I1_p31_27 I1_I2066_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I59_MN3 (VSS XI1_I2066_I59_Bn XI1_I2066_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I59_MN0 (XI1_I2066_I59_An I1_p31_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I230_MN1 (XI1_I2066_I230_Bn I1_I2066_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I230_MN5 (XI1_I2066_I230_n2 I1_I2066_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I230_MN4 (I1_ru27 XI1_I2066_I230_An XI1_I2066_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I230_MN2 (XI1_I2066_I230_n1 I1_I2066_pn27 I1_ru27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I230_MN3 (VSS XI1_I2066_I230_Bn XI1_I2066_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I230_MN0 (XI1_I2066_I230_An I1_I2066_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I229_MN1 (XI1_I2066_I229_Bn I1_I2066_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I229_MN5 (XI1_I2066_I229_n2 I1_I2066_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I229_MN4 (I1_ru26 XI1_I2066_I229_An XI1_I2066_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I229_MN2 (XI1_I2066_I229_n1 I1_I2066_pn26 I1_ru26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I229_MN3 (VSS XI1_I2066_I229_Bn XI1_I2066_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I229_MN0 (XI1_I2066_I229_An I1_I2066_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2234_MN1 (XI1_I2234_Bn I1_nrkn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2234_MN5 (XI1_I2234_n2 I1_nrkn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2234_MN4 (DIVR_22 XI1_I2234_An XI1_I2234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2234_MN2 (XI1_I2234_n1 I1_ru22 DIVR_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2234_MN3 (VSS XI1_I2234_Bn XI1_I2234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2234_MN0 (XI1_I2234_An I1_ru22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2246_MN1 (XI1_I2246_Bn I1_nrkn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2246_MN5 (XI1_I2246_n2 I1_nrkn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2246_MN4 (DIVR_26 XI1_I2246_An XI1_I2246_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2246_MN2 (XI1_I2246_n1 I1_ru26 DIVR_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2246_MN3 (VSS XI1_I2246_Bn XI1_I2246_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2246_MN0 (XI1_I2246_An I1_ru26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I124_MN1 (XI0_I1660_I124_Bn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I124_MN5 (XI0_I1660_I124_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I124_MN4 (I0_I1660_pn60 XI0_I1660_I124_An XI0_I1660_I124_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I124_MN2 (XI0_I1660_I124_n1 I0_fa247_0 I0_I1660_pn60 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I124_MN3 (VSS XI0_I1660_I124_Bn XI0_I1660_I124_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I124_MN0 (XI0_I1660_I124_An I0_fa247_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I118_MN1 (XI0_I1660_I118_Bn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I118_MN5 (XI0_I1660_I118_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I118_MN4 (I0_I1660_pn54 XI0_I1660_I118_An XI0_I1660_I118_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I118_MN2 (XI0_I1660_I118_n1 I0_fa296_0 I0_I1660_pn54 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I118_MN3 (VSS XI0_I1660_I118_Bn XI0_I1660_I118_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I118_MN0 (XI0_I1660_I118_An I0_fa296_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I116_MN1 (XI0_I1660_I116_Bn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I116_MN5 (XI0_I1660_I116_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I116_MN4 (I0_I1660_pn52 XI0_I1660_I116_An XI0_I1660_I116_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I116_MN2 (XI0_I1660_I116_n1 I0_fa295_0 I0_I1660_pn52 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I116_MN3 (VSS XI0_I1660_I116_Bn XI0_I1660_I116_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I116_MN0 (XI0_I1660_I116_An I0_fa295_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I117_MN1 (XI0_I1660_I117_Bn I0_fa244_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I117_MN5 (XI0_I1660_I117_n2 I0_fa244_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I117_MN4 (I0_I1660_pn53 XI0_I1660_I117_An XI0_I1660_I117_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I117_MN2 (XI0_I1660_I117_n1 I0_fa295_1 I0_I1660_pn53 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I117_MN3 (VSS XI0_I1660_I117_Bn XI0_I1660_I117_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I117_MN0 (XI0_I1660_I117_An I0_fa295_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I115_MN1 (XI0_I1660_I115_Bn I0_fa243_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I115_MN5 (XI0_I1660_I115_n2 I0_fa243_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I115_MN4 (I0_I1660_pn51 XI0_I1660_I115_An XI0_I1660_I115_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I115_MN2 (XI0_I1660_I115_n1 I0_ha294_1 I0_I1660_pn51 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I115_MN3 (VSS XI0_I1660_I115_Bn XI0_I1660_I115_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I115_MN0 (XI0_I1660_I115_An I0_ha294_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I119_MN1 (XI0_I1660_I119_Bn I0_fa245_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I119_MN5 (XI0_I1660_I119_n2 I0_fa245_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I119_MN4 (I0_I1660_pn55 XI0_I1660_I119_An XI0_I1660_I119_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I119_MN2 (XI0_I1660_I119_n1 I0_fa296_1 I0_I1660_pn55 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I119_MN3 (VSS XI0_I1660_I119_Bn XI0_I1660_I119_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I119_MN0 (XI0_I1660_I119_An I0_fa296_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I231_MN1 (XI1_I1850_I231_Bn I1_I1850_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I231_MN5 (XI1_I1850_I231_n2 I1_I1850_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I231_MN4 (I1_p28_28 XI1_I1850_I231_An XI1_I1850_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I231_MN2 (XI1_I1850_I231_n1 I1_I1850_pn28 I1_p28_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I231_MN3 (VSS XI1_I1850_I231_Bn XI1_I1850_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I231_MN0 (XI1_I1850_I231_An I1_I1850_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I61_MN1 (XI1_I1850_I61_Bn I1_b28_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I61_MN5 (XI1_I1850_I61_n2 I1_b28_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I61_MN4 (I1_I1850_pn29 XI1_I1850_I61_An XI1_I1850_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I61_MN2 (XI1_I1850_I61_n1 I1_p27_28 I1_I1850_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I61_MN3 (VSS XI1_I1850_I61_Bn XI1_I1850_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I61_MN0 (XI1_I1850_I61_An I1_p27_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I60_MN1 (XI1_I1850_I60_Bn I1_b28_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I60_MN5 (XI1_I1850_I60_n2 I1_b28_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I60_MN4 (I1_I1850_pn28 XI1_I1850_I60_An XI1_I1850_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I60_MN2 (XI1_I1850_I60_n1 I1_p27_27 I1_I1850_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I60_MN3 (VSS XI1_I1850_I60_Bn XI1_I1850_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I60_MN0 (XI1_I1850_I60_An I1_p27_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I59_MN1 (XI1_I1850_I59_Bn I1_b28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I59_MN5 (XI1_I1850_I59_n2 I1_b28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I59_MN4 (I1_I1850_pn27 XI1_I1850_I59_An XI1_I1850_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I59_MN2 (XI1_I1850_I59_n1 I1_p27_26 I1_I1850_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I59_MN3 (VSS XI1_I1850_I59_Bn XI1_I1850_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I59_MN0 (XI1_I1850_I59_An I1_p27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I229_MN1 (XI1_I1850_I229_Bn I1_I1850_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I229_MN5 (XI1_I1850_I229_n2 I1_I1850_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I229_MN4 (I1_p28_26 XI1_I1850_I229_An XI1_I1850_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I229_MN2 (XI1_I1850_I229_n1 I1_I1850_pn26 I1_p28_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I229_MN3 (VSS XI1_I1850_I229_Bn XI1_I1850_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I229_MN0 (XI1_I1850_I229_An I1_I1850_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I58_MN1 (XI1_I1850_I58_Bn I1_b28_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I58_MN5 (XI1_I1850_I58_n2 I1_b28_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I58_MN4 (I1_I1850_pn26 XI1_I1850_I58_An XI1_I1850_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I58_MN2 (XI1_I1850_I58_n1 I1_p27_25 I1_I1850_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I58_MN3 (VSS XI1_I1850_I58_Bn XI1_I1850_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I58_MN0 (XI1_I1850_I58_An I1_p27_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I230_MN1 (XI1_I1850_I230_Bn I1_I1850_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I230_MN5 (XI1_I1850_I230_n2 I1_I1850_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I230_MN4 (I1_p28_27 XI1_I1850_I230_An XI1_I1850_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I230_MN2 (XI1_I1850_I230_n1 I1_I1850_pn27 I1_p28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I230_MN3 (VSS XI1_I1850_I230_Bn XI1_I1850_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I230_MN0 (XI1_I1850_I230_An I1_I1850_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I232_MN1 (XI1_I1850_I232_Bn I1_I1850_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I232_MN5 (XI1_I1850_I232_n2 I1_I1850_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I232_MN4 (I1_p28_29 XI1_I1850_I232_An XI1_I1850_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I232_MN2 (XI1_I1850_I232_n1 I1_I1850_pn29 I1_p28_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I232_MN3 (VSS XI1_I1850_I232_Bn XI1_I1850_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I232_MN0 (XI1_I1850_I232_An I1_I1850_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I59_MN1 (XI1_I1896_I59_Bn I1_b29_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I59_MN5 (XI1_I1896_I59_n2 I1_b29_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I59_MN4 (I1_I1896_pn27 XI1_I1896_I59_An XI1_I1896_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I59_MN2 (XI1_I1896_I59_n1 I1_p28_26 I1_I1896_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I59_MN3 (VSS XI1_I1896_I59_Bn XI1_I1896_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I59_MN0 (XI1_I1896_I59_An I1_p28_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I60_MN1 (XI1_I1896_I60_Bn I1_b29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I60_MN5 (XI1_I1896_I60_n2 I1_b29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I60_MN4 (I1_I1896_pn28 XI1_I1896_I60_An XI1_I1896_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I60_MN2 (XI1_I1896_I60_n1 I1_p28_27 I1_I1896_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I60_MN3 (VSS XI1_I1896_I60_Bn XI1_I1896_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I60_MN0 (XI1_I1896_I60_An I1_p28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I61_MN1 (XI1_I1896_I61_Bn I1_b29_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I61_MN5 (XI1_I1896_I61_n2 I1_b29_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I61_MN4 (I1_I1896_pn29 XI1_I1896_I61_An XI1_I1896_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I61_MN2 (XI1_I1896_I61_n1 I1_p28_28 I1_I1896_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I61_MN3 (VSS XI1_I1896_I61_Bn XI1_I1896_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I61_MN0 (XI1_I1896_I61_An I1_p28_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I62_MN1 (XI1_I1896_I62_Bn I1_b29_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I62_MN5 (XI1_I1896_I62_n2 I1_b29_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I62_MN4 (I1_I1896_pn30 XI1_I1896_I62_An XI1_I1896_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I62_MN2 (XI1_I1896_I62_n1 I1_p28_29 I1_I1896_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I62_MN3 (VSS XI1_I1896_I62_Bn XI1_I1896_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I62_MN0 (XI1_I1896_I62_An I1_p28_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I233_MN1 (XI1_I1896_I233_Bn I1_I1896_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I233_MN5 (XI1_I1896_I233_n2 I1_I1896_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I233_MN4 (I1_p29_30 XI1_I1896_I233_An XI1_I1896_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I233_MN2 (XI1_I1896_I233_n1 I1_I1896_pn30 I1_p29_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I233_MN3 (VSS XI1_I1896_I233_Bn XI1_I1896_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I233_MN0 (XI1_I1896_I233_An I1_I1896_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I231_MN1 (XI1_I1896_I231_Bn I1_I1896_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I231_MN5 (XI1_I1896_I231_n2 I1_I1896_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I231_MN4 (I1_p29_28 XI1_I1896_I231_An XI1_I1896_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I231_MN2 (XI1_I1896_I231_n1 I1_I1896_pn28 I1_p29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I231_MN3 (VSS XI1_I1896_I231_Bn XI1_I1896_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I231_MN0 (XI1_I1896_I231_An I1_I1896_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I230_MN1 (XI1_I1896_I230_Bn I1_I1896_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I230_MN5 (XI1_I1896_I230_n2 I1_I1896_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I230_MN4 (I1_p29_27 XI1_I1896_I230_An XI1_I1896_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I230_MN2 (XI1_I1896_I230_n1 I1_I1896_pn27 I1_p29_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I230_MN3 (VSS XI1_I1896_I230_Bn XI1_I1896_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I230_MN0 (XI1_I1896_I230_An I1_I1896_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I232_MN1 (XI1_I1896_I232_Bn I1_I1896_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I232_MN5 (XI1_I1896_I232_n2 I1_I1896_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I232_MN4 (I1_p29_29 XI1_I1896_I232_An XI1_I1896_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I232_MN2 (XI1_I1896_I232_n1 I1_I1896_pn29 I1_p29_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I232_MN3 (VSS XI1_I1896_I232_Bn XI1_I1896_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I232_MN0 (XI1_I1896_I232_An I1_I1896_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I234_MN1 (XI1_I1896_I234_Bn I1_c29_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I234_MN5 (XI1_I1896_I234_n2 I1_c29_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I234_MN4 (I1_p29_31 XI1_I1896_I234_An XI1_I1896_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I234_MN2 (XI1_I1896_I234_n1 I1_I1896_pn31 I1_p29_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I234_MN3 (VSS XI1_I1896_I234_Bn XI1_I1896_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I234_MN0 (XI1_I1896_I234_An I1_I1896_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I61_MN1 (XI1_I1942_I61_Bn I1_b30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I61_MN5 (XI1_I1942_I61_n2 I1_b30_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I61_MN4 (I1_I1942_pn29 XI1_I1942_I61_An XI1_I1942_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I61_MN2 (XI1_I1942_I61_n1 I1_p29_28 I1_I1942_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I61_MN3 (VSS XI1_I1942_I61_Bn XI1_I1942_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I61_MN0 (XI1_I1942_I61_An I1_p29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I60_MN1 (XI1_I1942_I60_Bn I1_b30_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I60_MN5 (XI1_I1942_I60_n2 I1_b30_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I60_MN4 (I1_I1942_pn28 XI1_I1942_I60_An XI1_I1942_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I60_MN2 (XI1_I1942_I60_n1 I1_p29_27 I1_I1942_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I60_MN3 (VSS XI1_I1942_I60_Bn XI1_I1942_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I60_MN0 (XI1_I1942_I60_An I1_p29_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I63_MN1 (XI1_I1942_I63_Bn I1_b30_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I63_MN5 (XI1_I1942_I63_n2 I1_b30_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I63_MN4 (I1_I1942_pn31 XI1_I1942_I63_An XI1_I1942_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I63_MN2 (XI1_I1942_I63_n1 I1_p29_30 I1_I1942_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I63_MN3 (VSS XI1_I1942_I63_Bn XI1_I1942_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I63_MN0 (XI1_I1942_I63_An I1_p29_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I231_MN1 (XI1_I1942_I231_Bn I1_I1942_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I231_MN5 (XI1_I1942_I231_n2 I1_I1942_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I231_MN4 (I1_p30_28 XI1_I1942_I231_An XI1_I1942_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I231_MN2 (XI1_I1942_I231_n1 I1_I1942_pn28 I1_p30_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I231_MN3 (VSS XI1_I1942_I231_Bn XI1_I1942_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I231_MN0 (XI1_I1942_I231_An I1_I1942_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I62_MN1 (XI1_I1942_I62_Bn I1_b30_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I62_MN5 (XI1_I1942_I62_n2 I1_b30_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I62_MN4 (I1_I1942_pn30 XI1_I1942_I62_An XI1_I1942_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I62_MN2 (XI1_I1942_I62_n1 I1_p29_29 I1_I1942_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I62_MN3 (VSS XI1_I1942_I62_Bn XI1_I1942_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I62_MN0 (XI1_I1942_I62_An I1_p29_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I233_MN1 (XI1_I1942_I233_Bn I1_I1942_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I233_MN5 (XI1_I1942_I233_n2 I1_I1942_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I233_MN4 (I1_p30_30 XI1_I1942_I233_An XI1_I1942_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I233_MN2 (XI1_I1942_I233_n1 I1_I1942_pn30 I1_p30_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I233_MN3 (VSS XI1_I1942_I233_Bn XI1_I1942_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I233_MN0 (XI1_I1942_I233_An I1_I1942_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I232_MN1 (XI1_I1942_I232_Bn I1_I1942_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I232_MN5 (XI1_I1942_I232_n2 I1_I1942_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I232_MN4 (I1_p30_29 XI1_I1942_I232_An XI1_I1942_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I232_MN2 (XI1_I1942_I232_n1 I1_I1942_pn29 I1_p30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I232_MN3 (VSS XI1_I1942_I232_Bn XI1_I1942_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I232_MN0 (XI1_I1942_I232_An I1_I1942_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I61_MN1 (XI1_I1988_I61_Bn I1_b31_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I61_MN5 (XI1_I1988_I61_n2 I1_b31_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I61_MN4 (I1_I1988_pn29 XI1_I1988_I61_An XI1_I1988_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I61_MN2 (XI1_I1988_I61_n1 I1_p30_28 I1_I1988_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I61_MN3 (VSS XI1_I1988_I61_Bn XI1_I1988_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I61_MN0 (XI1_I1988_I61_An I1_p30_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I63_MN1 (XI1_I1988_I63_Bn I1_b31_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I63_MN5 (XI1_I1988_I63_n2 I1_b31_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I63_MN4 (I1_I1988_pn31 XI1_I1988_I63_An XI1_I1988_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I63_MN2 (XI1_I1988_I63_n1 I1_p30_30 I1_I1988_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I63_MN3 (VSS XI1_I1988_I63_Bn XI1_I1988_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I63_MN0 (XI1_I1988_I63_An I1_p30_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I62_MN1 (XI1_I1988_I62_Bn I1_b31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I62_MN5 (XI1_I1988_I62_n2 I1_b31_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I62_MN4 (I1_I1988_pn30 XI1_I1988_I62_An XI1_I1988_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I62_MN2 (XI1_I1988_I62_n1 I1_p30_29 I1_I1988_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I62_MN3 (VSS XI1_I1988_I62_Bn XI1_I1988_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I62_MN0 (XI1_I1988_I62_An I1_p30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I233_MN1 (XI1_I1988_I233_Bn I1_I1988_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I233_MN5 (XI1_I1988_I233_n2 I1_I1988_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I233_MN4 (I1_p31_30 XI1_I1988_I233_An XI1_I1988_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I233_MN2 (XI1_I1988_I233_n1 I1_I1988_pn30 I1_p31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I233_MN3 (VSS XI1_I1988_I233_Bn XI1_I1988_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I233_MN0 (XI1_I1988_I233_An I1_I1988_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I62_MN1 (XI1_I2066_I62_Bn I1_dm30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I62_MN5 (XI1_I2066_I62_n2 I1_dm30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I62_MN4 (I1_I2066_pn30 XI1_I2066_I62_An XI1_I2066_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I62_MN2 (XI1_I2066_I62_n1 I1_p31_30 I1_I2066_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I62_MN3 (VSS XI1_I2066_I62_Bn XI1_I2066_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I62_MN0 (XI1_I2066_I62_An I1_p31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I63_MN1 (XI1_I2066_I63_Bn I1_dm31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I63_MN5 (XI1_I2066_I63_n2 I1_dm31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I63_MN4 (I1_I2066_pn31 XI1_I2066_I63_An XI1_I2066_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I63_MN2 (XI1_I2066_I63_n1 I1_p31_31 I1_I2066_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I63_MN3 (VSS XI1_I2066_I63_Bn XI1_I2066_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I63_MN0 (XI1_I2066_I63_An I1_p31_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I61_MN1 (XI1_I2066_I61_Bn I1_dm29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I61_MN5 (XI1_I2066_I61_n2 I1_dm29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I61_MN4 (I1_I2066_pn29 XI1_I2066_I61_An XI1_I2066_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I61_MN2 (XI1_I2066_I61_n1 I1_p31_29 I1_I2066_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I61_MN3 (VSS XI1_I2066_I61_Bn XI1_I2066_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I61_MN0 (XI1_I2066_I61_An I1_p31_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I234_MN1 (XI1_I2066_I234_Bn I1_rcm VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I234_MN5 (XI1_I2066_I234_n2 I1_rcm VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I234_MN4 (I1_ru31 XI1_I2066_I234_An XI1_I2066_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I234_MN2 (XI1_I2066_I234_n1 I1_I2066_pn31 I1_ru31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I234_MN3 (VSS XI1_I2066_I234_Bn XI1_I2066_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I234_MN0 (XI1_I2066_I234_An I1_I2066_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I232_MN1 (XI1_I2066_I232_Bn I1_I2066_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I232_MN5 (XI1_I2066_I232_n2 I1_I2066_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I232_MN4 (I1_ru29 XI1_I2066_I232_An XI1_I2066_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I232_MN2 (XI1_I2066_I232_n1 I1_I2066_pn29 I1_ru29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I232_MN3 (VSS XI1_I2066_I232_Bn XI1_I2066_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I232_MN0 (XI1_I2066_I232_An I1_I2066_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I233_MN1 (XI1_I2066_I233_Bn I1_I2066_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I233_MN5 (XI1_I2066_I233_n2 I1_I2066_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I233_MN4 (I1_ru30 XI1_I2066_I233_An XI1_I2066_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I233_MN2 (XI1_I2066_I233_n1 I1_I2066_pn30 I1_ru30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I233_MN3 (VSS XI1_I2066_I233_Bn XI1_I2066_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I233_MN0 (XI1_I2066_I233_An I1_I2066_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I231_MN1 (XI1_I2066_I231_Bn I1_I2066_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I231_MN5 (XI1_I2066_I231_n2 I1_I2066_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I231_MN4 (I1_ru28 XI1_I2066_I231_An XI1_I2066_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I231_MN2 (XI1_I2066_I231_n1 I1_I2066_pn28 I1_ru28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I231_MN3 (VSS XI1_I2066_I231_Bn XI1_I2066_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I231_MN0 (XI1_I2066_I231_An I1_I2066_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2261_MN1 (XI1_I2261_Bn I1_nrkn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2261_MN5 (XI1_I2261_n2 I1_nrkn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2261_MN4 (DIVR_31 XI1_I2261_An XI1_I2261_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2261_MN2 (XI1_I2261_n1 I1_ru31 DIVR_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2261_MN3 (VSS XI1_I2261_Bn XI1_I2261_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2261_MN0 (XI1_I2261_An I1_ru31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2258_MN1 (XI1_I2258_Bn I1_nrkn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2258_MN5 (XI1_I2258_n2 I1_nrkn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2258_MN4 (DIVR_30 XI1_I2258_An XI1_I2258_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2258_MN2 (XI1_I2258_n1 I1_ru30 DIVR_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2258_MN3 (VSS XI1_I2258_Bn XI1_I2258_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2258_MN0 (XI1_I2258_An I1_ru30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2255_MN1 (XI1_I2255_Bn I1_nrkn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2255_MN5 (XI1_I2255_n2 I1_nrkn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2255_MN4 (DIVR_29 XI1_I2255_An XI1_I2255_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2255_MN2 (XI1_I2255_n1 I1_ru29 DIVR_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2255_MN3 (VSS XI1_I2255_Bn XI1_I2255_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2255_MN0 (XI1_I2255_An I1_ru29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2249_MN1 (XI1_I2249_Bn I1_nrkn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2249_MN5 (XI1_I2249_n2 I1_nrkn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2249_MN4 (DIVR_27 XI1_I2249_An XI1_I2249_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2249_MN2 (XI1_I2249_n1 I1_ru27 DIVR_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2249_MN3 (VSS XI1_I2249_Bn XI1_I2249_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2249_MN0 (XI1_I2249_An I1_ru27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2252_MN1 (XI1_I2252_Bn I1_nrkn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2252_MN5 (XI1_I2252_n2 I1_nrkn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2252_MN4 (DIVR_28 XI1_I2252_An XI1_I2252_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2252_MN2 (XI1_I2252_n1 I1_ru28 DIVR_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2252_MN3 (VSS XI1_I2252_Bn XI1_I2252_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2252_MN0 (XI1_I2252_An I1_ru28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I126_MN1 (XI0_I1660_I126_Bn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I126_MN5 (XI0_I1660_I126_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I126_MN4 (I0_I1660_pn62 XI0_I1660_I126_An XI0_I1660_I126_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I126_MN2 (XI0_I1660_I126_n1 I0_fa248_0 I0_I1660_pn62 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I126_MN3 (VSS XI0_I1660_I126_Bn XI0_I1660_I126_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I126_MN0 (XI0_I1660_I126_An I0_fa248_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I127_MN1 (XI0_I1660_I127_Bn I0_sn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I127_MN5 (XI0_I1660_I127_n2 I0_sn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I127_MN4 (I0_I1660_pn63 XI0_I1660_I127_An XI0_I1660_I127_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I127_MN2 (XI0_I1660_I127_n1 I0_fa248_1 I0_I1660_pn63 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I127_MN3 (VSS XI0_I1660_I127_Bn XI0_I1660_I127_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I127_MN0 (XI0_I1660_I127_An I0_fa248_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I125_MN1 (XI0_I1660_I125_Bn I0_fa208_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I125_MN5 (XI0_I1660_I125_n2 I0_fa208_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I125_MN4 (I0_I1660_pn61 XI0_I1660_I125_An XI0_I1660_I125_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I125_MN2 (XI0_I1660_I125_n1 I0_fa247_1 I0_I1660_pn61 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I125_MN3 (VSS XI0_I1660_I125_Bn XI0_I1660_I125_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I125_MN0 (XI0_I1660_I125_An I0_fa247_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1301_MN1 (I1_qu15 I1_p16_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1301_MN1_1 (VSS I1_p16_32 I1_qu15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I841_MN1 (I1_qu25 I1_p6_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I841_MN1_1 (VSS I1_p6_32 I1_qu25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I797_MN1 (I1_qu26_b1_0 I1_qu26_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I797_MN1_1 (VSS I1_qu26_b0 I1_qu26_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I795_MN1 (I1_qu26 I1_p5_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I795_MN1_1 (VSS I1_p5_32 I1_qu26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1347_MN1 (I1_qu14 I1_p17_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1347_MN1_1 (VSS I1_p17_32 I1_qu14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1349_MN1 (I1_qu14_b1_0 I1_qu14_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1349_MN1_1 (VSS I1_qu14_b0 I1_qu14_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1303_MN1 (I1_qu15_b1_0 I1_qu15_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1303_MN1_1 (VSS I1_qu15_b0 I1_qu15_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1257_MN1 (I1_qu16_b1_0 I1_qu16_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1257_MN1_1 (VSS I1_qu16_b0 I1_qu16_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1255_MN1 (I1_qu16 I1_p15_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1255_MN1_1 (VSS I1_p15_32 I1_qu16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I758_MN1 (I1_qu27_b3_4 I1_qu27_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I758_MN1_1 (VSS I1_qu27_b2_1 I1_qu27_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1218_MN1 (I1_qu17_b3_4 I1_qu17_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1218_MN1_1 (VSS I1_qu17_b2_1 I1_qu17_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1172_MN1 (I1_qu18_b3_4 I1_qu18_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1172_MN1_1 (VSS I1_qu18_b2_1 I1_qu18_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I843_MN1 (I1_qu25_b1_0 I1_qu25_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I843_MN1_1 (VSS I1_qu25_b0 I1_qu25_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I759_MN1 (I1_qu27_b3_5 I1_qu27_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I759_MN1_1 (VSS I1_qu27_b2_1 I1_qu27_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1217_MN1 (I1_qu17_b3_3 I1_qu17_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1217_MN1_1 (VSS I1_qu17_b2_1 I1_qu17_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1171_MN1 (I1_qu18_b3_3 I1_qu18_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1171_MN1_1 (VSS I1_qu18_b2_1 I1_qu18_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I804_MN1 (I1_qu26_b3_4 I1_qu26_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I804_MN1_1 (VSS I1_qu26_b2_1 I1_qu26_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I757_MN1 (I1_qu27_b3_3 I1_qu27_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I757_MN1_1 (VSS I1_qu27_b2_1 I1_qu27_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I803_MN1 (I1_qu26_b3_3 I1_qu26_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I803_MN1_1 (VSS I1_qu26_b2_1 I1_qu26_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I712_MN1 (I1_qu28_b3_4 I1_qu28_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I712_MN1_1 (VSS I1_qu28_b2_1 I1_qu28_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1310_MN1 (I1_qu15_b3_4 I1_qu15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1310_MN1_1 (VSS I1_qu15_b2_1 I1_qu15_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I850_MN1 (I1_qu25_b3_4 I1_qu25_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I850_MN1_1 (VSS I1_qu25_b2_1 I1_qu25_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I849_MN1 (I1_qu25_b3_3 I1_qu25_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I849_MN1_1 (VSS I1_qu25_b2_1 I1_qu25_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I845_MN1 (I1_qu25_b2_1 I1_qu25_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I845_MN1_1 (VSS I1_qu25_b1_0 I1_qu25_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I798_MN1 (I1_qu26_b2_0 I1_qu26_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I798_MN1_1 (VSS I1_qu26_b1_0 I1_qu26_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I753_MN1 (I1_qu27_b2_1 I1_qu27_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I753_MN1_1 (VSS I1_qu27_b1_0 I1_qu27_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1311_MN1 (I1_qu15_b3_5 I1_qu15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1311_MN1_1 (VSS I1_qu15_b2_1 I1_qu15_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I851_MN1 (I1_qu25_b3_5 I1_qu25_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I851_MN1_1 (VSS I1_qu25_b2_1 I1_qu25_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I802_MN1 (I1_qu26_b3_2 I1_qu26_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I802_MN1_1 (VSS I1_qu26_b2_0 I1_qu26_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1305_MN1 (I1_qu15_b2_1 I1_qu15_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1305_MN1_1 (VSS I1_qu15_b1_0 I1_qu15_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I848_MN1 (I1_qu25_b3_2 I1_qu25_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I848_MN1_1 (VSS I1_qu25_b2_0 I1_qu25_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I844_MN1 (I1_qu25_b2_0 I1_qu25_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I844_MN1_1 (VSS I1_qu25_b1_0 I1_qu25_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1309_MN1 (I1_qu15_b3_3 I1_qu15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1309_MN1_1 (VSS I1_qu15_b2_1 I1_qu15_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1304_MN1 (I1_qu15_b2_0 I1_qu15_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1304_MN1_1 (VSS I1_qu15_b1_0 I1_qu15_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1262_MN1 (I1_qu16_b3_2 I1_qu16_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1262_MN1_1 (VSS I1_qu16_b2_0 I1_qu16_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I847_MN1 (I1_qu25_b3_1 I1_qu25_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I847_MN1_1 (VSS I1_qu25_b2_0 I1_qu25_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I801_MN1 (I1_qu26_b3_1 I1_qu26_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I801_MN1_1 (VSS I1_qu26_b2_0 I1_qu26_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1357_MN1 (I1_qu14_b3_5 I1_qu14_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1357_MN1_1 (VSS I1_qu14_b2_1 I1_qu14_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1355_MN1 (I1_qu14_b3_3 I1_qu14_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1355_MN1_1 (VSS I1_qu14_b2_1 I1_qu14_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1350_MN1 (I1_qu14_b2_0 I1_qu14_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1350_MN1_1 (VSS I1_qu14_b1_0 I1_qu14_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1216_MN1 (I1_qu17_b3_2 I1_qu17_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1216_MN1_1 (VSS I1_qu17_b2_0 I1_qu17_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1213_MN1 (I1_qu17_b2_1 I1_qu17_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1213_MN1_1 (VSS I1_qu17_b1_0 I1_qu17_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1219_MN1 (I1_qu17_b3_5 I1_qu17_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1219_MN1_1 (VSS I1_qu17_b2_1 I1_qu17_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1167_MN1 (I1_qu18_b2_1 I1_qu18_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1167_MN1_1 (VSS I1_qu18_b1_0 I1_qu18_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1173_MN1 (I1_qu18_b3_5 I1_qu18_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1173_MN1_1 (VSS I1_qu18_b2_1 I1_qu18_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I846_MN1 (I1_qu25_b3_0 I1_qu25_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I846_MN1_1 (VSS I1_qu25_b2_0 I1_qu25_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I800_MN1 (I1_qu26_b3_0 I1_qu26_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I800_MN1_1 (VSS I1_qu26_b2_0 I1_qu26_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I756_MN1 (I1_qu27_b3_2 I1_qu27_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I756_MN1_1 (VSS I1_qu27_b2_0 I1_qu27_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I752_MN1 (I1_qu27_b2_0 I1_qu27_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I752_MN1_1 (VSS I1_qu27_b1_0 I1_qu27_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I751_MN1 (I1_qu27_b1_0 I1_qu27_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I751_MN1_1 (VSS I1_qu27_b0 I1_qu27_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I713_MN1 (I1_qu28_b3_5 I1_qu28_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I713_MN1_1 (VSS I1_qu28_b2_1 I1_qu28_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I749_MN1 (I1_qu27 I1_p4_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I749_MN1_1 (VSS I1_p4_32 I1_qu27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1308_MN1 (I1_qu15_b3_2 I1_qu15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1308_MN1_1 (VSS I1_qu15_b2_0 I1_qu15_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1209_MN1 (I1_qu17 I1_p14_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1209_MN1_1 (VSS I1_p14_32 I1_qu17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1165_MN1 (I1_qu18_b1_0 I1_qu18_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1165_MN1_1 (VSS I1_qu18_b0 I1_qu18_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1166_MN1 (I1_qu18_b2_0 I1_qu18_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1166_MN1_1 (VSS I1_qu18_b1_0 I1_qu18_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1170_MN1 (I1_qu18_b3_2 I1_qu18_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1170_MN1_1 (VSS I1_qu18_b2_0 I1_qu18_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I703_MN1 (I1_qu28 I1_p3_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I703_MN1_1 (VSS I1_p3_32 I1_qu28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1354_MN1 (I1_qu14_b3_2 I1_qu14_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1354_MN1_1 (VSS I1_qu14_b2_0 I1_qu14_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1261_MN1 (I1_qu16_b3_1 I1_qu16_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1261_MN1_1 (VSS I1_qu16_b2_0 I1_qu16_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1214_MN1 (I1_qu17_b3_0 I1_qu17_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1214_MN1_1 (VSS I1_qu17_b2_0 I1_qu17_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1215_MN1 (I1_qu17_b3_1 I1_qu17_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1215_MN1_1 (VSS I1_qu17_b2_0 I1_qu17_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1163_MN1 (I1_qu18 I1_p13_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1163_MN1_1 (VSS I1_p13_32 I1_qu18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I887_MN1 (I1_qu24 I1_p7_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I887_MN1_1 (VSS I1_p7_32 I1_qu24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I754_MN1 (I1_qu27_b3_0 I1_qu27_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I754_MN1_1 (VSS I1_qu27_b2_0 I1_qu27_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I755_MN1 (I1_qu27_b3_1 I1_qu27_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I755_MN1_1 (VSS I1_qu27_b2_0 I1_qu27_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I708_MN1 (I1_qu28_b3_0 I1_qu28_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I708_MN1_1 (VSS I1_qu28_b2_0 I1_qu28_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I709_MN1 (I1_qu28_b3_1 I1_qu28_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I709_MN1_1 (VSS I1_qu28_b2_0 I1_qu28_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I710_MN1 (I1_qu28_b3_2 I1_qu28_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I710_MN1_1 (VSS I1_qu28_b2_0 I1_qu28_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1307_MN1 (I1_qu15_b3_1 I1_qu15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1307_MN1_1 (VSS I1_qu15_b2_0 I1_qu15_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1260_MN1 (I1_qu16_b3_0 I1_qu16_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1260_MN1_1 (VSS I1_qu16_b2_0 I1_qu16_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1169_MN1 (I1_qu18_b3_1 I1_qu18_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1169_MN1_1 (VSS I1_qu18_b2_0 I1_qu18_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1168_MN1 (I1_qu18_b3_0 I1_qu18_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1168_MN1_1 (VSS I1_qu18_b2_0 I1_qu18_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I889_MN1 (I1_qu24_b1_0 I1_qu24_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I889_MN1_1 (VSS I1_qu24_b0 I1_qu24_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1353_MN1 (I1_qu14_b3_1 I1_qu14_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1353_MN1_1 (VSS I1_qu14_b2_0 I1_qu14_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I890_MN1 (I1_qu24_b2_0 I1_qu24_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I890_MN1_1 (VSS I1_qu24_b1_0 I1_qu24_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I895_MN1 (I1_qu24_b3_3 I1_qu24_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I895_MN1_1 (VSS I1_qu24_b2_1 I1_qu24_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I894_MN1 (I1_qu24_b3_2 I1_qu24_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I894_MN1_1 (VSS I1_qu24_b2_0 I1_qu24_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I893_MN1 (I1_qu24_b3_1 I1_qu24_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I893_MN1_1 (VSS I1_qu24_b2_0 I1_qu24_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1393_MN1 (I1_qu13 I1_p18_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1393_MN1_1 (VSS I1_p18_32 I1_qu13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1306_MN1 (I1_qu15_b3_0 I1_qu15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1306_MN1_1 (VSS I1_qu15_b2_0 I1_qu15_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1352_MN1 (I1_qu14_b3_0 I1_qu14_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1352_MN1_1 (VSS I1_qu14_b2_0 I1_qu14_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I897_MN1 (I1_qu24_b3_5 I1_qu24_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I897_MN1_1 (VSS I1_qu24_b2_1 I1_qu24_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I892_MN1 (I1_qu24_b3_0 I1_qu24_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I892_MN1_1 (VSS I1_qu24_b2_0 I1_qu24_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I933_MN1 (I1_qu23 I1_p8_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I933_MN1_1 (VSS I1_p8_32 I1_qu23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I663_MN1 (I1_qu29_b3_1 I1_qu29_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I663_MN1_1 (VSS I1_qu29_b2_0 I1_qu29_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I664_MN1 (I1_qu29_b3_2 I1_qu29_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I664_MN1_1 (VSS I1_qu29_b2_0 I1_qu29_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I665_MN1 (I1_qu29_b3_3 I1_qu29_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I665_MN1_1 (VSS I1_qu29_b2_1 I1_qu29_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1395_MN1 (I1_qu13_b1_0 I1_qu13_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1395_MN1_1 (VSS I1_qu13_b0 I1_qu13_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1397_MN1 (I1_qu13_b2_1 I1_qu13_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1397_MN1_1 (VSS I1_qu13_b1_0 I1_qu13_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1396_MN1 (I1_qu13_b2_0 I1_qu13_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1396_MN1_1 (VSS I1_qu13_b1_0 I1_qu13_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1399_MN1 (I1_qu13_b3_1 I1_qu13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1399_MN1_1 (VSS I1_qu13_b2_0 I1_qu13_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1126_MN1 (I1_qu19_b3_4 I1_qu19_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1126_MN1_1 (VSS I1_qu19_b2_1 I1_qu19_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1125_MN1 (I1_qu19_b3_3 I1_qu19_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1125_MN1_1 (VSS I1_qu19_b2_1 I1_qu19_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I935_MN1 (I1_qu23_b1_0 I1_qu23_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I935_MN1_1 (VSS I1_qu23_b0 I1_qu23_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I498_MN1 (I1_dd29_b3_0 I1_dd29_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I498_MN1_1 (VSS I1_dd29_b2_0 I1_dd29_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I662_MN1 (I1_qu29_b3_0 I1_qu29_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I662_MN1_1 (VSS I1_qu29_b2_0 I1_qu29_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I660_MN1 (I1_qu29_b2_0 I1_qu29_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I660_MN1_1 (VSS I1_qu29_b1_0 I1_qu29_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I667_MN1 (I1_qu29_b3_5 I1_qu29_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I667_MN1_1 (VSS I1_qu29_b2_1 I1_qu29_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I666_MN1 (I1_qu29_b3_4 I1_qu29_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I666_MN1_1 (VSS I1_qu29_b2_1 I1_qu29_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I661_MN1 (I1_qu29_b2_1 I1_qu29_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I661_MN1_1 (VSS I1_qu29_b1_0 I1_qu29_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I659_MN1 (I1_qu29_b1_0 I1_qu29_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I659_MN1_1 (VSS I1_qu29_b0 I1_qu29_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I657_MN1 (I1_qu29 I1_p2_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I657_MN1_1 (VSS I1_p2_32 I1_qu29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1402_MN1 (I1_qu13_b3_4 I1_qu13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1402_MN1_1 (VSS I1_qu13_b2_1 I1_qu13_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1401_MN1 (I1_qu13_b3_3 I1_qu13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1401_MN1_1 (VSS I1_qu13_b2_1 I1_qu13_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1403_MN1 (I1_qu13_b3_5 I1_qu13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1403_MN1_1 (VSS I1_qu13_b2_1 I1_qu13_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1400_MN1 (I1_qu13_b3_2 I1_qu13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1400_MN1_1 (VSS I1_qu13_b2_0 I1_qu13_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1398_MN1 (I1_qu13_b3_0 I1_qu13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1398_MN1_1 (VSS I1_qu13_b2_0 I1_qu13_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1127_MN1 (I1_qu19_b3_5 I1_qu19_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1127_MN1_1 (VSS I1_qu19_b2_1 I1_qu19_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1080_MN1 (I1_qu20_b3_4 I1_qu20_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1080_MN1_1 (VSS I1_qu20_b2_1 I1_qu20_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1121_MN1 (I1_qu19_b2_1 I1_qu19_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1121_MN1_1 (VSS I1_qu19_b1_0 I1_qu19_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I461_MN1 (I1_dd26_b3_2 I1_dd26_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I461_MN1_1 (VSS I1_dd26_b2_0 I1_dd26_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I448_MN1 (I1_dd25_b3_2 I1_dd25_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I448_MN1_1 (VSS I1_dd25_b2_0 I1_dd25_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I435_MN1 (I1_dd24_b3_2 I1_dd24_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I435_MN1_1 (VSS I1_dd24_b2_0 I1_dd24_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I431_MN1 (I1_dd24_b2_0 I1_dd24_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I431_MN1_1 (VSS I1_dd24_b1_0 I1_dd24_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I460_MN1 (I1_dd26_b3_1 I1_dd26_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I460_MN1_1 (VSS I1_dd26_b2_0 I1_dd26_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I447_MN1 (I1_dd25_b3_1 I1_dd25_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I447_MN1_1 (VSS I1_dd25_b2_0 I1_dd25_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I434_MN1 (I1_dd24_b3_1 I1_dd24_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I434_MN1_1 (VSS I1_dd24_b2_0 I1_dd24_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I433_MN1 (I1_dd24_b3_0 I1_dd24_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I433_MN1_1 (VSS I1_dd24_b2_0 I1_dd24_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I472_MN1 (I1_dd27_b3_0 I1_dd27_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I472_MN1_1 (VSS I1_dd27_b2_0 I1_dd27_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I446_MN1 (I1_dd25_b3_0 I1_dd25_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I446_MN1_1 (VSS I1_dd25_b2_0 I1_dd25_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I459_MN1 (I1_dd26_b3_0 I1_dd26_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I459_MN1_1 (VSS I1_dd26_b2_0 I1_dd26_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I485_MN1 (I1_dd28_b3_0 I1_dd28_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I485_MN1_1 (VSS I1_dd28_b2_0 I1_dd28_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1119_MN1 (I1_qu19_b1_0 I1_qu19_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1119_MN1_1 (VSS I1_qu19_b0 I1_qu19_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1120_MN1 (I1_qu19_b2_0 I1_qu19_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1120_MN1_1 (VSS I1_qu19_b1_0 I1_qu19_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1124_MN1 (I1_qu19_b3_2 I1_qu19_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1124_MN1_1 (VSS I1_qu19_b2_0 I1_qu19_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1123_MN1 (I1_qu19_b3_1 I1_qu19_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1123_MN1_1 (VSS I1_qu19_b2_0 I1_qu19_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1122_MN1 (I1_qu19_b3_0 I1_qu19_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1122_MN1_1 (VSS I1_qu19_b2_0 I1_qu19_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1034_MN1 (I1_qu21_b3_4 I1_qu21_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1034_MN1_1 (VSS I1_qu21_b2_1 I1_qu21_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I513_MN1 (I1_dd30_b3_2 I1_dd30_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I513_MN1_1 (VSS I1_dd30_b2_0 I1_dd30_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I942_MN1 (I1_qu23_b3_4 I1_qu23_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I942_MN1_1 (VSS I1_qu23_b2_1 I1_qu23_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I937_MN1 (I1_qu23_b2_1 I1_qu23_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I937_MN1_1 (VSS I1_qu23_b1_0 I1_qu23_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I943_MN1 (I1_qu23_b3_5 I1_qu23_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I943_MN1_1 (VSS I1_qu23_b2_1 I1_qu23_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I941_MN1 (I1_qu23_b3_3 I1_qu23_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I941_MN1_1 (VSS I1_qu23_b2_1 I1_qu23_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I936_MN1 (I1_qu23_b2_0 I1_qu23_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I936_MN1_1 (VSS I1_qu23_b1_0 I1_qu23_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I940_MN1 (I1_qu23_b3_2 I1_qu23_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I940_MN1_1 (VSS I1_qu23_b2_0 I1_qu23_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1079_MN1 (I1_qu20_b3_3 I1_qu20_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1079_MN1_1 (VSS I1_qu20_b2_1 I1_qu20_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1081_MN1 (I1_qu20_b3_5 I1_qu20_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1081_MN1_1 (VSS I1_qu20_b2_1 I1_qu20_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1117_MN1 (I1_qu19 I1_p12_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1117_MN1_1 (VSS I1_p12_32 I1_qu19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I526_MN1 (I1_dd31_b3_2 I1_dd31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I526_MN1_1 (VSS I1_dd31_b2_0 I1_dd31_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I988_MN1 (I1_qu22_b3_4 I1_qu22_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I988_MN1_1 (VSS I1_qu22_b2_1 I1_qu22_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I939_MN1 (I1_qu23_b3_1 I1_qu23_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I939_MN1_1 (VSS I1_qu23_b2_0 I1_qu23_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1075_MN1 (I1_qu20_b2_1 I1_qu20_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1075_MN1_1 (VSS I1_qu20_b1_0 I1_qu20_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1073_MN1 (I1_qu20_b1_0 I1_qu20_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1073_MN1_1 (VSS I1_qu20_b0 I1_qu20_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1071_MN1 (I1_qu20 I1_p11_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1071_MN1_1 (VSS I1_p11_32 I1_qu20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1035_MN1 (I1_qu21_b3_5 I1_qu21_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1035_MN1_1 (VSS I1_qu21_b2_1 I1_qu21_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1033_MN1 (I1_qu21_b3_3 I1_qu21_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1033_MN1_1 (VSS I1_qu21_b2_1 I1_qu21_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I989_MN1 (I1_qu22_b3_5 I1_qu22_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I989_MN1_1 (VSS I1_qu22_b2_1 I1_qu22_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I979_MN1 (I1_qu22 I1_p9_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I979_MN1_1 (VSS I1_p9_32 I1_qu22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I938_MN1 (I1_qu23_b3_0 I1_qu23_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I938_MN1_1 (VSS I1_qu23_b2_0 I1_qu23_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1029_MN1 (I1_qu21_b2_1 I1_qu21_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1029_MN1_1 (VSS I1_qu21_b1_0 I1_qu21_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I396_MN1 (I1_dd21_b3_2 I1_dd21_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I396_MN1_1 (VSS I1_dd21_b2_0 I1_dd21_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I421_MN1 (I1_dd23_b3_1 I1_dd23_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I421_MN1_1 (VSS I1_dd23_b2_0 I1_dd23_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I987_MN1 (I1_qu22_b3_3 I1_qu22_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I987_MN1_1 (VSS I1_qu22_b2_1 I1_qu22_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I983_MN1 (I1_qu22_b2_1 I1_qu22_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I983_MN1_1 (VSS I1_qu22_b1_0 I1_qu22_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I981_MN1 (I1_qu22_b1_0 I1_qu22_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I981_MN1_1 (VSS I1_qu22_b0 I1_qu22_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I420_MN1 (I1_dd23_b3_0 I1_dd23_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I420_MN1_1 (VSS I1_dd23_b2_0 I1_dd23_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I511_MN1 (I1_dd30_b3_0 I1_dd30_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I511_MN1_1 (VSS I1_dd30_b2_0 I1_dd30_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I616_MN1 (I1_qu30_b3_0 I1_qu30_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I616_MN1_1 (VSS I1_qu30_b2_0 I1_qu30_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I619_MN1 (I1_qu30_b3_3 I1_qu30_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I619_MN1_1 (VSS I1_qu30_b2_1 I1_qu30_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I620_MN1 (I1_qu30_b3_4 I1_qu30_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I620_MN1_1 (VSS I1_qu30_b2_1 I1_qu30_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I408_MN1 (I1_dd22_b3_1 I1_dd22_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I408_MN1_1 (VSS I1_dd22_b2_0 I1_dd22_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I395_MN1 (I1_dd21_b3_1 I1_dd21_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I395_MN1_1 (VSS I1_dd21_b2_0 I1_dd21_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I524_MN1 (I1_dd31_b3_0 I1_dd31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I524_MN1_1 (VSS I1_dd31_b2_0 I1_dd31_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I407_MN1 (I1_dd22_b3_0 I1_dd22_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I407_MN1_1 (VSS I1_dd22_b2_0 I1_dd22_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I381_MN1 (I1_dd20_b3_0 I1_dd20_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I381_MN1_1 (VSS I1_dd20_b2_0 I1_dd20_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I394_MN1 (I1_dd21_b3_0 I1_dd21_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I394_MN1_1 (VSS I1_dd21_b2_0 I1_dd21_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I617_MN1 (I1_qu30_b3_1 I1_qu30_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I617_MN1_1 (VSS I1_qu30_b2_0 I1_qu30_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I618_MN1 (I1_qu30_b3_2 I1_qu30_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I618_MN1_1 (VSS I1_qu30_b2_0 I1_qu30_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I614_MN1 (I1_qu30_b2_0 I1_qu30_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I614_MN1_1 (VSS I1_qu30_b1_0 I1_qu30_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I621_MN1 (I1_qu30_b3_5 I1_qu30_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I621_MN1_1 (VSS I1_qu30_b2_1 I1_qu30_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I615_MN1 (I1_qu30_b2_1 I1_qu30_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I615_MN1_1 (VSS I1_qu30_b1_0 I1_qu30_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I613_MN1 (I1_qu30_b1_0 I1_qu30_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I613_MN1_1 (VSS I1_qu30_b0 I1_qu30_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1446_MN1 (I1_qu12_b3_2 I1_qu12_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1446_MN1_1 (VSS I1_qu12_b2_0 I1_qu12_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1445_MN1 (I1_qu12_b3_1 I1_qu12_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1445_MN1_1 (VSS I1_qu12_b2_0 I1_qu12_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1444_MN1 (I1_qu12_b3_0 I1_qu12_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1444_MN1_1 (VSS I1_qu12_b2_0 I1_qu12_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1027_MN1 (I1_qu21_b1_0 I1_qu21_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1027_MN1_1 (VSS I1_qu21_b0 I1_qu21_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I382_MN1 (I1_dd20_b3_1 I1_dd20_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I382_MN1_1 (VSS I1_dd20_b2_0 I1_dd20_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I369_MN1 (I1_dd19_b3_1 I1_dd19_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I369_MN1_1 (VSS I1_dd19_b2_0 I1_dd19_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I368_MN1 (I1_dd19_b3_0 I1_dd19_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I368_MN1_1 (VSS I1_dd19_b2_0 I1_dd19_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I611_MN1 (I1_qu30 I1_p1_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I611_MN1_1 (VSS I1_p1_32 I1_qu30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1441_MN1 (I1_qu12_b1_0 I1_qu12_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1441_MN1_1 (VSS I1_qu12_b0 I1_qu12_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1439_MN1 (I1_qu12 I1_p19_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1439_MN1_1 (VSS I1_p19_32 I1_qu12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1442_MN1 (I1_qu12_b2_0 I1_qu12_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1442_MN1_1 (VSS I1_qu12_b1_0 I1_qu12_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1443_MN1 (I1_qu12_b2_1 I1_qu12_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1443_MN1_1 (VSS I1_qu12_b1_0 I1_qu12_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1447_MN1 (I1_qu12_b3_3 I1_qu12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1447_MN1_1 (VSS I1_qu12_b2_1 I1_qu12_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I344_MN1 (I1_dd17_b3_2 I1_dd17_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I344_MN1_1 (VSS I1_dd17_b2_0 I1_dd17_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1025_MN1 (I1_qu21 I1_p10_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1025_MN1_1 (VSS I1_p10_32 I1_qu21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I356_MN1 (I1_dd18_b3_1 I1_dd18_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I356_MN1_1 (VSS I1_dd18_b2_0 I1_dd18_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I343_MN1 (I1_dd17_b3_1 I1_dd17_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I343_MN1_1 (VSS I1_dd17_b2_0 I1_dd17_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I355_MN1 (I1_dd18_b3_0 I1_dd18_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I355_MN1_1 (VSS I1_dd18_b2_0 I1_dd18_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1448_MN1 (I1_qu12_b3_4 I1_qu12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1448_MN1_1 (VSS I1_qu12_b2_1 I1_qu12_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1449_MN1 (I1_qu12_b3_5 I1_qu12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1449_MN1_1 (VSS I1_qu12_b2_1 I1_qu12_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1074_MN1 (I1_qu20_b2_0 I1_qu20_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1074_MN1_1 (VSS I1_qu20_b1_0 I1_qu20_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1078_MN1 (I1_qu20_b3_2 I1_qu20_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1078_MN1_1 (VSS I1_qu20_b2_0 I1_qu20_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1485_MN1 (I1_qu11 I1_p20_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1485_MN1_1 (VSS I1_p20_32 I1_qu11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I279_MN1 (I1_dd12_b3_2 I1_dd12_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I279_MN1_1 (VSS I1_dd12_b2_0 I1_dd12_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I305_MN1 (I1_dd14_b3_2 I1_dd14_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I305_MN1_1 (VSS I1_dd14_b2_0 I1_dd14_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I292_MN1 (I1_dd13_b3_2 I1_dd13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I292_MN1_1 (VSS I1_dd13_b2_0 I1_dd13_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1032_MN1 (I1_qu21_b3_2 I1_qu21_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1032_MN1_1 (VSS I1_qu21_b2_0 I1_qu21_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I330_MN1 (I1_dd16_b3_1 I1_dd16_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I330_MN1_1 (VSS I1_dd16_b2_0 I1_dd16_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I317_MN1 (I1_dd15_b3_1 I1_dd15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I317_MN1_1 (VSS I1_dd15_b2_0 I1_dd15_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I304_MN1 (I1_dd14_b3_1 I1_dd14_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I304_MN1_1 (VSS I1_dd14_b2_0 I1_dd14_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I291_MN1 (I1_dd13_b3_1 I1_dd13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I291_MN1_1 (VSS I1_dd13_b2_0 I1_dd13_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1487_MN1 (I1_qu11_b1_0 I1_qu11_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1487_MN1_1 (VSS I1_qu11_b0 I1_qu11_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1028_MN1 (I1_qu21_b2_0 I1_qu21_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1028_MN1_1 (VSS I1_qu21_b1_0 I1_qu21_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I982_MN1 (I1_qu22_b2_0 I1_qu22_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I982_MN1_1 (VSS I1_qu22_b1_0 I1_qu22_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I986_MN1 (I1_qu22_b3_2 I1_qu22_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I986_MN1_1 (VSS I1_qu22_b2_0 I1_qu22_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I278_MN1 (I1_dd12_b3_1 I1_dd12_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I278_MN1_1 (VSS I1_dd12_b2_0 I1_dd12_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I265_MN1 (I1_dd11_b3_1 I1_dd11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I265_MN1_1 (VSS I1_dd11_b2_0 I1_dd11_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I135_MN1 (I1_dd1_b3_1 I1_dd1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I135_MN1_1 (VSS I1_dd1_b2_0 I1_dd1_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I329_MN1 (I1_dd16_b3_0 I1_dd16_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I329_MN1_1 (VSS I1_dd16_b2_0 I1_dd16_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I134_MN1 (I1_dd1_b3_0 I1_dd1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I134_MN1_1 (VSS I1_dd1_b2_0 I1_dd1_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I342_MN1 (I1_dd17_b3_0 I1_dd17_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I342_MN1_1 (VSS I1_dd17_b2_0 I1_dd17_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I277_MN1 (I1_dd12_b3_0 I1_dd12_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I277_MN1_1 (VSS I1_dd12_b2_0 I1_dd12_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I290_MN1 (I1_dd13_b3_0 I1_dd13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I290_MN1_1 (VSS I1_dd13_b2_0 I1_dd13_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I570_MN1 (I1_qu31_b3_0 I1_qu31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I570_MN1_1 (VSS I1_qu31_b2_0 I1_qu31_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1488_MN1 (I1_qu11_b2_0 I1_qu11_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1488_MN1_1 (VSS I1_qu11_b1_0 I1_qu11_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1492_MN1 (I1_qu11_b3_2 I1_qu11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1492_MN1_1 (VSS I1_qu11_b2_0 I1_qu11_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1491_MN1 (I1_qu11_b3_1 I1_qu11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1491_MN1_1 (VSS I1_qu11_b2_0 I1_qu11_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1490_MN1 (I1_qu11_b3_0 I1_qu11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1490_MN1_1 (VSS I1_qu11_b2_0 I1_qu11_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I306_MN1 (I1_dd14_b3_3 I1_dd14_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I306_MN1_1 (VSS I1_dd14_b2_1 I1_dd14_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1077_MN1 (I1_qu20_b3_1 I1_qu20_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1077_MN1_1 (VSS I1_qu20_b2_0 I1_qu20_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1076_MN1 (I1_qu20_b3_0 I1_qu20_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1076_MN1_1 (VSS I1_qu20_b2_0 I1_qu20_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I253_MN1 (I1_dd10_b3_2 I1_dd10_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I253_MN1_1 (VSS I1_dd10_b2_0 I1_dd10_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I240_MN1 (I1_dd9_b3_2 I1_dd9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I240_MN1_1 (VSS I1_dd9_b2_0 I1_dd9_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I266_MN1 (I1_dd11_b3_2 I1_dd11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I266_MN1_1 (VSS I1_dd11_b2_0 I1_dd11_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I214_MN1 (I1_dd7_b3_2 I1_dd7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I214_MN1_1 (VSS I1_dd7_b2_0 I1_dd7_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I379_MN1 (I1_dd20_b2_0 I1_dd20_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I379_MN1_1 (VSS I1_dd20_b1_0 I1_dd20_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I984_MN1 (I1_qu22_b3_0 I1_qu22_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I984_MN1_1 (VSS I1_qu22_b2_0 I1_qu22_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I985_MN1 (I1_qu22_b3_1 I1_qu22_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I985_MN1_1 (VSS I1_qu22_b2_0 I1_qu22_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I252_MN1 (I1_dd10_b3_1 I1_dd10_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I252_MN1_1 (VSS I1_dd10_b2_0 I1_dd10_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I239_MN1 (I1_dd9_b3_1 I1_dd9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I239_MN1_1 (VSS I1_dd9_b2_0 I1_dd9_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I226_MN1 (I1_dd8_b3_1 I1_dd8_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I226_MN1_1 (VSS I1_dd8_b2_0 I1_dd8_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I174_MN1 (I1_dd4_b3_1 I1_dd4_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I174_MN1_1 (VSS I1_dd4_b2_0 I1_dd4_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I212_MN1 (I1_dd7_b3_0 I1_dd7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I212_MN1_1 (VSS I1_dd7_b2_0 I1_dd7_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I187_MN1 (I1_dd5_b3_1 I1_dd5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I187_MN1_1 (VSS I1_dd5_b2_0 I1_dd5_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I264_MN1 (I1_dd11_b3_0 I1_dd11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I264_MN1_1 (VSS I1_dd11_b2_0 I1_dd11_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I225_MN1 (I1_dd8_b3_0 I1_dd8_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I225_MN1_1 (VSS I1_dd8_b2_0 I1_dd8_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I251_MN1 (I1_dd10_b3_0 I1_dd10_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I251_MN1_1 (VSS I1_dd10_b2_0 I1_dd10_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I173_MN1 (I1_dd4_b3_0 I1_dd4_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I173_MN1_1 (VSS I1_dd4_b2_0 I1_dd4_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I186_MN1 (I1_dd5_b3_0 I1_dd5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I186_MN1_1 (VSS I1_dd5_b2_0 I1_dd5_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I316_MN1 (I1_dd15_b3_0 I1_dd15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I316_MN1_1 (VSS I1_dd15_b2_0 I1_dd15_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I238_MN1 (I1_dd9_b3_0 I1_dd9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I238_MN1_1 (VSS I1_dd9_b2_0 I1_dd9_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I303_MN1 (I1_dd14_b3_0 I1_dd14_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I303_MN1_1 (VSS I1_dd14_b2_0 I1_dd14_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I571_MN1 (I1_qu31_b3_1 I1_qu31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I571_MN1_1 (VSS I1_qu31_b2_0 I1_qu31_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I332_MN1 (I1_dd16_b3_3 I1_dd16_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I332_MN1_1 (VSS I1_dd16_b2_1 I1_dd16_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I345_MN1 (I1_dd17_b3_3 I1_dd17_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I345_MN1_1 (VSS I1_dd17_b2_1 I1_dd17_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I319_MN1 (I1_dd15_b3_3 I1_dd15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I319_MN1_1 (VSS I1_dd15_b2_1 I1_dd15_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I293_MN1 (I1_dd13_b3_3 I1_dd13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I293_MN1_1 (VSS I1_dd13_b2_1 I1_dd13_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I227_MN1 (I1_dd8_b3_2 I1_dd8_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I227_MN1_1 (VSS I1_dd8_b2_0 I1_dd8_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I201_MN1 (I1_dd6_b3_2 I1_dd6_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I201_MN1_1 (VSS I1_dd6_b2_0 I1_dd6_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1031_MN1 (I1_qu21_b3_1 I1_qu21_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1031_MN1_1 (VSS I1_qu21_b2_0 I1_qu21_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1030_MN1 (I1_qu21_b3_0 I1_qu21_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1030_MN1_1 (VSS I1_qu21_b2_0 I1_qu21_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I314_MN1 (I1_dd15_b2_0 I1_dd15_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I314_MN1_1 (VSS I1_dd15_b1_0 I1_dd15_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I149_MN1 (I1_dd2_b3_2 I1_dd2_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I149_MN1_1 (VSS I1_dd2_b2_0 I1_dd2_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I136_MN1 (I1_dd1_b3_2 I1_dd1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I136_MN1_1 (VSS I1_dd1_b2_0 I1_dd1_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I327_MN1 (I1_dd16_b2_0 I1_dd16_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I327_MN1_1 (VSS I1_dd16_b1_0 I1_dd16_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I522_MN1 (I1_dd31_b2_0 I1_dd31_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I522_MN1_1 (VSS I1_dd31_b1_0 I1_dd31_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I161_MN1 (I1_dd3_b3_1 I1_dd3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I161_MN1_1 (VSS I1_dd3_b2_0 I1_dd3_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I148_MN1 (I1_dd2_b3_1 I1_dd2_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I148_MN1_1 (VSS I1_dd2_b2_0 I1_dd2_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I147_MN1 (I1_dd2_b3_0 I1_dd2_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I147_MN1_1 (VSS I1_dd2_b2_0 I1_dd2_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I160_MN1 (I1_dd3_b3_0 I1_dd3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I160_MN1_1 (VSS I1_dd3_b2_0 I1_dd3_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I199_MN1 (I1_dd6_b3_0 I1_dd6_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I199_MN1_1 (VSS I1_dd6_b2_0 I1_dd6_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I572_MN1 (I1_qu31_b3_2 I1_qu31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I572_MN1_1 (VSS I1_qu31_b2_0 I1_qu31_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I569_MN1 (I1_qu31_b2_1 I1_qu31_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I569_MN1_1 (VSS I1_qu31_b1_0 I1_qu31_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I568_MN1 (I1_qu31_b2_0 I1_qu31_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I568_MN1_1 (VSS I1_qu31_b1_0 I1_qu31_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I573_MN1 (I1_qu31_b3_3 I1_qu31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I573_MN1_1 (VSS I1_qu31_b2_1 I1_qu31_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I575_MN1 (I1_qu31_b3_5 I1_qu31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I575_MN1_1 (VSS I1_qu31_b2_1 I1_qu31_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I574_MN1 (I1_qu31_b3_4 I1_qu31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I574_MN1_1 (VSS I1_qu31_b2_1 I1_qu31_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1489_MN1 (I1_qu11_b2_1 I1_qu11_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1489_MN1_1 (VSS I1_qu11_b1_0 I1_qu11_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I384_MN1 (I1_dd20_b3_3 I1_dd20_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I384_MN1_1 (VSS I1_dd20_b2_1 I1_dd20_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I371_MN1 (I1_dd19_b3_3 I1_dd19_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I371_MN1_1 (VSS I1_dd19_b2_1 I1_dd19_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I358_MN1 (I1_dd18_b3_3 I1_dd18_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I358_MN1_1 (VSS I1_dd18_b2_1 I1_dd18_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I280_MN1 (I1_dd12_b3_3 I1_dd12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I280_MN1_1 (VSS I1_dd12_b2_1 I1_dd12_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I328_MN1 (I1_dd16_b2_1 I1_dd16_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I328_MN1_1 (VSS I1_dd16_b1_0 I1_dd16_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I241_MN1 (I1_dd9_b3_3 I1_dd9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I241_MN1_1 (VSS I1_dd9_b2_1 I1_dd9_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I315_MN1 (I1_dd15_b2_1 I1_dd15_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I315_MN1_1 (VSS I1_dd15_b1_0 I1_dd15_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I228_MN1 (I1_dd8_b3_3 I1_dd8_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I228_MN1_1 (VSS I1_dd8_b2_1 I1_dd8_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I188_MN1 (I1_dd5_b3_2 I1_dd5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I188_MN1_1 (VSS I1_dd5_b2_0 I1_dd5_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I175_MN1 (I1_dd4_b3_2 I1_dd4_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I175_MN1_1 (VSS I1_dd4_b2_0 I1_dd4_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I162_MN1 (I1_dd3_b3_2 I1_dd3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I162_MN1_1 (VSS I1_dd3_b2_0 I1_dd3_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I288_MN1 (I1_dd13_b2_0 I1_dd13_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I288_MN1_1 (VSS I1_dd13_b1_0 I1_dd13_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I132_MN1 (I1_dd1_b2_0 I1_dd1_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I132_MN1_1 (VSS I1_dd1_b1_0 I1_dd1_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I313_MN1 (I1_dd15_b1_0 I1_dd15_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I313_MN1_1 (VSS I1_dd15_b0 I1_dd15_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I32_MN1 (I1_B_0_b3_2 I1_B_0_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I32_MN1_1 (VSS I1_B_0_b2_0 I1_B_0_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I31_MN1 (I1_B_0_b3_1 I1_B_0_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I31_MN1_1 (VSS I1_B_0_b2_0 I1_B_0_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I340_MN1 (I1_dd17_b2_0 I1_dd17_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I340_MN1_1 (VSS I1_dd17_b1_0 I1_dd17_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I30_MN1 (I1_B_0_b3_0 I1_B_0_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I30_MN1_1 (VSS I1_B_0_b2_0 I1_B_0_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I405_MN1 (I1_dd22_b2_0 I1_dd22_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I405_MN1_1 (VSS I1_dd22_b1_0 I1_dd22_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I509_MN1 (I1_dd30_b2_0 I1_dd30_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I509_MN1_1 (VSS I1_dd30_b1_0 I1_dd30_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I392_MN1 (I1_dd21_b2_0 I1_dd21_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I392_MN1_1 (VSS I1_dd21_b1_0 I1_dd21_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I353_MN1 (I1_dd18_b2_0 I1_dd18_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I353_MN1_1 (VSS I1_dd18_b1_0 I1_dd18_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I366_MN1 (I1_dd19_b2_0 I1_dd19_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I366_MN1_1 (VSS I1_dd19_b1_0 I1_dd19_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I567_MN1 (I1_qu31_b1_0 I1_qu31_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I567_MN1_1 (VSS I1_qu31_b0 I1_qu31_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1494_MN1 (I1_qu11_b3_4 I1_qu11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1494_MN1_1 (VSS I1_qu11_b2_1 I1_qu11_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1493_MN1 (I1_qu11_b3_3 I1_qu11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1493_MN1_1 (VSS I1_qu11_b2_1 I1_qu11_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I410_MN1 (I1_dd22_b3_3 I1_dd22_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I410_MN1_1 (VSS I1_dd22_b2_1 I1_dd22_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I497_MN1 (I1_dd29_b2_1 I1_dd29_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I497_MN1_1 (VSS I1_dd29_b1_0 I1_dd29_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I397_MN1 (I1_dd21_b3_3 I1_dd21_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I397_MN1_1 (VSS I1_dd21_b2_1 I1_dd21_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I267_MN1 (I1_dd11_b3_3 I1_dd11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I267_MN1_1 (VSS I1_dd11_b2_1 I1_dd11_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I302_MN1 (I1_dd14_b2_1 I1_dd14_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I302_MN1_1 (VSS I1_dd14_b1_0 I1_dd14_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I215_MN1 (I1_dd7_b3_3 I1_dd7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I215_MN1_1 (VSS I1_dd7_b2_1 I1_dd7_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I137_MN1 (I1_dd1_b3_3 I1_dd1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I137_MN1_1 (VSS I1_dd1_b2_1 I1_dd1_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I237_MN1 (I1_dd9_b2_1 I1_dd9_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I237_MN1_1 (VSS I1_dd9_b1_0 I1_dd9_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I224_MN1 (I1_dd8_b2_1 I1_dd8_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I224_MN1_1 (VSS I1_dd8_b1_0 I1_dd8_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I367_MN1 (I1_dd19_b2_1 I1_dd19_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I367_MN1_1 (VSS I1_dd19_b1_0 I1_dd19_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I276_MN1 (I1_dd12_b2_1 I1_dd12_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I276_MN1_1 (VSS I1_dd12_b1_0 I1_dd12_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I393_MN1 (I1_dd21_b2_1 I1_dd21_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I393_MN1_1 (VSS I1_dd21_b1_0 I1_dd21_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I185_MN1 (I1_dd5_b2_1 I1_dd5_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I185_MN1_1 (VSS I1_dd5_b1_0 I1_dd5_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I133_MN1 (I1_dd1_b2_1 I1_dd1_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I133_MN1_1 (VSS I1_dd1_b1_0 I1_dd1_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I236_MN1 (I1_dd9_b2_0 I1_dd9_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I236_MN1_1 (VSS I1_dd9_b1_0 I1_dd9_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I223_MN1 (I1_dd8_b2_0 I1_dd8_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I223_MN1_1 (VSS I1_dd8_b1_0 I1_dd8_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I274_MN1 (I1_dd12_b1_0 I1_dd12_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I274_MN1_1 (VSS I1_dd12_b0 I1_dd12_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I275_MN1 (I1_dd12_b2_0 I1_dd12_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I275_MN1_1 (VSS I1_dd12_b1_0 I1_dd12_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I184_MN1 (I1_dd5_b2_0 I1_dd5_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I184_MN1_1 (VSS I1_dd5_b1_0 I1_dd5_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I197_MN1 (I1_dd6_b2_0 I1_dd6_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I197_MN1_1 (VSS I1_dd6_b1_0 I1_dd6_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I210_MN1 (I1_dd7_b2_0 I1_dd7_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I210_MN1_1 (VSS I1_dd7_b1_0 I1_dd7_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I171_MN1 (I1_dd4_b2_0 I1_dd4_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I171_MN1_1 (VSS I1_dd4_b1_0 I1_dd4_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I158_MN1 (I1_dd3_b2_0 I1_dd3_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I158_MN1_1 (VSS I1_dd3_b1_0 I1_dd3_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I287_MN1 (I1_dd13_b1_0 I1_dd13_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I287_MN1_1 (VSS I1_dd13_b0 I1_dd13_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I301_MN1 (I1_dd14_b2_0 I1_dd14_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I301_MN1_1 (VSS I1_dd14_b1_0 I1_dd14_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I145_MN1 (I1_dd2_b2_0 I1_dd2_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I145_MN1_1 (VSS I1_dd2_b1_0 I1_dd2_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I28_MN1 (I1_B_0_b2_0 I1_B_0_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I28_MN1_1 (VSS I1_B_0_b1_0 I1_B_0_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2075_MN1 (I1_sq_b3_3 I1_sq_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2075_MN1_1 (VSS I1_sq_b2_1 I1_sq_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I378_MN1 (I1_dd20_b1_0 I1_dd20_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I378_MN1_1 (VSS I1_dd20_b0 I1_dd20_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I391_MN1 (I1_dd21_b1_0 I1_dd21_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I391_MN1_1 (VSS I1_dd21_b0 I1_dd21_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I365_MN1 (I1_dd19_b1_0 I1_dd19_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I365_MN1_1 (VSS I1_dd19_b0 I1_dd19_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I495_MN1 (I1_dd29_b1_0 I1_dd29_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I495_MN1_1 (VSS I1_dd29_b0 I1_dd29_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2076_MN1 (I1_sq_b3_4 I1_sq_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2076_MN1_1 (VSS I1_sq_b2_1 I1_sq_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2077_MN1 (I1_sq_b3_5 I1_sq_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2077_MN1_1 (VSS I1_sq_b2_1 I1_sq_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I514_MN1 (I1_dd30_b3_3 I1_dd30_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I514_MN1_1 (VSS I1_dd30_b2_1 I1_dd30_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I501_MN1 (I1_dd29_b3_3 I1_dd29_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I501_MN1_1 (VSS I1_dd29_b2_1 I1_dd29_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1495_MN1 (I1_qu11_b3_5 I1_qu11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1495_MN1_1 (VSS I1_qu11_b2_1 I1_qu11_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I423_MN1 (I1_dd23_b3_3 I1_dd23_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I423_MN1_1 (VSS I1_dd23_b2_1 I1_dd23_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I462_MN1 (I1_dd26_b3_3 I1_dd26_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I462_MN1_1 (VSS I1_dd26_b2_1 I1_dd26_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I419_MN1 (I1_dd23_b2_1 I1_dd23_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I419_MN1_1 (VSS I1_dd23_b1_0 I1_dd23_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I406_MN1 (I1_dd22_b2_1 I1_dd22_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I406_MN1_1 (VSS I1_dd22_b1_0 I1_dd22_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I484_MN1 (I1_dd28_b2_1 I1_dd28_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I484_MN1_1 (VSS I1_dd28_b1_0 I1_dd28_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I510_MN1 (I1_dd30_b2_1 I1_dd30_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I510_MN1_1 (VSS I1_dd30_b1_0 I1_dd30_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I250_MN1 (I1_dd10_b2_1 I1_dd10_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I250_MN1_1 (VSS I1_dd10_b1_0 I1_dd10_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I263_MN1 (I1_dd11_b2_1 I1_dd11_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I263_MN1_1 (VSS I1_dd11_b1_0 I1_dd11_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I198_MN1 (I1_dd6_b2_1 I1_dd6_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I198_MN1_1 (VSS I1_dd6_b1_0 I1_dd6_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I172_MN1 (I1_dd4_b2_1 I1_dd4_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I172_MN1_1 (VSS I1_dd4_b1_0 I1_dd4_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I146_MN1 (I1_dd2_b2_1 I1_dd2_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I146_MN1_1 (VSS I1_dd2_b1_0 I1_dd2_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I249_MN1 (I1_dd10_b2_0 I1_dd10_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I249_MN1_1 (VSS I1_dd10_b1_0 I1_dd10_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I235_MN1 (I1_dd9_b1_0 I1_dd9_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I235_MN1_1 (VSS I1_dd9_b0 I1_dd9_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I262_MN1 (I1_dd11_b2_0 I1_dd11_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I262_MN1_1 (VSS I1_dd11_b1_0 I1_dd11_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I209_MN1 (I1_dd7_b1_0 I1_dd7_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I209_MN1_1 (VSS I1_dd7_b0 I1_dd7_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I183_MN1 (I1_dd5_b1_0 I1_dd5_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I183_MN1_1 (VSS I1_dd5_b0 I1_dd5_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I157_MN1 (I1_dd3_b1_0 I1_dd3_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I157_MN1_1 (VSS I1_dd3_b0 I1_dd3_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I300_MN1 (I1_dd14_b1_0 I1_dd14_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I300_MN1_1 (VSS I1_dd14_b0 I1_dd14_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I144_MN1 (I1_dd2_b1_0 I1_dd2_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I144_MN1_1 (VSS I1_dd2_b0 I1_dd2_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I131_MN1 (I1_dd1_b1_0 I1_dd1_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I131_MN1_1 (VSS I1_dd1_b0 I1_dd1_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I326_MN1 (I1_dd16_b1_0 I1_dd16_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I326_MN1_1 (VSS I1_dd16_b0 I1_dd16_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I404_MN1 (I1_dd22_b1_0 I1_dd22_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I404_MN1_1 (VSS I1_dd22_b0 I1_dd22_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I339_MN1 (I1_dd17_b1_0 I1_dd17_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I339_MN1_1 (VSS I1_dd17_b0 I1_dd17_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I508_MN1 (I1_dd30_b1_0 I1_dd30_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I508_MN1_1 (VSS I1_dd30_b0 I1_dd30_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I417_MN1 (I1_dd23_b1_0 I1_dd23_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I417_MN1_1 (VSS I1_dd23_b0 I1_dd23_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I521_MN1 (I1_dd31_b1_0 I1_dd31_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I521_MN1_1 (VSS I1_dd31_b0 I1_dd31_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2071_MN1 (I1_sq_b2_1 I1_sq_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2071_MN1_1 (VSS I1_sq_b1_0 I1_sq_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2069_MN1 (I1_sq_b1_0 I1_sq_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2069_MN1_1 (VSS I1_sq_b0 I1_sq_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I482_MN1 (I1_dd28_b1_0 I1_dd28_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I482_MN1_1 (VSS I1_dd28_b0 I1_dd28_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I469_MN1 (I1_dd27_b1_0 I1_dd27_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I469_MN1_1 (VSS I1_dd27_b0 I1_dd27_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I527_MN1 (I1_dd31_b3_3 I1_dd31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I527_MN1_1 (VSS I1_dd31_b2_1 I1_dd31_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I449_MN1 (I1_dd25_b3_3 I1_dd25_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I449_MN1_1 (VSS I1_dd25_b2_1 I1_dd25_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I488_MN1 (I1_dd28_b3_3 I1_dd28_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I488_MN1_1 (VSS I1_dd28_b2_1 I1_dd28_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I475_MN1 (I1_dd27_b3_3 I1_dd27_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I475_MN1_1 (VSS I1_dd27_b2_1 I1_dd27_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I436_MN1 (I1_dd24_b3_3 I1_dd24_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I436_MN1_1 (VSS I1_dd24_b2_1 I1_dd24_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I471_MN1 (I1_dd27_b2_1 I1_dd27_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I471_MN1_1 (VSS I1_dd27_b1_0 I1_dd27_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I248_MN1 (I1_dd10_b1_0 I1_dd10_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I248_MN1_1 (VSS I1_dd10_b0 I1_dd10_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I7_MN1 (I1_A_31_b3_2 I1_A_31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I7_MN1_1 (VSS I1_A_31_b2_0 I1_A_31_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I352_MN1 (I1_dd18_b1_0 I1_dd18_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I352_MN1_1 (VSS I1_dd18_b0 I1_dd18_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2070_MN1 (I1_sq_b2_0 I1_sq_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2070_MN1_1 (VSS I1_sq_b1_0 I1_sq_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I430_MN1 (I1_dd24_b1_0 I1_dd24_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I430_MN1_1 (VSS I1_dd24_b0 I1_dd24_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I443_MN1 (I1_dd25_b1_0 I1_dd25_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I443_MN1_1 (VSS I1_dd25_b0 I1_dd25_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I456_MN1 (I1_dd26_b1_0 I1_dd26_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I456_MN1_1 (VSS I1_dd26_b0 I1_dd26_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I8_MN1 (I1_A_31_b3_3 I1_A_31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I8_MN1_1 (VSS I1_A_31_b2_0 I1_A_31_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I23_MN1 (I1_B_31_b3_3 I1_B_31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I23_MN1_1 (VSS I1_B_31_b2_1 I1_B_31_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I25_MN1 (I1_B_31_b3_5 I1_B_31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I25_MN1_1 (VSS I1_B_31_b2_1 I1_B_31_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2074_MN1 (I1_sq_b3_2 I1_sq_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2074_MN1_1 (VSS I1_sq_b2_0 I1_sq_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I21_MN1 (I1_B_31_b3_1 I1_B_31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I21_MN1_1 (VSS I1_B_31_b2_0 I1_B_31_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I20_MN1 (I1_B_31_b3_0 I1_B_31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I20_MN1_1 (VSS I1_B_31_b2_0 I1_B_31_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I22_MN1 (I1_B_31_b3_2 I1_B_31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I22_MN1_1 (VSS I1_B_31_b2_0 I1_B_31_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I18_MN1 (I1_B_31_b2_0 I1_B_31_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I18_MN1_1 (VSS I1_B_31_b1_0 I1_B_31_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I19_MN1 (I1_B_31_b2_1 I1_B_31_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I19_MN1_1 (VSS I1_B_31_b1_0 I1_B_31_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I24_MN1 (I1_B_31_b3_4 I1_B_31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I24_MN1_1 (VSS I1_B_31_b2_1 I1_B_31_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I64_MN1 (I2_I3_SEL_DIV_b3_3 I2_I3_SEL_DIV_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I64_MN1_1 (VSS I2_I3_SEL_DIV_b2_0 I2_I3_SEL_DIV_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I8_MN1 (I2_I1_SUB_b3_4 I2_I1_SUB_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I8_MN1_1 (VSS I2_I1_SUB_b2_1 I2_I1_SUB_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I7_MN1 (I2_I1_SUB_b3_3 I2_I1_SUB_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I7_MN1_1 (VSS I2_I1_SUB_b2_1 I2_I1_SUB_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I17_MN1 (I1_B_31_b1_0 I1_B_31_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I17_MN1_1 (VSS I1_B_31_b0 I1_B_31_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I63_MN1 (I2_I3_SEL_DIV_b3_2 I2_I3_SEL_DIV_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I63_MN1_1 (VSS I2_I3_SEL_DIV_b2_0 I2_I3_SEL_DIV_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I79_MN1 (I2_I3_SEL_AS_b3_3 I2_I3_SEL_AS_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I79_MN1_1 (VSS I2_I3_SEL_AS_b2_1 I2_I3_SEL_AS_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I80_MN1 (I2_I3_SEL_AS_b3_4 I2_I3_SEL_AS_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I80_MN1_1 (VSS I2_I3_SEL_AS_b2_1 I2_I3_SEL_AS_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I9_MN1 (I1_A_31_b3_4 I1_A_31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I9_MN1_1 (VSS I1_A_31_b2_1 I1_A_31_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I17_MN1 (I2_I3_SEL_OR_b3_3 I2_I3_SEL_OR_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I17_MN1_1 (VSS I2_I3_SEL_OR_b2_1 I2_I3_SEL_OR_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I7_MN1 (I2_I3_SEL_AND_b3_3 I2_I3_SEL_AND_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I7_MN1_1 (VSS I2_I3_SEL_AND_b2_1 I2_I3_SEL_AND_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I18_MN1 (I2_I3_SEL_OR_b3_4 I2_I3_SEL_OR_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I18_MN1_1 (VSS I2_I3_SEL_OR_b2_1 I2_I3_SEL_OR_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I38_MN1 (I2_I3_SEL_NOT_b3_4 I2_I3_SEL_NOT_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I38_MN1_1 (VSS I2_I3_SEL_NOT_b2_1 I2_I3_SEL_NOT_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I19_MN1 (I2_I3_SEL_OR_b3_5 I2_I3_SEL_OR_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I19_MN1_1 (VSS I2_I3_SEL_OR_b2_1 I2_I3_SEL_OR_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I29_MN1 (I2_I3_SEL_XOR_b3_5 I2_I3_SEL_XOR_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I29_MN1_1 (VSS I2_I3_SEL_XOR_b2_1 I2_I3_SEL_XOR_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I28_MN1 (I2_I3_SEL_XOR_b3_4 I2_I3_SEL_XOR_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I28_MN1_1 (VSS I2_I3_SEL_XOR_b2_1 I2_I3_SEL_XOR_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I9_MN1 (I2_I3_SEL_AND_b3_5 I2_I3_SEL_AND_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I9_MN1_1 (VSS I2_I3_SEL_AND_b2_1 I2_I3_SEL_AND_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1531_MN1 (I1_qu10 I1_p21_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1531_MN1_1 (VSS I1_p21_32 I1_qu10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I6_MN1 (I2_I1_SUB_b3_2 I2_I1_SUB_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I6_MN1_1 (VSS I2_I1_SUB_b2_0 I2_I1_SUB_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I75_MN1 (I2_I3_SEL_AS_b2_1 I2_I3_SEL_AS_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I75_MN1_1 (VSS I2_I3_SEL_AS_b1_0 I2_I3_SEL_AS_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I81_MN1 (I2_I3_SEL_AS_b3_5 I2_I3_SEL_AS_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I81_MN1_1 (VSS I2_I3_SEL_AS_b2_1 I2_I3_SEL_AS_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I13_MN1 (I2_I3_SEL_OR_b2_1 I2_I3_SEL_OR_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I13_MN1_1 (VSS I2_I3_SEL_OR_b1_0 I2_I3_SEL_OR_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I33_MN1 (I2_I3_SEL_NOT_b2_1 I2_I3_SEL_NOT_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I33_MN1_1 (VSS I2_I3_SEL_NOT_b1_0 I2_I3_SEL_NOT_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I23_MN1 (I2_I3_SEL_XOR_b2_1 I2_I3_SEL_XOR_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I23_MN1_1 (VSS I2_I3_SEL_XOR_b1_0 I2_I3_SEL_XOR_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I3_MN1 (I2_I3_SEL_AND_b2_1 I2_I3_SEL_AND_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I3_MN1_1 (VSS I2_I3_SEL_AND_b1_0 I2_I3_SEL_AND_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I8_MN1 (I2_I3_SEL_AND_b3_4 I2_I3_SEL_AND_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I8_MN1_1 (VSS I2_I3_SEL_AND_b2_1 I2_I3_SEL_AND_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I39_MN1 (I2_I3_SEL_NOT_b3_5 I2_I3_SEL_NOT_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I39_MN1_1 (VSS I2_I3_SEL_NOT_b2_1 I2_I3_SEL_NOT_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I565_MN1 (I1_qu31 I1_p0_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I565_MN1_1 (VSS I1_p0_32 I1_qu31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1533_MN1 (I1_qu10_b1_0 I1_qu10_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1533_MN1_1 (VSS I1_qu10_b0 I1_qu10_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I22_MN1 (I2_I3_SEL_XOR_b2_0 I2_I3_SEL_XOR_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I22_MN1_1 (VSS I2_I3_SEL_XOR_b1_0 I2_I3_SEL_XOR_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I32_MN1 (I2_I3_SEL_NOT_b2_0 I2_I3_SEL_NOT_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I32_MN1_1 (VSS I2_I3_SEL_NOT_b1_0 I2_I3_SEL_NOT_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I2_MN1 (I2_I1_SUB_b2_0 I2_I1_SUB_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I2_MN1_1 (VSS I2_I1_SUB_b1_0 I2_I1_SUB_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I9_MN1 (I2_I1_SUB_b3_5 I2_I1_SUB_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I9_MN1_1 (VSS I2_I1_SUB_b2_1 I2_I1_SUB_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I3_MN1 (I2_I1_SUB_b2_1 I2_I1_SUB_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I3_MN1_1 (VSS I2_I1_SUB_b1_0 I2_I1_SUB_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I1_MN1 (I2_I1_SUB_b1_0 I2_I1_SUB_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I1_MN1_1 (VSS I2_I1_SUB_b0 I2_I1_SUB_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I11_MN1 (I2_I3_SEL_OR_b1_0 I2_I3_SEL_OR_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I11_MN1_1 (VSS I2_I3_SEL_OR_b0 I2_I3_SEL_OR_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I31_MN1 (I2_I3_SEL_NOT_b1_0 I2_I3_SEL_NOT_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I31_MN1_1 (VSS I2_I3_SEL_NOT_b0 I2_I3_SEL_NOT_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I21_MN1 (I2_I3_SEL_XOR_b1_0 I2_I3_SEL_XOR_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I21_MN1_1 (VSS I2_I3_SEL_XOR_b0 I2_I3_SEL_XOR_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I1_MN1 (I2_I3_SEL_AND_b1_0 I2_I3_SEL_AND_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I1_MN1_1 (VSS I2_I3_SEL_AND_b0 I2_I3_SEL_AND_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I443_MN1 (I0_B_25_b1_0 I0_B_25_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I443_MN1_1 (VSS I0_B_25_b0 I0_B_25_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I433_MN1 (I0_B_23_b1_0 I0_B_23_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I433_MN1_1 (VSS I0_B_23_b0 I0_B_23_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I191_MN1 (I0_A_18_b1_0 I0_A_18_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I191_MN1_1 (VSS I0_A_18_b0 I0_A_18_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I181_MN1 (I0_A_17_b1_0 I0_A_17_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I181_MN1_1 (VSS I0_A_17_b0 I0_A_17_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I201_MN1 (I0_A_19_b1_0 I0_A_19_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I201_MN1_1 (VSS I0_A_19_b0 I0_A_19_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I221_MN1 (I0_A_21_b1_0 I0_A_21_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I221_MN1_1 (VSS I0_A_21_b0 I0_A_21_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I211_MN1 (I0_A_20_b1_0 I0_A_20_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I211_MN1_1 (VSS I0_A_20_b0 I0_A_20_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I231_MN1 (I0_A_22_b1_0 I0_A_22_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I231_MN1_1 (VSS I0_A_22_b0 I0_A_22_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I261_MN1 (I0_A_25_b1_0 I0_A_25_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I261_MN1_1 (VSS I0_A_25_b0 I0_A_25_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I241_MN1 (I0_A_23_b1_0 I0_A_23_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I241_MN1_1 (VSS I0_A_23_b0 I0_A_23_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I281_MN1 (I0_A_27_b1_0 I0_A_27_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I281_MN1_1 (VSS I0_A_27_b0 I0_A_27_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I251_MN1 (I0_A_24_b1_0 I0_A_24_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I251_MN1_1 (VSS I0_A_24_b0 I0_A_24_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I423_MN1 (I0_B_21_b1_0 I0_B_21_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I423_MN1_1 (VSS I0_B_21_b0 I0_B_21_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I2_MN1 (I2_I3_SEL_AND_b2_0 I2_I3_SEL_AND_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I2_MN1_1 (VSS I2_I3_SEL_AND_b1_0 I2_I3_SEL_AND_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I12_MN1 (I2_I3_SEL_OR_b2_0 I2_I3_SEL_OR_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I12_MN1_1 (VSS I2_I3_SEL_OR_b1_0 I2_I3_SEL_OR_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I73_MN1 (I2_I3_SEL_AS_b1_0 I2_I3_SEL_AS_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I73_MN1_1 (VSS I2_I3_SEL_AS_b0 I2_I3_SEL_AS_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I501_MN1 (I0_two0_b3_4 I0_two0_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I501_MN1_1 (VSS I0_two0_b2_1 I0_two0_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I453_MN1 (I0_B_27_b1_0 I0_B_27_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I453_MN1_1 (VSS I0_B_27_b0 I0_B_27_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I463_MN1 (I0_B_29_b1_0 I0_B_29_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I463_MN1_1 (VSS I0_B_29_b0 I0_B_29_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I314_MN1 (I0_A_30_b3_0 I0_A_30_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I314_MN1_1 (VSS I0_A_30_b2_0 I0_A_30_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I291_MN1 (I0_A_28_b1_0 I0_A_28_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I291_MN1_1 (VSS I0_A_28_b0 I0_A_28_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I311_MN1 (I0_A_30_b1_0 I0_A_30_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I311_MN1_1 (VSS I0_A_30_b0 I0_A_30_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I312_MN1 (I0_A_30_b2_0 I0_A_30_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I312_MN1_1 (VSS I0_A_30_b1_0 I0_A_30_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I301_MN1 (I0_A_29_b1_0 I0_A_29_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I301_MN1_1 (VSS I0_A_29_b0 I0_A_29_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I78_MN1 (I2_I3_SEL_AS_b3_2 I2_I3_SEL_AS_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I78_MN1_1 (VSS I2_I3_SEL_AS_b2_0 I2_I3_SEL_AS_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I151_MN1 (I0_A_14_b1_0 I0_A_14_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I151_MN1_1 (VSS I0_A_14_b0 I0_A_14_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I9_MN1 (I0_B_1_b3_5 I0_B_1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I9_MN1_1 (VSS I0_B_1_b2_1 I0_B_1_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I161_MN1 (I0_A_15_b1_0 I0_A_15_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I161_MN1_1 (VSS I0_A_15_b0 I0_A_15_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I74_MN1 (I2_I3_SEL_AS_b2_0 I2_I3_SEL_AS_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I74_MN1_1 (VSS I2_I3_SEL_AS_b1_0 I2_I3_SEL_AS_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I383_MN1 (I0_B_13_b1_0 I0_B_13_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I383_MN1_1 (VSS I0_B_13_b0 I0_B_13_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I500_MN1 (I0_two0_b3_3 I0_two0_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I500_MN1_1 (VSS I0_two0_b2_1 I0_two0_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I490_MN1 (I0_one0_b3_3 I0_one0_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I490_MN1_1 (VSS I0_one0_b2_1 I0_one0_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I7_MN1 (I0_B_1_b3_3 I0_B_1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I7_MN1_1 (VSS I0_B_1_b2_1 I0_B_1_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I545_MN1 (I0_one1_b3_3 I0_one1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I545_MN1_1 (VSS I0_one1_b2_1 I0_one1_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I555_MN1 (I0_two1_b3_3 I0_two1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I555_MN1_1 (VSS I0_two1_b2_1 I0_two1_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I8_MN1 (I0_B_1_b3_4 I0_B_1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I8_MN1_1 (VSS I0_B_1_b2_1 I0_B_1_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I491_MN1 (I0_one0_b3_4 I0_one0_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I491_MN1_1 (VSS I0_one0_b2_1 I0_one0_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I546_MN1 (I0_one1_b3_4 I0_one1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I546_MN1_1 (VSS I0_one1_b2_1 I0_one1_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I557_MN1 (I0_two1_b3_5 I0_two1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I557_MN1_1 (VSS I0_two1_b2_1 I0_two1_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I492_MN1 (I0_one0_b3_5 I0_one0_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I492_MN1_1 (VSS I0_one0_b2_1 I0_one0_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I502_MN1 (I0_two0_b3_5 I0_two0_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I502_MN1_1 (VSS I0_two0_b2_1 I0_two0_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I547_MN1 (I0_one1_b3_5 I0_one1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I547_MN1_1 (VSS I0_one1_b2_1 I0_one1_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I601_MN1 (I0_one2_b3_4 I0_one2_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I601_MN1_1 (VSS I0_one2_b2_1 I0_one2_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I612_MN1 (I0_two2_b3_5 I0_two2_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I612_MN1_1 (VSS I0_two2_b2_1 I0_two2_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I602_MN1 (I0_one2_b3_5 I0_one2_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I602_MN1_1 (VSS I0_one2_b2_1 I0_one2_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I171_MN1 (I0_A_16_b1_0 I0_A_16_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I171_MN1_1 (VSS I0_A_16_b0 I0_A_16_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I284_MN1 (I0_A_27_b3_0 I0_A_27_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I284_MN1_1 (VSS I0_A_27_b2_0 I0_A_27_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I294_MN1 (I0_A_28_b3_0 I0_A_28_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I294_MN1_1 (VSS I0_A_28_b2_0 I0_A_28_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I292_MN1 (I0_A_28_b2_0 I0_A_28_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I292_MN1_1 (VSS I0_A_28_b1_0 I0_A_28_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I324_MN1 (I0_A_31_b3_0 I0_A_31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I324_MN1_1 (VSS I0_A_31_b2_0 I0_A_31_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I325_MN1 (I0_A_31_b3_1 I0_A_31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I325_MN1_1 (VSS I0_A_31_b2_0 I0_A_31_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I304_MN1 (I0_A_29_b3_0 I0_A_29_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I304_MN1_1 (VSS I0_A_29_b2_0 I0_A_29_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I302_MN1 (I0_A_29_b2_0 I0_A_29_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I302_MN1_1 (VSS I0_A_29_b1_0 I0_A_29_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I403_MN1 (I0_B_17_b1_0 I0_B_17_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I403_MN1_1 (VSS I0_B_17_b0 I0_B_17_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I413_MN1 (I0_B_19_b1_0 I0_B_19_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I413_MN1_1 (VSS I0_B_19_b0 I0_B_19_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1674_MN1 (I1_qu7_b3_0 I1_qu7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1674_MN1_1 (VSS I1_qu7_b2_0 I1_qu7_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1540_MN1 (I1_qu10_b3_4 I1_qu10_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1540_MN1_1 (VSS I1_qu10_b2_1 I1_qu10_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1541_MN1 (I1_qu10_b3_5 I1_qu10_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1541_MN1_1 (VSS I1_qu10_b2_1 I1_qu10_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1535_MN1 (I1_qu10_b2_1 I1_qu10_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1535_MN1_1 (VSS I1_qu10_b1_0 I1_qu10_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1539_MN1 (I1_qu10_b3_3 I1_qu10_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1539_MN1_1 (VSS I1_qu10_b2_1 I1_qu10_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1534_MN1 (I1_qu10_b2_0 I1_qu10_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1534_MN1_1 (VSS I1_qu10_b1_0 I1_qu10_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1536_MN1 (I1_qu10_b3_0 I1_qu10_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1536_MN1_1 (VSS I1_qu10_b2_0 I1_qu10_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I151_MN1 (I1_dd2_b3_4 I1_dd2_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I151_MN1_1 (VSS I1_dd2_b2_1 I1_dd2_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I34_MN1 (I1_B_0_b3_4 I1_B_0_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I34_MN1_1 (VSS I1_B_0_b2_1 I1_B_0_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I33_MN1 (I1_B_0_b3_3 I1_B_0_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I33_MN1_1 (VSS I1_B_0_b2_1 I1_B_0_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I35_MN1 (I1_B_0_b3_5 I1_B_0_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I35_MN1_1 (VSS I1_B_0_b2_1 I1_B_0_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I6_MN1 (I1_A_31_b3_1 I1_A_31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I6_MN1_1 (VSS I1_A_31_b2_0 I1_A_31_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I29_MN1 (I1_B_0_b2_1 I1_B_0_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I29_MN1_1 (VSS I1_B_0_b1_0 I1_B_0_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I5_MN1 (I2_I1_SUB_b3_1 I2_I1_SUB_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I5_MN1_1 (VSS I2_I1_SUB_b2_0 I2_I1_SUB_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I58_MN1 (I2_I3_SEL_DIV_b2_0 I2_I3_SEL_DIV_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I58_MN1_1 (VSS I2_I3_SEL_DIV_b1_0 I2_I3_SEL_DIV_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I3_MN1 (I0_B_1_b2_1 I0_B_1_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I3_MN1_1 (VSS I0_B_1_b1_0 I0_B_1_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I335_MN1 (I0_B_3_b2_1 I0_B_3_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I335_MN1_1 (VSS I0_B_3_b1_0 I0_B_3_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I57_MN1 (I2_I3_SEL_DIV_b1_0 I2_I3_SEL_DIV_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I57_MN1_1 (VSS I2_I3_SEL_DIV_b0 I2_I3_SEL_DIV_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I541_MN1 (I0_one1_b2_1 I0_one1_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I541_MN1_1 (VSS I0_one1_b1_0 I0_one1_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I373_MN1 (I0_B_11_b1_0 I0_B_11_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I373_MN1_1 (VSS I0_B_11_b0 I0_B_11_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I551_MN1 (I0_two1_b2_1 I0_two1_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I551_MN1_1 (VSS I0_two1_b1_0 I0_two1_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I141_MN1 (I0_A_13_b1_0 I0_A_13_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I141_MN1_1 (VSS I0_A_13_b0 I0_A_13_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I131_MN1 (I0_A_12_b1_0 I0_A_12_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I131_MN1_1 (VSS I0_A_12_b0 I0_A_12_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I596_MN1 (I0_one2_b2_1 I0_one2_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I596_MN1_1 (VSS I0_one2_b1_0 I0_one2_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I606_MN1 (I0_two2_b2_1 I0_two2_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I606_MN1_1 (VSS I0_two2_b1_0 I0_two2_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I341_MN1 (I0_B_3_b3_5 I0_B_3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I341_MN1_1 (VSS I0_B_3_b2_1 I0_B_3_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I351_MN1 (I0_B_5_b3_5 I0_B_5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I351_MN1_1 (VSS I0_B_5_b2_1 I0_B_5_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I393_MN1 (I0_B_15_b1_0 I0_B_15_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I393_MN1_1 (VSS I0_B_15_b0 I0_B_15_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I340_MN1 (I0_B_3_b3_4 I0_B_3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I340_MN1_1 (VSS I0_B_3_b2_1 I0_B_3_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I339_MN1 (I0_B_3_b3_3 I0_B_3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I339_MN1_1 (VSS I0_B_3_b2_1 I0_B_3_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I600_MN1 (I0_one2_b3_3 I0_one2_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I600_MN1_1 (VSS I0_one2_b2_1 I0_one2_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I610_MN1 (I0_two2_b3_3 I0_two2_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I610_MN1_1 (VSS I0_two2_b2_1 I0_two2_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I349_MN1 (I0_B_5_b3_3 I0_B_5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I349_MN1_1 (VSS I0_B_5_b2_1 I0_B_5_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I350_MN1 (I0_B_5_b3_4 I0_B_5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I350_MN1_1 (VSS I0_B_5_b2_1 I0_B_5_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I556_MN1 (I0_two1_b3_4 I0_two1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I556_MN1_1 (VSS I0_two1_b2_1 I0_two1_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I611_MN1 (I0_two2_b3_4 I0_two2_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I611_MN1_1 (VSS I0_two2_b2_1 I0_two2_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I274_MN1 (I0_A_26_b3_0 I0_A_26_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
