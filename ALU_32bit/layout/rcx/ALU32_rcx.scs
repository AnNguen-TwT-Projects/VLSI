    I_MXI1_I654_I218_MN5 (XI1_I654_I218_n2 XI1_I654_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I654_I218_MN4 (I1_p2_15 XI1_I654_I218_An XI1_I654_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I654_I218_MN2 (XI1_I654_I218_n1 I1_I654_pn15 I1_p2_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I654_I218_MN3 (VSS I1_I654_G14_0n XI1_I654_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I654_I218_MN0 (XI1_I654_I218_An I1_I654_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I218_MN1 (XI1_I1436_I218_Bn I1_I1436_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I218_MN5 (XI1_I1436_I218_n2 XI1_I1436_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1436_I218_MN4 (I1_p19_15 XI1_I1436_I218_An XI1_I1436_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1436_I218_MN2 (XI1_I1436_I218_n1 I1_I1436_pn15 I1_p19_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1436_I218_MN3 (VSS I1_I1436_G14_0n XI1_I1436_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1436_I218_MN0 (XI1_I1436_I218_An I1_I1436_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1405_MN1 (XI1_I1405_Bn I1_qu13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1405_MN5 (XI1_I1405_n2 XI1_I1405_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1405_MN4 (I1_b19_1 XI1_I1405_An XI1_I1405_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1405_MN2 (XI1_I1405_n1 I1_dd1_b3_3 I1_b19_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1405_MN3 (VSS I1_qu13_b3_0 XI1_I1405_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1405_MN0 (XI1_I1405_An I1_dd1_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I219_MN1 (XI1_I1114_I219_Bn I1_I1114_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I219_MN5 (XI1_I1114_I219_n2 XI1_I1114_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1114_I219_MN4 (I1_p12_16 XI1_I1114_I219_An XI1_I1114_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1114_I219_MN2 (XI1_I1114_I219_n1 I1_I1114_pn16 I1_p12_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1114_I219_MN3 (VSS I1_I1114_G15_0n XI1_I1114_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1114_I219_MN0 (XI1_I1114_I219_An I1_I1114_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1102_MN1 (XI1_I1102_Bn I1_qu20_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1102_MN5 (XI1_I1102_n2 XI1_I1102_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1102_MN4 (I1_b12_20 XI1_I1102_An XI1_I1102_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1102_MN2 (XI1_I1102_n1 I1_dd20_b3_2 I1_b12_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1102_MN3 (VSS I1_qu20_b3_3 XI1_I1102_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1102_MN0 (XI1_I1102_An I1_dd20_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1101_MN1 (XI1_I1101_Bn I1_qu20_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1101_MN5 (XI1_I1101_n2 XI1_I1101_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1101_MN4 (I1_b12_19 XI1_I1101_An XI1_I1101_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1101_MN2 (XI1_I1101_n1 I1_dd19_b3_2 I1_b12_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1101_MN3 (VSS I1_qu20_b3_3 XI1_I1101_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1101_MN0 (XI1_I1101_An I1_dd19_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1070_MN1 (XI1_I1070_Bn I1_c11_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1070_MN5 (XI1_I1070_n2 XI1_I1070_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1070_MN4 (I1_p11_32 XI1_I1070_An XI1_I1070_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1070_MN2 (XI1_I1070_n1 I1_h11 I1_p11_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1070_MN3 (VSS I1_c11_o XI1_I1070_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1070_MN0 (XI1_I1070_An I1_h11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1069_MN1 (XI1_I1069_Bn I1_qu21_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1069_MN5 (XI1_I1069_n2 XI1_I1069_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1069_MN4 (I1_h11 XI1_I1069_An XI1_I1069_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1069_MN2 (XI1_I1069_n1 I1_p10_31 I1_h11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1069_MN3 (VSS I1_qu21_b3_5 XI1_I1069_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1069_MN0 (XI1_I1069_An I1_p10_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1020_MN1 (XI1_I1020_Bn I1_qu22_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1020_MN5 (XI1_I1020_n2 XI1_I1020_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1020_MN4 (I1_b10_30 XI1_I1020_An XI1_I1020_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1020_MN2 (XI1_I1020_n1 I1_dd30_b3_1 I1_b10_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1020_MN3 (VSS I1_qu22_b3_5 XI1_I1020_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1020_MN0 (XI1_I1020_An I1_dd30_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1021_MN1 (XI1_I1021_Bn I1_qu22_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1021_MN5 (XI1_I1021_n2 XI1_I1021_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1021_MN4 (I1_b10_31 XI1_I1021_An XI1_I1021_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1021_MN2 (XI1_I1021_n1 I1_dd31_b3_1 I1_b10_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1021_MN3 (VSS I1_qu22_b3_5 XI1_I1021_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1021_MN0 (XI1_I1021_An I1_dd31_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I952_MN1 (XI1_I952_Bn I1_qu23_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I952_MN5 (XI1_I952_n2 XI1_I952_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I952_MN4 (I1_b9_8 XI1_I952_An XI1_I952_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I952_MN2 (XI1_I952_n1 I1_dd8_b3_1 I1_b9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I952_MN3 (VSS I1_qu23_b3_1 XI1_I952_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I952_MN0 (XI1_I952_An I1_dd8_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I950_MN1 (XI1_I950_Bn I1_qu23_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I950_MN5 (XI1_I950_n2 XI1_I950_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I950_MN4 (I1_b9_6 XI1_I950_An XI1_I950_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I950_MN2 (XI1_I950_n1 I1_dd6_b3_1 I1_b9_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I950_MN3 (VSS I1_qu23_b3_1 XI1_I950_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I950_MN0 (XI1_I950_An I1_dd6_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I623_MN1 (XI1_I623_Bn I1_qu30_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I623_MN5 (XI1_I623_n2 XI1_I623_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I623_MN4 (I1_b2_1 XI1_I623_An XI1_I623_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I623_MN2 (XI1_I623_n1 I1_dd1_b3_0 I1_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I623_MN3 (VSS I1_qu30_b3_0 XI1_I623_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I623_MN0 (XI1_I623_An I1_dd1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I624_MN1 (XI1_I624_Bn I1_qu30_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I624_MN5 (XI1_I624_n2 XI1_I624_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I624_MN4 (I1_b2_2 XI1_I624_An XI1_I624_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I624_MN2 (XI1_I624_n1 I1_dd2_b3_0 I1_b2_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I624_MN3 (VSS I1_qu30_b3_0 XI1_I624_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I624_MN0 (XI1_I624_An I1_dd2_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I625_MN1 (XI1_I625_Bn I1_qu30_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I625_MN5 (XI1_I625_n2 XI1_I625_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I625_MN4 (I1_b2_3 XI1_I625_An XI1_I625_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I625_MN2 (XI1_I625_n1 I1_dd3_b3_0 I1_b2_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I625_MN3 (VSS I1_qu30_b3_0 XI1_I625_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I625_MN0 (XI1_I625_An I1_dd3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1434_MN1 (XI1_I1434_Bn I1_qu13_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1434_MN5 (XI1_I1434_n2 XI1_I1434_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1434_MN4 (I1_b19_30 XI1_I1434_An XI1_I1434_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1434_MN2 (XI1_I1434_n1 I1_dd30_b3_3 I1_b19_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1434_MN3 (VSS I1_qu13_b3_5 XI1_I1434_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1434_MN0 (XI1_I1434_An I1_dd30_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I216_MN1 (XI1_I1436_I216_Bn I1_I1436_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I216_MN5 (XI1_I1436_I216_n2 XI1_I1436_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1436_I216_MN4 (I1_p19_13 XI1_I1436_I216_An XI1_I1436_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1436_I216_MN2 (XI1_I1436_I216_n1 I1_I1436_pn13 I1_p19_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1436_I216_MN3 (VSS I1_I1436_G12_0n XI1_I1436_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1436_I216_MN0 (XI1_I1436_I216_An I1_I1436_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I214_MN1 (XI1_I1436_I214_Bn I1_I1436_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I214_MN5 (XI1_I1436_I214_n2 XI1_I1436_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1436_I214_MN4 (I1_p19_11 XI1_I1436_I214_An XI1_I1436_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1436_I214_MN2 (XI1_I1436_I214_n1 I1_I1436_pn11 I1_p19_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1436_I214_MN3 (VSS I1_I1436_G10_0n XI1_I1436_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1436_I214_MN0 (XI1_I1436_I214_An I1_I1436_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I212_MN1 (XI1_I1436_I212_Bn I1_I1436_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I212_MN5 (XI1_I1436_I212_n2 XI1_I1436_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1436_I212_MN4 (I1_p19_9 XI1_I1436_I212_An XI1_I1436_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1436_I212_MN2 (XI1_I1436_I212_n1 I1_I1436_pn9 I1_p19_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1436_I212_MN3 (VSS I1_I1436_G8_0n XI1_I1436_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1436_I212_MN0 (XI1_I1436_I212_An I1_I1436_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1100_MN1 (XI1_I1100_Bn I1_qu20_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1100_MN5 (XI1_I1100_n2 XI1_I1100_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1100_MN4 (I1_b12_18 XI1_I1100_An XI1_I1100_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1100_MN2 (XI1_I1100_n1 I1_dd18_b3_2 I1_b12_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1100_MN3 (VSS I1_qu20_b3_3 XI1_I1100_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1100_MN0 (XI1_I1100_An I1_dd18_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1059_MN1 (XI1_I1059_Bn I1_qu21_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1059_MN5 (XI1_I1059_n2 XI1_I1059_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1059_MN4 (I1_b11_23 XI1_I1059_An XI1_I1059_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1059_MN2 (XI1_I1059_n1 I1_dd23_b3_2 I1_b11_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1059_MN3 (VSS I1_qu21_b3_3 XI1_I1059_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1059_MN0 (XI1_I1059_An I1_dd23_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I978_MN1 (XI1_I978_Bn I1_c9_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I978_MN5 (XI1_I978_n2 XI1_I978_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I978_MN4 (I1_p9_32 XI1_I978_An XI1_I978_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I978_MN2 (XI1_I978_n1 I1_h9 I1_p9_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I978_MN3 (VSS I1_c9_o XI1_I978_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I978_MN0 (XI1_I978_An I1_h9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I899_MN1 (XI1_I899_Bn I1_qu24_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I899_MN5 (XI1_I899_n2 XI1_I899_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I899_MN4 (I1_b8_1 XI1_I899_An XI1_I899_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I899_MN2 (XI1_I899_n1 I1_dd1_b3_1 I1_b8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I899_MN3 (VSS I1_qu24_b3_0 XI1_I899_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I899_MN0 (XI1_I899_An I1_dd1_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I622_MN1 (XI1_I622_Bn I1_qu30_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I622_MN5 (XI1_I622_n2 XI1_I622_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I622_MN4 (I1_b2_0 XI1_I622_An XI1_I622_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I622_MN2 (XI1_I622_n1 I1_B_0_b3_0 I1_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I622_MN3 (VSS I1_qu30_b3_0 XI1_I622_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I622_MN0 (XI1_I622_An I1_B_0_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I626_MN1 (XI1_I626_Bn I1_qu30_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I626_MN5 (XI1_I626_n2 XI1_I626_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I626_MN4 (I1_b2_4 XI1_I626_An XI1_I626_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I626_MN2 (XI1_I626_n1 I1_dd4_b3_0 I1_b2_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I626_MN3 (VSS I1_qu30_b3_0 XI1_I626_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I626_MN0 (XI1_I626_An I1_dd4_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I627_MN1 (XI1_I627_Bn I1_qu30_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I627_MN5 (XI1_I627_n2 XI1_I627_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I627_MN4 (I1_b2_5 XI1_I627_An XI1_I627_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I627_MN2 (XI1_I627_n1 I1_dd5_b3_0 I1_b2_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I627_MN3 (VSS I1_qu30_b3_0 XI1_I627_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I627_MN0 (XI1_I627_An I1_dd5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I650_MN1 (XI1_I650_Bn I1_qu30_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I650_MN5 (XI1_I650_n2 XI1_I650_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I650_MN4 (I1_b2_28 XI1_I650_An XI1_I650_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I650_MN2 (XI1_I650_n1 I1_dd28_b3_0 I1_b2_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I650_MN3 (VSS I1_qu30_b3_4 XI1_I650_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I650_MN0 (XI1_I650_An I1_dd28_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I651_MN1 (XI1_I651_Bn I1_qu30_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I651_MN5 (XI1_I651_n2 XI1_I651_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I651_MN4 (I1_b2_29 XI1_I651_An XI1_I651_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I651_MN2 (XI1_I651_n1 I1_dd29_b3_0 I1_b2_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I651_MN3 (VSS I1_qu30_b3_4 XI1_I651_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I651_MN0 (XI1_I651_An I1_dd29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I217_MN1 (XI1_I1436_I217_Bn I1_I1436_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I217_MN5 (XI1_I1436_I217_n2 XI1_I1436_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1436_I217_MN4 (I1_p19_14 XI1_I1436_I217_An XI1_I1436_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1436_I217_MN2 (XI1_I1436_I217_n1 I1_I1436_pn14 I1_p19_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1436_I217_MN3 (VSS I1_I1436_G13_0n XI1_I1436_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1436_I217_MN0 (XI1_I1436_I217_An I1_I1436_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I206_MN1 (XI1_I1436_I206_Bn I1_I1436_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I206_MN5 (XI1_I1436_I206_n2 XI1_I1436_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1436_I206_MN4 (I1_p19_3 XI1_I1436_I206_An XI1_I1436_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1436_I206_MN2 (XI1_I1436_I206_n1 I1_I1436_pn3 I1_p19_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1436_I206_MN3 (VSS I1_I1436_G2_0n XI1_I1436_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1436_I206_MN0 (XI1_I1436_I206_An I1_I1436_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1404_MN1 (XI1_I1404_Bn I1_qu13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1404_MN5 (XI1_I1404_n2 XI1_I1404_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1404_MN4 (I1_b19_0 XI1_I1404_An XI1_I1404_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1404_MN2 (XI1_I1404_n1 I1_B_0_b3_3 I1_b19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1404_MN3 (VSS I1_qu13_b3_0 XI1_I1404_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1404_MN0 (XI1_I1404_An I1_B_0_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I217_MN1 (XI1_I1114_I217_Bn I1_I1114_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I217_MN5 (XI1_I1114_I217_n2 XI1_I1114_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1114_I217_MN4 (I1_p12_14 XI1_I1114_I217_An XI1_I1114_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1114_I217_MN2 (XI1_I1114_I217_n1 I1_I1114_pn14 I1_p12_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1114_I217_MN3 (VSS I1_I1114_G13_0n XI1_I1114_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1114_I217_MN0 (XI1_I1114_I217_An I1_I1114_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I219_MN1 (XI1_I1068_I219_Bn I1_I1068_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I219_MN5 (XI1_I1068_I219_n2 XI1_I1068_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1068_I219_MN4 (I1_p11_16 XI1_I1068_I219_An XI1_I1068_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1068_I219_MN2 (XI1_I1068_I219_n1 I1_I1068_pn16 I1_p11_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1068_I219_MN3 (VSS I1_I1068_G15_0n XI1_I1068_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1068_I219_MN0 (XI1_I1068_I219_An I1_I1068_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1058_MN1 (XI1_I1058_Bn I1_qu21_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1058_MN5 (XI1_I1058_n2 XI1_I1058_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1058_MN4 (I1_b11_22 XI1_I1058_An XI1_I1058_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1058_MN2 (XI1_I1058_n1 I1_dd22_b3_2 I1_b11_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1058_MN3 (VSS I1_qu21_b3_3 XI1_I1058_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1058_MN0 (XI1_I1058_An I1_dd22_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1057_MN1 (XI1_I1057_Bn I1_qu21_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1057_MN5 (XI1_I1057_n2 XI1_I1057_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1057_MN4 (I1_b11_21 XI1_I1057_An XI1_I1057_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1057_MN2 (XI1_I1057_n1 I1_dd21_b3_2 I1_b11_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1057_MN3 (VSS I1_qu21_b3_3 XI1_I1057_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1057_MN0 (XI1_I1057_An I1_dd21_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1013_MN1 (XI1_I1013_Bn I1_qu22_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1013_MN5 (XI1_I1013_n2 XI1_I1013_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1013_MN4 (I1_b10_23 XI1_I1013_An XI1_I1013_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1013_MN2 (XI1_I1013_n1 I1_dd23_b3_1 I1_b10_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1013_MN3 (VSS I1_qu22_b3_3 XI1_I1013_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1013_MN0 (XI1_I1013_An I1_dd23_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I219_MN1 (XI1_I976_I219_Bn I1_I976_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I219_MN5 (XI1_I976_I219_n2 XI1_I976_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I976_I219_MN4 (I1_p9_16 XI1_I976_I219_An XI1_I976_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I976_I219_MN2 (XI1_I976_I219_n1 I1_I976_pn16 I1_p9_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I976_I219_MN3 (VSS I1_I976_G15_0n XI1_I976_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I976_I219_MN0 (XI1_I976_I219_An I1_I976_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I217_MN1 (XI1_I976_I217_Bn I1_I976_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I217_MN5 (XI1_I976_I217_n2 XI1_I976_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I976_I217_MN4 (I1_p9_14 XI1_I976_I217_An XI1_I976_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I976_I217_MN2 (XI1_I976_I217_n1 I1_I976_pn14 I1_p9_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I976_I217_MN3 (VSS I1_I976_G13_0n XI1_I976_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I976_I217_MN0 (XI1_I976_I217_An I1_I976_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I898_MN1 (XI1_I898_Bn I1_qu24_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I898_MN5 (XI1_I898_n2 XI1_I898_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I898_MN4 (I1_b8_0 XI1_I898_An XI1_I898_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I898_MN2 (XI1_I898_n1 I1_B_0_b3_1 I1_b8_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I898_MN3 (VSS I1_qu24_b3_0 XI1_I898_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I898_MN0 (XI1_I898_An I1_B_0_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I949_MN1 (XI1_I949_Bn I1_qu23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I949_MN5 (XI1_I949_n2 XI1_I949_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I949_MN4 (I1_b9_5 XI1_I949_An XI1_I949_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I949_MN2 (XI1_I949_n1 I1_dd5_b3_1 I1_b9_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I949_MN3 (VSS I1_qu23_b3_0 XI1_I949_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I949_MN0 (XI1_I949_An I1_dd5_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I629_MN1 (XI1_I629_Bn I1_qu30_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I629_MN5 (XI1_I629_n2 XI1_I629_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I629_MN4 (I1_b2_7 XI1_I629_An XI1_I629_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I629_MN2 (XI1_I629_n1 I1_dd7_b3_0 I1_b2_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I629_MN3 (VSS I1_qu30_b3_1 XI1_I629_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I629_MN0 (XI1_I629_An I1_dd7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I630_MN1 (XI1_I630_Bn I1_qu30_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I630_MN5 (XI1_I630_n2 XI1_I630_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I630_MN4 (I1_b2_8 XI1_I630_An XI1_I630_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I630_MN2 (XI1_I630_n1 I1_dd8_b3_0 I1_b2_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I630_MN3 (VSS I1_qu30_b3_1 XI1_I630_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I630_MN0 (XI1_I630_An I1_dd8_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I631_MN1 (XI1_I631_Bn I1_qu30_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I631_MN5 (XI1_I631_n2 XI1_I631_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I631_MN4 (I1_b2_9 XI1_I631_An XI1_I631_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I631_MN2 (XI1_I631_n1 I1_dd9_b3_0 I1_b2_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I631_MN3 (VSS I1_qu30_b3_1 XI1_I631_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I631_MN0 (XI1_I631_An I1_dd9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I633_MN1 (XI1_I633_Bn I1_qu30_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I633_MN5 (XI1_I633_n2 XI1_I633_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I633_MN4 (I1_b2_11 XI1_I633_An XI1_I633_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I633_MN2 (XI1_I633_n1 I1_dd11_b3_0 I1_b2_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I633_MN3 (VSS I1_qu30_b3_1 XI1_I633_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I633_MN0 (XI1_I633_An I1_dd11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I635_MN1 (XI1_I635_Bn I1_qu30_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I635_MN5 (XI1_I635_n2 XI1_I635_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I635_MN4 (I1_b2_13 XI1_I635_An XI1_I635_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I635_MN2 (XI1_I635_n1 I1_dd13_b3_0 I1_b2_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I635_MN3 (VSS I1_qu30_b3_2 XI1_I635_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I635_MN0 (XI1_I635_An I1_dd13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I638_MN1 (XI1_I638_Bn I1_qu30_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I638_MN5 (XI1_I638_n2 XI1_I638_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I638_MN4 (I1_b2_16 XI1_I638_An XI1_I638_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I638_MN2 (XI1_I638_n1 I1_dd16_b3_0 I1_b2_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I638_MN3 (VSS I1_qu30_b3_2 XI1_I638_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I638_MN0 (XI1_I638_An I1_dd16_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I641_MN1 (XI1_I641_Bn I1_qu30_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I641_MN5 (XI1_I641_n2 XI1_I641_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I641_MN4 (I1_b2_19 XI1_I641_An XI1_I641_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I641_MN2 (XI1_I641_n1 I1_dd19_b3_0 I1_b2_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I641_MN3 (VSS I1_qu30_b3_3 XI1_I641_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I641_MN0 (XI1_I641_An I1_dd19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I644_MN1 (XI1_I644_Bn I1_qu30_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I644_MN5 (XI1_I644_n2 XI1_I644_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I644_MN4 (I1_b2_22 XI1_I644_An XI1_I644_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I644_MN2 (XI1_I644_n1 I1_dd22_b3_0 I1_b2_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I644_MN3 (VSS I1_qu30_b3_3 XI1_I644_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I644_MN0 (XI1_I644_An I1_dd22_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I646_MN1 (XI1_I646_Bn I1_qu30_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I646_MN5 (XI1_I646_n2 XI1_I646_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I646_MN4 (I1_b2_24 XI1_I646_An XI1_I646_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I646_MN2 (XI1_I646_n1 I1_dd24_b3_0 I1_b2_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I646_MN3 (VSS I1_qu30_b3_4 XI1_I646_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I646_MN0 (XI1_I646_An I1_dd24_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I648_MN1 (XI1_I648_Bn I1_qu30_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I648_MN5 (XI1_I648_n2 XI1_I648_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I648_MN4 (I1_b2_26 XI1_I648_An XI1_I648_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I648_MN2 (XI1_I648_n1 I1_dd26_b3_0 I1_b2_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I648_MN3 (VSS I1_qu30_b3_4 XI1_I648_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I648_MN0 (XI1_I648_An I1_dd26_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I649_MN1 (XI1_I649_Bn I1_qu30_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I649_MN5 (XI1_I649_n2 XI1_I649_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I649_MN4 (I1_b2_27 XI1_I649_An XI1_I649_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I649_MN2 (XI1_I649_n1 I1_dd27_b3_0 I1_b2_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I649_MN3 (VSS I1_qu30_b3_4 XI1_I649_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I649_MN0 (XI1_I649_An I1_dd27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I647_MN1 (XI1_I647_Bn I1_qu30_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I647_MN5 (XI1_I647_n2 XI1_I647_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I647_MN4 (I1_b2_25 XI1_I647_An XI1_I647_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I647_MN2 (XI1_I647_n1 I1_dd25_b3_0 I1_b2_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I647_MN3 (VSS I1_qu30_b3_4 XI1_I647_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I647_MN0 (XI1_I647_An I1_dd25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I652_MN1 (XI1_I652_Bn I1_qu30_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I652_MN5 (XI1_I652_n2 XI1_I652_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I652_MN4 (I1_b2_30 XI1_I652_An XI1_I652_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I652_MN2 (XI1_I652_n1 I1_dd30_b3_0 I1_b2_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I652_MN3 (VSS I1_qu30_b3_5 XI1_I652_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I652_MN0 (XI1_I652_An I1_dd30_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1435_MN1 (XI1_I1435_Bn I1_qu13_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1435_MN5 (XI1_I1435_n2 XI1_I1435_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1435_MN4 (I1_b19_31 XI1_I1435_An XI1_I1435_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1435_MN2 (XI1_I1435_n1 I1_dd31_b3_3 I1_b19_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1435_MN3 (VSS I1_qu13_b3_5 XI1_I1435_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1435_MN0 (XI1_I1435_An I1_dd31_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I219_MN1 (XI1_I1436_I219_Bn I1_I1436_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I219_MN5 (XI1_I1436_I219_n2 XI1_I1436_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1436_I219_MN4 (I1_p19_16 XI1_I1436_I219_An XI1_I1436_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1436_I219_MN2 (XI1_I1436_I219_n1 I1_I1436_pn16 I1_p19_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1436_I219_MN3 (VSS I1_I1436_G15_0n XI1_I1436_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1436_I219_MN0 (XI1_I1436_I219_An I1_I1436_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1466_MN1 (XI1_I1466_Bn I1_qu12_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1466_MN5 (XI1_I1466_n2 XI1_I1466_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1466_MN4 (I1_b20_16 XI1_I1466_An XI1_I1466_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1466_MN2 (XI1_I1466_n1 I1_dd16_b3_3 I1_b20_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1466_MN3 (VSS I1_qu12_b3_2 XI1_I1466_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1466_MN0 (XI1_I1466_An I1_dd16_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1464_MN1 (XI1_I1464_Bn I1_qu12_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1464_MN5 (XI1_I1464_n2 XI1_I1464_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1464_MN4 (I1_b20_14 XI1_I1464_An XI1_I1464_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1464_MN2 (XI1_I1464_n1 I1_dd14_b3_3 I1_b20_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1464_MN3 (VSS I1_qu12_b3_2 XI1_I1464_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1464_MN0 (XI1_I1464_An I1_dd14_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I215_MN1 (XI1_I1436_I215_Bn I1_I1436_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I215_MN5 (XI1_I1436_I215_n2 XI1_I1436_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1436_I215_MN4 (I1_p19_12 XI1_I1436_I215_An XI1_I1436_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1436_I215_MN2 (XI1_I1436_I215_n1 I1_I1436_pn12 I1_p19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1436_I215_MN3 (VSS I1_I1436_G11_0n XI1_I1436_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1436_I215_MN0 (XI1_I1436_I215_An I1_I1436_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I213_MN1 (XI1_I1436_I213_Bn I1_I1436_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I213_MN5 (XI1_I1436_I213_n2 XI1_I1436_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1436_I213_MN4 (I1_p19_10 XI1_I1436_I213_An XI1_I1436_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1436_I213_MN2 (XI1_I1436_I213_n1 I1_I1436_pn10 I1_p19_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1436_I213_MN3 (VSS I1_I1436_G9_0n XI1_I1436_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1436_I213_MN0 (XI1_I1436_I213_An I1_I1436_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1456_MN1 (XI1_I1456_Bn I1_qu12_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1456_MN5 (XI1_I1456_n2 XI1_I1456_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1456_MN4 (I1_b20_6 XI1_I1456_An XI1_I1456_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1456_MN2 (XI1_I1456_n1 I1_dd6_b3_3 I1_b20_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1456_MN3 (VSS I1_qu12_b3_1 XI1_I1456_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1456_MN0 (XI1_I1456_An I1_dd6_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1458_MN1 (XI1_I1458_Bn I1_qu12_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1458_MN5 (XI1_I1458_n2 XI1_I1458_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1458_MN4 (I1_b20_8 XI1_I1458_An XI1_I1458_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1458_MN2 (XI1_I1458_n1 I1_dd8_b3_3 I1_b20_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1458_MN3 (VSS I1_qu12_b3_1 XI1_I1458_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1458_MN0 (XI1_I1458_An I1_dd8_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I207_MN1 (XI1_I1436_I207_Bn I1_I1436_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I207_MN5 (XI1_I1436_I207_n2 XI1_I1436_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1436_I207_MN4 (I1_p19_4 XI1_I1436_I207_An XI1_I1436_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1436_I207_MN2 (XI1_I1436_I207_n1 I1_I1436_pn4 I1_p19_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1436_I207_MN3 (VSS I1_I1436_G3_0n XI1_I1436_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1436_I207_MN0 (XI1_I1436_I207_An I1_I1436_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I214_MN1 (XI1_I1114_I214_Bn I1_I1114_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I214_MN5 (XI1_I1114_I214_n2 XI1_I1114_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1114_I214_MN4 (I1_p12_11 XI1_I1114_I214_An XI1_I1114_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1114_I214_MN2 (XI1_I1114_I214_n1 I1_I1114_pn11 I1_p12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1114_I214_MN3 (VSS I1_I1114_G10_0n XI1_I1114_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1114_I214_MN0 (XI1_I1114_I214_An I1_I1114_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1098_MN1 (XI1_I1098_Bn I1_qu20_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1098_MN5 (XI1_I1098_n2 XI1_I1098_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1098_MN4 (I1_b12_16 XI1_I1098_An XI1_I1098_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1098_MN2 (XI1_I1098_n1 I1_dd16_b3_2 I1_b12_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1098_MN3 (VSS I1_qu20_b3_2 XI1_I1098_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1098_MN0 (XI1_I1098_An I1_dd16_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1099_MN1 (XI1_I1099_Bn I1_qu20_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1099_MN5 (XI1_I1099_n2 XI1_I1099_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1099_MN4 (I1_b12_17 XI1_I1099_An XI1_I1099_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1099_MN2 (XI1_I1099_n1 I1_dd17_b3_2 I1_b12_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1099_MN3 (VSS I1_qu20_b3_2 XI1_I1099_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1099_MN0 (XI1_I1099_An I1_dd17_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I218_MN1 (XI1_I1068_I218_Bn I1_I1068_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I218_MN5 (XI1_I1068_I218_n2 XI1_I1068_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1068_I218_MN4 (I1_p11_15 XI1_I1068_I218_An XI1_I1068_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1068_I218_MN2 (XI1_I1068_I218_n1 I1_I1068_pn15 I1_p11_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1068_I218_MN3 (VSS I1_I1068_G14_0n XI1_I1068_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1068_I218_MN0 (XI1_I1068_I218_An I1_I1068_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1055_MN1 (XI1_I1055_Bn I1_qu21_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1055_MN5 (XI1_I1055_n2 XI1_I1055_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1055_MN4 (I1_b11_19 XI1_I1055_An XI1_I1055_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1055_MN2 (XI1_I1055_n1 I1_dd19_b3_2 I1_b11_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1055_MN3 (VSS I1_qu21_b3_3 XI1_I1055_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1055_MN0 (XI1_I1055_An I1_dd19_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1056_MN1 (XI1_I1056_Bn I1_qu21_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1056_MN5 (XI1_I1056_n2 XI1_I1056_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1056_MN4 (I1_b11_20 XI1_I1056_An XI1_I1056_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1056_MN2 (XI1_I1056_n1 I1_dd20_b3_2 I1_b11_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1056_MN3 (VSS I1_qu21_b3_3 XI1_I1056_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1056_MN0 (XI1_I1056_An I1_dd20_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1012_MN1 (XI1_I1012_Bn I1_qu22_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1012_MN5 (XI1_I1012_n2 XI1_I1012_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1012_MN4 (I1_b10_22 XI1_I1012_An XI1_I1012_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1012_MN2 (XI1_I1012_n1 I1_dd22_b3_1 I1_b10_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1012_MN3 (VSS I1_qu22_b3_3 XI1_I1012_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1012_MN0 (XI1_I1012_An I1_dd22_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1011_MN1 (XI1_I1011_Bn I1_qu22_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1011_MN5 (XI1_I1011_n2 XI1_I1011_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1011_MN4 (I1_b10_21 XI1_I1011_An XI1_I1011_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1011_MN2 (XI1_I1011_n1 I1_dd21_b3_1 I1_b10_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1011_MN3 (VSS I1_qu22_b3_3 XI1_I1011_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1011_MN0 (XI1_I1011_An I1_dd21_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I213_MN1 (XI1_I976_I213_Bn I1_I976_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I213_MN5 (XI1_I976_I213_n2 XI1_I976_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I976_I213_MN4 (I1_p9_10 XI1_I976_I213_An XI1_I976_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I976_I213_MN2 (XI1_I976_I213_n1 I1_I976_pn10 I1_p9_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I976_I213_MN3 (VSS I1_I976_G9_0n XI1_I976_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I976_I213_MN0 (XI1_I976_I213_An I1_I976_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I206_MN1 (XI1_I608_I206_Bn I1_I608_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I206_MN5 (XI1_I608_I206_n2 XI1_I608_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I608_I206_MN4 (I1_p1_3 XI1_I608_I206_An XI1_I608_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I608_I206_MN2 (XI1_I608_I206_n1 I1_I608_pn3 I1_p1_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I608_I206_MN3 (VSS I1_I608_G2_0n XI1_I608_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I608_I206_MN0 (XI1_I608_I206_An I1_I608_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I628_MN1 (XI1_I628_Bn I1_qu30_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I628_MN5 (XI1_I628_n2 XI1_I628_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I628_MN4 (I1_b2_6 XI1_I628_An XI1_I628_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I628_MN2 (XI1_I628_n1 I1_dd6_b3_0 I1_b2_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I628_MN3 (VSS I1_qu30_b3_1 XI1_I628_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I628_MN0 (XI1_I628_An I1_dd6_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I632_MN1 (XI1_I632_Bn I1_qu30_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I632_MN5 (XI1_I632_n2 XI1_I632_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I632_MN4 (I1_b2_10 XI1_I632_An XI1_I632_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I632_MN2 (XI1_I632_n1 I1_dd10_b3_0 I1_b2_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I632_MN3 (VSS I1_qu30_b3_1 XI1_I632_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I632_MN0 (XI1_I632_An I1_dd10_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I212_MN1 (XI1_I608_I212_Bn I1_I608_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I212_MN5 (XI1_I608_I212_n2 XI1_I608_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I608_I212_MN4 (I1_p1_9 XI1_I608_I212_An XI1_I608_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I608_I212_MN2 (XI1_I608_I212_n1 I1_I608_pn9 I1_p1_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I608_I212_MN3 (VSS I1_I608_G8_0n XI1_I608_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I608_I212_MN0 (XI1_I608_I212_An I1_I608_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I214_MN1 (XI1_I608_I214_Bn I1_I608_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I214_MN5 (XI1_I608_I214_n2 XI1_I608_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I608_I214_MN4 (I1_p1_11 XI1_I608_I214_An XI1_I608_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I608_I214_MN2 (XI1_I608_I214_n1 I1_I608_pn11 I1_p1_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I608_I214_MN3 (VSS I1_I608_G10_0n XI1_I608_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I608_I214_MN0 (XI1_I608_I214_An I1_I608_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I634_MN1 (XI1_I634_Bn I1_qu30_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I634_MN5 (XI1_I634_n2 XI1_I634_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I634_MN4 (I1_b2_12 XI1_I634_An XI1_I634_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I634_MN2 (XI1_I634_n1 I1_dd12_b3_0 I1_b2_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I634_MN3 (VSS I1_qu30_b3_2 XI1_I634_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I634_MN0 (XI1_I634_An I1_dd12_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I216_MN1 (XI1_I608_I216_Bn I1_I608_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I216_MN5 (XI1_I608_I216_n2 XI1_I608_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I608_I216_MN4 (I1_p1_13 XI1_I608_I216_An XI1_I608_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I608_I216_MN2 (XI1_I608_I216_n1 I1_I608_pn13 I1_p1_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I608_I216_MN3 (VSS I1_I608_G12_0n XI1_I608_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I608_I216_MN0 (XI1_I608_I216_An I1_I608_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I636_MN1 (XI1_I636_Bn I1_qu30_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I636_MN5 (XI1_I636_n2 XI1_I636_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I636_MN4 (I1_b2_14 XI1_I636_An XI1_I636_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I636_MN2 (XI1_I636_n1 I1_dd14_b3_0 I1_b2_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I636_MN3 (VSS I1_qu30_b3_2 XI1_I636_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I636_MN0 (XI1_I636_An I1_dd14_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I637_MN1 (XI1_I637_Bn I1_qu30_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I637_MN5 (XI1_I637_n2 XI1_I637_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I637_MN4 (I1_b2_15 XI1_I637_An XI1_I637_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I637_MN2 (XI1_I637_n1 I1_dd15_b3_0 I1_b2_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I637_MN3 (VSS I1_qu30_b3_2 XI1_I637_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I637_MN0 (XI1_I637_An I1_dd15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I639_MN1 (XI1_I639_Bn I1_qu30_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I639_MN5 (XI1_I639_n2 XI1_I639_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I639_MN4 (I1_b2_17 XI1_I639_An XI1_I639_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I639_MN2 (XI1_I639_n1 I1_dd17_b3_0 I1_b2_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I639_MN3 (VSS I1_qu30_b3_2 XI1_I639_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I639_MN0 (XI1_I639_An I1_dd17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I218_MN1 (XI1_I608_I218_Bn I1_I608_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I218_MN5 (XI1_I608_I218_n2 XI1_I608_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I608_I218_MN4 (I1_p1_15 XI1_I608_I218_An XI1_I608_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I608_I218_MN2 (XI1_I608_I218_n1 I1_I608_pn15 I1_p1_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I608_I218_MN3 (VSS I1_I608_G14_0n XI1_I608_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I608_I218_MN0 (XI1_I608_I218_An I1_I608_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I640_MN1 (XI1_I640_Bn I1_qu30_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I640_MN5 (XI1_I640_n2 XI1_I640_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I640_MN4 (I1_b2_18 XI1_I640_An XI1_I640_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I640_MN2 (XI1_I640_n1 I1_dd18_b3_0 I1_b2_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I640_MN3 (VSS I1_qu30_b3_3 XI1_I640_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I640_MN0 (XI1_I640_An I1_dd18_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I643_MN1 (XI1_I643_Bn I1_qu30_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I643_MN5 (XI1_I643_n2 XI1_I643_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I643_MN4 (I1_b2_21 XI1_I643_An XI1_I643_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I643_MN2 (XI1_I643_n1 I1_dd21_b3_0 I1_b2_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I643_MN3 (VSS I1_qu30_b3_3 XI1_I643_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I643_MN0 (XI1_I643_An I1_dd21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I642_MN1 (XI1_I642_Bn I1_qu30_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I642_MN5 (XI1_I642_n2 XI1_I642_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I642_MN4 (I1_b2_20 XI1_I642_An XI1_I642_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I642_MN2 (XI1_I642_n1 I1_dd20_b3_0 I1_b2_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I642_MN3 (VSS I1_qu30_b3_3 XI1_I642_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I642_MN0 (XI1_I642_An I1_dd20_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I645_MN1 (XI1_I645_Bn I1_qu30_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I645_MN5 (XI1_I645_n2 XI1_I645_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I645_MN4 (I1_b2_23 XI1_I645_An XI1_I645_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I645_MN2 (XI1_I645_n1 I1_dd23_b3_0 I1_b2_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I645_MN3 (VSS I1_qu30_b3_3 XI1_I645_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I645_MN0 (XI1_I645_An I1_dd23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I655_MN1 (XI1_I655_Bn I1_qu30_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I655_MN5 (XI1_I655_n2 XI1_I655_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I655_MN4 (I1_h2 XI1_I655_An XI1_I655_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I655_MN2 (XI1_I655_n1 I1_p1_31 I1_h2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I655_MN3 (VSS I1_qu30_b3_5 XI1_I655_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I655_MN0 (XI1_I655_An I1_p1_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I653_MN1 (XI1_I653_Bn I1_qu30_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I653_MN5 (XI1_I653_n2 XI1_I653_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I653_MN4 (I1_b2_31 XI1_I653_An XI1_I653_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I653_MN2 (XI1_I653_n1 I1_dd31_b3_0 I1_b2_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I653_MN3 (VSS I1_qu30_b3_5 XI1_I653_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I653_MN0 (XI1_I653_An I1_dd31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1437_MN1 (XI1_I1437_Bn I1_qu13_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1437_MN5 (XI1_I1437_n2 XI1_I1437_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1437_MN4 (I1_h19 XI1_I1437_An XI1_I1437_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1437_MN2 (XI1_I1437_n1 I1_p18_31 I1_h19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1437_MN3 (VSS I1_qu13_b3_5 XI1_I1437_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1437_MN0 (XI1_I1437_An I1_p18_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1438_MN1 (XI1_I1438_Bn I1_c19_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1438_MN5 (XI1_I1438_n2 XI1_I1438_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1438_MN4 (I1_p19_32 XI1_I1438_An XI1_I1438_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1438_MN2 (XI1_I1438_n1 I1_h19 I1_p19_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1438_MN3 (VSS I1_c19_o XI1_I1438_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1438_MN0 (XI1_I1438_An I1_h19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1473_MN1 (XI1_I1473_Bn I1_qu12_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1473_MN5 (XI1_I1473_n2 XI1_I1473_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1473_MN4 (I1_b20_23 XI1_I1473_An XI1_I1473_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1473_MN2 (XI1_I1473_n1 I1_dd23_b3_3 I1_b20_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1473_MN3 (VSS I1_qu12_b3_3 XI1_I1473_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1473_MN0 (XI1_I1473_An I1_dd23_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1472_MN1 (XI1_I1472_Bn I1_qu12_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1472_MN5 (XI1_I1472_n2 XI1_I1472_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1472_MN4 (I1_b20_22 XI1_I1472_An XI1_I1472_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1472_MN2 (XI1_I1472_n1 I1_dd22_b3_3 I1_b20_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1472_MN3 (VSS I1_qu12_b3_3 XI1_I1472_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1472_MN0 (XI1_I1472_An I1_dd22_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1471_MN1 (XI1_I1471_Bn I1_qu12_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1471_MN5 (XI1_I1471_n2 XI1_I1471_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1471_MN4 (I1_b20_21 XI1_I1471_An XI1_I1471_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1471_MN2 (XI1_I1471_n1 I1_dd21_b3_3 I1_b20_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1471_MN3 (VSS I1_qu12_b3_3 XI1_I1471_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1471_MN0 (XI1_I1471_An I1_dd21_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1470_MN1 (XI1_I1470_Bn I1_qu12_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1470_MN5 (XI1_I1470_n2 XI1_I1470_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1470_MN4 (I1_b20_20 XI1_I1470_An XI1_I1470_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1470_MN2 (XI1_I1470_n1 I1_dd20_b3_3 I1_b20_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1470_MN3 (VSS I1_qu12_b3_3 XI1_I1470_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1470_MN0 (XI1_I1470_An I1_dd20_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1469_MN1 (XI1_I1469_Bn I1_qu12_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1469_MN5 (XI1_I1469_n2 XI1_I1469_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1469_MN4 (I1_b20_19 XI1_I1469_An XI1_I1469_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1469_MN2 (XI1_I1469_n1 I1_dd19_b3_3 I1_b20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1469_MN3 (VSS I1_qu12_b3_3 XI1_I1469_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1469_MN0 (XI1_I1469_An I1_dd19_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1468_MN1 (XI1_I1468_Bn I1_qu12_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1468_MN5 (XI1_I1468_n2 XI1_I1468_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1468_MN4 (I1_b20_18 XI1_I1468_An XI1_I1468_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1468_MN2 (XI1_I1468_n1 I1_dd18_b3_3 I1_b20_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1468_MN3 (VSS I1_qu12_b3_3 XI1_I1468_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1468_MN0 (XI1_I1468_An I1_dd18_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1467_MN1 (XI1_I1467_Bn I1_qu12_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1467_MN5 (XI1_I1467_n2 XI1_I1467_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1467_MN4 (I1_b20_17 XI1_I1467_An XI1_I1467_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1467_MN2 (XI1_I1467_n1 I1_dd17_b3_3 I1_b20_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1467_MN3 (VSS I1_qu12_b3_2 XI1_I1467_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1467_MN0 (XI1_I1467_An I1_dd17_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1463_MN1 (XI1_I1463_Bn I1_qu12_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1463_MN5 (XI1_I1463_n2 XI1_I1463_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1463_MN4 (I1_b20_13 XI1_I1463_An XI1_I1463_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1463_MN2 (XI1_I1463_n1 I1_dd13_b3_3 I1_b20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1463_MN3 (VSS I1_qu12_b3_2 XI1_I1463_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1463_MN0 (XI1_I1463_An I1_dd13_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1462_MN1 (XI1_I1462_Bn I1_qu12_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1462_MN5 (XI1_I1462_n2 XI1_I1462_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1462_MN4 (I1_b20_12 XI1_I1462_An XI1_I1462_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1462_MN2 (XI1_I1462_n1 I1_dd12_b3_3 I1_b20_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1462_MN3 (VSS I1_qu12_b3_2 XI1_I1462_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1462_MN0 (XI1_I1462_An I1_dd12_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1460_MN1 (XI1_I1460_Bn I1_qu12_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1460_MN5 (XI1_I1460_n2 XI1_I1460_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1460_MN4 (I1_b20_10 XI1_I1460_An XI1_I1460_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1460_MN2 (XI1_I1460_n1 I1_dd10_b3_3 I1_b20_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1460_MN3 (VSS I1_qu12_b3_1 XI1_I1460_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1460_MN0 (XI1_I1460_An I1_dd10_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1459_MN1 (XI1_I1459_Bn I1_qu12_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1459_MN5 (XI1_I1459_n2 XI1_I1459_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1459_MN4 (I1_b20_9 XI1_I1459_An XI1_I1459_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1459_MN2 (XI1_I1459_n1 I1_dd9_b3_3 I1_b20_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1459_MN3 (VSS I1_qu12_b3_1 XI1_I1459_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1459_MN0 (XI1_I1459_An I1_dd9_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1461_MN1 (XI1_I1461_Bn I1_qu12_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1461_MN5 (XI1_I1461_n2 XI1_I1461_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1461_MN4 (I1_b20_11 XI1_I1461_An XI1_I1461_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1461_MN2 (XI1_I1461_n1 I1_dd11_b3_3 I1_b20_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1461_MN3 (VSS I1_qu12_b3_1 XI1_I1461_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1461_MN0 (XI1_I1461_An I1_dd11_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1457_MN1 (XI1_I1457_Bn I1_qu12_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1457_MN5 (XI1_I1457_n2 XI1_I1457_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1457_MN4 (I1_b20_7 XI1_I1457_An XI1_I1457_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1457_MN2 (XI1_I1457_n1 I1_dd7_b3_3 I1_b20_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1457_MN3 (VSS I1_qu12_b3_1 XI1_I1457_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1457_MN0 (XI1_I1457_An I1_dd7_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1455_MN1 (XI1_I1455_Bn I1_qu12_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1455_MN5 (XI1_I1455_n2 XI1_I1455_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1455_MN4 (I1_b20_5 XI1_I1455_An XI1_I1455_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1455_MN2 (XI1_I1455_n1 I1_dd5_b3_3 I1_b20_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1455_MN3 (VSS I1_qu12_b3_0 XI1_I1455_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1455_MN0 (XI1_I1455_An I1_dd5_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1454_MN1 (XI1_I1454_Bn I1_qu12_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1454_MN5 (XI1_I1454_n2 XI1_I1454_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1454_MN4 (I1_b20_4 XI1_I1454_An XI1_I1454_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1454_MN2 (XI1_I1454_n1 I1_dd4_b3_3 I1_b20_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1454_MN3 (VSS I1_qu12_b3_0 XI1_I1454_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1454_MN0 (XI1_I1454_An I1_dd4_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1453_MN1 (XI1_I1453_Bn I1_qu12_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1453_MN5 (XI1_I1453_n2 XI1_I1453_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1453_MN4 (I1_b20_3 XI1_I1453_An XI1_I1453_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1453_MN2 (XI1_I1453_n1 I1_dd3_b3_3 I1_b20_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1453_MN3 (VSS I1_qu12_b3_0 XI1_I1453_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1453_MN0 (XI1_I1453_An I1_dd3_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I216_MN1 (XI1_I1114_I216_Bn I1_I1114_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I216_MN5 (XI1_I1114_I216_n2 XI1_I1114_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1114_I216_MN4 (I1_p12_13 XI1_I1114_I216_An XI1_I1114_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1114_I216_MN2 (XI1_I1114_I216_n1 I1_I1114_pn13 I1_p12_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1114_I216_MN3 (VSS I1_I1114_G12_0n XI1_I1114_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1114_I216_MN0 (XI1_I1114_I216_An I1_I1114_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I215_MN1 (XI1_I1114_I215_Bn I1_I1114_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I215_MN5 (XI1_I1114_I215_n2 XI1_I1114_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1114_I215_MN4 (I1_p12_12 XI1_I1114_I215_An XI1_I1114_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1114_I215_MN2 (XI1_I1114_I215_n1 I1_I1114_pn12 I1_p12_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1114_I215_MN3 (VSS I1_I1114_G11_0n XI1_I1114_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1114_I215_MN0 (XI1_I1114_I215_An I1_I1114_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1097_MN1 (XI1_I1097_Bn I1_qu20_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1097_MN5 (XI1_I1097_n2 XI1_I1097_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1097_MN4 (I1_b12_15 XI1_I1097_An XI1_I1097_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1097_MN2 (XI1_I1097_n1 I1_dd15_b3_2 I1_b12_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1097_MN3 (VSS I1_qu20_b3_2 XI1_I1097_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1097_MN0 (XI1_I1097_An I1_dd15_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I217_MN1 (XI1_I1068_I217_Bn I1_I1068_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I217_MN5 (XI1_I1068_I217_n2 XI1_I1068_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1068_I217_MN4 (I1_p11_14 XI1_I1068_I217_An XI1_I1068_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1068_I217_MN2 (XI1_I1068_I217_n1 I1_I1068_pn14 I1_p11_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1068_I217_MN3 (VSS I1_I1068_G13_0n XI1_I1068_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1068_I217_MN0 (XI1_I1068_I217_An I1_I1068_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1054_MN1 (XI1_I1054_Bn I1_qu21_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1054_MN5 (XI1_I1054_n2 XI1_I1054_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1054_MN4 (I1_b11_18 XI1_I1054_An XI1_I1054_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1054_MN2 (XI1_I1054_n1 I1_dd18_b3_2 I1_b11_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1054_MN3 (VSS I1_qu21_b3_3 XI1_I1054_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1054_MN0 (XI1_I1054_An I1_dd18_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1023_MN1 (XI1_I1023_Bn I1_qu22_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1023_MN5 (XI1_I1023_n2 XI1_I1023_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1023_MN4 (I1_h10 XI1_I1023_An XI1_I1023_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1023_MN2 (XI1_I1023_n1 I1_p9_31 I1_h10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1023_MN3 (VSS I1_qu22_b3_5 XI1_I1023_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1023_MN0 (XI1_I1023_An I1_p9_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1010_MN1 (XI1_I1010_Bn I1_qu22_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1010_MN5 (XI1_I1010_n2 XI1_I1010_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1010_MN4 (I1_b10_20 XI1_I1010_An XI1_I1010_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1010_MN2 (XI1_I1010_n1 I1_dd20_b3_1 I1_b10_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1010_MN3 (VSS I1_qu22_b3_3 XI1_I1010_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1010_MN0 (XI1_I1010_An I1_dd20_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I215_MN1 (XI1_I976_I215_Bn I1_I976_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I215_MN5 (XI1_I976_I215_n2 XI1_I976_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I976_I215_MN4 (I1_p9_12 XI1_I976_I215_An XI1_I976_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I976_I215_MN2 (XI1_I976_I215_n1 I1_I976_pn12 I1_p9_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I976_I215_MN3 (VSS I1_I976_G11_0n XI1_I976_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I976_I215_MN0 (XI1_I976_I215_An I1_I976_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I948_MN1 (XI1_I948_Bn I1_qu23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I948_MN5 (XI1_I948_n2 XI1_I948_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I948_MN4 (I1_b9_4 XI1_I948_An XI1_I948_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I948_MN2 (XI1_I948_n1 I1_dd4_b3_1 I1_b9_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I948_MN3 (VSS I1_qu23_b3_0 XI1_I948_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I948_MN0 (XI1_I948_An I1_dd4_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1474_MN1 (XI1_I1474_Bn I1_qu12_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1474_MN5 (XI1_I1474_n2 XI1_I1474_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1474_MN4 (I1_b20_24 XI1_I1474_An XI1_I1474_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1474_MN2 (XI1_I1474_n1 I1_dd24_b3_3 I1_b20_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1474_MN3 (VSS I1_qu12_b3_4 XI1_I1474_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1474_MN0 (XI1_I1474_An I1_dd24_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1465_MN1 (XI1_I1465_Bn I1_qu12_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1465_MN5 (XI1_I1465_n2 XI1_I1465_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1465_MN4 (I1_b20_15 XI1_I1465_An XI1_I1465_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1465_MN2 (XI1_I1465_n1 I1_dd15_b3_3 I1_b20_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1465_MN3 (VSS I1_qu12_b3_2 XI1_I1465_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1465_MN0 (XI1_I1465_An I1_dd15_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1452_MN1 (XI1_I1452_Bn I1_qu12_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1452_MN5 (XI1_I1452_n2 XI1_I1452_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1452_MN4 (I1_b20_2 XI1_I1452_An XI1_I1452_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1452_MN2 (XI1_I1452_n1 I1_dd2_b3_3 I1_b20_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1452_MN3 (VSS I1_qu12_b3_0 XI1_I1452_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1452_MN0 (XI1_I1452_An I1_dd2_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I213_MN1 (XI1_I1114_I213_Bn I1_I1114_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I213_MN5 (XI1_I1114_I213_n2 XI1_I1114_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1114_I213_MN4 (I1_p12_10 XI1_I1114_I213_An XI1_I1114_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1114_I213_MN2 (XI1_I1114_I213_n1 I1_I1114_pn10 I1_p12_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1114_I213_MN3 (VSS I1_I1114_G9_0n XI1_I1114_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1114_I213_MN0 (XI1_I1114_I213_An I1_I1114_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1095_MN1 (XI1_I1095_Bn I1_qu20_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1095_MN5 (XI1_I1095_n2 XI1_I1095_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1095_MN4 (I1_b12_13 XI1_I1095_An XI1_I1095_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1095_MN2 (XI1_I1095_n1 I1_dd13_b3_2 I1_b12_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1095_MN3 (VSS I1_qu20_b3_2 XI1_I1095_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1095_MN0 (XI1_I1095_An I1_dd13_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1096_MN1 (XI1_I1096_Bn I1_qu20_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1096_MN5 (XI1_I1096_n2 XI1_I1096_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1096_MN4 (I1_b12_14 XI1_I1096_An XI1_I1096_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1096_MN2 (XI1_I1096_n1 I1_dd14_b3_2 I1_b12_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1096_MN3 (VSS I1_qu20_b3_2 XI1_I1096_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1096_MN0 (XI1_I1096_An I1_dd14_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I216_MN1 (XI1_I1068_I216_Bn I1_I1068_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I216_MN5 (XI1_I1068_I216_n2 XI1_I1068_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1068_I216_MN4 (I1_p11_13 XI1_I1068_I216_An XI1_I1068_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1068_I216_MN2 (XI1_I1068_I216_n1 I1_I1068_pn13 I1_p11_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1068_I216_MN3 (VSS I1_I1068_G12_0n XI1_I1068_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1068_I216_MN0 (XI1_I1068_I216_An I1_I1068_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I215_MN1 (XI1_I1068_I215_Bn I1_I1068_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I215_MN5 (XI1_I1068_I215_n2 XI1_I1068_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1068_I215_MN4 (I1_p11_12 XI1_I1068_I215_An XI1_I1068_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1068_I215_MN2 (XI1_I1068_I215_n1 I1_I1068_pn12 I1_p11_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1068_I215_MN3 (VSS I1_I1068_G11_0n XI1_I1068_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1068_I215_MN0 (XI1_I1068_I215_An I1_I1068_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1053_MN1 (XI1_I1053_Bn I1_qu21_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1053_MN5 (XI1_I1053_n2 XI1_I1053_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1053_MN4 (I1_b11_17 XI1_I1053_An XI1_I1053_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1053_MN2 (XI1_I1053_n1 I1_dd17_b3_2 I1_b11_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1053_MN3 (VSS I1_qu21_b3_2 XI1_I1053_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1053_MN0 (XI1_I1053_An I1_dd17_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1024_MN1 (XI1_I1024_Bn I1_c10_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1024_MN5 (XI1_I1024_n2 XI1_I1024_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1024_MN4 (I1_p10_32 XI1_I1024_An XI1_I1024_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1024_MN2 (XI1_I1024_n1 I1_h10 I1_p10_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1024_MN3 (VSS I1_c10_o XI1_I1024_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1024_MN0 (XI1_I1024_An I1_h10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1009_MN1 (XI1_I1009_Bn I1_qu22_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1009_MN5 (XI1_I1009_n2 XI1_I1009_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1009_MN4 (I1_b10_19 XI1_I1009_An XI1_I1009_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1009_MN2 (XI1_I1009_n1 I1_dd19_b3_1 I1_b10_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1009_MN3 (VSS I1_qu22_b3_3 XI1_I1009_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1009_MN0 (XI1_I1009_An I1_dd19_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1008_MN1 (XI1_I1008_Bn I1_qu22_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1008_MN5 (XI1_I1008_n2 XI1_I1008_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1008_MN4 (I1_b10_18 XI1_I1008_An XI1_I1008_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1008_MN2 (XI1_I1008_n1 I1_dd18_b3_1 I1_b10_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1008_MN3 (VSS I1_qu22_b3_3 XI1_I1008_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1008_MN0 (XI1_I1008_An I1_dd18_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I218_MN1 (XI1_I976_I218_Bn I1_I976_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I218_MN5 (XI1_I976_I218_n2 XI1_I976_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I976_I218_MN4 (I1_p9_15 XI1_I976_I218_An XI1_I976_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I976_I218_MN2 (XI1_I976_I218_n1 I1_I976_pn15 I1_p9_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I976_I218_MN3 (VSS I1_I976_G14_0n XI1_I976_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I976_I218_MN0 (XI1_I976_I218_An I1_I976_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I207_MN1 (XI1_I976_I207_Bn I1_I976_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I207_MN5 (XI1_I976_I207_n2 XI1_I976_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I976_I207_MN4 (I1_p9_4 XI1_I976_I207_An XI1_I976_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I976_I207_MN2 (XI1_I976_I207_n1 I1_I976_pn4 I1_p9_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I976_I207_MN3 (VSS I1_I976_G3_0n XI1_I976_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I976_I207_MN0 (XI1_I976_I207_An I1_I976_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I947_MN1 (XI1_I947_Bn I1_qu23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I947_MN5 (XI1_I947_n2 XI1_I947_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I947_MN4 (I1_b9_3 XI1_I947_An XI1_I947_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I947_MN2 (XI1_I947_n1 I1_dd3_b3_1 I1_b9_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I947_MN3 (VSS I1_qu23_b3_0 XI1_I947_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I947_MN0 (XI1_I947_An I1_dd3_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I577_MN1 (XI1_I577_Bn I1_qu31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I577_MN5 (XI1_I577_n2 XI1_I577_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I577_MN4 (I1_b1_1 XI1_I577_An XI1_I577_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I577_MN2 (XI1_I577_n1 I1_dd1_b3_0 I1_b1_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I577_MN3 (VSS I1_qu31_b3_0 XI1_I577_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I577_MN0 (XI1_I577_An I1_dd1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I207_MN1 (XI1_I608_I207_Bn I1_I608_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I207_MN5 (XI1_I608_I207_n2 XI1_I608_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I608_I207_MN4 (I1_p1_4 XI1_I608_I207_An XI1_I608_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I608_I207_MN2 (XI1_I608_I207_n1 I1_I608_pn4 I1_p1_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I608_I207_MN3 (VSS I1_I608_G3_0n XI1_I608_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I608_I207_MN0 (XI1_I608_I207_An I1_I608_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I213_MN1 (XI1_I608_I213_Bn I1_I608_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I213_MN5 (XI1_I608_I213_n2 XI1_I608_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I608_I213_MN4 (I1_p1_10 XI1_I608_I213_An XI1_I608_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I608_I213_MN2 (XI1_I608_I213_n1 I1_I608_pn10 I1_p1_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I608_I213_MN3 (VSS I1_I608_G9_0n XI1_I608_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I608_I213_MN0 (XI1_I608_I213_An I1_I608_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I215_MN1 (XI1_I608_I215_Bn I1_I608_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I215_MN5 (XI1_I608_I215_n2 XI1_I608_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I608_I215_MN4 (I1_p1_12 XI1_I608_I215_An XI1_I608_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I608_I215_MN2 (XI1_I608_I215_n1 I1_I608_pn12 I1_p1_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I608_I215_MN3 (VSS I1_I608_G11_0n XI1_I608_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I608_I215_MN0 (XI1_I608_I215_An I1_I608_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I217_MN1 (XI1_I608_I217_Bn I1_I608_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I217_MN5 (XI1_I608_I217_n2 XI1_I608_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I608_I217_MN4 (I1_p1_14 XI1_I608_I217_An XI1_I608_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I608_I217_MN2 (XI1_I608_I217_n1 I1_I608_pn14 I1_p1_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I608_I217_MN3 (VSS I1_I608_G13_0n XI1_I608_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I608_I217_MN0 (XI1_I608_I217_An I1_I608_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1483_MN1 (XI1_I1483_Bn I1_qu12_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1483_MN5 (XI1_I1483_n2 XI1_I1483_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1483_MN4 (I1_h20 XI1_I1483_An XI1_I1483_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1483_MN2 (XI1_I1483_n1 I1_p19_31 I1_h20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1483_MN3 (VSS I1_qu12_b3_5 XI1_I1483_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1483_MN0 (XI1_I1483_An I1_p19_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1475_MN1 (XI1_I1475_Bn I1_qu12_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1475_MN5 (XI1_I1475_n2 XI1_I1475_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1475_MN4 (I1_b20_25 XI1_I1475_An XI1_I1475_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1475_MN2 (XI1_I1475_n1 I1_dd25_b3_3 I1_b20_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1475_MN3 (VSS I1_qu12_b3_4 XI1_I1475_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1475_MN0 (XI1_I1475_An I1_dd25_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1451_MN1 (XI1_I1451_Bn I1_qu12_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1451_MN5 (XI1_I1451_n2 XI1_I1451_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1451_MN4 (I1_b20_1 XI1_I1451_An XI1_I1451_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1451_MN2 (XI1_I1451_n1 I1_dd1_b3_3 I1_b20_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1451_MN3 (VSS I1_qu12_b3_0 XI1_I1451_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1451_MN0 (XI1_I1451_An I1_dd1_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1450_MN1 (XI1_I1450_Bn I1_qu12_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1450_MN5 (XI1_I1450_n2 XI1_I1450_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1450_MN4 (I1_b20_0 XI1_I1450_An XI1_I1450_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1450_MN2 (XI1_I1450_n1 I1_B_0_b3_3 I1_b20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1450_MN3 (VSS I1_qu12_b3_0 XI1_I1450_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1450_MN0 (XI1_I1450_An I1_B_0_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1094_MN1 (XI1_I1094_Bn I1_qu20_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1094_MN5 (XI1_I1094_n2 XI1_I1094_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1094_MN4 (I1_b12_12 XI1_I1094_An XI1_I1094_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1094_MN2 (XI1_I1094_n1 I1_dd12_b3_2 I1_b12_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1094_MN3 (VSS I1_qu20_b3_2 XI1_I1094_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1094_MN0 (XI1_I1094_An I1_dd12_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I214_MN1 (XI1_I1068_I214_Bn I1_I1068_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I214_MN5 (XI1_I1068_I214_n2 XI1_I1068_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1068_I214_MN4 (I1_p11_11 XI1_I1068_I214_An XI1_I1068_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1068_I214_MN2 (XI1_I1068_I214_n1 I1_I1068_pn11 I1_p11_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1068_I214_MN3 (VSS I1_I1068_G10_0n XI1_I1068_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1068_I214_MN0 (XI1_I1068_I214_An I1_I1068_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1050_MN1 (XI1_I1050_Bn I1_qu21_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1050_MN5 (XI1_I1050_n2 XI1_I1050_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1050_MN4 (I1_b11_14 XI1_I1050_An XI1_I1050_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1050_MN2 (XI1_I1050_n1 I1_dd14_b3_2 I1_b11_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1050_MN3 (VSS I1_qu21_b3_2 XI1_I1050_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1050_MN0 (XI1_I1050_An I1_dd14_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1052_MN1 (XI1_I1052_Bn I1_qu21_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1052_MN5 (XI1_I1052_n2 XI1_I1052_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1052_MN4 (I1_b11_16 XI1_I1052_An XI1_I1052_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1052_MN2 (XI1_I1052_n1 I1_dd16_b3_2 I1_b11_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1052_MN3 (VSS I1_qu21_b3_2 XI1_I1052_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1052_MN0 (XI1_I1052_An I1_dd16_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1051_MN1 (XI1_I1051_Bn I1_qu21_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1051_MN5 (XI1_I1051_n2 XI1_I1051_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1051_MN4 (I1_b11_15 XI1_I1051_An XI1_I1051_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1051_MN2 (XI1_I1051_n1 I1_dd15_b3_2 I1_b11_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1051_MN3 (VSS I1_qu21_b3_2 XI1_I1051_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1051_MN0 (XI1_I1051_An I1_dd15_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I219_MN1 (XI1_I1022_I219_Bn I1_I1022_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I219_MN5 (XI1_I1022_I219_n2 XI1_I1022_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1022_I219_MN4 (I1_p10_16 XI1_I1022_I219_An XI1_I1022_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1022_I219_MN2 (XI1_I1022_I219_n1 I1_I1022_pn16 I1_p10_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1022_I219_MN3 (VSS I1_I1022_G15_0n XI1_I1022_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1022_I219_MN0 (XI1_I1022_I219_An I1_I1022_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1007_MN1 (XI1_I1007_Bn I1_qu22_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1007_MN5 (XI1_I1007_n2 XI1_I1007_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1007_MN4 (I1_b10_17 XI1_I1007_An XI1_I1007_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1007_MN2 (XI1_I1007_n1 I1_dd17_b3_1 I1_b10_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1007_MN3 (VSS I1_qu22_b3_2 XI1_I1007_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1007_MN0 (XI1_I1007_An I1_dd17_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I216_MN1 (XI1_I976_I216_Bn I1_I976_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I216_MN5 (XI1_I976_I216_n2 XI1_I976_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I976_I216_MN4 (I1_p9_13 XI1_I976_I216_An XI1_I976_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I976_I216_MN2 (XI1_I976_I216_n1 I1_I976_pn13 I1_p9_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I976_I216_MN3 (VSS I1_I976_G12_0n XI1_I976_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I976_I216_MN0 (XI1_I976_I216_An I1_I976_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I214_MN1 (XI1_I976_I214_Bn I1_I976_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I214_MN5 (XI1_I976_I214_n2 XI1_I976_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I976_I214_MN4 (I1_p9_11 XI1_I976_I214_An XI1_I976_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I976_I214_MN2 (XI1_I976_I214_n1 I1_I976_pn11 I1_p9_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I976_I214_MN3 (VSS I1_I976_G10_0n XI1_I976_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I976_I214_MN0 (XI1_I976_I214_An I1_I976_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I578_MN1 (XI1_I578_Bn I1_qu31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I578_MN5 (XI1_I578_n2 XI1_I578_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I578_MN4 (I1_b1_2 XI1_I578_An XI1_I578_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I578_MN2 (XI1_I578_n1 I1_dd2_b3_0 I1_b1_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I578_MN3 (VSS I1_qu31_b3_0 XI1_I578_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I578_MN0 (XI1_I578_An I1_dd2_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I219_MN1 (XI1_I608_I219_Bn I1_I608_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I219_MN5 (XI1_I608_I219_n2 XI1_I608_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I608_I219_MN4 (I1_p1_16 XI1_I608_I219_An XI1_I608_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I608_I219_MN2 (XI1_I608_I219_n1 I1_I608_pn16 I1_p1_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I608_I219_MN3 (VSS I1_I608_G15_0n XI1_I608_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I608_I219_MN0 (XI1_I608_I219_An I1_I608_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I610_MN1 (XI1_I610_Bn I1_c1_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I610_MN5 (XI1_I610_n2 XI1_I610_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I610_MN4 (I1_p1_32 XI1_I610_An XI1_I610_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I610_MN2 (XI1_I610_n1 I1_h1 I1_p1_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I610_MN3 (VSS I1_c1_o XI1_I610_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I610_MN0 (XI1_I610_An I1_h1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I606_MN1 (XI1_I606_Bn I1_qu31_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I606_MN5 (XI1_I606_n2 XI1_I606_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I606_MN4 (I1_b1_30 XI1_I606_An XI1_I606_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I606_MN2 (XI1_I606_n1 I1_dd30_b3_0 I1_b1_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I606_MN3 (VSS I1_qu31_b3_5 XI1_I606_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I606_MN0 (XI1_I606_An I1_dd30_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1484_MN1 (XI1_I1484_Bn I1_c20_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1484_MN5 (XI1_I1484_n2 XI1_I1484_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1484_MN4 (I1_p20_32 XI1_I1484_An XI1_I1484_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1484_MN2 (XI1_I1484_n1 I1_h20 I1_p20_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1484_MN3 (VSS I1_c20_o XI1_I1484_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1484_MN0 (XI1_I1484_An I1_h20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I207_MN1 (XI1_I1482_I207_Bn I1_I1482_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I207_MN5 (XI1_I1482_I207_n2 XI1_I1482_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1482_I207_MN4 (I1_p20_4 XI1_I1482_I207_An XI1_I1482_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1482_I207_MN2 (XI1_I1482_I207_n1 I1_I1482_pn4 I1_p20_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1482_I207_MN3 (VSS I1_I1482_G3_0n XI1_I1482_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1482_I207_MN0 (XI1_I1482_I207_An I1_I1482_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1505_MN1 (XI1_I1505_Bn I1_qu11_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1505_MN5 (XI1_I1505_n2 XI1_I1505_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1505_MN4 (I1_b21_9 XI1_I1505_An XI1_I1505_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1505_MN2 (XI1_I1505_n1 I1_dd9_b3_3 I1_b21_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1505_MN3 (VSS I1_qu11_b3_1 XI1_I1505_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1505_MN0 (XI1_I1505_An I1_dd9_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I212_MN1 (XI1_I1114_I212_Bn I1_I1114_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I212_MN5 (XI1_I1114_I212_n2 XI1_I1114_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1114_I212_MN4 (I1_p12_9 XI1_I1114_I212_An XI1_I1114_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1114_I212_MN2 (XI1_I1114_I212_n1 I1_I1114_pn9 I1_p12_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1114_I212_MN3 (VSS I1_I1114_G8_0n XI1_I1114_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1114_I212_MN0 (XI1_I1114_I212_An I1_I1114_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I207_MN1 (XI1_I1114_I207_Bn I1_I1114_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I207_MN5 (XI1_I1114_I207_n2 XI1_I1114_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1114_I207_MN4 (I1_p12_4 XI1_I1114_I207_An XI1_I1114_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1114_I207_MN2 (XI1_I1114_I207_n1 I1_I1114_pn4 I1_p12_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1114_I207_MN3 (VSS I1_I1114_G3_0n XI1_I1114_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1114_I207_MN0 (XI1_I1114_I207_An I1_I1114_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I206_MN1 (XI1_I1114_I206_Bn I1_I1114_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I206_MN5 (XI1_I1114_I206_n2 XI1_I1114_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1114_I206_MN4 (I1_p12_3 XI1_I1114_I206_An XI1_I1114_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1114_I206_MN2 (XI1_I1114_I206_n1 I1_I1114_pn3 I1_p12_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1114_I206_MN3 (VSS I1_I1114_G2_0n XI1_I1114_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1114_I206_MN0 (XI1_I1114_I206_An I1_I1114_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I213_MN1 (XI1_I1068_I213_Bn I1_I1068_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I213_MN5 (XI1_I1068_I213_n2 XI1_I1068_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1068_I213_MN4 (I1_p11_10 XI1_I1068_I213_An XI1_I1068_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1068_I213_MN2 (XI1_I1068_I213_n1 I1_I1068_pn10 I1_p11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1068_I213_MN3 (VSS I1_I1068_G9_0n XI1_I1068_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1068_I213_MN0 (XI1_I1068_I213_An I1_I1068_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1048_MN1 (XI1_I1048_Bn I1_qu21_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1048_MN5 (XI1_I1048_n2 XI1_I1048_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1048_MN4 (I1_b11_12 XI1_I1048_An XI1_I1048_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1048_MN2 (XI1_I1048_n1 I1_dd12_b3_2 I1_b11_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1048_MN3 (VSS I1_qu21_b3_2 XI1_I1048_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1048_MN0 (XI1_I1048_An I1_dd12_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1049_MN1 (XI1_I1049_Bn I1_qu21_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1049_MN5 (XI1_I1049_n2 XI1_I1049_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1049_MN4 (I1_b11_13 XI1_I1049_An XI1_I1049_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1049_MN2 (XI1_I1049_n1 I1_dd13_b3_2 I1_b11_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1049_MN3 (VSS I1_qu21_b3_2 XI1_I1049_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1049_MN0 (XI1_I1049_An I1_dd13_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I218_MN1 (XI1_I1022_I218_Bn I1_I1022_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I218_MN5 (XI1_I1022_I218_n2 XI1_I1022_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1022_I218_MN4 (I1_p10_15 XI1_I1022_I218_An XI1_I1022_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1022_I218_MN2 (XI1_I1022_I218_n1 I1_I1022_pn15 I1_p10_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1022_I218_MN3 (VSS I1_I1022_G14_0n XI1_I1022_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1022_I218_MN0 (XI1_I1022_I218_An I1_I1022_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I216_MN1 (XI1_I1022_I216_Bn I1_I1022_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I216_MN5 (XI1_I1022_I216_n2 XI1_I1022_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1022_I216_MN4 (I1_p10_13 XI1_I1022_I216_An XI1_I1022_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1022_I216_MN2 (XI1_I1022_I216_n1 I1_I1022_pn13 I1_p10_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1022_I216_MN3 (VSS I1_I1022_G12_0n XI1_I1022_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1022_I216_MN0 (XI1_I1022_I216_An I1_I1022_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I217_MN1 (XI1_I1022_I217_Bn I1_I1022_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I217_MN5 (XI1_I1022_I217_n2 XI1_I1022_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1022_I217_MN4 (I1_p10_14 XI1_I1022_I217_An XI1_I1022_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1022_I217_MN2 (XI1_I1022_I217_n1 I1_I1022_pn14 I1_p10_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1022_I217_MN3 (VSS I1_I1022_G13_0n XI1_I1022_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1022_I217_MN0 (XI1_I1022_I217_An I1_I1022_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1006_MN1 (XI1_I1006_Bn I1_qu22_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1006_MN5 (XI1_I1006_n2 XI1_I1006_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1006_MN4 (I1_b10_16 XI1_I1006_An XI1_I1006_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1006_MN2 (XI1_I1006_n1 I1_dd16_b3_1 I1_b10_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1006_MN3 (VSS I1_qu22_b3_2 XI1_I1006_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1006_MN0 (XI1_I1006_An I1_dd16_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1005_MN1 (XI1_I1005_Bn I1_qu22_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1005_MN5 (XI1_I1005_n2 XI1_I1005_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1005_MN4 (I1_b10_15 XI1_I1005_An XI1_I1005_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1005_MN2 (XI1_I1005_n1 I1_dd15_b3_1 I1_b10_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1005_MN3 (VSS I1_qu22_b3_2 XI1_I1005_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1005_MN0 (XI1_I1005_An I1_dd15_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1004_MN1 (XI1_I1004_Bn I1_qu22_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1004_MN5 (XI1_I1004_n2 XI1_I1004_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1004_MN4 (I1_b10_14 XI1_I1004_An XI1_I1004_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1004_MN2 (XI1_I1004_n1 I1_dd14_b3_1 I1_b10_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1004_MN3 (VSS I1_qu22_b3_2 XI1_I1004_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1004_MN0 (XI1_I1004_An I1_dd14_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1003_MN1 (XI1_I1003_Bn I1_qu22_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1003_MN5 (XI1_I1003_n2 XI1_I1003_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1003_MN4 (I1_b10_13 XI1_I1003_An XI1_I1003_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1003_MN2 (XI1_I1003_n1 I1_dd13_b3_1 I1_b10_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1003_MN3 (VSS I1_qu22_b3_2 XI1_I1003_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1003_MN0 (XI1_I1003_An I1_dd13_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I212_MN1 (XI1_I976_I212_Bn I1_I976_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I212_MN5 (XI1_I976_I212_n2 XI1_I976_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I976_I212_MN4 (I1_p9_9 XI1_I976_I212_An XI1_I976_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I976_I212_MN2 (XI1_I976_I212_n1 I1_I976_pn9 I1_p9_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I976_I212_MN3 (VSS I1_I976_G8_0n XI1_I976_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I976_I212_MN0 (XI1_I976_I212_An I1_I976_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I946_MN1 (XI1_I946_Bn I1_qu23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I946_MN5 (XI1_I946_n2 XI1_I946_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I946_MN4 (I1_b9_2 XI1_I946_An XI1_I946_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I946_MN2 (XI1_I946_n1 I1_dd2_b3_1 I1_b9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I946_MN3 (VSS I1_qu23_b3_0 XI1_I946_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I946_MN0 (XI1_I946_An I1_dd2_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I576_MN1 (XI1_I576_Bn I1_qu31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I576_MN5 (XI1_I576_n2 XI1_I576_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I576_MN4 (I1_b1_0 XI1_I576_An XI1_I576_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I576_MN2 (XI1_I576_n1 I1_B_0_b3_0 I1_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I576_MN3 (VSS I1_qu31_b3_0 XI1_I576_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I576_MN0 (XI1_I576_An I1_B_0_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I579_MN1 (XI1_I579_Bn I1_qu31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I579_MN5 (XI1_I579_n2 XI1_I579_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I579_MN4 (I1_b1_3 XI1_I579_An XI1_I579_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I579_MN2 (XI1_I579_n1 I1_dd3_b3_0 I1_b1_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I579_MN3 (VSS I1_qu31_b3_0 XI1_I579_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I579_MN0 (XI1_I579_An I1_dd3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I580_MN1 (XI1_I580_Bn I1_qu31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I580_MN5 (XI1_I580_n2 XI1_I580_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I580_MN4 (I1_b1_4 XI1_I580_An XI1_I580_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I580_MN2 (XI1_I580_n1 I1_dd4_b3_0 I1_b1_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I580_MN3 (VSS I1_qu31_b3_0 XI1_I580_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I580_MN0 (XI1_I580_An I1_dd4_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I607_MN1 (XI1_I607_Bn I1_qu31_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I607_MN5 (XI1_I607_n2 XI1_I607_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I607_MN4 (I1_b1_31 XI1_I607_An XI1_I607_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I607_MN2 (XI1_I607_n1 I1_dd31_b3_0 I1_b1_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I607_MN3 (VSS I1_qu31_b3_5 XI1_I607_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I607_MN0 (XI1_I607_An I1_dd31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1476_MN1 (XI1_I1476_Bn I1_qu12_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1476_MN5 (XI1_I1476_n2 XI1_I1476_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1476_MN4 (I1_b20_26 XI1_I1476_An XI1_I1476_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1476_MN2 (XI1_I1476_n1 I1_dd26_b3_3 I1_b20_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1476_MN3 (VSS I1_qu12_b3_4 XI1_I1476_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1476_MN0 (XI1_I1476_An I1_dd26_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I219_MN1 (XI1_I1482_I219_Bn I1_I1482_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I219_MN5 (XI1_I1482_I219_n2 XI1_I1482_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1482_I219_MN4 (I1_p20_16 XI1_I1482_I219_An XI1_I1482_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1482_I219_MN2 (XI1_I1482_I219_n1 I1_I1482_pn16 I1_p20_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1482_I219_MN3 (VSS I1_I1482_G15_0n XI1_I1482_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1482_I219_MN0 (XI1_I1482_I219_An I1_I1482_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I217_MN1 (XI1_I1482_I217_Bn I1_I1482_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I217_MN5 (XI1_I1482_I217_n2 XI1_I1482_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1482_I217_MN4 (I1_p20_14 XI1_I1482_I217_An XI1_I1482_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1482_I217_MN2 (XI1_I1482_I217_n1 I1_I1482_pn14 I1_p20_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1482_I217_MN3 (VSS I1_I1482_G13_0n XI1_I1482_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1482_I217_MN0 (XI1_I1482_I217_An I1_I1482_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I215_MN1 (XI1_I1482_I215_Bn I1_I1482_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I215_MN5 (XI1_I1482_I215_n2 XI1_I1482_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1482_I215_MN4 (I1_p20_12 XI1_I1482_I215_An XI1_I1482_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1482_I215_MN2 (XI1_I1482_I215_n1 I1_I1482_pn12 I1_p20_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1482_I215_MN3 (VSS I1_I1482_G11_0n XI1_I1482_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1482_I215_MN0 (XI1_I1482_I215_An I1_I1482_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I213_MN1 (XI1_I1482_I213_Bn I1_I1482_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I213_MN5 (XI1_I1482_I213_n2 XI1_I1482_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1482_I213_MN4 (I1_p20_10 XI1_I1482_I213_An XI1_I1482_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1482_I213_MN2 (XI1_I1482_I213_n1 I1_I1482_pn10 I1_p20_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1482_I213_MN3 (VSS I1_I1482_G9_0n XI1_I1482_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1482_I213_MN0 (XI1_I1482_I213_An I1_I1482_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I206_MN1 (XI1_I1482_I206_Bn I1_I1482_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I206_MN5 (XI1_I1482_I206_n2 XI1_I1482_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1482_I206_MN4 (I1_p20_3 XI1_I1482_I206_An XI1_I1482_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1482_I206_MN2 (XI1_I1482_I206_n1 I1_I1482_pn3 I1_p20_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1482_I206_MN3 (VSS I1_I1482_G2_0n XI1_I1482_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1482_I206_MN0 (XI1_I1482_I206_An I1_I1482_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1506_MN1 (XI1_I1506_Bn I1_qu11_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1506_MN5 (XI1_I1506_n2 XI1_I1506_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1506_MN4 (I1_b21_10 XI1_I1506_An XI1_I1506_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1506_MN2 (XI1_I1506_n1 I1_dd10_b3_3 I1_b21_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1506_MN3 (VSS I1_qu11_b3_1 XI1_I1506_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1506_MN0 (XI1_I1506_An I1_dd10_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1502_MN1 (XI1_I1502_Bn I1_qu11_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1502_MN5 (XI1_I1502_n2 XI1_I1502_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1502_MN4 (I1_b21_6 XI1_I1502_An XI1_I1502_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1502_MN2 (XI1_I1502_n1 I1_dd6_b3_3 I1_b21_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1502_MN3 (VSS I1_qu11_b3_1 XI1_I1502_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1502_MN0 (XI1_I1502_An I1_dd6_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1503_MN1 (XI1_I1503_Bn I1_qu11_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1503_MN5 (XI1_I1503_n2 XI1_I1503_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1503_MN4 (I1_b21_7 XI1_I1503_An XI1_I1503_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1503_MN2 (XI1_I1503_n1 I1_dd7_b3_3 I1_b21_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1503_MN3 (VSS I1_qu11_b3_1 XI1_I1503_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1503_MN0 (XI1_I1503_An I1_dd7_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1093_MN1 (XI1_I1093_Bn I1_qu20_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1093_MN5 (XI1_I1093_n2 XI1_I1093_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1093_MN4 (I1_b12_11 XI1_I1093_An XI1_I1093_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1093_MN2 (XI1_I1093_n1 I1_dd11_b3_2 I1_b12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1093_MN3 (VSS I1_qu20_b3_1 XI1_I1093_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1093_MN0 (XI1_I1093_An I1_dd11_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I212_MN1 (XI1_I1068_I212_Bn I1_I1068_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I212_MN5 (XI1_I1068_I212_n2 XI1_I1068_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1068_I212_MN4 (I1_p11_9 XI1_I1068_I212_An XI1_I1068_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1068_I212_MN2 (XI1_I1068_I212_n1 I1_I1068_pn9 I1_p11_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1068_I212_MN3 (VSS I1_I1068_G8_0n XI1_I1068_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1068_I212_MN0 (XI1_I1068_I212_An I1_I1068_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I214_MN1 (XI1_I1022_I214_Bn I1_I1022_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I214_MN5 (XI1_I1022_I214_n2 XI1_I1022_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1022_I214_MN4 (I1_p10_11 XI1_I1022_I214_An XI1_I1022_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1022_I214_MN2 (XI1_I1022_I214_n1 I1_I1022_pn11 I1_p10_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1022_I214_MN3 (VSS I1_I1022_G10_0n XI1_I1022_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1022_I214_MN0 (XI1_I1022_I214_An I1_I1022_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I215_MN1 (XI1_I1022_I215_Bn I1_I1022_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I215_MN5 (XI1_I1022_I215_n2 XI1_I1022_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1022_I215_MN4 (I1_p10_12 XI1_I1022_I215_An XI1_I1022_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1022_I215_MN2 (XI1_I1022_I215_n1 I1_I1022_pn12 I1_p10_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1022_I215_MN3 (VSS I1_I1022_G11_0n XI1_I1022_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1022_I215_MN0 (XI1_I1022_I215_An I1_I1022_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1002_MN1 (XI1_I1002_Bn I1_qu22_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1002_MN5 (XI1_I1002_n2 XI1_I1002_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1002_MN4 (I1_b10_12 XI1_I1002_An XI1_I1002_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1002_MN2 (XI1_I1002_n1 I1_dd12_b3_1 I1_b10_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1002_MN3 (VSS I1_qu22_b3_2 XI1_I1002_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1002_MN0 (XI1_I1002_An I1_dd12_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1001_MN1 (XI1_I1001_Bn I1_qu22_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1001_MN5 (XI1_I1001_n2 XI1_I1001_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1001_MN4 (I1_b10_11 XI1_I1001_An XI1_I1001_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1001_MN2 (XI1_I1001_n1 I1_dd11_b3_1 I1_b10_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1001_MN3 (VSS I1_qu22_b3_1 XI1_I1001_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1001_MN0 (XI1_I1001_An I1_dd11_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I206_MN1 (XI1_I976_I206_Bn I1_I976_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I206_MN5 (XI1_I976_I206_n2 XI1_I976_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I976_I206_MN4 (I1_p9_3 XI1_I976_I206_An XI1_I976_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I976_I206_MN2 (XI1_I976_I206_n1 I1_I976_pn3 I1_p9_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I976_I206_MN3 (VSS I1_I976_G2_0n XI1_I976_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I976_I206_MN0 (XI1_I976_I206_An I1_I976_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I945_MN1 (XI1_I945_Bn I1_qu23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I945_MN5 (XI1_I945_n2 XI1_I945_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I945_MN4 (I1_b9_1 XI1_I945_An XI1_I945_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I945_MN2 (XI1_I945_n1 I1_dd1_b3_1 I1_b9_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I945_MN3 (VSS I1_qu23_b3_0 XI1_I945_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I945_MN0 (XI1_I945_An I1_dd1_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I531_MN1 (XI1_I531_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I531_MN5 (XI1_I531_n2 XI1_I531_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I531_MN4 (I1_b0_1 XI1_I531_An XI1_I531_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I531_MN2 (XI1_I531_n1 I1_dd1_b3_0 I1_b0_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I531_MN3 (VSS VDD XI1_I531_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I531_MN0 (XI1_I531_An I1_dd1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I581_MN1 (XI1_I581_Bn I1_qu31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I581_MN5 (XI1_I581_n2 XI1_I581_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I581_MN4 (I1_b1_5 XI1_I581_An XI1_I581_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I581_MN2 (XI1_I581_n1 I1_dd5_b3_0 I1_b1_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I581_MN3 (VSS I1_qu31_b3_0 XI1_I581_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I581_MN0 (XI1_I581_An I1_dd5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I582_MN1 (XI1_I582_Bn I1_qu31_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I582_MN5 (XI1_I582_n2 XI1_I582_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I582_MN4 (I1_b1_6 XI1_I582_An XI1_I582_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I582_MN2 (XI1_I582_n1 I1_dd6_b3_0 I1_b1_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I582_MN3 (VSS I1_qu31_b3_1 XI1_I582_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I582_MN0 (XI1_I582_An I1_dd6_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I604_MN1 (XI1_I604_Bn I1_qu31_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I604_MN5 (XI1_I604_n2 XI1_I604_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I604_MN4 (I1_b1_28 XI1_I604_An XI1_I604_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I604_MN2 (XI1_I604_n1 I1_dd28_b3_0 I1_b1_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I604_MN3 (VSS I1_qu31_b3_4 XI1_I604_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I604_MN0 (XI1_I604_An I1_dd28_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I605_MN1 (XI1_I605_Bn I1_qu31_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I605_MN5 (XI1_I605_n2 XI1_I605_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I605_MN4 (I1_b1_29 XI1_I605_An XI1_I605_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I605_MN2 (XI1_I605_n1 I1_dd29_b3_0 I1_b1_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I605_MN3 (VSS I1_qu31_b3_4 XI1_I605_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I605_MN0 (XI1_I605_An I1_dd29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1477_MN1 (XI1_I1477_Bn I1_qu12_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1477_MN5 (XI1_I1477_n2 XI1_I1477_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1477_MN4 (I1_b20_27 XI1_I1477_An XI1_I1477_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1477_MN2 (XI1_I1477_n1 I1_dd27_b3_3 I1_b20_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1477_MN3 (VSS I1_qu12_b3_4 XI1_I1477_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1477_MN0 (XI1_I1477_An I1_dd27_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1513_MN1 (XI1_I1513_Bn I1_qu11_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1513_MN5 (XI1_I1513_n2 XI1_I1513_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1513_MN4 (I1_b21_17 XI1_I1513_An XI1_I1513_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1513_MN2 (XI1_I1513_n1 I1_dd17_b3_3 I1_b21_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1513_MN3 (VSS I1_qu11_b3_2 XI1_I1513_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1513_MN0 (XI1_I1513_An I1_dd17_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I212_MN1 (XI1_I1482_I212_Bn I1_I1482_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I212_MN5 (XI1_I1482_I212_n2 XI1_I1482_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1482_I212_MN4 (I1_p20_9 XI1_I1482_I212_An XI1_I1482_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1482_I212_MN2 (XI1_I1482_I212_n1 I1_I1482_pn9 I1_p20_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1482_I212_MN3 (VSS I1_I1482_G8_0n XI1_I1482_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1482_I212_MN0 (XI1_I1482_I212_An I1_I1482_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1510_MN1 (XI1_I1510_Bn I1_qu11_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1510_MN5 (XI1_I1510_n2 XI1_I1510_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1510_MN4 (I1_b21_14 XI1_I1510_An XI1_I1510_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1510_MN2 (XI1_I1510_n1 I1_dd14_b3_3 I1_b21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1510_MN3 (VSS I1_qu11_b3_2 XI1_I1510_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1510_MN0 (XI1_I1510_An I1_dd14_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1509_MN1 (XI1_I1509_Bn I1_qu11_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1509_MN5 (XI1_I1509_n2 XI1_I1509_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1509_MN4 (I1_b21_13 XI1_I1509_An XI1_I1509_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1509_MN2 (XI1_I1509_n1 I1_dd13_b3_3 I1_b21_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1509_MN3 (VSS I1_qu11_b3_2 XI1_I1509_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1509_MN0 (XI1_I1509_An I1_dd13_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1507_MN1 (XI1_I1507_Bn I1_qu11_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1507_MN5 (XI1_I1507_n2 XI1_I1507_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1507_MN4 (I1_b21_11 XI1_I1507_An XI1_I1507_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1507_MN2 (XI1_I1507_n1 I1_dd11_b3_3 I1_b21_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1507_MN3 (VSS I1_qu11_b3_1 XI1_I1507_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1507_MN0 (XI1_I1507_An I1_dd11_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1504_MN1 (XI1_I1504_Bn I1_qu11_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1504_MN5 (XI1_I1504_n2 XI1_I1504_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1504_MN4 (I1_b21_8 XI1_I1504_An XI1_I1504_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1504_MN2 (XI1_I1504_n1 I1_dd8_b3_3 I1_b21_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1504_MN3 (VSS I1_qu11_b3_1 XI1_I1504_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1504_MN0 (XI1_I1504_An I1_dd8_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1501_MN1 (XI1_I1501_Bn I1_qu11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1501_MN5 (XI1_I1501_n2 XI1_I1501_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1501_MN4 (I1_b21_5 XI1_I1501_An XI1_I1501_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1501_MN2 (XI1_I1501_n1 I1_dd5_b3_3 I1_b21_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1501_MN3 (VSS I1_qu11_b3_0 XI1_I1501_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1501_MN0 (XI1_I1501_An I1_dd5_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1500_MN1 (XI1_I1500_Bn I1_qu11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1500_MN5 (XI1_I1500_n2 XI1_I1500_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1500_MN4 (I1_b21_4 XI1_I1500_An XI1_I1500_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1500_MN2 (XI1_I1500_n1 I1_dd4_b3_3 I1_b21_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1500_MN3 (VSS I1_qu11_b3_0 XI1_I1500_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1500_MN0 (XI1_I1500_An I1_dd4_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1091_MN1 (XI1_I1091_Bn I1_qu20_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1091_MN5 (XI1_I1091_n2 XI1_I1091_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1091_MN4 (I1_b12_9 XI1_I1091_An XI1_I1091_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1091_MN2 (XI1_I1091_n1 I1_dd9_b3_2 I1_b12_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1091_MN3 (VSS I1_qu20_b3_1 XI1_I1091_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1091_MN0 (XI1_I1091_An I1_dd9_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1092_MN1 (XI1_I1092_Bn I1_qu20_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1092_MN5 (XI1_I1092_n2 XI1_I1092_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1092_MN4 (I1_b12_10 XI1_I1092_An XI1_I1092_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1092_MN2 (XI1_I1092_n1 I1_dd10_b3_2 I1_b12_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1092_MN3 (VSS I1_qu20_b3_1 XI1_I1092_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1092_MN0 (XI1_I1092_An I1_dd10_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1089_MN1 (XI1_I1089_Bn I1_qu20_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1089_MN5 (XI1_I1089_n2 XI1_I1089_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1089_MN4 (I1_b12_7 XI1_I1089_An XI1_I1089_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1089_MN2 (XI1_I1089_n1 I1_dd7_b3_2 I1_b12_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1089_MN3 (VSS I1_qu20_b3_1 XI1_I1089_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1089_MN0 (XI1_I1089_An I1_dd7_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1045_MN1 (XI1_I1045_Bn I1_qu21_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1045_MN5 (XI1_I1045_n2 XI1_I1045_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1045_MN4 (I1_b11_9 XI1_I1045_An XI1_I1045_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1045_MN2 (XI1_I1045_n1 I1_dd9_b3_2 I1_b11_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1045_MN3 (VSS I1_qu21_b3_1 XI1_I1045_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1045_MN0 (XI1_I1045_An I1_dd9_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1046_MN1 (XI1_I1046_Bn I1_qu21_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1046_MN5 (XI1_I1046_n2 XI1_I1046_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1046_MN4 (I1_b11_10 XI1_I1046_An XI1_I1046_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1046_MN2 (XI1_I1046_n1 I1_dd10_b3_2 I1_b11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1046_MN3 (VSS I1_qu21_b3_1 XI1_I1046_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1046_MN0 (XI1_I1046_An I1_dd10_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1043_MN1 (XI1_I1043_Bn I1_qu21_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1043_MN5 (XI1_I1043_n2 XI1_I1043_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1043_MN4 (I1_b11_7 XI1_I1043_An XI1_I1043_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1043_MN2 (XI1_I1043_n1 I1_dd7_b3_2 I1_b11_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1043_MN3 (VSS I1_qu21_b3_1 XI1_I1043_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1043_MN0 (XI1_I1043_An I1_dd7_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1082_MN1 (XI1_I1082_Bn I1_qu20_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1082_MN5 (XI1_I1082_n2 XI1_I1082_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1082_MN4 (I1_b12_0 XI1_I1082_An XI1_I1082_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1082_MN2 (XI1_I1082_n1 I1_B_0_b3_2 I1_b12_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1082_MN3 (VSS I1_qu20_b3_0 XI1_I1082_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1082_MN0 (XI1_I1082_An I1_B_0_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1047_MN1 (XI1_I1047_Bn I1_qu21_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1047_MN5 (XI1_I1047_n2 XI1_I1047_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1047_MN4 (I1_b11_11 XI1_I1047_An XI1_I1047_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1047_MN2 (XI1_I1047_n1 I1_dd11_b3_2 I1_b11_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1047_MN3 (VSS I1_qu21_b3_1 XI1_I1047_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1047_MN0 (XI1_I1047_An I1_dd11_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I212_MN1 (XI1_I1022_I212_Bn I1_I1022_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I212_MN5 (XI1_I1022_I212_n2 XI1_I1022_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1022_I212_MN4 (I1_p10_9 XI1_I1022_I212_An XI1_I1022_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1022_I212_MN2 (XI1_I1022_I212_n1 I1_I1022_pn9 I1_p10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1022_I212_MN3 (VSS I1_I1022_G8_0n XI1_I1022_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1022_I212_MN0 (XI1_I1022_I212_An I1_I1022_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I213_MN1 (XI1_I1022_I213_Bn I1_I1022_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I213_MN5 (XI1_I1022_I213_n2 XI1_I1022_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1022_I213_MN4 (I1_p10_10 XI1_I1022_I213_An XI1_I1022_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1022_I213_MN2 (XI1_I1022_I213_n1 I1_I1022_pn10 I1_p10_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1022_I213_MN3 (VSS I1_I1022_G9_0n XI1_I1022_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1022_I213_MN0 (XI1_I1022_I213_An I1_I1022_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I998_MN1 (XI1_I998_Bn I1_qu22_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I998_MN5 (XI1_I998_n2 XI1_I998_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I998_MN4 (I1_b10_8 XI1_I998_An XI1_I998_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I998_MN2 (XI1_I998_n1 I1_dd8_b3_1 I1_b10_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I998_MN3 (VSS I1_qu22_b3_1 XI1_I998_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I998_MN0 (XI1_I998_An I1_dd8_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1000_MN1 (XI1_I1000_Bn I1_qu22_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1000_MN5 (XI1_I1000_n2 XI1_I1000_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1000_MN4 (I1_b10_10 XI1_I1000_An XI1_I1000_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1000_MN2 (XI1_I1000_n1 I1_dd10_b3_1 I1_b10_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1000_MN3 (VSS I1_qu22_b3_1 XI1_I1000_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1000_MN0 (XI1_I1000_An I1_dd10_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I999_MN1 (XI1_I999_Bn I1_qu22_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I999_MN5 (XI1_I999_n2 XI1_I999_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I999_MN4 (I1_b10_9 XI1_I999_An XI1_I999_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I999_MN2 (XI1_I999_n1 I1_dd9_b3_1 I1_b10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I999_MN3 (VSS I1_qu22_b3_1 XI1_I999_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I999_MN0 (XI1_I999_An I1_dd9_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I995_MN1 (XI1_I995_Bn I1_qu22_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I995_MN5 (XI1_I995_n2 XI1_I995_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I995_MN4 (I1_b10_5 XI1_I995_An XI1_I995_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I995_MN2 (XI1_I995_n1 I1_dd5_b3_1 I1_b10_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I995_MN3 (VSS I1_qu22_b3_0 XI1_I995_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I995_MN0 (XI1_I995_An I1_dd5_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I991_MN1 (XI1_I991_Bn I1_qu22_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I991_MN5 (XI1_I991_n2 XI1_I991_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I991_MN4 (I1_b10_1 XI1_I991_An XI1_I991_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I991_MN2 (XI1_I991_n1 I1_dd1_b3_1 I1_b10_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I991_MN3 (VSS I1_qu22_b3_0 XI1_I991_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I991_MN0 (XI1_I991_An I1_dd1_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I534_MN1 (XI1_I534_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I534_MN5 (XI1_I534_n2 XI1_I534_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I534_MN4 (I1_b0_4 XI1_I534_An XI1_I534_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I534_MN2 (XI1_I534_n1 I1_dd4_b3_0 I1_b0_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I534_MN3 (VSS VDD XI1_I534_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I534_MN0 (XI1_I534_An I1_dd4_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I535_MN1 (XI1_I535_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I535_MN5 (XI1_I535_n2 XI1_I535_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I535_MN4 (I1_b0_5 XI1_I535_An XI1_I535_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I535_MN2 (XI1_I535_n1 I1_dd5_b3_0 I1_b0_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I535_MN3 (VSS VDD XI1_I535_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I535_MN0 (XI1_I535_An I1_dd5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I583_MN1 (XI1_I583_Bn I1_qu31_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I583_MN5 (XI1_I583_n2 XI1_I583_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I583_MN4 (I1_b1_7 XI1_I583_An XI1_I583_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I583_MN2 (XI1_I583_n1 I1_dd7_b3_0 I1_b1_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I583_MN3 (VSS I1_qu31_b3_1 XI1_I583_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I583_MN0 (XI1_I583_An I1_dd7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I584_MN1 (XI1_I584_Bn I1_qu31_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I584_MN5 (XI1_I584_n2 XI1_I584_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I584_MN4 (I1_b1_8 XI1_I584_An XI1_I584_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I584_MN2 (XI1_I584_n1 I1_dd8_b3_0 I1_b1_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I584_MN3 (VSS I1_qu31_b3_1 XI1_I584_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I584_MN0 (XI1_I584_An I1_dd8_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I587_MN1 (XI1_I587_Bn I1_qu31_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I587_MN5 (XI1_I587_n2 XI1_I587_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I587_MN4 (I1_b1_11 XI1_I587_An XI1_I587_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I587_MN2 (XI1_I587_n1 I1_dd11_b3_0 I1_b1_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I587_MN3 (VSS I1_qu31_b3_1 XI1_I587_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I587_MN0 (XI1_I587_An I1_dd11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I585_MN1 (XI1_I585_Bn I1_qu31_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I585_MN5 (XI1_I585_n2 XI1_I585_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I585_MN4 (I1_b1_9 XI1_I585_An XI1_I585_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I585_MN2 (XI1_I585_n1 I1_dd9_b3_0 I1_b1_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I585_MN3 (VSS I1_qu31_b3_1 XI1_I585_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I585_MN0 (XI1_I585_An I1_dd9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I586_MN1 (XI1_I586_Bn I1_qu31_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I586_MN5 (XI1_I586_n2 XI1_I586_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I586_MN4 (I1_b1_10 XI1_I586_An XI1_I586_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I586_MN2 (XI1_I586_n1 I1_dd10_b3_0 I1_b1_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I586_MN3 (VSS I1_qu31_b3_1 XI1_I586_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I586_MN0 (XI1_I586_An I1_dd10_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I588_MN1 (XI1_I588_Bn I1_qu31_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I588_MN5 (XI1_I588_n2 XI1_I588_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I588_MN4 (I1_b1_12 XI1_I588_An XI1_I588_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I588_MN2 (XI1_I588_n1 I1_dd12_b3_0 I1_b1_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I588_MN3 (VSS I1_qu31_b3_2 XI1_I588_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I588_MN0 (XI1_I588_An I1_dd12_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I589_MN1 (XI1_I589_Bn I1_qu31_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I589_MN5 (XI1_I589_n2 XI1_I589_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I589_MN4 (I1_b1_13 XI1_I589_An XI1_I589_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I589_MN2 (XI1_I589_n1 I1_dd13_b3_0 I1_b1_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I589_MN3 (VSS I1_qu31_b3_2 XI1_I589_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I589_MN0 (XI1_I589_An I1_dd13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I590_MN1 (XI1_I590_Bn I1_qu31_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I590_MN5 (XI1_I590_n2 XI1_I590_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I590_MN4 (I1_b1_14 XI1_I590_An XI1_I590_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I590_MN2 (XI1_I590_n1 I1_dd14_b3_0 I1_b1_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I590_MN3 (VSS I1_qu31_b3_2 XI1_I590_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I590_MN0 (XI1_I590_An I1_dd14_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I595_MN1 (XI1_I595_Bn I1_qu31_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I595_MN5 (XI1_I595_n2 XI1_I595_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I595_MN4 (I1_b1_19 XI1_I595_An XI1_I595_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I595_MN2 (XI1_I595_n1 I1_dd19_b3_0 I1_b1_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I595_MN3 (VSS I1_qu31_b3_3 XI1_I595_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I595_MN0 (XI1_I595_An I1_dd19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I599_MN1 (XI1_I599_Bn I1_qu31_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I599_MN5 (XI1_I599_n2 XI1_I599_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I599_MN4 (I1_b1_23 XI1_I599_An XI1_I599_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I599_MN2 (XI1_I599_n1 I1_dd23_b3_0 I1_b1_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I599_MN3 (VSS I1_qu31_b3_3 XI1_I599_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I599_MN0 (XI1_I599_An I1_dd23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I601_MN1 (XI1_I601_Bn I1_qu31_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I601_MN5 (XI1_I601_n2 XI1_I601_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I601_MN4 (I1_b1_25 XI1_I601_An XI1_I601_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I601_MN2 (XI1_I601_n1 I1_dd25_b3_0 I1_b1_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I601_MN3 (VSS I1_qu31_b3_4 XI1_I601_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I601_MN0 (XI1_I601_An I1_dd25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I602_MN1 (XI1_I602_Bn I1_qu31_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I602_MN5 (XI1_I602_n2 XI1_I602_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I602_MN4 (I1_b1_26 XI1_I602_An XI1_I602_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I602_MN2 (XI1_I602_n1 I1_dd26_b3_0 I1_b1_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I602_MN3 (VSS I1_qu31_b3_4 XI1_I602_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I602_MN0 (XI1_I602_An I1_dd26_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I558_MN1 (XI1_I558_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I558_MN5 (XI1_I558_n2 XI1_I558_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I558_MN4 (I1_b0_28 XI1_I558_An XI1_I558_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I558_MN2 (XI1_I558_n1 I1_dd28_b3_0 I1_b0_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I558_MN3 (VSS VDD XI1_I558_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I558_MN0 (XI1_I558_An I1_dd28_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I603_MN1 (XI1_I603_Bn I1_qu31_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I603_MN5 (XI1_I603_n2 XI1_I603_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I603_MN4 (I1_b1_27 XI1_I603_An XI1_I603_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I603_MN2 (XI1_I603_n1 I1_dd27_b3_0 I1_b1_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I603_MN3 (VSS I1_qu31_b3_4 XI1_I603_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I603_MN0 (XI1_I603_An I1_dd27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I561_MN1 (XI1_I561_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I561_MN5 (XI1_I561_n2 XI1_I561_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I561_MN4 (I1_b0_31 XI1_I561_An XI1_I561_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I561_MN2 (XI1_I561_n1 I1_dd31_b3_0 I1_b0_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I561_MN3 (VSS VDD XI1_I561_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I561_MN0 (XI1_I561_An I1_dd31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1479_MN1 (XI1_I1479_Bn I1_qu12_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1479_MN5 (XI1_I1479_n2 XI1_I1479_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1479_MN4 (I1_b20_29 XI1_I1479_An XI1_I1479_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1479_MN2 (XI1_I1479_n1 I1_dd29_b3_3 I1_b20_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1479_MN3 (VSS I1_qu12_b3_4 XI1_I1479_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1479_MN0 (XI1_I1479_An I1_dd29_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1478_MN1 (XI1_I1478_Bn I1_qu12_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1478_MN5 (XI1_I1478_n2 XI1_I1478_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1478_MN4 (I1_b20_28 XI1_I1478_An XI1_I1478_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1478_MN2 (XI1_I1478_n1 I1_dd28_b3_3 I1_b20_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1478_MN3 (VSS I1_qu12_b3_4 XI1_I1478_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1478_MN0 (XI1_I1478_An I1_dd28_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I216_MN1 (XI1_I1482_I216_Bn I1_I1482_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I216_MN5 (XI1_I1482_I216_n2 XI1_I1482_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1482_I216_MN4 (I1_p20_13 XI1_I1482_I216_An XI1_I1482_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1482_I216_MN2 (XI1_I1482_I216_n1 I1_I1482_pn13 I1_p20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1482_I216_MN3 (VSS I1_I1482_G12_0n XI1_I1482_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1482_I216_MN0 (XI1_I1482_I216_An I1_I1482_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I214_MN1 (XI1_I1482_I214_Bn I1_I1482_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I214_MN5 (XI1_I1482_I214_n2 XI1_I1482_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1482_I214_MN4 (I1_p20_11 XI1_I1482_I214_An XI1_I1482_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1482_I214_MN2 (XI1_I1482_I214_n1 I1_I1482_pn11 I1_p20_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1482_I214_MN3 (VSS I1_I1482_G10_0n XI1_I1482_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1482_I214_MN0 (XI1_I1482_I214_An I1_I1482_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1512_MN1 (XI1_I1512_Bn I1_qu11_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1512_MN5 (XI1_I1512_n2 XI1_I1512_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1512_MN4 (I1_b21_16 XI1_I1512_An XI1_I1512_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1512_MN2 (XI1_I1512_n1 I1_dd16_b3_3 I1_b21_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1512_MN3 (VSS I1_qu11_b3_2 XI1_I1512_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1512_MN0 (XI1_I1512_An I1_dd16_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1511_MN1 (XI1_I1511_Bn I1_qu11_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1511_MN5 (XI1_I1511_n2 XI1_I1511_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1511_MN4 (I1_b21_15 XI1_I1511_An XI1_I1511_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1511_MN2 (XI1_I1511_n1 I1_dd15_b3_3 I1_b21_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1511_MN3 (VSS I1_qu11_b3_2 XI1_I1511_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1511_MN0 (XI1_I1511_An I1_dd15_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1508_MN1 (XI1_I1508_Bn I1_qu11_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1508_MN5 (XI1_I1508_n2 XI1_I1508_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1508_MN4 (I1_b21_12 XI1_I1508_An XI1_I1508_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1508_MN2 (XI1_I1508_n1 I1_dd12_b3_3 I1_b21_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1508_MN3 (VSS I1_qu11_b3_2 XI1_I1508_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1508_MN0 (XI1_I1508_An I1_dd12_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1499_MN1 (XI1_I1499_Bn I1_qu11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1499_MN5 (XI1_I1499_n2 XI1_I1499_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1499_MN4 (I1_b21_3 XI1_I1499_An XI1_I1499_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1499_MN2 (XI1_I1499_n1 I1_dd3_b3_3 I1_b21_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1499_MN3 (VSS I1_qu11_b3_0 XI1_I1499_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1499_MN0 (XI1_I1499_An I1_dd3_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1090_MN1 (XI1_I1090_Bn I1_qu20_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1090_MN5 (XI1_I1090_n2 XI1_I1090_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1090_MN4 (I1_b12_8 XI1_I1090_An XI1_I1090_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1090_MN2 (XI1_I1090_n1 I1_dd8_b3_2 I1_b12_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1090_MN3 (VSS I1_qu20_b3_1 XI1_I1090_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1090_MN0 (XI1_I1090_An I1_dd8_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1088_MN1 (XI1_I1088_Bn I1_qu20_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1088_MN5 (XI1_I1088_n2 XI1_I1088_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1088_MN4 (I1_b12_6 XI1_I1088_An XI1_I1088_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1088_MN2 (XI1_I1088_n1 I1_dd6_b3_2 I1_b12_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1088_MN3 (VSS I1_qu20_b3_1 XI1_I1088_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1088_MN0 (XI1_I1088_An I1_dd6_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1087_MN1 (XI1_I1087_Bn I1_qu20_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1087_MN5 (XI1_I1087_n2 XI1_I1087_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1087_MN4 (I1_b12_5 XI1_I1087_An XI1_I1087_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1087_MN2 (XI1_I1087_n1 I1_dd5_b3_2 I1_b12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1087_MN3 (VSS I1_qu20_b3_0 XI1_I1087_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1087_MN0 (XI1_I1087_An I1_dd5_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1084_MN1 (XI1_I1084_Bn I1_qu20_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1084_MN5 (XI1_I1084_n2 XI1_I1084_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1084_MN4 (I1_b12_2 XI1_I1084_An XI1_I1084_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1084_MN2 (XI1_I1084_n1 I1_dd2_b3_2 I1_b12_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1084_MN3 (VSS I1_qu20_b3_0 XI1_I1084_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1084_MN0 (XI1_I1084_An I1_dd2_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1083_MN1 (XI1_I1083_Bn I1_qu20_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1083_MN5 (XI1_I1083_n2 XI1_I1083_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1083_MN4 (I1_b12_1 XI1_I1083_An XI1_I1083_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1083_MN2 (XI1_I1083_n1 I1_dd1_b3_2 I1_b12_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1083_MN3 (VSS I1_qu20_b3_0 XI1_I1083_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1083_MN0 (XI1_I1083_An I1_dd1_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I207_MN1 (XI1_I1068_I207_Bn I1_I1068_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I207_MN5 (XI1_I1068_I207_n2 XI1_I1068_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1068_I207_MN4 (I1_p11_4 XI1_I1068_I207_An XI1_I1068_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1068_I207_MN2 (XI1_I1068_I207_n1 I1_I1068_pn4 I1_p11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1068_I207_MN3 (VSS I1_I1068_G3_0n XI1_I1068_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1068_I207_MN0 (XI1_I1068_I207_An I1_I1068_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1044_MN1 (XI1_I1044_Bn I1_qu21_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1044_MN5 (XI1_I1044_n2 XI1_I1044_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1044_MN4 (I1_b11_8 XI1_I1044_An XI1_I1044_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1044_MN2 (XI1_I1044_n1 I1_dd8_b3_2 I1_b11_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1044_MN3 (VSS I1_qu21_b3_1 XI1_I1044_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1044_MN0 (XI1_I1044_An I1_dd8_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1042_MN1 (XI1_I1042_Bn I1_qu21_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1042_MN5 (XI1_I1042_n2 XI1_I1042_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1042_MN4 (I1_b11_6 XI1_I1042_An XI1_I1042_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1042_MN2 (XI1_I1042_n1 I1_dd6_b3_2 I1_b11_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1042_MN3 (VSS I1_qu21_b3_1 XI1_I1042_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1042_MN0 (XI1_I1042_An I1_dd6_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I996_MN1 (XI1_I996_Bn I1_qu22_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I996_MN5 (XI1_I996_n2 XI1_I996_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I996_MN4 (I1_b10_6 XI1_I996_An XI1_I996_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I996_MN2 (XI1_I996_n1 I1_dd6_b3_1 I1_b10_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I996_MN3 (VSS I1_qu22_b3_1 XI1_I996_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I996_MN0 (XI1_I996_An I1_dd6_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I997_MN1 (XI1_I997_Bn I1_qu22_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I997_MN5 (XI1_I997_n2 XI1_I997_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I997_MN4 (I1_b10_7 XI1_I997_An XI1_I997_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I997_MN2 (XI1_I997_n1 I1_dd7_b3_1 I1_b10_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I997_MN3 (VSS I1_qu22_b3_1 XI1_I997_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I997_MN0 (XI1_I997_An I1_dd7_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I993_MN1 (XI1_I993_Bn I1_qu22_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I993_MN5 (XI1_I993_n2 XI1_I993_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I993_MN4 (I1_b10_3 XI1_I993_An XI1_I993_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I993_MN2 (XI1_I993_n1 I1_dd3_b3_1 I1_b10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I993_MN3 (VSS I1_qu22_b3_0 XI1_I993_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I993_MN0 (XI1_I993_An I1_dd3_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I944_MN1 (XI1_I944_Bn I1_qu23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I944_MN5 (XI1_I944_n2 XI1_I944_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I944_MN4 (I1_b9_0 XI1_I944_An XI1_I944_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I944_MN2 (XI1_I944_n1 I1_B_0_b3_1 I1_b9_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I944_MN3 (VSS I1_qu23_b3_0 XI1_I944_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I944_MN0 (XI1_I944_An I1_B_0_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I992_MN1 (XI1_I992_Bn I1_qu22_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I992_MN5 (XI1_I992_n2 XI1_I992_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I992_MN4 (I1_b10_2 XI1_I992_An XI1_I992_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I992_MN2 (XI1_I992_n1 I1_dd2_b3_1 I1_b10_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I992_MN3 (VSS I1_qu22_b3_0 XI1_I992_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I992_MN0 (XI1_I992_An I1_dd2_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I994_MN1 (XI1_I994_Bn I1_qu22_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I994_MN5 (XI1_I994_n2 XI1_I994_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I994_MN4 (I1_b10_4 XI1_I994_An XI1_I994_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I994_MN2 (XI1_I994_n1 I1_dd4_b3_1 I1_b10_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I994_MN3 (VSS I1_qu22_b3_0 XI1_I994_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I994_MN0 (XI1_I994_An I1_dd4_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I532_MN1 (XI1_I532_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I532_MN5 (XI1_I532_n2 XI1_I532_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I532_MN4 (I1_b0_2 XI1_I532_An XI1_I532_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I532_MN2 (XI1_I532_n1 I1_dd2_b3_0 I1_b0_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I532_MN3 (VSS VDD XI1_I532_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I532_MN0 (XI1_I532_An I1_dd2_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I533_MN1 (XI1_I533_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I533_MN5 (XI1_I533_n2 XI1_I533_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I533_MN4 (I1_b0_3 XI1_I533_An XI1_I533_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I533_MN2 (XI1_I533_n1 I1_dd3_b3_0 I1_b0_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I533_MN3 (VSS VDD XI1_I533_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I533_MN0 (XI1_I533_An I1_dd3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I536_MN1 (XI1_I536_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I536_MN5 (XI1_I536_n2 XI1_I536_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I536_MN4 (I1_b0_6 XI1_I536_An XI1_I536_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I536_MN2 (XI1_I536_n1 I1_dd6_b3_0 I1_b0_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I536_MN3 (VSS VDD XI1_I536_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I536_MN0 (XI1_I536_An I1_dd6_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I537_MN1 (XI1_I537_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I537_MN5 (XI1_I537_n2 XI1_I537_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I537_MN4 (I1_b0_7 XI1_I537_An XI1_I537_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I537_MN2 (XI1_I537_n1 I1_dd7_b3_0 I1_b0_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I537_MN3 (VSS VDD XI1_I537_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I537_MN0 (XI1_I537_An I1_dd7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I538_MN1 (XI1_I538_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I538_MN5 (XI1_I538_n2 XI1_I538_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I538_MN4 (I1_b0_8 XI1_I538_An XI1_I538_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I538_MN2 (XI1_I538_n1 I1_dd8_b3_0 I1_b0_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I538_MN3 (VSS VDD XI1_I538_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I538_MN0 (XI1_I538_An I1_dd8_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I539_MN1 (XI1_I539_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I539_MN5 (XI1_I539_n2 XI1_I539_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I539_MN4 (I1_b0_9 XI1_I539_An XI1_I539_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I539_MN2 (XI1_I539_n1 I1_dd9_b3_0 I1_b0_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I539_MN3 (VSS VDD XI1_I539_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I539_MN0 (XI1_I539_An I1_dd9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I540_MN1 (XI1_I540_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I540_MN5 (XI1_I540_n2 XI1_I540_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I540_MN4 (I1_b0_10 XI1_I540_An XI1_I540_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I540_MN2 (XI1_I540_n1 I1_dd10_b3_0 I1_b0_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I540_MN3 (VSS VDD XI1_I540_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I540_MN0 (XI1_I540_An I1_dd10_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I541_MN1 (XI1_I541_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I541_MN5 (XI1_I541_n2 XI1_I541_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I541_MN4 (I1_b0_11 XI1_I541_An XI1_I541_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I541_MN2 (XI1_I541_n1 I1_dd11_b3_0 I1_b0_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I541_MN3 (VSS VDD XI1_I541_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I541_MN0 (XI1_I541_An I1_dd11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I542_MN1 (XI1_I542_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I542_MN5 (XI1_I542_n2 XI1_I542_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I542_MN4 (I1_b0_12 XI1_I542_An XI1_I542_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I542_MN2 (XI1_I542_n1 I1_dd12_b3_0 I1_b0_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I542_MN3 (VSS VDD XI1_I542_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I542_MN0 (XI1_I542_An I1_dd12_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I543_MN1 (XI1_I543_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I543_MN5 (XI1_I543_n2 XI1_I543_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I543_MN4 (I1_b0_13 XI1_I543_An XI1_I543_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I543_MN2 (XI1_I543_n1 I1_dd13_b3_0 I1_b0_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I543_MN3 (VSS VDD XI1_I543_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I543_MN0 (XI1_I543_An I1_dd13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I544_MN1 (XI1_I544_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I544_MN5 (XI1_I544_n2 XI1_I544_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I544_MN4 (I1_b0_14 XI1_I544_An XI1_I544_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I544_MN2 (XI1_I544_n1 I1_dd14_b3_0 I1_b0_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I544_MN3 (VSS VDD XI1_I544_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I544_MN0 (XI1_I544_An I1_dd14_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I591_MN1 (XI1_I591_Bn I1_qu31_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I591_MN5 (XI1_I591_n2 XI1_I591_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I591_MN4 (I1_b1_15 XI1_I591_An XI1_I591_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I591_MN2 (XI1_I591_n1 I1_dd15_b3_0 I1_b1_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I591_MN3 (VSS I1_qu31_b3_2 XI1_I591_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I591_MN0 (XI1_I591_An I1_dd15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I593_MN1 (XI1_I593_Bn I1_qu31_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I593_MN5 (XI1_I593_n2 XI1_I593_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I593_MN4 (I1_b1_17 XI1_I593_An XI1_I593_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I593_MN2 (XI1_I593_n1 I1_dd17_b3_0 I1_b1_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I593_MN3 (VSS I1_qu31_b3_2 XI1_I593_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I593_MN0 (XI1_I593_An I1_dd17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I592_MN1 (XI1_I592_Bn I1_qu31_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I592_MN5 (XI1_I592_n2 XI1_I592_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I592_MN4 (I1_b1_16 XI1_I592_An XI1_I592_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I592_MN2 (XI1_I592_n1 I1_dd16_b3_0 I1_b1_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I592_MN3 (VSS I1_qu31_b3_2 XI1_I592_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I592_MN0 (XI1_I592_An I1_dd16_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I594_MN1 (XI1_I594_Bn I1_qu31_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I594_MN5 (XI1_I594_n2 XI1_I594_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I594_MN4 (I1_b1_18 XI1_I594_An XI1_I594_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I594_MN2 (XI1_I594_n1 I1_dd18_b3_0 I1_b1_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I594_MN3 (VSS I1_qu31_b3_3 XI1_I594_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I594_MN0 (XI1_I594_An I1_dd18_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I548_MN1 (XI1_I548_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I548_MN5 (XI1_I548_n2 XI1_I548_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I548_MN4 (I1_b0_18 XI1_I548_An XI1_I548_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I548_MN2 (XI1_I548_n1 I1_dd18_b3_0 I1_b0_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I548_MN3 (VSS VDD XI1_I548_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I548_MN0 (XI1_I548_An I1_dd18_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I549_MN1 (XI1_I549_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I549_MN5 (XI1_I549_n2 XI1_I549_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I549_MN4 (I1_b0_19 XI1_I549_An XI1_I549_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I549_MN2 (XI1_I549_n1 I1_dd19_b3_0 I1_b0_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I549_MN3 (VSS VDD XI1_I549_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I549_MN0 (XI1_I549_An I1_dd19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I596_MN1 (XI1_I596_Bn I1_qu31_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I596_MN5 (XI1_I596_n2 XI1_I596_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I596_MN4 (I1_b1_20 XI1_I596_An XI1_I596_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I596_MN2 (XI1_I596_n1 I1_dd20_b3_0 I1_b1_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I596_MN3 (VSS I1_qu31_b3_3 XI1_I596_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I596_MN0 (XI1_I596_An I1_dd20_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I597_MN1 (XI1_I597_Bn I1_qu31_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I597_MN5 (XI1_I597_n2 XI1_I597_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I597_MN4 (I1_b1_21 XI1_I597_An XI1_I597_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I597_MN2 (XI1_I597_n1 I1_dd21_b3_0 I1_b1_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I597_MN3 (VSS I1_qu31_b3_3 XI1_I597_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I597_MN0 (XI1_I597_An I1_dd21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I598_MN1 (XI1_I598_Bn I1_qu31_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I598_MN5 (XI1_I598_n2 XI1_I598_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I598_MN4 (I1_b1_22 XI1_I598_An XI1_I598_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I598_MN2 (XI1_I598_n1 I1_dd22_b3_0 I1_b1_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I598_MN3 (VSS I1_qu31_b3_3 XI1_I598_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I598_MN0 (XI1_I598_An I1_dd22_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I551_MN1 (XI1_I551_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I551_MN5 (XI1_I551_n2 XI1_I551_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I551_MN4 (I1_b0_21 XI1_I551_An XI1_I551_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I551_MN2 (XI1_I551_n1 I1_dd21_b3_0 I1_b0_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I551_MN3 (VSS VDD XI1_I551_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I551_MN0 (XI1_I551_An I1_dd21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I600_MN1 (XI1_I600_Bn I1_qu31_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I600_MN5 (XI1_I600_n2 XI1_I600_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I600_MN4 (I1_b1_24 XI1_I600_An XI1_I600_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I600_MN2 (XI1_I600_n1 I1_dd24_b3_0 I1_b1_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I600_MN3 (VSS I1_qu31_b3_4 XI1_I600_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I600_MN0 (XI1_I600_An I1_dd24_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I609_MN1 (XI1_I609_Bn I1_qu31_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I609_MN5 (XI1_I609_n2 XI1_I609_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I609_MN4 (I1_h1 XI1_I609_An XI1_I609_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I609_MN2 (XI1_I609_n1 I1_p0_31 I1_h1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I609_MN3 (VSS I1_qu31_b3_5 XI1_I609_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I609_MN0 (XI1_I609_An I1_p0_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I556_MN1 (XI1_I556_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I556_MN5 (XI1_I556_n2 XI1_I556_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I556_MN4 (I1_b0_26 XI1_I556_An XI1_I556_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I556_MN2 (XI1_I556_n1 I1_dd26_b3_0 I1_b0_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I556_MN3 (VSS VDD XI1_I556_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I556_MN0 (XI1_I556_An I1_dd26_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I557_MN1 (XI1_I557_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I557_MN5 (XI1_I557_n2 XI1_I557_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I557_MN4 (I1_b0_27 XI1_I557_An XI1_I557_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I557_MN2 (XI1_I557_n1 I1_dd27_b3_0 I1_b0_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I557_MN3 (VSS VDD XI1_I557_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I557_MN0 (XI1_I557_An I1_dd27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I560_MN1 (XI1_I560_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I560_MN5 (XI1_I560_n2 XI1_I560_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I560_MN4 (I1_b0_30 XI1_I560_An XI1_I560_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I560_MN2 (XI1_I560_n1 I1_dd30_b3_0 I1_b0_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I560_MN3 (VSS VDD XI1_I560_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I560_MN0 (XI1_I560_An I1_dd30_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I218_MN1 (XI1_I1482_I218_Bn I1_I1482_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I218_MN5 (XI1_I1482_I218_n2 XI1_I1482_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1482_I218_MN4 (I1_p20_15 XI1_I1482_I218_An XI1_I1482_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1482_I218_MN2 (XI1_I1482_I218_n1 I1_I1482_pn15 I1_p20_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1482_I218_MN3 (VSS I1_I1482_G14_0n XI1_I1482_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1482_I218_MN0 (XI1_I1482_I218_An I1_I1482_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1516_MN1 (XI1_I1516_Bn I1_qu11_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1516_MN5 (XI1_I1516_n2 XI1_I1516_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1516_MN4 (I1_b21_20 XI1_I1516_An XI1_I1516_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1516_MN2 (XI1_I1516_n1 I1_dd20_b3_3 I1_b21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1516_MN3 (VSS I1_qu11_b3_3 XI1_I1516_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1516_MN0 (XI1_I1516_An I1_dd20_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1515_MN1 (XI1_I1515_Bn I1_qu11_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1515_MN5 (XI1_I1515_n2 XI1_I1515_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1515_MN4 (I1_b21_19 XI1_I1515_An XI1_I1515_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1515_MN2 (XI1_I1515_n1 I1_dd19_b3_3 I1_b21_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1515_MN3 (VSS I1_qu11_b3_3 XI1_I1515_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1515_MN0 (XI1_I1515_An I1_dd19_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1514_MN1 (XI1_I1514_Bn I1_qu11_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1514_MN5 (XI1_I1514_n2 XI1_I1514_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1514_MN4 (I1_b21_18 XI1_I1514_An XI1_I1514_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1514_MN2 (XI1_I1514_n1 I1_dd18_b3_3 I1_b21_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1514_MN3 (VSS I1_qu11_b3_3 XI1_I1514_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1514_MN0 (XI1_I1514_An I1_dd18_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1498_MN1 (XI1_I1498_Bn I1_qu11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1498_MN5 (XI1_I1498_n2 XI1_I1498_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1498_MN4 (I1_b21_2 XI1_I1498_An XI1_I1498_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1498_MN2 (XI1_I1498_n1 I1_dd2_b3_3 I1_b21_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1498_MN3 (VSS I1_qu11_b3_0 XI1_I1498_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1498_MN0 (XI1_I1498_An I1_dd2_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1086_MN1 (XI1_I1086_Bn I1_qu20_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1086_MN5 (XI1_I1086_n2 XI1_I1086_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1086_MN4 (I1_b12_4 XI1_I1086_An XI1_I1086_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1086_MN2 (XI1_I1086_n1 I1_dd4_b3_2 I1_b12_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1086_MN3 (VSS I1_qu20_b3_0 XI1_I1086_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1086_MN0 (XI1_I1086_An I1_dd4_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1085_MN1 (XI1_I1085_Bn I1_qu20_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1085_MN5 (XI1_I1085_n2 XI1_I1085_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1085_MN4 (I1_b12_3 XI1_I1085_An XI1_I1085_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1085_MN2 (XI1_I1085_n1 I1_dd3_b3_2 I1_b12_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1085_MN3 (VSS I1_qu20_b3_0 XI1_I1085_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1085_MN0 (XI1_I1085_An I1_dd3_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I206_MN1 (XI1_I1068_I206_Bn I1_I1068_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I206_MN5 (XI1_I1068_I206_n2 XI1_I1068_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1068_I206_MN4 (I1_p11_3 XI1_I1068_I206_An XI1_I1068_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1068_I206_MN2 (XI1_I1068_I206_n1 I1_I1068_pn3 I1_p11_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1068_I206_MN3 (VSS I1_I1068_G2_0n XI1_I1068_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1068_I206_MN0 (XI1_I1068_I206_An I1_I1068_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1037_MN1 (XI1_I1037_Bn I1_qu21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1037_MN5 (XI1_I1037_n2 XI1_I1037_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1037_MN4 (I1_b11_1 XI1_I1037_An XI1_I1037_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1037_MN2 (XI1_I1037_n1 I1_dd1_b3_2 I1_b11_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1037_MN3 (VSS I1_qu21_b3_0 XI1_I1037_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1037_MN0 (XI1_I1037_An I1_dd1_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1038_MN1 (XI1_I1038_Bn I1_qu21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1038_MN5 (XI1_I1038_n2 XI1_I1038_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1038_MN4 (I1_b11_2 XI1_I1038_An XI1_I1038_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1038_MN2 (XI1_I1038_n1 I1_dd2_b3_2 I1_b11_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1038_MN3 (VSS I1_qu21_b3_0 XI1_I1038_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1038_MN0 (XI1_I1038_An I1_dd2_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1039_MN1 (XI1_I1039_Bn I1_qu21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1039_MN5 (XI1_I1039_n2 XI1_I1039_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1039_MN4 (I1_b11_3 XI1_I1039_An XI1_I1039_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1039_MN2 (XI1_I1039_n1 I1_dd3_b3_2 I1_b11_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1039_MN3 (VSS I1_qu21_b3_0 XI1_I1039_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1039_MN0 (XI1_I1039_An I1_dd3_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1040_MN1 (XI1_I1040_Bn I1_qu21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1040_MN5 (XI1_I1040_n2 XI1_I1040_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1040_MN4 (I1_b11_4 XI1_I1040_An XI1_I1040_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1040_MN2 (XI1_I1040_n1 I1_dd4_b3_2 I1_b11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1040_MN3 (VSS I1_qu21_b3_0 XI1_I1040_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1040_MN0 (XI1_I1040_An I1_dd4_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1041_MN1 (XI1_I1041_Bn I1_qu21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1041_MN5 (XI1_I1041_n2 XI1_I1041_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1041_MN4 (I1_b11_5 XI1_I1041_An XI1_I1041_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1041_MN2 (XI1_I1041_n1 I1_dd5_b3_2 I1_b11_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1041_MN3 (VSS I1_qu21_b3_0 XI1_I1041_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1041_MN0 (XI1_I1041_An I1_dd5_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1036_MN1 (XI1_I1036_Bn I1_qu21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1036_MN5 (XI1_I1036_n2 XI1_I1036_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1036_MN4 (I1_b11_0 XI1_I1036_An XI1_I1036_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1036_MN2 (XI1_I1036_n1 I1_B_0_b3_2 I1_b11_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1036_MN3 (VSS I1_qu21_b3_0 XI1_I1036_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1036_MN0 (XI1_I1036_An I1_B_0_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I206_MN1 (XI1_I1022_I206_Bn I1_I1022_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I206_MN5 (XI1_I1022_I206_n2 XI1_I1022_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1022_I206_MN4 (I1_p10_3 XI1_I1022_I206_An XI1_I1022_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1022_I206_MN2 (XI1_I1022_I206_n1 I1_I1022_pn3 I1_p10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1022_I206_MN3 (VSS I1_I1022_G2_0n XI1_I1022_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1022_I206_MN0 (XI1_I1022_I206_An I1_I1022_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I207_MN1 (XI1_I1022_I207_Bn I1_I1022_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I207_MN5 (XI1_I1022_I207_n2 XI1_I1022_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1022_I207_MN4 (I1_p10_4 XI1_I1022_I207_An XI1_I1022_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1022_I207_MN2 (XI1_I1022_I207_n1 I1_I1022_pn4 I1_p10_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1022_I207_MN3 (VSS I1_I1022_G3_0n XI1_I1022_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1022_I207_MN0 (XI1_I1022_I207_An I1_I1022_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I990_MN1 (XI1_I990_Bn I1_qu22_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I990_MN5 (XI1_I990_n2 XI1_I990_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I990_MN4 (I1_b10_0 XI1_I990_An XI1_I990_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I990_MN2 (XI1_I990_n1 I1_B_0_b3_1 I1_b10_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I990_MN3 (VSS I1_qu22_b3_0 XI1_I990_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I990_MN0 (XI1_I990_An I1_B_0_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I530_MN1 (XI1_I530_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I530_MN5 (XI1_I530_n2 XI1_I530_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I530_MN4 (I1_b0_0 XI1_I530_An XI1_I530_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I530_MN2 (XI1_I530_n1 I1_B_0_b3_0 I1_b0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I530_MN3 (VSS VDD XI1_I530_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I530_MN0 (XI1_I530_An I1_B_0_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I206_MN1 (XI1_I562_I206_Bn I1_I562_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I206_MN5 (XI1_I562_I206_n2 XI1_I562_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I562_I206_MN4 (I1_p0_3 XI1_I562_I206_An XI1_I562_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I562_I206_MN2 (XI1_I562_I206_n1 I1_I562_pn3 I1_p0_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I562_I206_MN3 (VSS I1_I562_G2_0n XI1_I562_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I562_I206_MN0 (XI1_I562_I206_An I1_I562_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I212_MN1 (XI1_I562_I212_Bn I1_I562_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I212_MN5 (XI1_I562_I212_n2 XI1_I562_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I562_I212_MN4 (I1_p0_9 XI1_I562_I212_An XI1_I562_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I562_I212_MN2 (XI1_I562_I212_n1 I1_I562_pn9 I1_p0_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I562_I212_MN3 (VSS I1_I562_G8_0n XI1_I562_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I562_I212_MN0 (XI1_I562_I212_An I1_I562_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I214_MN1 (XI1_I562_I214_Bn I1_I562_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I214_MN5 (XI1_I562_I214_n2 XI1_I562_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I562_I214_MN4 (I1_p0_11 XI1_I562_I214_An XI1_I562_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I562_I214_MN2 (XI1_I562_I214_n1 I1_I562_pn11 I1_p0_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I562_I214_MN3 (VSS I1_I562_G10_0n XI1_I562_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I562_I214_MN0 (XI1_I562_I214_An I1_I562_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I216_MN1 (XI1_I562_I216_Bn I1_I562_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I216_MN5 (XI1_I562_I216_n2 XI1_I562_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I562_I216_MN4 (I1_p0_13 XI1_I562_I216_An XI1_I562_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I562_I216_MN2 (XI1_I562_I216_n1 I1_I562_pn13 I1_p0_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I562_I216_MN3 (VSS I1_I562_G12_0n XI1_I562_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I562_I216_MN0 (XI1_I562_I216_An I1_I562_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I545_MN1 (XI1_I545_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I545_MN5 (XI1_I545_n2 XI1_I545_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I545_MN4 (I1_b0_15 XI1_I545_An XI1_I545_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I545_MN2 (XI1_I545_n1 I1_dd15_b3_0 I1_b0_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I545_MN3 (VSS VDD XI1_I545_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I545_MN0 (XI1_I545_An I1_dd15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I546_MN1 (XI1_I546_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I546_MN5 (XI1_I546_n2 XI1_I546_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I546_MN4 (I1_b0_16 XI1_I546_An XI1_I546_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I546_MN2 (XI1_I546_n1 I1_dd16_b3_0 I1_b0_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I546_MN3 (VSS VDD XI1_I546_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I546_MN0 (XI1_I546_An I1_dd16_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I547_MN1 (XI1_I547_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I547_MN5 (XI1_I547_n2 XI1_I547_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I547_MN4 (I1_b0_17 XI1_I547_An XI1_I547_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I547_MN2 (XI1_I547_n1 I1_dd17_b3_0 I1_b0_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I547_MN3 (VSS VDD XI1_I547_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I547_MN0 (XI1_I547_An I1_dd17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I550_MN1 (XI1_I550_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I550_MN5 (XI1_I550_n2 XI1_I550_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I550_MN4 (I1_b0_20 XI1_I550_An XI1_I550_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I550_MN2 (XI1_I550_n1 I1_dd20_b3_0 I1_b0_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I550_MN3 (VSS VDD XI1_I550_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I550_MN0 (XI1_I550_An I1_dd20_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I552_MN1 (XI1_I552_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I552_MN5 (XI1_I552_n2 XI1_I552_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I552_MN4 (I1_b0_22 XI1_I552_An XI1_I552_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I552_MN2 (XI1_I552_n1 I1_dd22_b3_0 I1_b0_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I552_MN3 (VSS VDD XI1_I552_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I552_MN0 (XI1_I552_An I1_dd22_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I553_MN1 (XI1_I553_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I553_MN5 (XI1_I553_n2 XI1_I553_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I553_MN4 (I1_b0_23 XI1_I553_An XI1_I553_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I553_MN2 (XI1_I553_n1 I1_dd23_b3_0 I1_b0_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I553_MN3 (VSS VDD XI1_I553_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I553_MN0 (XI1_I553_An I1_dd23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I554_MN1 (XI1_I554_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I554_MN5 (XI1_I554_n2 XI1_I554_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I554_MN4 (I1_b0_24 XI1_I554_An XI1_I554_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I554_MN2 (XI1_I554_n1 I1_dd24_b3_0 I1_b0_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I554_MN3 (VSS VDD XI1_I554_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I554_MN0 (XI1_I554_An I1_dd24_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I555_MN1 (XI1_I555_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I555_MN5 (XI1_I555_n2 XI1_I555_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I555_MN4 (I1_b0_25 XI1_I555_An XI1_I555_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I555_MN2 (XI1_I555_n1 I1_dd25_b3_0 I1_b0_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I555_MN3 (VSS VDD XI1_I555_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I555_MN0 (XI1_I555_An I1_dd25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I559_MN1 (XI1_I559_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I559_MN5 (XI1_I559_n2 XI1_I559_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I559_MN4 (I1_b0_29 XI1_I559_An XI1_I559_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I559_MN2 (XI1_I559_n1 I1_dd29_b3_0 I1_b0_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I559_MN3 (VSS VDD XI1_I559_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I559_MN0 (XI1_I559_An I1_dd29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1521_MN1 (XI1_I1521_Bn I1_qu11_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1521_MN5 (XI1_I1521_n2 XI1_I1521_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1521_MN4 (I1_b21_25 XI1_I1521_An XI1_I1521_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1521_MN2 (XI1_I1521_n1 I1_dd25_b3_3 I1_b21_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1521_MN3 (VSS I1_qu11_b3_4 XI1_I1521_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1521_MN0 (XI1_I1521_An I1_dd25_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1520_MN1 (XI1_I1520_Bn I1_qu11_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1520_MN5 (XI1_I1520_n2 XI1_I1520_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1520_MN4 (I1_b21_24 XI1_I1520_An XI1_I1520_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1520_MN2 (XI1_I1520_n1 I1_dd24_b3_3 I1_b21_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1520_MN3 (VSS I1_qu11_b3_4 XI1_I1520_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1520_MN0 (XI1_I1520_An I1_dd24_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1519_MN1 (XI1_I1519_Bn I1_qu11_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1519_MN5 (XI1_I1519_n2 XI1_I1519_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1519_MN4 (I1_b21_23 XI1_I1519_An XI1_I1519_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1519_MN2 (XI1_I1519_n1 I1_dd23_b3_3 I1_b21_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1519_MN3 (VSS I1_qu11_b3_3 XI1_I1519_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1519_MN0 (XI1_I1519_An I1_dd23_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1518_MN1 (XI1_I1518_Bn I1_qu11_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1518_MN5 (XI1_I1518_n2 XI1_I1518_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1518_MN4 (I1_b21_22 XI1_I1518_An XI1_I1518_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1518_MN2 (XI1_I1518_n1 I1_dd22_b3_3 I1_b21_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1518_MN3 (VSS I1_qu11_b3_3 XI1_I1518_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1518_MN0 (XI1_I1518_An I1_dd22_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1517_MN1 (XI1_I1517_Bn I1_qu11_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1517_MN5 (XI1_I1517_n2 XI1_I1517_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1517_MN4 (I1_b21_21 XI1_I1517_An XI1_I1517_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1517_MN2 (XI1_I1517_n1 I1_dd21_b3_3 I1_b21_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1517_MN3 (VSS I1_qu11_b3_3 XI1_I1517_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1517_MN0 (XI1_I1517_An I1_dd21_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1497_MN1 (XI1_I1497_Bn I1_qu11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1497_MN5 (XI1_I1497_n2 XI1_I1497_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1497_MN4 (I1_b21_1 XI1_I1497_An XI1_I1497_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1497_MN2 (XI1_I1497_n1 I1_dd1_b3_3 I1_b21_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1497_MN3 (VSS I1_qu11_b3_0 XI1_I1497_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1497_MN0 (XI1_I1497_An I1_dd1_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1496_MN1 (XI1_I1496_Bn I1_qu11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1496_MN5 (XI1_I1496_n2 XI1_I1496_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1496_MN4 (I1_b21_0 XI1_I1496_An XI1_I1496_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1496_MN2 (XI1_I1496_n1 I1_B_0_b3_3 I1_b21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1496_MN3 (VSS I1_qu11_b3_0 XI1_I1496_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1496_MN0 (XI1_I1496_An I1_B_0_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I218_MN1 (XI1_I562_I218_Bn I1_I562_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I218_MN5 (XI1_I562_I218_n2 XI1_I562_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I562_I218_MN4 (I1_p0_15 XI1_I562_I218_An XI1_I562_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I562_I218_MN2 (XI1_I562_I218_n1 I1_I562_pn15 I1_p0_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I562_I218_MN3 (VSS I1_I562_G14_0n XI1_I562_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I562_I218_MN0 (XI1_I562_I218_An I1_I562_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1480_MN1 (XI1_I1480_Bn I1_qu12_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1480_MN5 (XI1_I1480_n2 XI1_I1480_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1480_MN4 (I1_b20_30 XI1_I1480_An XI1_I1480_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1480_MN2 (XI1_I1480_n1 I1_dd30_b3_3 I1_b20_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1480_MN3 (VSS I1_qu12_b3_5 XI1_I1480_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1480_MN0 (XI1_I1480_An I1_dd30_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1481_MN1 (XI1_I1481_Bn I1_qu12_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1481_MN5 (XI1_I1481_n2 XI1_I1481_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1481_MN4 (I1_b20_31 XI1_I1481_An XI1_I1481_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1481_MN2 (XI1_I1481_n1 I1_dd31_b3_3 I1_b20_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1481_MN3 (VSS I1_qu12_b3_5 XI1_I1481_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1481_MN0 (XI1_I1481_An I1_dd31_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1526_MN1 (XI1_I1526_Bn I1_qu11_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1526_MN5 (XI1_I1526_n2 XI1_I1526_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1526_MN4 (I1_b21_30 XI1_I1526_An XI1_I1526_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1526_MN2 (XI1_I1526_n1 I1_dd30_b3_3 I1_b21_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1526_MN3 (VSS I1_qu11_b3_5 XI1_I1526_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1526_MN0 (XI1_I1526_An I1_dd30_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1525_MN1 (XI1_I1525_Bn I1_qu11_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1525_MN5 (XI1_I1525_n2 XI1_I1525_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1525_MN4 (I1_b21_29 XI1_I1525_An XI1_I1525_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1525_MN2 (XI1_I1525_n1 I1_dd29_b3_3 I1_b21_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1525_MN3 (VSS I1_qu11_b3_4 XI1_I1525_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1525_MN0 (XI1_I1525_An I1_dd29_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1524_MN1 (XI1_I1524_Bn I1_qu11_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1524_MN5 (XI1_I1524_n2 XI1_I1524_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1524_MN4 (I1_b21_28 XI1_I1524_An XI1_I1524_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1524_MN2 (XI1_I1524_n1 I1_dd28_b3_3 I1_b21_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1524_MN3 (VSS I1_qu11_b3_4 XI1_I1524_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1524_MN0 (XI1_I1524_An I1_dd28_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1523_MN1 (XI1_I1523_Bn I1_qu11_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1523_MN5 (XI1_I1523_n2 XI1_I1523_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1523_MN4 (I1_b21_27 XI1_I1523_An XI1_I1523_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1523_MN2 (XI1_I1523_n1 I1_dd27_b3_3 I1_b21_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1523_MN3 (VSS I1_qu11_b3_4 XI1_I1523_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1523_MN0 (XI1_I1523_An I1_dd27_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1522_MN1 (XI1_I1522_Bn I1_qu11_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1522_MN5 (XI1_I1522_n2 XI1_I1522_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1522_MN4 (I1_b21_26 XI1_I1522_An XI1_I1522_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1522_MN2 (XI1_I1522_n1 I1_dd26_b3_3 I1_b21_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1522_MN3 (VSS I1_qu11_b3_4 XI1_I1522_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1522_MN0 (XI1_I1522_An I1_dd26_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I214_MN1 (XI1_I1528_I214_Bn I1_I1528_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I214_MN5 (XI1_I1528_I214_n2 XI1_I1528_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1528_I214_MN4 (I1_p21_11 XI1_I1528_I214_An XI1_I1528_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1528_I214_MN2 (XI1_I1528_I214_n1 I1_I1528_pn11 I1_p21_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1528_I214_MN3 (VSS I1_I1528_G10_0n XI1_I1528_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1528_I214_MN0 (XI1_I1528_I214_An I1_I1528_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I212_MN1 (XI1_I1528_I212_Bn I1_I1528_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I212_MN5 (XI1_I1528_I212_n2 XI1_I1528_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1528_I212_MN4 (I1_p21_9 XI1_I1528_I212_An XI1_I1528_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1528_I212_MN2 (XI1_I1528_I212_n1 I1_I1528_pn9 I1_p21_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1528_I212_MN3 (VSS I1_I1528_G8_0n XI1_I1528_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1528_I212_MN0 (XI1_I1528_I212_An I1_I1528_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I206_MN1 (XI1_I1528_I206_Bn I1_I1528_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I206_MN5 (XI1_I1528_I206_n2 XI1_I1528_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1528_I206_MN4 (I1_p21_3 XI1_I1528_I206_An XI1_I1528_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1528_I206_MN2 (XI1_I1528_I206_n1 I1_I1528_pn3 I1_p21_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1528_I206_MN3 (VSS I1_I1528_G2_0n XI1_I1528_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1528_I206_MN0 (XI1_I1528_I206_An I1_I1528_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2067_MN1 (XI1_I2067_Bn I1_B_31_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2067_MN5 (XI1_I2067_n2 XI1_I2067_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I2067_MN4 (I1_sq XI1_I2067_An XI1_I2067_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I2067_MN2 (XI1_I2067_n1 I1_A_31_b3_5 I1_sq VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I2067_MN3 (VSS I1_B_31_b3_5 XI1_I2067_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I2067_MN0 (XI1_I2067_An I1_A_31_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1527_MN1 (XI1_I1527_Bn I1_qu11_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1527_MN5 (XI1_I1527_n2 XI1_I1527_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1527_MN4 (I1_b21_31 XI1_I1527_An XI1_I1527_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1527_MN2 (XI1_I1527_n1 I1_dd31_b3_3 I1_b21_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1527_MN3 (VSS I1_qu11_b3_5 XI1_I1527_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1527_MN0 (XI1_I1527_An I1_dd31_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I218_MN1 (XI1_I1528_I218_Bn I1_I1528_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I218_MN5 (XI1_I1528_I218_n2 XI1_I1528_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1528_I218_MN4 (I1_p21_15 XI1_I1528_I218_An XI1_I1528_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1528_I218_MN2 (XI1_I1528_I218_n1 I1_I1528_pn15 I1_p21_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1528_I218_MN3 (VSS I1_I1528_G14_0n XI1_I1528_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1528_I218_MN0 (XI1_I1528_I218_An I1_I1528_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I216_MN1 (XI1_I1528_I216_Bn I1_I1528_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I216_MN5 (XI1_I1528_I216_n2 XI1_I1528_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1528_I216_MN4 (I1_p21_13 XI1_I1528_I216_An XI1_I1528_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1528_I216_MN2 (XI1_I1528_I216_n1 I1_I1528_pn13 I1_p21_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1528_I216_MN3 (VSS I1_I1528_G12_0n XI1_I1528_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1528_I216_MN0 (XI1_I1528_I216_An I1_I1528_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I213_MN1 (XI1_I1528_I213_Bn I1_I1528_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I213_MN5 (XI1_I1528_I213_n2 XI1_I1528_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1528_I213_MN4 (I1_p21_10 XI1_I1528_I213_An XI1_I1528_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1528_I213_MN2 (XI1_I1528_I213_n1 I1_I1528_pn10 I1_p21_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1528_I213_MN3 (VSS I1_I1528_G9_0n XI1_I1528_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1528_I213_MN0 (XI1_I1528_I213_An I1_I1528_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I207_MN1 (XI1_I1528_I207_Bn I1_I1528_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I207_MN5 (XI1_I1528_I207_n2 XI1_I1528_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1528_I207_MN4 (I1_p21_4 XI1_I1528_I207_An XI1_I1528_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1528_I207_MN2 (XI1_I1528_I207_n1 I1_I1528_pn4 I1_p21_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1528_I207_MN3 (VSS I1_I1528_G3_0n XI1_I1528_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1528_I207_MN0 (XI1_I1528_I207_An I1_I1528_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I118_MN1 (XI2_I2_I118_Bn B_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I118_MN5 (XI2_I2_I118_n2 XI2_I2_I118_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I118_MN4 (I2_XOR_19 XI2_I2_I118_An XI2_I2_I118_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I118_MN2 (XI2_I2_I118_n1 A_19 I2_XOR_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I118_MN3 (VSS B_19 XI2_I2_I118_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I118_MN0 (XI2_I2_I118_An A_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I112_MN1 (XI2_I2_I112_Bn B_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I112_MN5 (XI2_I2_I112_n2 XI2_I2_I112_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I112_MN4 (I2_XOR_18 XI2_I2_I112_An XI2_I2_I112_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I112_MN2 (XI2_I2_I112_n1 A_18 I2_XOR_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I112_MN3 (VSS B_18 XI2_I2_I112_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I112_MN0 (XI2_I2_I112_An A_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I124_MN1 (XI2_I2_I124_Bn B_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I124_MN5 (XI2_I2_I124_n2 XI2_I2_I124_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I124_MN4 (I2_XOR_20 XI2_I2_I124_An XI2_I2_I124_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I124_MN2 (XI2_I2_I124_n1 A_20 I2_XOR_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I124_MN3 (VSS B_20 XI2_I2_I124_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I124_MN0 (XI2_I2_I124_An A_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I142_MN1 (XI2_I2_I142_Bn B_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I142_MN5 (XI2_I2_I142_n2 XI2_I2_I142_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I142_MN4 (I2_XOR_23 XI2_I2_I142_An XI2_I2_I142_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I142_MN2 (XI2_I2_I142_n1 A_23 I2_XOR_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I142_MN3 (VSS B_23 XI2_I2_I142_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I142_MN0 (XI2_I2_I142_An A_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I207_MN1 (XI1_I562_I207_Bn I1_I562_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I207_MN5 (XI1_I562_I207_n2 XI1_I562_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I562_I207_MN4 (I1_p0_4 XI1_I562_I207_An XI1_I562_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I562_I207_MN2 (XI1_I562_I207_n1 I1_I562_pn4 I1_p0_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I562_I207_MN3 (VSS I1_I562_G3_0n XI1_I562_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I562_I207_MN0 (XI1_I562_I207_An I1_I562_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1529_MN1 (XI1_I1529_Bn I1_qu11_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1529_MN5 (XI1_I1529_n2 XI1_I1529_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1529_MN4 (I1_h21 XI1_I1529_An XI1_I1529_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1529_MN2 (XI1_I1529_n1 I1_p20_31 I1_h21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1529_MN3 (VSS I1_qu11_b3_5 XI1_I1529_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1529_MN0 (XI1_I1529_An I1_p20_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I26_MN1 (XI2_I1_I26_Bn I2_I1_SUB_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I26_MN5 (XI2_I1_I26_n2 XI2_I1_I26_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I26_MN4 (I2_I1_bx16 XI2_I1_I26_An XI2_I1_I26_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I26_MN2 (XI2_I1_I26_n1 B_16 I2_I1_bx16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I26_MN3 (VSS I2_I1_SUB_b3_2 XI2_I1_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I26_MN0 (XI2_I1_I26_An B_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I27_MN1 (XI2_I1_I27_Bn I2_I1_SUB_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I27_MN5 (XI2_I1_I27_n2 XI2_I1_I27_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I27_MN4 (I2_I1_bx17 XI2_I1_I27_An XI2_I1_I27_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I27_MN2 (XI2_I1_I27_n1 B_17 I2_I1_bx17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I27_MN3 (VSS I2_I1_SUB_b3_3 XI2_I1_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I27_MN0 (XI2_I1_I27_An B_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I28_MN1 (XI2_I1_I28_Bn I2_I1_SUB_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I28_MN5 (XI2_I1_I28_n2 XI2_I1_I28_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I28_MN4 (I2_I1_bx18 XI2_I1_I28_An XI2_I1_I28_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I28_MN2 (XI2_I1_I28_n1 B_18 I2_I1_bx18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I28_MN3 (VSS I2_I1_SUB_b3_3 XI2_I1_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I28_MN0 (XI2_I1_I28_An B_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I29_MN1 (XI2_I1_I29_Bn I2_I1_SUB_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I29_MN5 (XI2_I1_I29_n2 XI2_I1_I29_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I29_MN4 (I2_I1_bx19 XI2_I1_I29_An XI2_I1_I29_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I29_MN2 (XI2_I1_I29_n1 B_19 I2_I1_bx19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I29_MN3 (VSS I2_I1_SUB_b3_3 XI2_I1_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I29_MN0 (XI2_I1_I29_An B_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I30_MN1 (XI2_I1_I30_Bn I2_I1_SUB_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I30_MN5 (XI2_I1_I30_n2 XI2_I1_I30_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I30_MN4 (I2_I1_bx20 XI2_I1_I30_An XI2_I1_I30_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I30_MN2 (XI2_I1_I30_n1 B_20 I2_I1_bx20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I30_MN3 (VSS I2_I1_SUB_b3_3 XI2_I1_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I30_MN0 (XI2_I1_I30_An B_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I130_MN1 (XI2_I2_I130_Bn B_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I130_MN5 (XI2_I2_I130_n2 XI2_I2_I130_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I130_MN4 (I2_XOR_21 XI2_I2_I130_An XI2_I2_I130_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I130_MN2 (XI2_I2_I130_n1 A_21 I2_XOR_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I130_MN3 (VSS B_21 XI2_I2_I130_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I130_MN0 (XI2_I2_I130_An A_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I100_MN1 (XI2_I2_I100_Bn B_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I100_MN5 (XI2_I2_I100_n2 XI2_I2_I100_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I100_MN4 (I2_XOR_16 XI2_I2_I100_An XI2_I2_I100_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I100_MN2 (XI2_I2_I100_n1 A_16 I2_XOR_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I100_MN3 (VSS B_16 XI2_I2_I100_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I100_MN0 (XI2_I2_I100_An A_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I136_MN1 (XI2_I2_I136_Bn B_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I136_MN5 (XI2_I2_I136_n2 XI2_I2_I136_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I136_MN4 (I2_XOR_22 XI2_I2_I136_An XI2_I2_I136_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I136_MN2 (XI2_I2_I136_n1 A_22 I2_XOR_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I136_MN3 (VSS B_22 XI2_I2_I136_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I136_MN0 (XI2_I2_I136_An A_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I213_MN1 (XI1_I562_I213_Bn I1_I562_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I213_MN5 (XI1_I562_I213_n2 XI1_I562_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I562_I213_MN4 (I1_p0_10 XI1_I562_I213_An XI1_I562_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I562_I213_MN2 (XI1_I562_I213_n1 I1_I562_pn10 I1_p0_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I562_I213_MN3 (VSS I1_I562_G9_0n XI1_I562_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I562_I213_MN0 (XI1_I562_I213_An I1_I562_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I215_MN1 (XI1_I562_I215_Bn I1_I562_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I215_MN5 (XI1_I562_I215_n2 XI1_I562_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I562_I215_MN4 (I1_p0_12 XI1_I562_I215_An XI1_I562_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I562_I215_MN2 (XI1_I562_I215_n1 I1_I562_pn12 I1_p0_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I562_I215_MN3 (VSS I1_I562_G11_0n XI1_I562_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I562_I215_MN0 (XI1_I562_I215_An I1_I562_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I217_MN1 (XI1_I562_I217_Bn I1_I562_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I217_MN5 (XI1_I562_I217_n2 XI1_I562_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I562_I217_MN4 (I1_p0_14 XI1_I562_I217_An XI1_I562_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I562_I217_MN2 (XI1_I562_I217_n1 I1_I562_pn14 I1_p0_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I562_I217_MN3 (VSS I1_I562_G13_0n XI1_I562_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I562_I217_MN0 (XI1_I562_I217_An I1_I562_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I215_MN1 (XI1_I1528_I215_Bn I1_I1528_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I215_MN5 (XI1_I1528_I215_n2 XI1_I1528_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1528_I215_MN4 (I1_p21_12 XI1_I1528_I215_An XI1_I1528_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1528_I215_MN2 (XI1_I1528_I215_n1 I1_I1528_pn12 I1_p21_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1528_I215_MN3 (VSS I1_I1528_G11_0n XI1_I1528_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1528_I215_MN0 (XI1_I1528_I215_An I1_I1528_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I215_MN1 (XI1_I1574_I215_Bn I1_I1574_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I215_MN5 (XI1_I1574_I215_n2 XI1_I1574_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1574_I215_MN4 (I1_p22_12 XI1_I1574_I215_An XI1_I1574_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1574_I215_MN2 (XI1_I1574_I215_n1 I1_I1574_pn12 I1_p22_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1574_I215_MN3 (VSS I1_I1574_G11_0n XI1_I1574_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1574_I215_MN0 (XI1_I1574_I215_An I1_I1574_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I23_MN1 (XI2_I1_I23_Bn I2_I1_SUB_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I23_MN5 (XI2_I1_I23_n2 XI2_I1_I23_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I23_MN4 (I2_I1_bx13 XI2_I1_I23_An XI2_I1_I23_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I23_MN2 (XI2_I1_I23_n1 B_13 I2_I1_bx13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I23_MN3 (VSS I2_I1_SUB_b3_2 XI2_I1_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I23_MN0 (XI2_I1_I23_An B_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I25_MN1 (XI2_I1_I25_Bn I2_I1_SUB_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I25_MN5 (XI2_I1_I25_n2 XI2_I1_I25_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I25_MN4 (I2_I1_bx15 XI2_I1_I25_An XI2_I1_I25_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I25_MN2 (XI2_I1_I25_n1 B_15 I2_I1_bx15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I25_MN3 (VSS I2_I1_SUB_b3_2 XI2_I1_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I25_MN0 (XI2_I1_I25_An B_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I24_MN1 (XI2_I1_I24_Bn I2_I1_SUB_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I24_MN5 (XI2_I1_I24_n2 XI2_I1_I24_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I24_MN4 (I2_I1_bx14 XI2_I1_I24_An XI2_I1_I24_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I24_MN2 (XI2_I1_I24_n1 B_14 I2_I1_bx14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I24_MN3 (VSS I2_I1_SUB_b3_2 XI2_I1_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I24_MN0 (XI2_I1_I24_An B_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I31_MN1 (XI2_I1_I31_Bn I2_I1_SUB_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I31_MN5 (XI2_I1_I31_n2 XI2_I1_I31_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I31_MN4 (I2_I1_bx21 XI2_I1_I31_An XI2_I1_I31_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I31_MN2 (XI2_I1_I31_n1 B_21 I2_I1_bx21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I31_MN3 (VSS I2_I1_SUB_b3_3 XI2_I1_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I31_MN0 (XI2_I1_I31_An B_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I32_MN1 (XI2_I1_I32_Bn I2_I1_SUB_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I32_MN5 (XI2_I1_I32_n2 XI2_I1_I32_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I32_MN4 (I2_I1_bx22 XI2_I1_I32_An XI2_I1_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I32_MN2 (XI2_I1_I32_n1 B_22 I2_I1_bx22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I32_MN3 (VSS I2_I1_SUB_b3_4 XI2_I1_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I32_MN0 (XI2_I1_I32_An B_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I33_MN1 (XI2_I1_I33_Bn I2_I1_SUB_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I33_MN5 (XI2_I1_I33_n2 XI2_I1_I33_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I33_MN4 (I2_I1_bx23 XI2_I1_I33_An XI2_I1_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I33_MN2 (XI2_I1_I33_n1 B_23 I2_I1_bx23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I33_MN3 (VSS I2_I1_SUB_b3_4 XI2_I1_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I33_MN0 (XI2_I1_I33_An B_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I106_MN1 (XI2_I2_I106_Bn B_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I106_MN5 (XI2_I2_I106_n2 XI2_I2_I106_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I106_MN4 (I2_XOR_17 XI2_I2_I106_An XI2_I2_I106_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I106_MN2 (XI2_I2_I106_n1 A_17 I2_XOR_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I106_MN3 (VSS B_17 XI2_I2_I106_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I106_MN0 (XI2_I2_I106_An A_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I219_MN1 (XI1_I562_I219_Bn I1_I562_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I219_MN5 (XI1_I562_I219_n2 XI1_I562_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I562_I219_MN4 (I1_p0_16 XI1_I562_I219_An XI1_I562_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I562_I219_MN2 (XI1_I562_I219_n1 I1_I562_pn16 I1_p0_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I562_I219_MN3 (VSS I1_I562_G15_0n XI1_I562_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I562_I219_MN0 (XI1_I562_I219_An I1_I562_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1530_MN1 (XI1_I1530_Bn I1_c21_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1530_MN5 (XI1_I1530_n2 XI1_I1530_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1530_MN4 (I1_p21_32 XI1_I1530_An XI1_I1530_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1530_MN2 (XI1_I1530_n1 I1_h21 I1_p21_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1530_MN3 (VSS I1_c21_o XI1_I1530_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1530_MN0 (XI1_I1530_An I1_h21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I219_MN1 (XI1_I1528_I219_Bn I1_I1528_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I219_MN5 (XI1_I1528_I219_n2 XI1_I1528_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1528_I219_MN4 (I1_p21_16 XI1_I1528_I219_An XI1_I1528_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1528_I219_MN2 (XI1_I1528_I219_n1 I1_I1528_pn16 I1_p21_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1528_I219_MN3 (VSS I1_I1528_G15_0n XI1_I1528_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1528_I219_MN0 (XI1_I1528_I219_An I1_I1528_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1575_MN1 (XI1_I1575_Bn I1_qu10_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1575_MN5 (XI1_I1575_n2 XI1_I1575_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1575_MN4 (I1_h22 XI1_I1575_An XI1_I1575_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1575_MN2 (XI1_I1575_n1 I1_p21_31 I1_h22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1575_MN3 (VSS I1_qu10_b3_5 XI1_I1575_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1575_MN0 (XI1_I1575_An I1_p21_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I217_MN1 (XI1_I1528_I217_Bn I1_I1528_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I217_MN5 (XI1_I1528_I217_n2 XI1_I1528_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1528_I217_MN4 (I1_p21_14 XI1_I1528_I217_An XI1_I1528_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1528_I217_MN2 (XI1_I1528_I217_n1 I1_I1528_pn14 I1_p21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1528_I217_MN3 (VSS I1_I1528_G13_0n XI1_I1528_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1528_I217_MN0 (XI1_I1528_I217_An I1_I1528_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1576_MN1 (XI1_I1576_Bn I1_c22_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1576_MN5 (XI1_I1576_n2 XI1_I1576_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1576_MN4 (I1_p22_32 XI1_I1576_An XI1_I1576_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1576_MN2 (XI1_I1576_n1 I1_h22 I1_p22_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1576_MN3 (VSS I1_c22_o XI1_I1576_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1576_MN0 (XI1_I1576_An I1_h22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I82_MN1 (XI2_I2_I82_Bn B_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I82_MN5 (XI2_I2_I82_n2 XI2_I2_I82_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I82_MN4 (I2_XOR_13 XI2_I2_I82_An XI2_I2_I82_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I82_MN2 (XI2_I2_I82_n1 A_13 I2_XOR_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I82_MN3 (VSS B_13 XI2_I2_I82_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I82_MN0 (XI2_I2_I82_An A_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I94_MN1 (XI2_I2_I94_Bn B_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I94_MN5 (XI2_I2_I94_n2 XI2_I2_I94_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I94_MN4 (I2_XOR_15 XI2_I2_I94_An XI2_I2_I94_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I94_MN2 (XI2_I2_I94_n1 A_15 I2_XOR_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I94_MN3 (VSS B_15 XI2_I2_I94_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I94_MN0 (XI2_I2_I94_An A_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I21_MN1 (XI2_I1_I21_Bn I2_I1_SUB_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I21_MN5 (XI2_I1_I21_n2 XI2_I1_I21_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I21_MN4 (I2_I1_bx11 XI2_I1_I21_An XI2_I1_I21_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I21_MN2 (XI2_I1_I21_n1 B_11 I2_I1_bx11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I21_MN3 (VSS I2_I1_SUB_b3_2 XI2_I1_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I21_MN0 (XI2_I1_I21_An B_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I34_MN1 (XI2_I1_I34_Bn I2_I1_SUB_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I34_MN5 (XI2_I1_I34_n2 XI2_I1_I34_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I34_MN4 (I2_I1_bx24 XI2_I1_I34_An XI2_I1_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I34_MN2 (XI2_I1_I34_n1 B_24 I2_I1_bx24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I34_MN3 (VSS I2_I1_SUB_b3_4 XI2_I1_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I34_MN0 (XI2_I1_I34_An B_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I35_MN1 (XI2_I1_I35_Bn I2_I1_SUB_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I35_MN5 (XI2_I1_I35_n2 XI2_I1_I35_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I35_MN4 (I2_I1_bx25 XI2_I1_I35_An XI2_I1_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I35_MN2 (XI2_I1_I35_n1 B_25 I2_I1_bx25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I35_MN3 (VSS I2_I1_SUB_b3_4 XI2_I1_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I35_MN0 (XI2_I1_I35_An B_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I36_MN1 (XI2_I1_I36_Bn I2_I1_SUB_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I36_MN5 (XI2_I1_I36_n2 XI2_I1_I36_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I36_MN4 (I2_I1_bx26 XI2_I1_I36_An XI2_I1_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I36_MN2 (XI2_I1_I36_n1 B_26 I2_I1_bx26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I36_MN3 (VSS I2_I1_SUB_b3_4 XI2_I1_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I36_MN0 (XI2_I1_I36_An B_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I37_MN1 (XI2_I1_I37_Bn I2_I1_SUB_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I37_MN5 (XI2_I1_I37_n2 XI2_I1_I37_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I37_MN4 (I2_I1_bx27 XI2_I1_I37_An XI2_I1_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I37_MN2 (XI2_I1_I37_n1 B_27 I2_I1_bx27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I37_MN3 (VSS I2_I1_SUB_b3_4 XI2_I1_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I37_MN0 (XI2_I1_I37_An B_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I154_MN1 (XI2_I2_I154_Bn B_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I154_MN5 (XI2_I2_I154_n2 XI2_I2_I154_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I154_MN4 (I2_XOR_25 XI2_I2_I154_An XI2_I2_I154_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I154_MN2 (XI2_I2_I154_n1 A_25 I2_XOR_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I154_MN3 (VSS B_25 XI2_I2_I154_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I154_MN0 (XI2_I2_I154_An A_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I166_MN1 (XI2_I2_I166_Bn B_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I166_MN5 (XI2_I2_I166_n2 XI2_I2_I166_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I166_MN4 (I2_XOR_27 XI2_I2_I166_An XI2_I2_I166_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I166_MN2 (XI2_I2_I166_n1 A_27 I2_XOR_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I166_MN3 (VSS B_27 XI2_I2_I166_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I166_MN0 (XI2_I2_I166_An A_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I178_MN1 (XI2_I2_I178_Bn B_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I178_MN5 (XI2_I2_I178_n2 XI2_I2_I178_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I178_MN4 (I2_XOR_29 XI2_I2_I178_An XI2_I2_I178_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I178_MN2 (XI2_I2_I178_n1 A_29 I2_XOR_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I178_MN3 (VSS B_29 XI2_I2_I178_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I178_MN0 (XI2_I2_I178_An A_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I207_MN1 (XI1_I1712_I207_Bn I1_I1712_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I207_MN5 (XI1_I1712_I207_n2 XI1_I1712_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1712_I207_MN4 (I1_p25_4 XI1_I1712_I207_An XI1_I1712_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1712_I207_MN2 (XI1_I1712_I207_n1 I1_I1712_pn4 I1_p25_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1712_I207_MN3 (VSS I1_I1712_G3_0n XI1_I1712_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1712_I207_MN0 (XI1_I1712_I207_An I1_I1712_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I217_MN1 (XI1_I1574_I217_Bn I1_I1574_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I217_MN5 (XI1_I1574_I217_n2 XI1_I1574_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1574_I217_MN4 (I1_p22_14 XI1_I1574_I217_An XI1_I1574_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1574_I217_MN2 (XI1_I1574_I217_n1 I1_I1574_pn14 I1_p22_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1574_I217_MN3 (VSS I1_I1574_G13_0n XI1_I1574_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1574_I217_MN0 (XI1_I1574_I217_An I1_I1574_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I213_MN1 (XI1_I1574_I213_Bn I1_I1574_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I213_MN5 (XI1_I1574_I213_n2 XI1_I1574_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1574_I213_MN4 (I1_p22_10 XI1_I1574_I213_An XI1_I1574_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1574_I213_MN2 (XI1_I1574_I213_n1 I1_I1574_pn10 I1_p22_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1574_I213_MN3 (VSS I1_I1574_G9_0n XI1_I1574_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1574_I213_MN0 (XI1_I1574_I213_An I1_I1574_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I207_MN1 (XI1_I1574_I207_Bn I1_I1574_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I207_MN5 (XI1_I1574_I207_n2 XI1_I1574_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1574_I207_MN4 (I1_p22_4 XI1_I1574_I207_An XI1_I1574_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1574_I207_MN2 (XI1_I1574_I207_n1 I1_I1574_pn4 I1_p22_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1574_I207_MN3 (VSS I1_I1574_G3_0n XI1_I1574_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1574_I207_MN0 (XI1_I1574_I207_An I1_I1574_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I88_MN1 (XI2_I2_I88_Bn B_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I88_MN5 (XI2_I2_I88_n2 XI2_I2_I88_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I88_MN4 (I2_XOR_14 XI2_I2_I88_An XI2_I2_I88_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I88_MN2 (XI2_I2_I88_n1 A_14 I2_XOR_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I88_MN3 (VSS B_14 XI2_I2_I88_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I88_MN0 (XI2_I2_I88_An A_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I22_MN1 (XI2_I1_I22_Bn I2_I1_SUB_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I22_MN5 (XI2_I1_I22_n2 XI2_I1_I22_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I22_MN4 (I2_I1_bx12 XI2_I1_I22_An XI2_I1_I22_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I22_MN2 (XI2_I1_I22_n1 B_12 I2_I1_bx12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I22_MN3 (VSS I2_I1_SUB_b3_2 XI2_I1_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I22_MN0 (XI2_I1_I22_An B_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I216_MN1 (XI2_I1_I42_I216_Bn I2_I1_I42_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I216_MN5 (XI2_I1_I42_I216_n2 XI2_I1_I42_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I42_I216_MN4 (I2_S_13 XI2_I1_I42_I216_An XI2_I1_I42_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I42_I216_MN2 (XI2_I1_I42_I216_n1 I2_I1_I42_pn13 I2_S_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I42_I216_MN3 (VSS I2_I1_I42_G12_0n XI2_I1_I42_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I42_I216_MN0 (XI2_I1_I42_I216_An I2_I1_I42_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I219_MN1 (XI2_I1_I42_I219_Bn I2_I1_I42_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I219_MN5 (XI2_I1_I42_I219_n2 XI2_I1_I42_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I42_I219_MN4 (I2_S_16 XI2_I1_I42_I219_An XI2_I1_I42_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I42_I219_MN2 (XI2_I1_I42_I219_n1 I2_I1_I42_pn16 I2_S_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I42_I219_MN3 (VSS I2_I1_I42_G15_0n XI2_I1_I42_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I42_I219_MN0 (XI2_I1_I42_I219_An I2_I1_I42_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I148_MN1 (XI2_I2_I148_Bn B_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I148_MN5 (XI2_I2_I148_n2 XI2_I2_I148_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I148_MN4 (I2_XOR_24 XI2_I2_I148_An XI2_I2_I148_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I148_MN2 (XI2_I2_I148_n1 A_24 I2_XOR_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I148_MN3 (VSS B_24 XI2_I2_I148_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I148_MN0 (XI2_I2_I148_An A_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I160_MN1 (XI2_I2_I160_Bn B_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I160_MN5 (XI2_I2_I160_n2 XI2_I2_I160_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I160_MN4 (I2_XOR_26 XI2_I2_I160_An XI2_I2_I160_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I160_MN2 (XI2_I2_I160_n1 A_26 I2_XOR_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I160_MN3 (VSS B_26 XI2_I2_I160_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I160_MN0 (XI2_I2_I160_An A_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I172_MN1 (XI2_I2_I172_Bn B_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I172_MN5 (XI2_I2_I172_n2 XI2_I2_I172_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I172_MN4 (I2_XOR_28 XI2_I2_I172_An XI2_I2_I172_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I172_MN2 (XI2_I2_I172_n1 A_28 I2_XOR_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I172_MN3 (VSS B_28 XI2_I2_I172_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I172_MN0 (XI2_I2_I172_An A_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I213_MN1 (XI1_I1712_I213_Bn I1_I1712_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I213_MN5 (XI1_I1712_I213_n2 XI1_I1712_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1712_I213_MN4 (I1_p25_10 XI1_I1712_I213_An XI1_I1712_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1712_I213_MN2 (XI1_I1712_I213_n1 I1_I1712_pn10 I1_p25_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1712_I213_MN3 (VSS I1_I1712_G9_0n XI1_I1712_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1712_I213_MN0 (XI1_I1712_I213_An I1_I1712_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1684_MN1 (XI1_I1684_Bn I1_qu7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1684_MN5 (XI1_I1684_n2 XI1_I1684_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1684_MN4 (I1_b25_4 XI1_I1684_An XI1_I1684_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1684_MN2 (XI1_I1684_n1 I1_dd4_b3_4 I1_b25_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1684_MN3 (VSS I1_qu7_b3_0 XI1_I1684_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1684_MN0 (XI1_I1684_An I1_dd4_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1683_MN1 (XI1_I1683_Bn I1_qu7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1683_MN5 (XI1_I1683_n2 XI1_I1683_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1683_MN4 (I1_b25_3 XI1_I1683_An XI1_I1683_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1683_MN2 (XI1_I1683_n1 I1_dd3_b3_4 I1_b25_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1683_MN3 (VSS I1_qu7_b3_0 XI1_I1683_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1683_MN0 (XI1_I1683_An I1_dd3_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1573_MN1 (XI1_I1573_Bn I1_qu10_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1573_MN5 (XI1_I1573_n2 XI1_I1573_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1573_MN4 (I1_b22_31 XI1_I1573_An XI1_I1573_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1573_MN2 (XI1_I1573_n1 I1_dd31_b3_4 I1_b22_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1573_MN3 (VSS I1_qu10_b3_5 XI1_I1573_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1573_MN0 (XI1_I1573_An I1_dd31_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I219_MN1 (XI1_I1574_I219_Bn I1_I1574_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I219_MN5 (XI1_I1574_I219_n2 XI1_I1574_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1574_I219_MN4 (I1_p22_16 XI1_I1574_I219_An XI1_I1574_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1574_I219_MN2 (XI1_I1574_I219_n1 I1_I1574_pn16 I1_p22_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1574_I219_MN3 (VSS I1_I1574_G15_0n XI1_I1574_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1574_I219_MN0 (XI1_I1574_I219_An I1_I1574_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I216_MN1 (XI1_I1574_I216_Bn I1_I1574_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I216_MN5 (XI1_I1574_I216_n2 XI1_I1574_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1574_I216_MN4 (I1_p22_13 XI1_I1574_I216_An XI1_I1574_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1574_I216_MN2 (XI1_I1574_I216_n1 I1_I1574_pn13 I1_p22_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1574_I216_MN3 (VSS I1_I1574_G12_0n XI1_I1574_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1574_I216_MN0 (XI1_I1574_I216_An I1_I1574_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1547_MN1 (XI1_I1547_Bn I1_qu10_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1547_MN5 (XI1_I1547_n2 XI1_I1547_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1547_MN4 (I1_b22_5 XI1_I1547_An XI1_I1547_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1547_MN2 (XI1_I1547_n1 I1_dd5_b3_4 I1_b22_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1547_MN3 (VSS I1_qu10_b3_0 XI1_I1547_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1547_MN0 (XI1_I1547_An I1_dd5_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1546_MN1 (XI1_I1546_Bn I1_qu10_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1546_MN5 (XI1_I1546_n2 XI1_I1546_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1546_MN4 (I1_b22_4 XI1_I1546_An XI1_I1546_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1546_MN2 (XI1_I1546_n1 I1_dd4_b3_4 I1_b22_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1546_MN3 (VSS I1_qu10_b3_0 XI1_I1546_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1546_MN0 (XI1_I1546_An I1_dd4_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1545_MN1 (XI1_I1545_Bn I1_qu10_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1545_MN5 (XI1_I1545_n2 XI1_I1545_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1545_MN4 (I1_b22_3 XI1_I1545_An XI1_I1545_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1545_MN2 (XI1_I1545_n1 I1_dd3_b3_4 I1_b22_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1545_MN3 (VSS I1_qu10_b3_0 XI1_I1545_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1545_MN0 (XI1_I1545_An I1_dd3_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I218_MN1 (XI2_I1_I42_I218_Bn I2_I1_I42_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I218_MN5 (XI2_I1_I42_I218_n2 XI2_I1_I42_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I42_I218_MN4 (I2_S_15 XI2_I1_I42_I218_An XI2_I1_I42_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I42_I218_MN2 (XI2_I1_I42_I218_n1 I2_I1_I42_pn15 I2_S_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I42_I218_MN3 (VSS I2_I1_I42_G14_0n XI2_I1_I42_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I42_I218_MN0 (XI2_I1_I42_I218_An I2_I1_I42_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I38_MN1 (XI2_I1_I38_Bn I2_I1_SUB_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I38_MN5 (XI2_I1_I38_n2 XI2_I1_I38_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I38_MN4 (I2_I1_bx28 XI2_I1_I38_An XI2_I1_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I38_MN2 (XI2_I1_I38_n1 B_28 I2_I1_bx28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I38_MN3 (VSS I2_I1_SUB_b3_5 XI2_I1_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I38_MN0 (XI2_I1_I38_An B_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I39_MN1 (XI2_I1_I39_Bn I2_I1_SUB_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I39_MN5 (XI2_I1_I39_n2 XI2_I1_I39_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I39_MN4 (I2_I1_bx29 XI2_I1_I39_An XI2_I1_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I39_MN2 (XI2_I1_I39_n1 B_29 I2_I1_bx29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I39_MN3 (VSS I2_I1_SUB_b3_5 XI2_I1_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I39_MN0 (XI2_I1_I39_An B_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I184_MN1 (XI2_I2_I184_Bn B_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I184_MN5 (XI2_I2_I184_n2 XI2_I2_I184_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I184_MN4 (I2_XOR_30 XI2_I2_I184_An XI2_I2_I184_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I184_MN2 (XI2_I2_I184_n1 A_30 I2_XOR_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I184_MN3 (VSS B_30 XI2_I2_I184_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I184_MN0 (XI2_I2_I184_An A_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I564_MN1 (XI1_I564_Bn I1_c0_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I564_MN5 (XI1_I564_n2 XI1_I564_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I564_MN4 (I1_p0_32 XI1_I564_An XI1_I564_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I564_MN2 (XI1_I564_n1 I1_h0 I1_p0_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I564_MN3 (VSS I1_c0_o XI1_I564_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I564_MN0 (XI1_I564_An I1_h0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I563_MN1 (XI1_I563_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I563_MN5 (XI1_I563_n2 XI1_I563_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I563_MN4 (I1_h0 XI1_I563_An XI1_I563_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I563_MN2 (XI1_I563_n1 VSS I1_h0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I563_MN3 (VSS VDD XI1_I563_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I563_MN0 (XI1_I563_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1685_MN1 (XI1_I1685_Bn I1_qu7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1685_MN5 (XI1_I1685_n2 XI1_I1685_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1685_MN4 (I1_b25_5 XI1_I1685_An XI1_I1685_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1685_MN2 (XI1_I1685_n1 I1_dd5_b3_4 I1_b25_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1685_MN3 (VSS I1_qu7_b3_0 XI1_I1685_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1685_MN0 (XI1_I1685_An I1_dd5_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1572_MN1 (XI1_I1572_Bn I1_qu10_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1572_MN5 (XI1_I1572_n2 XI1_I1572_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1572_MN4 (I1_b22_30 XI1_I1572_An XI1_I1572_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1572_MN2 (XI1_I1572_n1 I1_dd30_b3_4 I1_b22_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1572_MN3 (VSS I1_qu10_b3_5 XI1_I1572_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1572_MN0 (XI1_I1572_An I1_dd30_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1571_MN1 (XI1_I1571_Bn I1_qu10_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1571_MN5 (XI1_I1571_n2 XI1_I1571_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1571_MN4 (I1_b22_29 XI1_I1571_An XI1_I1571_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1571_MN2 (XI1_I1571_n1 I1_dd29_b3_4 I1_b22_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1571_MN3 (VSS I1_qu10_b3_4 XI1_I1571_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1571_MN0 (XI1_I1571_An I1_dd29_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1544_MN1 (XI1_I1544_Bn I1_qu10_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1544_MN5 (XI1_I1544_n2 XI1_I1544_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1544_MN4 (I1_b22_2 XI1_I1544_An XI1_I1544_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1544_MN2 (XI1_I1544_n1 I1_dd2_b3_4 I1_b22_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1544_MN3 (VSS I1_qu10_b3_0 XI1_I1544_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1544_MN0 (XI1_I1544_An I1_dd2_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I76_MN1 (XI2_I2_I76_Bn B_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I76_MN5 (XI2_I2_I76_n2 XI2_I2_I76_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I76_MN4 (I2_XOR_12 XI2_I2_I76_An XI2_I2_I76_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I76_MN2 (XI2_I2_I76_n1 A_12 I2_XOR_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I76_MN3 (VSS B_12 XI2_I2_I76_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I76_MN0 (XI2_I2_I76_An A_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I70_MN1 (XI2_I2_I70_Bn B_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I70_MN5 (XI2_I2_I70_n2 XI2_I2_I70_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I70_MN4 (I2_XOR_11 XI2_I2_I70_An XI2_I2_I70_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I70_MN2 (XI2_I2_I70_n1 A_11 I2_XOR_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I70_MN3 (VSS B_11 XI2_I2_I70_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I70_MN0 (XI2_I2_I70_An A_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I215_MN1 (XI2_I1_I42_I215_Bn I2_I1_I42_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I215_MN5 (XI2_I1_I42_I215_n2 XI2_I1_I42_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I42_I215_MN4 (I2_S_12 XI2_I1_I42_I215_An XI2_I1_I42_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I42_I215_MN2 (XI2_I1_I42_I215_n1 I2_I1_I42_pn12 I2_S_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I42_I215_MN3 (VSS I2_I1_I42_G11_0n XI2_I1_I42_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I42_I215_MN0 (XI2_I1_I42_I215_An I2_I1_I42_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I217_MN1 (XI2_I1_I42_I217_Bn I2_I1_I42_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I217_MN5 (XI2_I1_I42_I217_n2 XI2_I1_I42_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I42_I217_MN4 (I2_S_14 XI2_I1_I42_I217_An XI2_I1_I42_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I42_I217_MN2 (XI2_I1_I42_I217_n1 I2_I1_I42_pn14 I2_S_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I42_I217_MN3 (VSS I2_I1_I42_G13_0n XI2_I1_I42_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I42_I217_MN0 (XI2_I1_I42_I217_An I2_I1_I42_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I41_MN1 (XI2_I1_I41_Bn I2_I1_SUB_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I41_MN5 (XI2_I1_I41_n2 XI2_I1_I41_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I41_MN4 (I2_I1_bx31 XI2_I1_I41_An XI2_I1_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I41_MN2 (XI2_I1_I41_n1 B_31 I2_I1_bx31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I41_MN3 (VSS I2_I1_SUB_b3_5 XI2_I1_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I41_MN0 (XI2_I1_I41_An B_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I40_MN1 (XI2_I1_I40_Bn I2_I1_SUB_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I40_MN5 (XI2_I1_I40_n2 XI2_I1_I40_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I40_MN4 (I2_I1_bx30 XI2_I1_I40_An XI2_I1_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I40_MN2 (XI2_I1_I40_n1 B_30 I2_I1_bx30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I40_MN3 (VSS I2_I1_SUB_b3_5 XI2_I1_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I40_MN0 (XI2_I1_I40_An B_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I4_I66_MN1 (XI2_I4_I66_Bn I2_CO VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I4_I66_MN5 (XI2_I4_I66_n2 XI2_I4_I66_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I4_I66_MN4 (I2_I4_ovf XI2_I4_I66_An XI2_I4_I66_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I4_I66_MN2 (XI2_I4_I66_n1 I2_CM I2_I4_ovf VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I4_I66_MN3 (VSS I2_CO XI2_I4_I66_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I4_I66_MN0 (XI2_I4_I66_An I2_CM VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I190_MN1 (XI2_I2_I190_Bn B_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I190_MN5 (XI2_I2_I190_n2 XI2_I2_I190_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I190_MN4 (I2_XOR_31 XI2_I2_I190_An XI2_I2_I190_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I190_MN2 (XI2_I2_I190_n1 A_31 I2_XOR_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I190_MN3 (VSS B_31 XI2_I2_I190_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I190_MN0 (XI2_I2_I190_An A_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1709_MN1 (XI1_I1709_Bn I1_qu7_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1709_MN5 (XI1_I1709_n2 XI1_I1709_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1709_MN4 (I1_b25_29 XI1_I1709_An XI1_I1709_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1709_MN2 (XI1_I1709_n1 I1_dd29_b3_4 I1_b25_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1709_MN3 (VSS I1_qu7_b3_4 XI1_I1709_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1709_MN0 (XI1_I1709_An I1_dd29_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1707_MN1 (XI1_I1707_Bn I1_qu7_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1707_MN5 (XI1_I1707_n2 XI1_I1707_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1707_MN4 (I1_b25_27 XI1_I1707_An XI1_I1707_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1707_MN2 (XI1_I1707_n1 I1_dd27_b3_4 I1_b25_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1707_MN3 (VSS I1_qu7_b3_4 XI1_I1707_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1707_MN0 (XI1_I1707_An I1_dd27_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I206_MN1 (XI1_I1712_I206_Bn I1_I1712_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I206_MN5 (XI1_I1712_I206_n2 XI1_I1712_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1712_I206_MN4 (I1_p25_3 XI1_I1712_I206_An XI1_I1712_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1712_I206_MN2 (XI1_I1712_I206_n1 I1_I1712_pn3 I1_p25_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1712_I206_MN3 (VSS I1_I1712_G2_0n XI1_I1712_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1712_I206_MN0 (XI1_I1712_I206_An I1_I1712_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1682_MN1 (XI1_I1682_Bn I1_qu7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1682_MN5 (XI1_I1682_n2 XI1_I1682_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1682_MN4 (I1_b25_2 XI1_I1682_An XI1_I1682_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1682_MN2 (XI1_I1682_n1 I1_dd2_b3_4 I1_b25_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1682_MN3 (VSS I1_qu7_b3_0 XI1_I1682_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1682_MN0 (XI1_I1682_An I1_dd2_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1681_MN1 (XI1_I1681_Bn I1_qu7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1681_MN5 (XI1_I1681_n2 XI1_I1681_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1681_MN4 (I1_b25_1 XI1_I1681_An XI1_I1681_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1681_MN2 (XI1_I1681_n1 I1_dd1_b3_4 I1_b25_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1681_MN3 (VSS I1_qu7_b3_0 XI1_I1681_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1681_MN0 (XI1_I1681_An I1_dd1_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1569_MN1 (XI1_I1569_Bn I1_qu10_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1569_MN5 (XI1_I1569_n2 XI1_I1569_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1569_MN4 (I1_b22_27 XI1_I1569_An XI1_I1569_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1569_MN2 (XI1_I1569_n1 I1_dd27_b3_4 I1_b22_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1569_MN3 (VSS I1_qu10_b3_4 XI1_I1569_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1569_MN0 (XI1_I1569_An I1_dd27_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1570_MN1 (XI1_I1570_Bn I1_qu10_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1570_MN5 (XI1_I1570_n2 XI1_I1570_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1570_MN4 (I1_b22_28 XI1_I1570_An XI1_I1570_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1570_MN2 (XI1_I1570_n1 I1_dd28_b3_4 I1_b22_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1570_MN3 (VSS I1_qu10_b3_4 XI1_I1570_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1570_MN0 (XI1_I1570_An I1_dd28_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1568_MN1 (XI1_I1568_Bn I1_qu10_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1568_MN5 (XI1_I1568_n2 XI1_I1568_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1568_MN4 (I1_b22_26 XI1_I1568_An XI1_I1568_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1568_MN2 (XI1_I1568_n1 I1_dd26_b3_4 I1_b22_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1568_MN3 (VSS I1_qu10_b3_4 XI1_I1568_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1568_MN0 (XI1_I1568_An I1_dd26_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I212_MN1 (XI1_I1574_I212_Bn I1_I1574_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I212_MN5 (XI1_I1574_I212_n2 XI1_I1574_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1574_I212_MN4 (I1_p22_9 XI1_I1574_I212_An XI1_I1574_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1574_I212_MN2 (XI1_I1574_I212_n1 I1_I1574_pn9 I1_p22_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1574_I212_MN3 (VSS I1_I1574_G8_0n XI1_I1574_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1574_I212_MN0 (XI1_I1574_I212_An I1_I1574_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1543_MN1 (XI1_I1543_Bn I1_qu10_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1543_MN5 (XI1_I1543_n2 XI1_I1543_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1543_MN4 (I1_b22_1 XI1_I1543_An XI1_I1543_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1543_MN2 (XI1_I1543_n1 I1_dd1_b3_4 I1_b22_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1543_MN3 (VSS I1_qu10_b3_0 XI1_I1543_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1543_MN0 (XI1_I1543_An I1_dd1_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I214_MN1 (XI2_I1_I42_I214_Bn I2_I1_I42_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I214_MN5 (XI2_I1_I42_I214_n2 XI2_I1_I42_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I42_I214_MN4 (I2_S_11 XI2_I1_I42_I214_An XI2_I1_I42_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I42_I214_MN2 (XI2_I1_I42_I214_n1 I2_I1_I42_pn11 I2_S_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I42_I214_MN3 (VSS I2_I1_I42_G10_0n XI2_I1_I42_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I42_I214_MN0 (XI2_I1_I42_I214_An I2_I1_I42_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1708_MN1 (XI1_I1708_Bn I1_qu7_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1708_MN5 (XI1_I1708_n2 XI1_I1708_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1708_MN4 (I1_b25_28 XI1_I1708_An XI1_I1708_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1708_MN2 (XI1_I1708_n1 I1_dd28_b3_4 I1_b25_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1708_MN3 (VSS I1_qu7_b3_4 XI1_I1708_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1708_MN0 (XI1_I1708_An I1_dd28_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1704_MN1 (XI1_I1704_Bn I1_qu7_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1704_MN5 (XI1_I1704_n2 XI1_I1704_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1704_MN4 (I1_b25_24 XI1_I1704_An XI1_I1704_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1704_MN2 (XI1_I1704_n1 I1_dd24_b3_4 I1_b25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1704_MN3 (VSS I1_qu7_b3_4 XI1_I1704_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1704_MN0 (XI1_I1704_An I1_dd24_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I212_MN1 (XI1_I1712_I212_Bn I1_I1712_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I212_MN5 (XI1_I1712_I212_n2 XI1_I1712_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1712_I212_MN4 (I1_p25_9 XI1_I1712_I212_An XI1_I1712_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1712_I212_MN2 (XI1_I1712_I212_n1 I1_I1712_pn9 I1_p25_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1712_I212_MN3 (VSS I1_I1712_G8_0n XI1_I1712_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1712_I212_MN0 (XI1_I1712_I212_An I1_I1712_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1680_MN1 (XI1_I1680_Bn I1_qu7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1680_MN5 (XI1_I1680_n2 XI1_I1680_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1680_MN4 (I1_b25_0 XI1_I1680_An XI1_I1680_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1680_MN2 (XI1_I1680_n1 I1_B_0_b3_4 I1_b25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1680_MN3 (VSS I1_qu7_b3_0 XI1_I1680_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1680_MN0 (XI1_I1680_An I1_B_0_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1634_MN1 (XI1_I1634_Bn I1_qu8_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1634_MN5 (XI1_I1634_n2 XI1_I1634_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1634_MN4 (I1_b24_0 XI1_I1634_An XI1_I1634_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1634_MN2 (XI1_I1634_n1 I1_B_0_b3_4 I1_b24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1634_MN3 (VSS I1_qu8_b3_0 XI1_I1634_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1634_MN0 (XI1_I1634_An I1_B_0_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1635_MN1 (XI1_I1635_Bn I1_qu8_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1635_MN5 (XI1_I1635_n2 XI1_I1635_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1635_MN4 (I1_b24_1 XI1_I1635_An XI1_I1635_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1635_MN2 (XI1_I1635_n1 I1_dd1_b3_4 I1_b24_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1635_MN3 (VSS I1_qu8_b3_0 XI1_I1635_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1635_MN0 (XI1_I1635_An I1_dd1_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1636_MN1 (XI1_I1636_Bn I1_qu8_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1636_MN5 (XI1_I1636_n2 XI1_I1636_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1636_MN4 (I1_b24_2 XI1_I1636_An XI1_I1636_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1636_MN2 (XI1_I1636_n1 I1_dd2_b3_4 I1_b24_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1636_MN3 (VSS I1_qu8_b3_0 XI1_I1636_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1636_MN0 (XI1_I1636_An I1_dd2_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1567_MN1 (XI1_I1567_Bn I1_qu10_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1567_MN5 (XI1_I1567_n2 XI1_I1567_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1567_MN4 (I1_b22_25 XI1_I1567_An XI1_I1567_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1567_MN2 (XI1_I1567_n1 I1_dd25_b3_4 I1_b22_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1567_MN3 (VSS I1_qu10_b3_4 XI1_I1567_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1567_MN0 (XI1_I1567_An I1_dd25_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1566_MN1 (XI1_I1566_Bn I1_qu10_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1566_MN5 (XI1_I1566_n2 XI1_I1566_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1566_MN4 (I1_b22_24 XI1_I1566_An XI1_I1566_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1566_MN2 (XI1_I1566_n1 I1_dd24_b3_4 I1_b22_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1566_MN3 (VSS I1_qu10_b3_4 XI1_I1566_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1566_MN0 (XI1_I1566_An I1_dd24_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I206_MN1 (XI1_I1574_I206_Bn I1_I1574_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I206_MN5 (XI1_I1574_I206_n2 XI1_I1574_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1574_I206_MN4 (I1_p22_3 XI1_I1574_I206_An XI1_I1574_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1574_I206_MN2 (XI1_I1574_I206_n1 I1_I1574_pn3 I1_p22_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1574_I206_MN3 (VSS I1_I1574_G2_0n XI1_I1574_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1574_I206_MN0 (XI1_I1574_I206_An I1_I1574_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1542_MN1 (XI1_I1542_Bn I1_qu10_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1542_MN5 (XI1_I1542_n2 XI1_I1542_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1542_MN4 (I1_b22_0 XI1_I1542_An XI1_I1542_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1542_MN2 (XI1_I1542_n1 I1_B_0_b3_3 I1_b22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1542_MN3 (VSS I1_qu10_b3_0 XI1_I1542_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1542_MN0 (XI1_I1542_An I1_B_0_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I20_MN1 (XI2_I1_I20_Bn I2_I1_SUB_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I20_MN5 (XI2_I1_I20_n2 XI2_I1_I20_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I20_MN4 (I2_I1_bx10 XI2_I1_I20_An XI2_I1_I20_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I20_MN2 (XI2_I1_I20_n1 B_10 I2_I1_bx10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I20_MN3 (VSS I2_I1_SUB_b3_1 XI2_I1_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I20_MN0 (XI2_I1_I20_An B_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I213_MN1 (XI2_I1_I42_I213_Bn I2_I1_I42_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I213_MN5 (XI2_I1_I42_I213_n2 XI2_I1_I42_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I42_I213_MN4 (I2_S_10 XI2_I1_I42_I213_An XI2_I1_I42_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I42_I213_MN2 (XI2_I1_I42_I213_n1 I2_I1_I42_pn10 I2_S_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I42_I213_MN3 (VSS I2_I1_I42_G9_0n XI2_I1_I42_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I42_I213_MN0 (XI2_I1_I42_I213_An I2_I1_I42_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1710_MN1 (XI1_I1710_Bn I1_qu7_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1710_MN5 (XI1_I1710_n2 XI1_I1710_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1710_MN4 (I1_b25_30 XI1_I1710_An XI1_I1710_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1710_MN2 (XI1_I1710_n1 I1_dd30_b3_4 I1_b25_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1710_MN3 (VSS I1_qu7_b3_5 XI1_I1710_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1710_MN0 (XI1_I1710_An I1_dd30_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1706_MN1 (XI1_I1706_Bn I1_qu7_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1706_MN5 (XI1_I1706_n2 XI1_I1706_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1706_MN4 (I1_b25_26 XI1_I1706_An XI1_I1706_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1706_MN2 (XI1_I1706_n1 I1_dd26_b3_4 I1_b25_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1706_MN3 (VSS I1_qu7_b3_4 XI1_I1706_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1706_MN0 (XI1_I1706_An I1_dd26_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I215_MN1 (XI1_I1712_I215_Bn I1_I1712_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I215_MN5 (XI1_I1712_I215_n2 XI1_I1712_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1712_I215_MN4 (I1_p25_12 XI1_I1712_I215_An XI1_I1712_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1712_I215_MN2 (XI1_I1712_I215_n1 I1_I1712_pn12 I1_p25_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1712_I215_MN3 (VSS I1_I1712_G11_0n XI1_I1712_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1712_I215_MN0 (XI1_I1712_I215_An I1_I1712_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I214_MN1 (XI1_I1712_I214_Bn I1_I1712_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I214_MN5 (XI1_I1712_I214_n2 XI1_I1712_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1712_I214_MN4 (I1_p25_11 XI1_I1712_I214_An XI1_I1712_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1712_I214_MN2 (XI1_I1712_I214_n1 I1_I1712_pn11 I1_p25_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1712_I214_MN3 (VSS I1_I1712_G10_0n XI1_I1712_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1712_I214_MN0 (XI1_I1712_I214_An I1_I1712_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1690_MN1 (XI1_I1690_Bn I1_qu7_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1690_MN5 (XI1_I1690_n2 XI1_I1690_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1690_MN4 (I1_b25_10 XI1_I1690_An XI1_I1690_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1690_MN2 (XI1_I1690_n1 I1_dd10_b3_4 I1_b25_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1690_MN3 (VSS I1_qu7_b3_1 XI1_I1690_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1690_MN0 (XI1_I1690_An I1_dd10_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1687_MN1 (XI1_I1687_Bn I1_qu7_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1687_MN5 (XI1_I1687_n2 XI1_I1687_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1687_MN4 (I1_b25_7 XI1_I1687_An XI1_I1687_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1687_MN2 (XI1_I1687_n1 I1_dd7_b3_4 I1_b25_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1687_MN3 (VSS I1_qu7_b3_1 XI1_I1687_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1687_MN0 (XI1_I1687_An I1_dd7_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1686_MN1 (XI1_I1686_Bn I1_qu7_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1686_MN5 (XI1_I1686_n2 XI1_I1686_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1686_MN4 (I1_b25_6 XI1_I1686_An XI1_I1686_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1686_MN2 (XI1_I1686_n1 I1_dd6_b3_4 I1_b25_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1686_MN3 (VSS I1_qu7_b3_1 XI1_I1686_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1686_MN0 (XI1_I1686_An I1_dd6_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I206_MN1 (XI1_I1666_I206_Bn I1_I1666_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I206_MN5 (XI1_I1666_I206_n2 XI1_I1666_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1666_I206_MN4 (I1_p24_3 XI1_I1666_I206_An XI1_I1666_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1666_I206_MN2 (XI1_I1666_I206_n1 I1_I1666_pn3 I1_p24_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1666_I206_MN3 (VSS I1_I1666_G2_0n XI1_I1666_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1666_I206_MN0 (XI1_I1666_I206_An I1_I1666_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1637_MN1 (XI1_I1637_Bn I1_qu8_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1637_MN5 (XI1_I1637_n2 XI1_I1637_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1637_MN4 (I1_b24_3 XI1_I1637_An XI1_I1637_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1637_MN2 (XI1_I1637_n1 I1_dd3_b3_4 I1_b24_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1637_MN3 (VSS I1_qu8_b3_0 XI1_I1637_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1637_MN0 (XI1_I1637_An I1_dd3_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1565_MN1 (XI1_I1565_Bn I1_qu10_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1565_MN5 (XI1_I1565_n2 XI1_I1565_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1565_MN4 (I1_b22_23 XI1_I1565_An XI1_I1565_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1565_MN2 (XI1_I1565_n1 I1_dd23_b3_4 I1_b22_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1565_MN3 (VSS I1_qu10_b3_3 XI1_I1565_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1565_MN0 (XI1_I1565_An I1_dd23_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1564_MN1 (XI1_I1564_Bn I1_qu10_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1564_MN5 (XI1_I1564_n2 XI1_I1564_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1564_MN4 (I1_b22_22 XI1_I1564_An XI1_I1564_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1564_MN2 (XI1_I1564_n1 I1_dd22_b3_4 I1_b22_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1564_MN3 (VSS I1_qu10_b3_3 XI1_I1564_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1564_MN0 (XI1_I1564_An I1_dd22_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I214_MN1 (XI1_I1574_I214_Bn I1_I1574_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I214_MN5 (XI1_I1574_I214_n2 XI1_I1574_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1574_I214_MN4 (I1_p22_11 XI1_I1574_I214_An XI1_I1574_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1574_I214_MN2 (XI1_I1574_I214_n1 I1_I1574_pn11 I1_p22_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1574_I214_MN3 (VSS I1_I1574_G10_0n XI1_I1574_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1574_I214_MN0 (XI1_I1574_I214_An I1_I1574_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1552_MN1 (XI1_I1552_Bn I1_qu10_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1552_MN5 (XI1_I1552_n2 XI1_I1552_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1552_MN4 (I1_b22_10 XI1_I1552_An XI1_I1552_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1552_MN2 (XI1_I1552_n1 I1_dd10_b3_4 I1_b22_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1552_MN3 (VSS I1_qu10_b3_1 XI1_I1552_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1552_MN0 (XI1_I1552_An I1_dd10_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1550_MN1 (XI1_I1550_Bn I1_qu10_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1550_MN5 (XI1_I1550_n2 XI1_I1550_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1550_MN4 (I1_b22_8 XI1_I1550_An XI1_I1550_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1550_MN2 (XI1_I1550_n1 I1_dd8_b3_4 I1_b22_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1550_MN3 (VSS I1_qu10_b3_1 XI1_I1550_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1550_MN0 (XI1_I1550_An I1_dd8_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1549_MN1 (XI1_I1549_Bn I1_qu10_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1549_MN5 (XI1_I1549_n2 XI1_I1549_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1549_MN4 (I1_b22_7 XI1_I1549_An XI1_I1549_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1549_MN2 (XI1_I1549_n1 I1_dd7_b3_4 I1_b22_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1549_MN3 (VSS I1_qu10_b3_1 XI1_I1549_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1549_MN0 (XI1_I1549_An I1_dd7_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1548_MN1 (XI1_I1548_Bn I1_qu10_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1548_MN5 (XI1_I1548_n2 XI1_I1548_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1548_MN4 (I1_b22_6 XI1_I1548_An XI1_I1548_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1548_MN2 (XI1_I1548_n1 I1_dd6_b3_4 I1_b22_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1548_MN3 (VSS I1_qu10_b3_1 XI1_I1548_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1548_MN0 (XI1_I1548_An I1_dd6_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1592_MN1 (XI1_I1592_Bn I1_qu9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1592_MN5 (XI1_I1592_n2 XI1_I1592_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1592_MN4 (I1_b23_4 XI1_I1592_An XI1_I1592_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1592_MN2 (XI1_I1592_n1 I1_dd4_b3_4 I1_b23_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1592_MN3 (VSS I1_qu9_b3_0 XI1_I1592_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1592_MN0 (XI1_I1592_An I1_dd4_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1591_MN1 (XI1_I1591_Bn I1_qu9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1591_MN5 (XI1_I1591_n2 XI1_I1591_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1591_MN4 (I1_b23_3 XI1_I1591_An XI1_I1591_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1591_MN2 (XI1_I1591_n1 I1_dd3_b3_4 I1_b23_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1591_MN3 (VSS I1_qu9_b3_0 XI1_I1591_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1591_MN0 (XI1_I1591_An I1_dd3_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I18_MN1 (XI2_I1_I18_Bn I2_I1_SUB_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I18_MN5 (XI2_I1_I18_n2 XI2_I1_I18_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I18_MN4 (I2_I1_bx8 XI2_I1_I18_An XI2_I1_I18_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I18_MN2 (XI2_I1_I18_n1 B_8 I2_I1_bx8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I18_MN3 (VSS I2_I1_SUB_b3_1 XI2_I1_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I18_MN0 (XI2_I1_I18_An B_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I19_MN1 (XI2_I1_I19_Bn I2_I1_SUB_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I19_MN5 (XI2_I1_I19_n2 XI2_I1_I19_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I19_MN4 (I2_I1_bx9 XI2_I1_I19_An XI2_I1_I19_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I19_MN2 (XI2_I1_I19_n1 B_9 I2_I1_bx9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I19_MN3 (VSS I2_I1_SUB_b3_1 XI2_I1_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I19_MN0 (XI2_I1_I19_An B_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I212_MN1 (XI2_I1_I42_I212_Bn I2_I1_I42_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I212_MN5 (XI2_I1_I42_I212_n2 XI2_I1_I42_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I42_I212_MN4 (I2_S_9 XI2_I1_I42_I212_An XI2_I1_I42_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I42_I212_MN2 (XI2_I1_I42_I212_n1 I2_I1_I42_pn9 I2_S_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I42_I212_MN3 (VSS I2_I1_I42_G8_0n XI2_I1_I42_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I42_I212_MN0 (XI2_I1_I42_I212_An I2_I1_I42_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1754_MN1 (XI1_I1754_Bn I1_qu6_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1754_MN5 (XI1_I1754_n2 XI1_I1754_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1754_MN4 (I1_b26_28 XI1_I1754_An XI1_I1754_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1754_MN2 (XI1_I1754_n1 I1_dd28_b3_4 I1_b26_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1754_MN3 (VSS I1_qu6_b3_4 XI1_I1754_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1754_MN0 (XI1_I1754_An I1_dd28_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1711_MN1 (XI1_I1711_Bn I1_qu7_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1711_MN5 (XI1_I1711_n2 XI1_I1711_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1711_MN4 (I1_b25_31 XI1_I1711_An XI1_I1711_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1711_MN2 (XI1_I1711_n1 I1_dd31_b3_4 I1_b25_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1711_MN3 (VSS I1_qu7_b3_5 XI1_I1711_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1711_MN0 (XI1_I1711_An I1_dd31_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1705_MN1 (XI1_I1705_Bn I1_qu7_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1705_MN5 (XI1_I1705_n2 XI1_I1705_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1705_MN4 (I1_b25_25 XI1_I1705_An XI1_I1705_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1705_MN2 (XI1_I1705_n1 I1_dd25_b3_4 I1_b25_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1705_MN3 (VSS I1_qu7_b3_4 XI1_I1705_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1705_MN0 (XI1_I1705_An I1_dd25_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1702_MN1 (XI1_I1702_Bn I1_qu7_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1702_MN5 (XI1_I1702_n2 XI1_I1702_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1702_MN4 (I1_b25_22 XI1_I1702_An XI1_I1702_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1702_MN2 (XI1_I1702_n1 I1_dd22_b3_4 I1_b25_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1702_MN3 (VSS I1_qu7_b3_3 XI1_I1702_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1702_MN0 (XI1_I1702_An I1_dd22_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I217_MN1 (XI1_I1712_I217_Bn I1_I1712_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I217_MN5 (XI1_I1712_I217_n2 XI1_I1712_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1712_I217_MN4 (I1_p25_14 XI1_I1712_I217_An XI1_I1712_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1712_I217_MN2 (XI1_I1712_I217_n1 I1_I1712_pn14 I1_p25_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1712_I217_MN3 (VSS I1_I1712_G13_0n XI1_I1712_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1712_I217_MN0 (XI1_I1712_I217_An I1_I1712_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1689_MN1 (XI1_I1689_Bn I1_qu7_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1689_MN5 (XI1_I1689_n2 XI1_I1689_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1689_MN4 (I1_b25_9 XI1_I1689_An XI1_I1689_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1689_MN2 (XI1_I1689_n1 I1_dd9_b3_4 I1_b25_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1689_MN3 (VSS I1_qu7_b3_1 XI1_I1689_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1689_MN0 (XI1_I1689_An I1_dd9_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1691_MN1 (XI1_I1691_Bn I1_qu7_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1691_MN5 (XI1_I1691_n2 XI1_I1691_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1691_MN4 (I1_b25_11 XI1_I1691_An XI1_I1691_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1691_MN2 (XI1_I1691_n1 I1_dd11_b3_4 I1_b25_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1691_MN3 (VSS I1_qu7_b3_1 XI1_I1691_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1691_MN0 (XI1_I1691_An I1_dd11_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1688_MN1 (XI1_I1688_Bn I1_qu7_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1688_MN5 (XI1_I1688_n2 XI1_I1688_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1688_MN4 (I1_b25_8 XI1_I1688_An XI1_I1688_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1688_MN2 (XI1_I1688_n1 I1_dd8_b3_4 I1_b25_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1688_MN3 (VSS I1_qu7_b3_1 XI1_I1688_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1688_MN0 (XI1_I1688_An I1_dd8_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I207_MN1 (XI1_I1666_I207_Bn I1_I1666_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I207_MN5 (XI1_I1666_I207_n2 XI1_I1666_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1666_I207_MN4 (I1_p24_4 XI1_I1666_I207_An XI1_I1666_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1666_I207_MN2 (XI1_I1666_I207_n1 I1_I1666_pn4 I1_p24_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1666_I207_MN3 (VSS I1_I1666_G3_0n XI1_I1666_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1666_I207_MN0 (XI1_I1666_I207_An I1_I1666_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1638_MN1 (XI1_I1638_Bn I1_qu8_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1638_MN5 (XI1_I1638_n2 XI1_I1638_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1638_MN4 (I1_b24_4 XI1_I1638_An XI1_I1638_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1638_MN2 (XI1_I1638_n1 I1_dd4_b3_4 I1_b24_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1638_MN3 (VSS I1_qu8_b3_0 XI1_I1638_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1638_MN0 (XI1_I1638_An I1_dd4_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1563_MN1 (XI1_I1563_Bn I1_qu10_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1563_MN5 (XI1_I1563_n2 XI1_I1563_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1563_MN4 (I1_b22_21 XI1_I1563_An XI1_I1563_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1563_MN2 (XI1_I1563_n1 I1_dd21_b3_4 I1_b22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1563_MN3 (VSS I1_qu10_b3_3 XI1_I1563_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1563_MN0 (XI1_I1563_An I1_dd21_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1639_MN1 (XI1_I1639_Bn I1_qu8_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1639_MN5 (XI1_I1639_n2 XI1_I1639_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1639_MN4 (I1_b24_5 XI1_I1639_An XI1_I1639_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1639_MN2 (XI1_I1639_n1 I1_dd5_b3_4 I1_b24_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1639_MN3 (VSS I1_qu8_b3_0 XI1_I1639_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1639_MN0 (XI1_I1639_An I1_dd5_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1560_MN1 (XI1_I1560_Bn I1_qu10_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1560_MN5 (XI1_I1560_n2 XI1_I1560_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1560_MN4 (I1_b22_18 XI1_I1560_An XI1_I1560_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1560_MN2 (XI1_I1560_n1 I1_dd18_b3_4 I1_b22_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1560_MN3 (VSS I1_qu10_b3_3 XI1_I1560_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1560_MN0 (XI1_I1560_An I1_dd18_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1561_MN1 (XI1_I1561_Bn I1_qu10_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1561_MN5 (XI1_I1561_n2 XI1_I1561_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1561_MN4 (I1_b22_19 XI1_I1561_An XI1_I1561_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1561_MN2 (XI1_I1561_n1 I1_dd19_b3_4 I1_b22_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1561_MN3 (VSS I1_qu10_b3_3 XI1_I1561_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1561_MN0 (XI1_I1561_An I1_dd19_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1562_MN1 (XI1_I1562_Bn I1_qu10_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1562_MN5 (XI1_I1562_n2 XI1_I1562_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1562_MN4 (I1_b22_20 XI1_I1562_An XI1_I1562_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1562_MN2 (XI1_I1562_n1 I1_dd20_b3_4 I1_b22_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1562_MN3 (VSS I1_qu10_b3_3 XI1_I1562_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1562_MN0 (XI1_I1562_An I1_dd20_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1559_MN1 (XI1_I1559_Bn I1_qu10_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1559_MN5 (XI1_I1559_n2 XI1_I1559_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1559_MN4 (I1_b22_17 XI1_I1559_An XI1_I1559_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1559_MN2 (XI1_I1559_n1 I1_dd17_b3_4 I1_b22_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1559_MN3 (VSS I1_qu10_b3_2 XI1_I1559_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
