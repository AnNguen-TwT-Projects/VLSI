    I_MXI1_I1436_I228_MN2 (XI1_I1436_I228_n1 I1_I1436_pn25 I1_p19_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I228_MN3 (VSS XI1_I1436_I228_Bn XI1_I1436_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I228_MN0 (XI1_I1436_I228_An I1_I1436_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I34_MN1 (XI1_I1436_I34_Bn I1_b19_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I34_MN5 (XI1_I1436_I34_n2 I1_b19_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I34_MN4 (I1_I1436_pn2 XI1_I1436_I34_An XI1_I1436_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I34_MN2 (XI1_I1436_I34_n1 I1_p18_1 I1_I1436_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I34_MN3 (VSS XI1_I1436_I34_Bn XI1_I1436_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I34_MN0 (XI1_I1436_I34_An I1_p18_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I57_MN1 (XI1_I1114_I57_Bn I1_b12_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I57_MN5 (XI1_I1114_I57_n2 I1_b12_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I57_MN4 (I1_I1114_pn25 XI1_I1114_I57_An XI1_I1114_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I57_MN2 (XI1_I1114_I57_n1 I1_p11_24 I1_I1114_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I57_MN3 (VSS XI1_I1114_I57_Bn XI1_I1114_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I57_MN0 (XI1_I1114_I57_An I1_p11_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I56_MN1 (XI1_I1114_I56_Bn I1_b12_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I56_MN5 (XI1_I1114_I56_n2 I1_b12_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I56_MN4 (I1_I1114_pn24 XI1_I1114_I56_An XI1_I1114_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I56_MN2 (XI1_I1114_I56_n1 I1_p11_23 I1_I1114_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I56_MN3 (VSS XI1_I1114_I56_Bn XI1_I1114_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I56_MN0 (XI1_I1114_I56_An I1_p11_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I224_MN1 (XI1_I1114_I224_Bn I1_I1114_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I224_MN5 (XI1_I1114_I224_n2 I1_I1114_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I224_MN4 (I1_p12_21 XI1_I1114_I224_An XI1_I1114_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I224_MN2 (XI1_I1114_I224_n1 I1_I1114_pn21 I1_p12_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I224_MN3 (VSS XI1_I1114_I224_Bn XI1_I1114_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I224_MN0 (XI1_I1114_I224_An I1_I1114_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I54_MN1 (XI1_I1114_I54_Bn I1_b12_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I54_MN5 (XI1_I1114_I54_n2 I1_b12_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I54_MN4 (I1_I1114_pn22 XI1_I1114_I54_An XI1_I1114_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I54_MN2 (XI1_I1114_I54_n1 I1_p11_21 I1_I1114_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I54_MN3 (VSS XI1_I1114_I54_Bn XI1_I1114_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I54_MN0 (XI1_I1114_I54_An I1_p11_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I53_MN1 (XI1_I1114_I53_Bn I1_b12_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I53_MN5 (XI1_I1114_I53_n2 I1_b12_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I53_MN4 (I1_I1114_pn21 XI1_I1114_I53_An XI1_I1114_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I53_MN2 (XI1_I1114_I53_n1 I1_p11_20 I1_I1114_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I53_MN3 (VSS XI1_I1114_I53_Bn XI1_I1114_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I53_MN0 (XI1_I1114_I53_An I1_p11_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I228_MN1 (XI1_I1068_I228_Bn I1_I1068_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I228_MN5 (XI1_I1068_I228_n2 I1_I1068_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I228_MN4 (I1_p11_25 XI1_I1068_I228_An XI1_I1068_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I228_MN2 (XI1_I1068_I228_n1 I1_I1068_pn25 I1_p11_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I228_MN3 (VSS XI1_I1068_I228_Bn XI1_I1068_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I228_MN0 (XI1_I1068_I228_An I1_I1068_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I57_MN1 (XI1_I1068_I57_Bn I1_b11_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I57_MN5 (XI1_I1068_I57_n2 I1_b11_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I57_MN4 (I1_I1068_pn25 XI1_I1068_I57_An XI1_I1068_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I57_MN2 (XI1_I1068_I57_n1 I1_p10_24 I1_I1068_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I57_MN3 (VSS XI1_I1068_I57_Bn XI1_I1068_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I57_MN0 (XI1_I1068_I57_An I1_p10_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I58_MN1 (XI1_I1068_I58_Bn I1_b11_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I58_MN5 (XI1_I1068_I58_n2 I1_b11_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I58_MN4 (I1_I1068_pn26 XI1_I1068_I58_An XI1_I1068_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I58_MN2 (XI1_I1068_I58_n1 I1_p10_25 I1_I1068_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I58_MN3 (VSS XI1_I1068_I58_Bn XI1_I1068_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I58_MN0 (XI1_I1068_I58_An I1_p10_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I232_MN1 (XI1_I1022_I232_Bn I1_I1022_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I232_MN5 (XI1_I1022_I232_n2 I1_I1022_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I232_MN4 (I1_p10_29 XI1_I1022_I232_An XI1_I1022_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I232_MN2 (XI1_I1022_I232_n1 I1_I1022_pn29 I1_p10_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I232_MN3 (VSS XI1_I1022_I232_Bn XI1_I1022_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I232_MN0 (XI1_I1022_I232_An I1_I1022_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I233_MN1 (XI1_I1022_I233_Bn I1_I1022_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I233_MN5 (XI1_I1022_I233_n2 I1_I1022_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I233_MN4 (I1_p10_30 XI1_I1022_I233_An XI1_I1022_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I233_MN2 (XI1_I1022_I233_n1 I1_I1022_pn30 I1_p10_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I233_MN3 (VSS XI1_I1022_I233_Bn XI1_I1022_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I233_MN0 (XI1_I1022_I233_An I1_I1022_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I62_MN1 (XI1_I1022_I62_Bn I1_b10_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I62_MN5 (XI1_I1022_I62_n2 I1_b10_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I62_MN4 (I1_I1022_pn30 XI1_I1022_I62_An XI1_I1022_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I62_MN2 (XI1_I1022_I62_n1 I1_p9_29 I1_I1022_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I62_MN3 (VSS XI1_I1022_I62_Bn XI1_I1022_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I62_MN0 (XI1_I1022_I62_An I1_p9_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I63_MN1 (XI1_I1022_I63_Bn I1_b10_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I63_MN5 (XI1_I1022_I63_n2 I1_b10_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I63_MN4 (I1_I1022_pn31 XI1_I1022_I63_An XI1_I1022_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I63_MN2 (XI1_I1022_I63_n1 I1_p9_30 I1_I1022_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I63_MN3 (VSS XI1_I1022_I63_Bn XI1_I1022_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I63_MN0 (XI1_I1022_I63_An I1_p9_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I231_MN1 (XI1_I976_I231_Bn I1_I976_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I231_MN5 (XI1_I976_I231_n2 I1_I976_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I231_MN4 (I1_p9_28 XI1_I976_I231_An XI1_I976_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I231_MN2 (XI1_I976_I231_n1 I1_I976_pn28 I1_p9_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I231_MN3 (VSS XI1_I976_I231_Bn XI1_I976_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I231_MN0 (XI1_I976_I231_An I1_I976_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I230_MN1 (XI1_I976_I230_Bn I1_I976_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I230_MN5 (XI1_I976_I230_n2 I1_I976_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I230_MN4 (I1_p9_27 XI1_I976_I230_An XI1_I976_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I230_MN2 (XI1_I976_I230_n1 I1_I976_pn27 I1_p9_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I230_MN3 (VSS XI1_I976_I230_Bn XI1_I976_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I230_MN0 (XI1_I976_I230_An I1_I976_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I45_MN1 (XI1_I976_I45_Bn I1_b9_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I45_MN5 (XI1_I976_I45_n2 I1_b9_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I45_MN4 (I1_I976_pn13 XI1_I976_I45_An XI1_I976_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I45_MN2 (XI1_I976_I45_n1 I1_p8_12 I1_I976_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I45_MN3 (VSS XI1_I976_I45_Bn XI1_I976_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I45_MN0 (XI1_I976_I45_An I1_p8_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I42_MN1 (XI1_I976_I42_Bn I1_b9_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I42_MN5 (XI1_I976_I42_n2 I1_b9_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I42_MN4 (I1_I976_pn10 XI1_I976_I42_An XI1_I976_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I42_MN2 (XI1_I976_I42_n1 I1_p8_9 I1_I976_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I42_MN3 (VSS XI1_I976_I42_Bn XI1_I976_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I42_MN0 (XI1_I976_I42_An I1_p8_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I39_MN1 (XI1_I976_I39_Bn I1_b9_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I39_MN5 (XI1_I976_I39_n2 I1_b9_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I39_MN4 (I1_I976_pn7 XI1_I976_I39_An XI1_I976_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I39_MN2 (XI1_I976_I39_n1 I1_p8_6 I1_I976_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I39_MN3 (VSS XI1_I976_I39_Bn XI1_I976_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I39_MN0 (XI1_I976_I39_An I1_p8_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I203_MN1 (XI1_I884_I203_Bn I1_qu25_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I203_MN5 (XI1_I884_I203_n2 I1_qu25_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I203_MN4 (I1_p7_0 XI1_I884_I203_An XI1_I884_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I203_MN2 (XI1_I884_I203_n1 I1_I884_pn0 I1_p7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I203_MN3 (VSS XI1_I884_I203_Bn XI1_I884_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I203_MN0 (XI1_I884_I203_An I1_I884_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I32_MN1 (XI1_I884_I32_Bn I1_b7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I32_MN5 (XI1_I884_I32_n2 I1_b7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I32_MN4 (I1_I884_pn0 XI1_I884_I32_An XI1_I884_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I32_MN2 (XI1_I884_I32_n1 I1_aa24 I1_I884_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I32_MN3 (VSS XI1_I884_I32_Bn XI1_I884_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I32_MN0 (XI1_I884_I32_An I1_aa24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I60_MN1 (XI1_I654_I60_Bn I1_b2_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I60_MN5 (XI1_I654_I60_n2 I1_b2_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I60_MN4 (I1_I654_pn28 XI1_I654_I60_An XI1_I654_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I60_MN2 (XI1_I654_I60_n1 I1_p1_27 I1_I654_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I60_MN3 (VSS XI1_I654_I60_Bn XI1_I654_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I60_MN0 (XI1_I654_I60_An I1_p1_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I61_MN1 (XI1_I654_I61_Bn I1_b2_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I61_MN5 (XI1_I654_I61_n2 I1_b2_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I61_MN4 (I1_I654_pn29 XI1_I654_I61_An XI1_I654_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I61_MN2 (XI1_I654_I61_n1 I1_p1_28 I1_I654_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I61_MN3 (VSS XI1_I654_I61_Bn XI1_I654_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I61_MN0 (XI1_I654_I61_An I1_p1_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I232_MN1 (XI1_I1436_I232_Bn I1_I1436_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I232_MN5 (XI1_I1436_I232_n2 I1_I1436_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I232_MN4 (I1_p19_29 XI1_I1436_I232_An XI1_I1436_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I232_MN2 (XI1_I1436_I232_n1 I1_I1436_pn29 I1_p19_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I232_MN3 (VSS XI1_I1436_I232_Bn XI1_I1436_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I232_MN0 (XI1_I1436_I232_An I1_I1436_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I226_MN1 (XI1_I1436_I226_Bn I1_I1436_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I226_MN5 (XI1_I1436_I226_n2 I1_I1436_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I226_MN4 (I1_p19_23 XI1_I1436_I226_An XI1_I1436_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I226_MN2 (XI1_I1436_I226_n1 I1_I1436_pn23 I1_p19_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I226_MN3 (VSS XI1_I1436_I226_Bn XI1_I1436_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I226_MN0 (XI1_I1436_I226_An I1_I1436_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I224_MN1 (XI1_I1436_I224_Bn I1_I1436_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I224_MN5 (XI1_I1436_I224_n2 I1_I1436_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I224_MN4 (I1_p19_21 XI1_I1436_I224_An XI1_I1436_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I224_MN2 (XI1_I1436_I224_n1 I1_I1436_pn21 I1_p19_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I224_MN3 (VSS XI1_I1436_I224_Bn XI1_I1436_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I224_MN0 (XI1_I1436_I224_An I1_I1436_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I222_MN1 (XI1_I1436_I222_Bn I1_I1436_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I222_MN5 (XI1_I1436_I222_n2 I1_I1436_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I222_MN4 (I1_p19_19 XI1_I1436_I222_An XI1_I1436_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I222_MN2 (XI1_I1436_I222_n1 I1_I1436_pn19 I1_p19_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I222_MN3 (VSS XI1_I1436_I222_Bn XI1_I1436_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I222_MN0 (XI1_I1436_I222_An I1_I1436_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I220_MN1 (XI1_I1436_I220_Bn I1_I1436_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I220_MN5 (XI1_I1436_I220_n2 I1_I1436_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I220_MN4 (I1_p19_17 XI1_I1436_I220_An XI1_I1436_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I220_MN2 (XI1_I1436_I220_n1 I1_I1436_pn17 I1_p19_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I220_MN3 (VSS XI1_I1436_I220_Bn XI1_I1436_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I220_MN0 (XI1_I1436_I220_An I1_I1436_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I210_MN1 (XI1_I1436_I210_Bn I1_I1436_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I210_MN5 (XI1_I1436_I210_n2 I1_I1436_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I210_MN4 (I1_p19_7 XI1_I1436_I210_An XI1_I1436_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I210_MN2 (XI1_I1436_I210_n1 I1_I1436_pn7 I1_p19_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I210_MN3 (VSS XI1_I1436_I210_Bn XI1_I1436_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I210_MN0 (XI1_I1436_I210_An I1_I1436_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I208_MN1 (XI1_I1436_I208_Bn I1_I1436_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I208_MN5 (XI1_I1436_I208_n2 I1_I1436_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I208_MN4 (I1_p19_5 XI1_I1436_I208_An XI1_I1436_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I208_MN2 (XI1_I1436_I208_n1 I1_I1436_pn5 I1_p19_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I208_MN3 (VSS XI1_I1436_I208_Bn XI1_I1436_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I208_MN0 (XI1_I1436_I208_An I1_I1436_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I33_MN1 (XI1_I1436_I33_Bn I1_b19_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I33_MN5 (XI1_I1436_I33_n2 I1_b19_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I33_MN4 (I1_I1436_pn1 XI1_I1436_I33_An XI1_I1436_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I33_MN2 (XI1_I1436_I33_n1 I1_p18_0 I1_I1436_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I33_MN3 (VSS XI1_I1436_I33_Bn XI1_I1436_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I33_MN0 (XI1_I1436_I33_An I1_p18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I204_MN1 (XI1_I1436_I204_Bn I1_I1436_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I204_MN5 (XI1_I1436_I204_n2 I1_I1436_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I204_MN4 (I1_p19_1 XI1_I1436_I204_An XI1_I1436_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I204_MN2 (XI1_I1436_I204_n1 I1_I1436_pn1 I1_p19_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I204_MN3 (VSS XI1_I1436_I204_Bn XI1_I1436_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I204_MN0 (XI1_I1436_I204_An I1_I1436_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I225_MN1 (XI1_I1114_I225_Bn I1_I1114_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I225_MN5 (XI1_I1114_I225_n2 I1_I1114_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I225_MN4 (I1_p12_22 XI1_I1114_I225_An XI1_I1114_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I225_MN2 (XI1_I1114_I225_n1 I1_I1114_pn22 I1_p12_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I225_MN3 (VSS XI1_I1114_I225_Bn XI1_I1114_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I225_MN0 (XI1_I1114_I225_An I1_I1114_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I223_MN1 (XI1_I1114_I223_Bn I1_I1114_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I223_MN5 (XI1_I1114_I223_n2 I1_I1114_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I223_MN4 (I1_p12_20 XI1_I1114_I223_An XI1_I1114_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I223_MN2 (XI1_I1114_I223_n1 I1_I1114_pn20 I1_p12_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I223_MN3 (VSS XI1_I1114_I223_Bn XI1_I1114_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I223_MN0 (XI1_I1114_I223_An I1_I1114_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I222_MN1 (XI1_I1114_I222_Bn I1_I1114_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I222_MN5 (XI1_I1114_I222_n2 I1_I1114_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I222_MN4 (I1_p12_19 XI1_I1114_I222_An XI1_I1114_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I222_MN2 (XI1_I1114_I222_n1 I1_I1114_pn19 I1_p12_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I222_MN3 (VSS XI1_I1114_I222_Bn XI1_I1114_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I222_MN0 (XI1_I1114_I222_An I1_I1114_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I52_MN1 (XI1_I1114_I52_Bn I1_b12_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I52_MN5 (XI1_I1114_I52_n2 I1_b12_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I52_MN4 (I1_I1114_pn20 XI1_I1114_I52_An XI1_I1114_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I52_MN2 (XI1_I1114_I52_n1 I1_p11_19 I1_I1114_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I52_MN3 (VSS XI1_I1114_I52_Bn XI1_I1114_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I52_MN0 (XI1_I1114_I52_An I1_p11_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I51_MN1 (XI1_I1114_I51_Bn I1_b12_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I51_MN5 (XI1_I1114_I51_n2 I1_b12_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I51_MN4 (I1_I1114_pn19 XI1_I1114_I51_An XI1_I1114_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I51_MN2 (XI1_I1114_I51_n1 I1_p11_18 I1_I1114_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I51_MN3 (VSS XI1_I1114_I51_Bn XI1_I1114_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I51_MN0 (XI1_I1114_I51_An I1_p11_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I226_MN1 (XI1_I1068_I226_Bn I1_I1068_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I226_MN5 (XI1_I1068_I226_n2 I1_I1068_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I226_MN4 (I1_p11_23 XI1_I1068_I226_An XI1_I1068_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I226_MN2 (XI1_I1068_I226_n1 I1_I1068_pn23 I1_p11_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I226_MN3 (VSS XI1_I1068_I226_Bn XI1_I1068_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I226_MN0 (XI1_I1068_I226_An I1_I1068_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I227_MN1 (XI1_I1068_I227_Bn I1_I1068_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I227_MN5 (XI1_I1068_I227_n2 I1_I1068_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I227_MN4 (I1_p11_24 XI1_I1068_I227_An XI1_I1068_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I227_MN2 (XI1_I1068_I227_n1 I1_I1068_pn24 I1_p11_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I227_MN3 (VSS XI1_I1068_I227_Bn XI1_I1068_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I227_MN0 (XI1_I1068_I227_An I1_I1068_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I225_MN1 (XI1_I1068_I225_Bn I1_I1068_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I225_MN5 (XI1_I1068_I225_n2 I1_I1068_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I225_MN4 (I1_p11_22 XI1_I1068_I225_An XI1_I1068_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I225_MN2 (XI1_I1068_I225_n1 I1_I1068_pn22 I1_p11_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I225_MN3 (VSS XI1_I1068_I225_Bn XI1_I1068_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I225_MN0 (XI1_I1068_I225_An I1_I1068_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I56_MN1 (XI1_I1068_I56_Bn I1_b11_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I56_MN5 (XI1_I1068_I56_n2 I1_b11_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I56_MN4 (I1_I1068_pn24 XI1_I1068_I56_An XI1_I1068_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I56_MN2 (XI1_I1068_I56_n1 I1_p10_23 I1_I1068_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I56_MN3 (VSS XI1_I1068_I56_Bn XI1_I1068_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I56_MN0 (XI1_I1068_I56_An I1_p10_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I55_MN1 (XI1_I1068_I55_Bn I1_b11_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I55_MN5 (XI1_I1068_I55_n2 I1_b11_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I55_MN4 (I1_I1068_pn23 XI1_I1068_I55_An XI1_I1068_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I55_MN2 (XI1_I1068_I55_n1 I1_p10_22 I1_I1068_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I55_MN3 (VSS XI1_I1068_I55_Bn XI1_I1068_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I55_MN0 (XI1_I1068_I55_An I1_p10_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I230_MN1 (XI1_I1022_I230_Bn I1_I1022_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I230_MN5 (XI1_I1022_I230_n2 I1_I1022_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I230_MN4 (I1_p10_27 XI1_I1022_I230_An XI1_I1022_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I230_MN2 (XI1_I1022_I230_n1 I1_I1022_pn27 I1_p10_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I230_MN3 (VSS XI1_I1022_I230_Bn XI1_I1022_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I230_MN0 (XI1_I1022_I230_An I1_I1022_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I234_MN1 (XI1_I1022_I234_Bn I1_c10_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I234_MN5 (XI1_I1022_I234_n2 I1_c10_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I234_MN4 (I1_p10_31 XI1_I1022_I234_An XI1_I1022_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I234_MN2 (XI1_I1022_I234_n1 I1_I1022_pn31 I1_p10_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I234_MN3 (VSS XI1_I1022_I234_Bn XI1_I1022_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I234_MN0 (XI1_I1022_I234_An I1_I1022_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I59_MN1 (XI1_I1022_I59_Bn I1_b10_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I59_MN5 (XI1_I1022_I59_n2 I1_b10_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I59_MN4 (I1_I1022_pn27 XI1_I1022_I59_An XI1_I1022_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I59_MN2 (XI1_I1022_I59_n1 I1_p9_26 I1_I1022_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I59_MN3 (VSS XI1_I1022_I59_Bn XI1_I1022_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I59_MN0 (XI1_I1022_I59_An I1_p9_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I233_MN1 (XI1_I976_I233_Bn I1_I976_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I233_MN5 (XI1_I976_I233_n2 I1_I976_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I233_MN4 (I1_p9_30 XI1_I976_I233_An XI1_I976_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I233_MN2 (XI1_I976_I233_n1 I1_I976_pn30 I1_p9_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I233_MN3 (VSS XI1_I976_I233_Bn XI1_I976_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I233_MN0 (XI1_I976_I233_An I1_I976_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I232_MN1 (XI1_I976_I232_Bn I1_I976_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I232_MN5 (XI1_I976_I232_n2 I1_I976_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I232_MN4 (I1_p9_29 XI1_I976_I232_An XI1_I976_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I232_MN2 (XI1_I976_I232_n1 I1_I976_pn29 I1_p9_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I232_MN3 (VSS XI1_I976_I232_Bn XI1_I976_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I232_MN0 (XI1_I976_I232_An I1_I976_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I229_MN1 (XI1_I976_I229_Bn I1_I976_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I229_MN5 (XI1_I976_I229_n2 I1_I976_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I229_MN4 (I1_p9_26 XI1_I976_I229_An XI1_I976_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I229_MN2 (XI1_I976_I229_n1 I1_I976_pn26 I1_p9_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I229_MN3 (VSS XI1_I976_I229_Bn XI1_I976_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I229_MN0 (XI1_I976_I229_An I1_I976_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I228_MN1 (XI1_I976_I228_Bn I1_I976_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I228_MN5 (XI1_I976_I228_n2 I1_I976_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I228_MN4 (I1_p9_25 XI1_I976_I228_An XI1_I976_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I228_MN2 (XI1_I976_I228_n1 I1_I976_pn25 I1_p9_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I228_MN3 (VSS XI1_I976_I228_Bn XI1_I976_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I228_MN0 (XI1_I976_I228_An I1_I976_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I40_MN1 (XI1_I976_I40_Bn I1_b9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I40_MN5 (XI1_I976_I40_n2 I1_b9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I40_MN4 (I1_I976_pn8 XI1_I976_I40_An XI1_I976_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I40_MN2 (XI1_I976_I40_n1 I1_p8_7 I1_I976_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I40_MN3 (VSS XI1_I976_I40_Bn XI1_I976_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I40_MN0 (XI1_I976_I40_An I1_p8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I38_MN1 (XI1_I976_I38_Bn I1_b9_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I38_MN5 (XI1_I976_I38_n2 I1_b9_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I38_MN4 (I1_I976_pn6 XI1_I976_I38_An XI1_I976_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I38_MN2 (XI1_I976_I38_n1 I1_p8_5 I1_I976_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I38_MN3 (VSS XI1_I976_I38_Bn XI1_I976_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I38_MN0 (XI1_I976_I38_An I1_p8_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I33_MN1 (XI1_I930_I33_Bn I1_b8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I33_MN5 (XI1_I930_I33_n2 I1_b8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I33_MN4 (I1_I930_pn1 XI1_I930_I33_An XI1_I930_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I33_MN2 (XI1_I930_I33_n1 I1_p7_0 I1_I930_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I33_MN3 (VSS XI1_I930_I33_Bn XI1_I930_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I33_MN0 (XI1_I930_I33_An I1_p7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I36_MN1 (XI1_I654_I36_Bn I1_b2_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I36_MN5 (XI1_I654_I36_n2 I1_b2_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I36_MN4 (I1_I654_pn4 XI1_I654_I36_An XI1_I654_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I36_MN2 (XI1_I654_I36_n1 I1_p1_3 I1_I654_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I36_MN3 (VSS XI1_I654_I36_Bn XI1_I654_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I36_MN0 (XI1_I654_I36_An I1_p1_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I37_MN1 (XI1_I654_I37_Bn I1_b2_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I37_MN5 (XI1_I654_I37_n2 I1_b2_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I37_MN4 (I1_I654_pn5 XI1_I654_I37_An XI1_I654_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I37_MN2 (XI1_I654_I37_n1 I1_p1_4 I1_I654_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I37_MN3 (VSS XI1_I654_I37_Bn XI1_I654_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I37_MN0 (XI1_I654_I37_An I1_p1_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I39_MN1 (XI1_I654_I39_Bn I1_b2_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I39_MN5 (XI1_I654_I39_n2 I1_b2_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I39_MN4 (I1_I654_pn7 XI1_I654_I39_An XI1_I654_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I39_MN2 (XI1_I654_I39_n1 I1_p1_6 I1_I654_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I39_MN3 (VSS XI1_I654_I39_Bn XI1_I654_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I39_MN0 (XI1_I654_I39_An I1_p1_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I41_MN1 (XI1_I654_I41_Bn I1_b2_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I41_MN5 (XI1_I654_I41_n2 I1_b2_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I41_MN4 (I1_I654_pn9 XI1_I654_I41_An XI1_I654_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I41_MN2 (XI1_I654_I41_n1 I1_p1_8 I1_I654_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I41_MN3 (VSS XI1_I654_I41_Bn XI1_I654_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I41_MN0 (XI1_I654_I41_An I1_p1_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I45_MN1 (XI1_I654_I45_Bn I1_b2_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I45_MN5 (XI1_I654_I45_n2 I1_b2_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I45_MN4 (I1_I654_pn13 XI1_I654_I45_An XI1_I654_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I45_MN2 (XI1_I654_I45_n1 I1_p1_12 I1_I654_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I45_MN3 (VSS XI1_I654_I45_Bn XI1_I654_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I45_MN0 (XI1_I654_I45_An I1_p1_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I51_MN1 (XI1_I654_I51_Bn I1_b2_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I51_MN5 (XI1_I654_I51_n2 I1_b2_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I51_MN4 (I1_I654_pn19 XI1_I654_I51_An XI1_I654_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I51_MN2 (XI1_I654_I51_n1 I1_p1_18 I1_I654_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I51_MN3 (VSS XI1_I654_I51_Bn XI1_I654_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I51_MN0 (XI1_I654_I51_An I1_p1_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I52_MN1 (XI1_I654_I52_Bn I1_b2_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I52_MN5 (XI1_I654_I52_n2 I1_b2_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I52_MN4 (I1_I654_pn20 XI1_I654_I52_An XI1_I654_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I52_MN2 (XI1_I654_I52_n1 I1_p1_19 I1_I654_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I52_MN3 (VSS XI1_I654_I52_Bn XI1_I654_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I52_MN0 (XI1_I654_I52_An I1_p1_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I54_MN1 (XI1_I654_I54_Bn I1_b2_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I54_MN5 (XI1_I654_I54_n2 I1_b2_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I54_MN4 (I1_I654_pn22 XI1_I654_I54_An XI1_I654_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I54_MN2 (XI1_I654_I54_n1 I1_p1_21 I1_I654_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I54_MN3 (VSS XI1_I654_I54_Bn XI1_I654_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I54_MN0 (XI1_I654_I54_An I1_p1_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I56_MN1 (XI1_I654_I56_Bn I1_b2_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I56_MN5 (XI1_I654_I56_n2 I1_b2_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I56_MN4 (I1_I654_pn24 XI1_I654_I56_An XI1_I654_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I56_MN2 (XI1_I654_I56_n1 I1_p1_23 I1_I654_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I56_MN3 (VSS XI1_I654_I56_Bn XI1_I654_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I56_MN0 (XI1_I654_I56_An I1_p1_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I57_MN1 (XI1_I654_I57_Bn I1_b2_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I57_MN5 (XI1_I654_I57_n2 I1_b2_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I57_MN4 (I1_I654_pn25 XI1_I654_I57_An XI1_I654_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I57_MN2 (XI1_I654_I57_n1 I1_p1_24 I1_I654_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I57_MN3 (VSS XI1_I654_I57_Bn XI1_I654_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I57_MN0 (XI1_I654_I57_An I1_p1_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I59_MN1 (XI1_I654_I59_Bn I1_b2_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I59_MN5 (XI1_I654_I59_n2 I1_b2_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I59_MN4 (I1_I654_pn27 XI1_I654_I59_An XI1_I654_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I59_MN2 (XI1_I654_I59_n1 I1_p1_26 I1_I654_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I59_MN3 (VSS XI1_I654_I59_Bn XI1_I654_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I59_MN0 (XI1_I654_I59_An I1_p1_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I209_MN1 (XI1_I1436_I209_Bn I1_I1436_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I209_MN5 (XI1_I1436_I209_n2 I1_I1436_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I209_MN4 (I1_p19_6 XI1_I1436_I209_An XI1_I1436_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I209_MN2 (XI1_I1436_I209_n1 I1_I1436_pn6 I1_p19_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I209_MN3 (VSS XI1_I1436_I209_Bn XI1_I1436_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I209_MN0 (XI1_I1436_I209_An I1_I1436_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I221_MN1 (XI1_I1114_I221_Bn I1_I1114_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I221_MN5 (XI1_I1114_I221_n2 I1_I1114_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I221_MN4 (I1_p12_18 XI1_I1114_I221_An XI1_I1114_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I221_MN2 (XI1_I1114_I221_n1 I1_I1114_pn18 I1_p12_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I221_MN3 (VSS XI1_I1114_I221_Bn XI1_I1114_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I221_MN0 (XI1_I1114_I221_An I1_I1114_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I220_MN1 (XI1_I1114_I220_Bn I1_I1114_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I220_MN5 (XI1_I1114_I220_n2 I1_I1114_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I220_MN4 (I1_p12_17 XI1_I1114_I220_An XI1_I1114_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I220_MN2 (XI1_I1114_I220_n1 I1_I1114_pn17 I1_p12_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I220_MN3 (VSS XI1_I1114_I220_Bn XI1_I1114_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I220_MN0 (XI1_I1114_I220_An I1_I1114_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I50_MN1 (XI1_I1114_I50_Bn I1_b12_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I50_MN5 (XI1_I1114_I50_n2 I1_b12_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I50_MN4 (I1_I1114_pn18 XI1_I1114_I50_An XI1_I1114_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I50_MN2 (XI1_I1114_I50_n1 I1_p11_17 I1_I1114_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I50_MN3 (VSS XI1_I1114_I50_Bn XI1_I1114_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I50_MN0 (XI1_I1114_I50_An I1_p11_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I224_MN1 (XI1_I1068_I224_Bn I1_I1068_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I224_MN5 (XI1_I1068_I224_n2 I1_I1068_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I224_MN4 (I1_p11_21 XI1_I1068_I224_An XI1_I1068_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I224_MN2 (XI1_I1068_I224_n1 I1_I1068_pn21 I1_p11_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I224_MN3 (VSS XI1_I1068_I224_Bn XI1_I1068_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I224_MN0 (XI1_I1068_I224_An I1_I1068_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I54_MN1 (XI1_I1068_I54_Bn I1_b11_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I54_MN5 (XI1_I1068_I54_n2 I1_b11_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I54_MN4 (I1_I1068_pn22 XI1_I1068_I54_An XI1_I1068_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I54_MN2 (XI1_I1068_I54_n1 I1_p10_21 I1_I1068_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I54_MN3 (VSS XI1_I1068_I54_Bn XI1_I1068_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I54_MN0 (XI1_I1068_I54_An I1_p10_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I58_MN1 (XI1_I1022_I58_Bn I1_b10_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I58_MN5 (XI1_I1022_I58_n2 I1_b10_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I58_MN4 (I1_I1022_pn26 XI1_I1022_I58_An XI1_I1022_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I58_MN2 (XI1_I1022_I58_n1 I1_p9_25 I1_I1022_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I58_MN3 (VSS XI1_I1022_I58_Bn XI1_I1022_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I58_MN0 (XI1_I1022_I58_An I1_p9_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I57_MN1 (XI1_I1022_I57_Bn I1_b10_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I57_MN5 (XI1_I1022_I57_n2 I1_b10_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I57_MN4 (I1_I1022_pn25 XI1_I1022_I57_An XI1_I1022_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I57_MN2 (XI1_I1022_I57_n1 I1_p9_24 I1_I1022_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I57_MN3 (VSS XI1_I1022_I57_Bn XI1_I1022_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I57_MN0 (XI1_I1022_I57_An I1_p9_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I227_MN1 (XI1_I976_I227_Bn I1_I976_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I227_MN5 (XI1_I976_I227_n2 I1_I976_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I227_MN4 (I1_p9_24 XI1_I976_I227_An XI1_I976_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I227_MN2 (XI1_I976_I227_n1 I1_I976_pn24 I1_p9_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I227_MN3 (VSS XI1_I976_I227_Bn XI1_I976_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I227_MN0 (XI1_I976_I227_An I1_I976_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I226_MN1 (XI1_I976_I226_Bn I1_I976_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I226_MN5 (XI1_I976_I226_n2 I1_I976_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I226_MN4 (I1_p9_23 XI1_I976_I226_An XI1_I976_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I226_MN2 (XI1_I976_I226_n1 I1_I976_pn23 I1_p9_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I226_MN3 (VSS XI1_I976_I226_Bn XI1_I976_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I226_MN0 (XI1_I976_I226_An I1_I976_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I225_MN1 (XI1_I976_I225_Bn I1_I976_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I225_MN5 (XI1_I976_I225_n2 I1_I976_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I225_MN4 (I1_p9_22 XI1_I976_I225_An XI1_I976_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I225_MN2 (XI1_I976_I225_n1 I1_I976_pn22 I1_p9_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I225_MN3 (VSS XI1_I976_I225_Bn XI1_I976_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I225_MN0 (XI1_I976_I225_An I1_I976_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I223_MN1 (XI1_I976_I223_Bn I1_I976_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I223_MN5 (XI1_I976_I223_n2 I1_I976_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I223_MN4 (I1_p9_20 XI1_I976_I223_An XI1_I976_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I223_MN2 (XI1_I976_I223_n1 I1_I976_pn20 I1_p9_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I223_MN3 (VSS XI1_I976_I223_Bn XI1_I976_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I223_MN0 (XI1_I976_I223_An I1_I976_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I204_MN1 (XI1_I930_I204_Bn I1_I930_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I204_MN5 (XI1_I930_I204_n2 I1_I930_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I204_MN4 (I1_p8_1 XI1_I930_I204_An XI1_I930_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I204_MN2 (XI1_I930_I204_n1 I1_I930_pn1 I1_p8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I204_MN3 (VSS XI1_I930_I204_Bn XI1_I930_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I204_MN0 (XI1_I930_I204_An I1_I930_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I32_MN1 (XI1_I654_I32_Bn I1_b2_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I32_MN5 (XI1_I654_I32_n2 I1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I32_MN4 (I1_I654_pn0 XI1_I654_I32_An XI1_I654_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I32_MN2 (XI1_I654_I32_n1 I1_aa29 I1_I654_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I32_MN3 (VSS XI1_I654_I32_Bn XI1_I654_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I32_MN0 (XI1_I654_I32_An I1_aa29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I203_MN1 (XI1_I654_I203_Bn I1_qu30_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I203_MN5 (XI1_I654_I203_n2 I1_qu30_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I203_MN4 (I1_p2_0 XI1_I654_I203_An XI1_I654_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I203_MN2 (XI1_I654_I203_n1 I1_I654_pn0 I1_p2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I203_MN3 (VSS XI1_I654_I203_Bn XI1_I654_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I203_MN0 (XI1_I654_I203_An I1_I654_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I38_MN1 (XI1_I654_I38_Bn I1_b2_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I38_MN5 (XI1_I654_I38_n2 I1_b2_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I38_MN4 (I1_I654_pn6 XI1_I654_I38_An XI1_I654_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I38_MN2 (XI1_I654_I38_n1 I1_p1_5 I1_I654_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I38_MN3 (VSS XI1_I654_I38_Bn XI1_I654_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I38_MN0 (XI1_I654_I38_An I1_p1_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I40_MN1 (XI1_I654_I40_Bn I1_b2_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I40_MN5 (XI1_I654_I40_n2 I1_b2_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I40_MN4 (I1_I654_pn8 XI1_I654_I40_An XI1_I654_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I40_MN2 (XI1_I654_I40_n1 I1_p1_7 I1_I654_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I40_MN3 (VSS XI1_I654_I40_Bn XI1_I654_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I40_MN0 (XI1_I654_I40_An I1_p1_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I43_MN1 (XI1_I654_I43_Bn I1_b2_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I43_MN5 (XI1_I654_I43_n2 I1_b2_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I43_MN4 (I1_I654_pn11 XI1_I654_I43_An XI1_I654_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I43_MN2 (XI1_I654_I43_n1 I1_p1_10 I1_I654_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I43_MN3 (VSS XI1_I654_I43_Bn XI1_I654_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I43_MN0 (XI1_I654_I43_An I1_p1_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I42_MN1 (XI1_I654_I42_Bn I1_b2_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I42_MN5 (XI1_I654_I42_n2 I1_b2_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I42_MN4 (I1_I654_pn10 XI1_I654_I42_An XI1_I654_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I42_MN2 (XI1_I654_I42_n1 I1_p1_9 I1_I654_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I42_MN3 (VSS XI1_I654_I42_Bn XI1_I654_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I42_MN0 (XI1_I654_I42_An I1_p1_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I44_MN1 (XI1_I654_I44_Bn I1_b2_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I44_MN5 (XI1_I654_I44_n2 I1_b2_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I44_MN4 (I1_I654_pn12 XI1_I654_I44_An XI1_I654_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I44_MN2 (XI1_I654_I44_n1 I1_p1_11 I1_I654_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I44_MN3 (VSS XI1_I654_I44_Bn XI1_I654_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I44_MN0 (XI1_I654_I44_An I1_p1_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I46_MN1 (XI1_I654_I46_Bn I1_b2_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I46_MN5 (XI1_I654_I46_n2 I1_b2_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I46_MN4 (I1_I654_pn14 XI1_I654_I46_An XI1_I654_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I46_MN2 (XI1_I654_I46_n1 I1_p1_13 I1_I654_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I46_MN3 (VSS XI1_I654_I46_Bn XI1_I654_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I46_MN0 (XI1_I654_I46_An I1_p1_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I47_MN1 (XI1_I654_I47_Bn I1_b2_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I47_MN5 (XI1_I654_I47_n2 I1_b2_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I47_MN4 (I1_I654_pn15 XI1_I654_I47_An XI1_I654_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I47_MN2 (XI1_I654_I47_n1 I1_p1_14 I1_I654_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I47_MN3 (VSS XI1_I654_I47_Bn XI1_I654_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I47_MN0 (XI1_I654_I47_An I1_p1_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I48_MN1 (XI1_I654_I48_Bn I1_b2_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I48_MN5 (XI1_I654_I48_n2 I1_b2_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I48_MN4 (I1_I654_pn16 XI1_I654_I48_An XI1_I654_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I48_MN2 (XI1_I654_I48_n1 I1_p1_15 I1_I654_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I48_MN3 (VSS XI1_I654_I48_Bn XI1_I654_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I48_MN0 (XI1_I654_I48_An I1_p1_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I49_MN1 (XI1_I654_I49_Bn I1_b2_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I49_MN5 (XI1_I654_I49_n2 I1_b2_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I49_MN4 (I1_I654_pn17 XI1_I654_I49_An XI1_I654_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I49_MN2 (XI1_I654_I49_n1 I1_p1_16 I1_I654_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I49_MN3 (VSS XI1_I654_I49_Bn XI1_I654_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I49_MN0 (XI1_I654_I49_An I1_p1_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I50_MN1 (XI1_I654_I50_Bn I1_b2_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I50_MN5 (XI1_I654_I50_n2 I1_b2_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I50_MN4 (I1_I654_pn18 XI1_I654_I50_An XI1_I654_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I50_MN2 (XI1_I654_I50_n1 I1_p1_17 I1_I654_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I50_MN3 (VSS XI1_I654_I50_Bn XI1_I654_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I50_MN0 (XI1_I654_I50_An I1_p1_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I53_MN1 (XI1_I654_I53_Bn I1_b2_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I53_MN5 (XI1_I654_I53_n2 I1_b2_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I53_MN4 (I1_I654_pn21 XI1_I654_I53_An XI1_I654_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I53_MN2 (XI1_I654_I53_n1 I1_p1_20 I1_I654_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I53_MN3 (VSS XI1_I654_I53_Bn XI1_I654_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I53_MN0 (XI1_I654_I53_An I1_p1_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I55_MN1 (XI1_I654_I55_Bn I1_b2_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I55_MN5 (XI1_I654_I55_n2 I1_b2_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I55_MN4 (I1_I654_pn23 XI1_I654_I55_An XI1_I654_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I55_MN2 (XI1_I654_I55_n1 I1_p1_22 I1_I654_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I55_MN3 (VSS XI1_I654_I55_Bn XI1_I654_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I55_MN0 (XI1_I654_I55_An I1_p1_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I62_MN1 (XI1_I654_I62_Bn I1_b2_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I62_MN5 (XI1_I654_I62_n2 I1_b2_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I62_MN4 (I1_I654_pn30 XI1_I654_I62_An XI1_I654_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I62_MN2 (XI1_I654_I62_n1 I1_p1_29 I1_I654_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I62_MN3 (VSS XI1_I654_I62_Bn XI1_I654_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I62_MN0 (XI1_I654_I62_An I1_p1_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I63_MN1 (XI1_I1436_I63_Bn I1_b19_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I63_MN5 (XI1_I1436_I63_n2 I1_b19_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I63_MN4 (I1_I1436_pn31 XI1_I1436_I63_An XI1_I1436_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I63_MN2 (XI1_I1436_I63_n1 I1_p18_30 I1_I1436_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I63_MN3 (VSS XI1_I1436_I63_Bn XI1_I1436_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I63_MN0 (XI1_I1436_I63_An I1_p18_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I233_MN1 (XI1_I1436_I233_Bn I1_I1436_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I233_MN5 (XI1_I1436_I233_n2 I1_I1436_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I233_MN4 (I1_p19_30 XI1_I1436_I233_An XI1_I1436_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I233_MN2 (XI1_I1436_I233_n1 I1_I1436_pn30 I1_p19_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I233_MN3 (VSS XI1_I1436_I233_Bn XI1_I1436_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I233_MN0 (XI1_I1436_I233_An I1_I1436_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I229_MN1 (XI1_I1436_I229_Bn I1_I1436_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I229_MN5 (XI1_I1436_I229_n2 I1_I1436_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I229_MN4 (I1_p19_26 XI1_I1436_I229_An XI1_I1436_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I229_MN2 (XI1_I1436_I229_n1 I1_I1436_pn26 I1_p19_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I229_MN3 (VSS XI1_I1436_I229_Bn XI1_I1436_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I229_MN0 (XI1_I1436_I229_An I1_I1436_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I223_MN1 (XI1_I1436_I223_Bn I1_I1436_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I223_MN5 (XI1_I1436_I223_n2 I1_I1436_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I223_MN4 (I1_p19_20 XI1_I1436_I223_An XI1_I1436_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I223_MN2 (XI1_I1436_I223_n1 I1_I1436_pn20 I1_p19_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I223_MN3 (VSS XI1_I1436_I223_Bn XI1_I1436_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I223_MN0 (XI1_I1436_I223_An I1_I1436_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I221_MN1 (XI1_I1436_I221_Bn I1_I1436_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I221_MN5 (XI1_I1436_I221_n2 I1_I1436_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I221_MN4 (I1_p19_18 XI1_I1436_I221_An XI1_I1436_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I221_MN2 (XI1_I1436_I221_n1 I1_I1436_pn18 I1_p19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I221_MN3 (VSS XI1_I1436_I221_Bn XI1_I1436_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I221_MN0 (XI1_I1436_I221_An I1_I1436_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I211_MN1 (XI1_I1436_I211_Bn I1_I1436_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I211_MN5 (XI1_I1436_I211_n2 I1_I1436_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I211_MN4 (I1_p19_8 XI1_I1436_I211_An XI1_I1436_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I211_MN2 (XI1_I1436_I211_n1 I1_I1436_pn8 I1_p19_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I211_MN3 (VSS XI1_I1436_I211_Bn XI1_I1436_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I211_MN0 (XI1_I1436_I211_An I1_I1436_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I38_MN1 (XI1_I1482_I38_Bn I1_b20_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I38_MN5 (XI1_I1482_I38_n2 I1_b20_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I38_MN4 (I1_I1482_pn6 XI1_I1482_I38_An XI1_I1482_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I38_MN2 (XI1_I1482_I38_n1 I1_p19_5 I1_I1482_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I38_MN3 (VSS XI1_I1482_I38_Bn XI1_I1482_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I38_MN0 (XI1_I1482_I38_An I1_p19_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I205_MN1 (XI1_I1436_I205_Bn I1_I1436_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I205_MN5 (XI1_I1436_I205_n2 I1_I1436_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I205_MN4 (I1_p19_2 XI1_I1436_I205_An XI1_I1436_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I205_MN2 (XI1_I1436_I205_n1 I1_I1436_pn2 I1_p19_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I205_MN3 (VSS XI1_I1436_I205_Bn XI1_I1436_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I205_MN0 (XI1_I1436_I205_An I1_I1436_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I36_MN1 (XI1_I1482_I36_Bn I1_b20_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I36_MN5 (XI1_I1482_I36_n2 I1_b20_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I36_MN4 (I1_I1482_pn4 XI1_I1482_I36_An XI1_I1482_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I36_MN2 (XI1_I1482_I36_n1 I1_p19_3 I1_I1482_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I36_MN3 (VSS XI1_I1482_I36_Bn XI1_I1482_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I36_MN0 (XI1_I1482_I36_An I1_p19_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I32_MN1 (XI1_I1436_I32_Bn I1_b19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I32_MN5 (XI1_I1436_I32_n2 I1_b19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I32_MN4 (I1_I1436_pn0 XI1_I1436_I32_An XI1_I1436_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I32_MN2 (XI1_I1436_I32_n1 I1_aa12 I1_I1436_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I32_MN3 (VSS XI1_I1436_I32_Bn XI1_I1436_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I32_MN0 (XI1_I1436_I32_An I1_aa12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I48_MN1 (XI1_I1114_I48_Bn I1_b12_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I48_MN5 (XI1_I1114_I48_n2 I1_b12_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I48_MN4 (I1_I1114_pn16 XI1_I1114_I48_An XI1_I1114_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I48_MN2 (XI1_I1114_I48_n1 I1_p11_15 I1_I1114_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I48_MN3 (VSS XI1_I1114_I48_Bn XI1_I1114_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I48_MN0 (XI1_I1114_I48_An I1_p11_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I49_MN1 (XI1_I1114_I49_Bn I1_b12_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I49_MN5 (XI1_I1114_I49_n2 I1_b12_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I49_MN4 (I1_I1114_pn17 XI1_I1114_I49_An XI1_I1114_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I49_MN2 (XI1_I1114_I49_n1 I1_p11_16 I1_I1114_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I49_MN3 (VSS XI1_I1114_I49_Bn XI1_I1114_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I49_MN0 (XI1_I1114_I49_An I1_p11_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I222_MN1 (XI1_I1068_I222_Bn I1_I1068_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I222_MN5 (XI1_I1068_I222_n2 I1_I1068_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I222_MN4 (I1_p11_19 XI1_I1068_I222_An XI1_I1068_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I222_MN2 (XI1_I1068_I222_n1 I1_I1068_pn19 I1_p11_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I222_MN3 (VSS XI1_I1068_I222_Bn XI1_I1068_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I222_MN0 (XI1_I1068_I222_An I1_I1068_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I223_MN1 (XI1_I1068_I223_Bn I1_I1068_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I223_MN5 (XI1_I1068_I223_n2 I1_I1068_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I223_MN4 (I1_p11_20 XI1_I1068_I223_An XI1_I1068_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I223_MN2 (XI1_I1068_I223_n1 I1_I1068_pn20 I1_p11_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I223_MN3 (VSS XI1_I1068_I223_Bn XI1_I1068_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I223_MN0 (XI1_I1068_I223_An I1_I1068_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I52_MN1 (XI1_I1068_I52_Bn I1_b11_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I52_MN5 (XI1_I1068_I52_n2 I1_b11_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I52_MN4 (I1_I1068_pn20 XI1_I1068_I52_An XI1_I1068_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I52_MN2 (XI1_I1068_I52_n1 I1_p10_19 I1_I1068_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I52_MN3 (VSS XI1_I1068_I52_Bn XI1_I1068_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I52_MN0 (XI1_I1068_I52_An I1_p10_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I53_MN1 (XI1_I1068_I53_Bn I1_b11_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I53_MN5 (XI1_I1068_I53_n2 I1_b11_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I53_MN4 (I1_I1068_pn21 XI1_I1068_I53_An XI1_I1068_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I53_MN2 (XI1_I1068_I53_n1 I1_p10_20 I1_I1068_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I53_MN3 (VSS XI1_I1068_I53_Bn XI1_I1068_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I53_MN0 (XI1_I1068_I53_An I1_p10_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I226_MN1 (XI1_I1022_I226_Bn I1_I1022_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I226_MN5 (XI1_I1022_I226_n2 I1_I1022_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I226_MN4 (I1_p10_23 XI1_I1022_I226_An XI1_I1022_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I226_MN2 (XI1_I1022_I226_n1 I1_I1022_pn23 I1_p10_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I226_MN3 (VSS XI1_I1022_I226_Bn XI1_I1022_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I226_MN0 (XI1_I1022_I226_An I1_I1022_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I229_MN1 (XI1_I1022_I229_Bn I1_I1022_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I229_MN5 (XI1_I1022_I229_n2 I1_I1022_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I229_MN4 (I1_p10_26 XI1_I1022_I229_An XI1_I1022_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I229_MN2 (XI1_I1022_I229_n1 I1_I1022_pn26 I1_p10_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I229_MN3 (VSS XI1_I1022_I229_Bn XI1_I1022_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I229_MN0 (XI1_I1022_I229_An I1_I1022_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I227_MN1 (XI1_I1022_I227_Bn I1_I1022_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I227_MN5 (XI1_I1022_I227_n2 I1_I1022_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I227_MN4 (I1_p10_24 XI1_I1022_I227_An XI1_I1022_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I227_MN2 (XI1_I1022_I227_n1 I1_I1022_pn24 I1_p10_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I227_MN3 (VSS XI1_I1022_I227_Bn XI1_I1022_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I227_MN0 (XI1_I1022_I227_An I1_I1022_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I56_MN1 (XI1_I1022_I56_Bn I1_b10_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I56_MN5 (XI1_I1022_I56_n2 I1_b10_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I56_MN4 (I1_I1022_pn24 XI1_I1022_I56_An XI1_I1022_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I56_MN2 (XI1_I1022_I56_n1 I1_p9_23 I1_I1022_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I56_MN3 (VSS XI1_I1022_I56_Bn XI1_I1022_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I56_MN0 (XI1_I1022_I56_An I1_p9_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I55_MN1 (XI1_I1022_I55_Bn I1_b10_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I55_MN5 (XI1_I1022_I55_n2 I1_b10_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I55_MN4 (I1_I1022_pn23 XI1_I1022_I55_An XI1_I1022_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I55_MN2 (XI1_I1022_I55_n1 I1_p9_22 I1_I1022_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I55_MN3 (VSS XI1_I1022_I55_Bn XI1_I1022_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I55_MN0 (XI1_I1022_I55_An I1_p9_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I224_MN1 (XI1_I976_I224_Bn I1_I976_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I224_MN5 (XI1_I976_I224_n2 I1_I976_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I224_MN4 (I1_p9_21 XI1_I976_I224_An XI1_I976_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I224_MN2 (XI1_I976_I224_n1 I1_I976_pn21 I1_p9_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I224_MN3 (VSS XI1_I976_I224_Bn XI1_I976_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I224_MN0 (XI1_I976_I224_An I1_I976_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I221_MN1 (XI1_I976_I221_Bn I1_I976_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I221_MN5 (XI1_I976_I221_n2 I1_I976_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I221_MN4 (I1_p9_18 XI1_I976_I221_An XI1_I976_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I221_MN2 (XI1_I976_I221_n1 I1_I976_pn18 I1_p9_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I221_MN3 (VSS XI1_I976_I221_Bn XI1_I976_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I221_MN0 (XI1_I976_I221_An I1_I976_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I211_MN1 (XI1_I976_I211_Bn I1_I976_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I211_MN5 (XI1_I976_I211_n2 I1_I976_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I211_MN4 (I1_p9_8 XI1_I976_I211_An XI1_I976_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I211_MN2 (XI1_I976_I211_n1 I1_I976_pn8 I1_p9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I211_MN3 (VSS XI1_I976_I211_Bn XI1_I976_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I211_MN0 (XI1_I976_I211_An I1_I976_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I37_MN1 (XI1_I976_I37_Bn I1_b9_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I37_MN5 (XI1_I976_I37_n2 I1_b9_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I37_MN4 (I1_I976_pn5 XI1_I976_I37_An XI1_I976_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I37_MN2 (XI1_I976_I37_n1 I1_p8_4 I1_I976_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I37_MN3 (VSS XI1_I976_I37_Bn XI1_I976_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I37_MN0 (XI1_I976_I37_An I1_p8_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I204_MN1 (XI1_I608_I204_Bn I1_I608_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I204_MN5 (XI1_I608_I204_n2 I1_I608_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I204_MN4 (I1_p1_1 XI1_I608_I204_An XI1_I608_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I204_MN2 (XI1_I608_I204_n1 I1_I608_pn1 I1_p1_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I204_MN3 (VSS XI1_I608_I204_Bn XI1_I608_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I204_MN0 (XI1_I608_I204_An I1_I608_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I205_MN1 (XI1_I608_I205_Bn I1_I608_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I205_MN5 (XI1_I608_I205_n2 I1_I608_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I205_MN4 (I1_p1_2 XI1_I608_I205_An XI1_I608_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I205_MN2 (XI1_I608_I205_n1 I1_I608_pn2 I1_p1_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I205_MN3 (VSS XI1_I608_I205_Bn XI1_I608_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I205_MN0 (XI1_I608_I205_An I1_I608_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I208_MN1 (XI1_I608_I208_Bn I1_I608_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I208_MN5 (XI1_I608_I208_n2 I1_I608_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I208_MN4 (I1_p1_5 XI1_I608_I208_An XI1_I608_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I208_MN2 (XI1_I608_I208_n1 I1_I608_pn5 I1_p1_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I208_MN3 (VSS XI1_I608_I208_Bn XI1_I608_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I208_MN0 (XI1_I608_I208_An I1_I608_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I210_MN1 (XI1_I608_I210_Bn I1_I608_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I210_MN5 (XI1_I608_I210_n2 I1_I608_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I210_MN4 (I1_p1_7 XI1_I608_I210_An XI1_I608_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I210_MN2 (XI1_I608_I210_n1 I1_I608_pn7 I1_p1_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I210_MN3 (VSS XI1_I608_I210_Bn XI1_I608_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I210_MN0 (XI1_I608_I210_An I1_I608_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I220_MN1 (XI1_I608_I220_Bn I1_I608_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I220_MN5 (XI1_I608_I220_n2 I1_I608_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I220_MN4 (I1_p1_17 XI1_I608_I220_An XI1_I608_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I220_MN2 (XI1_I608_I220_n1 I1_I608_pn17 I1_p1_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I220_MN3 (VSS XI1_I608_I220_Bn XI1_I608_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I220_MN0 (XI1_I608_I220_An I1_I608_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I222_MN1 (XI1_I608_I222_Bn I1_I608_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I222_MN5 (XI1_I608_I222_n2 I1_I608_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I222_MN4 (I1_p1_19 XI1_I608_I222_An XI1_I608_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I222_MN2 (XI1_I608_I222_n1 I1_I608_pn19 I1_p1_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I222_MN3 (VSS XI1_I608_I222_Bn XI1_I608_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I222_MN0 (XI1_I608_I222_An I1_I608_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I224_MN1 (XI1_I608_I224_Bn I1_I608_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I224_MN5 (XI1_I608_I224_n2 I1_I608_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I224_MN4 (I1_p1_21 XI1_I608_I224_An XI1_I608_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I224_MN2 (XI1_I608_I224_n1 I1_I608_pn21 I1_p1_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I224_MN3 (VSS XI1_I608_I224_Bn XI1_I608_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I224_MN0 (XI1_I608_I224_An I1_I608_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I226_MN1 (XI1_I608_I226_Bn I1_I608_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I226_MN5 (XI1_I608_I226_n2 I1_I608_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I226_MN4 (I1_p1_23 XI1_I608_I226_An XI1_I608_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I226_MN2 (XI1_I608_I226_n1 I1_I608_pn23 I1_p1_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I226_MN3 (VSS XI1_I608_I226_Bn XI1_I608_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I226_MN0 (XI1_I608_I226_An I1_I608_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I228_MN1 (XI1_I608_I228_Bn I1_I608_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I228_MN5 (XI1_I608_I228_n2 I1_I608_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I228_MN4 (I1_p1_25 XI1_I608_I228_An XI1_I608_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I228_MN2 (XI1_I608_I228_n1 I1_I608_pn25 I1_p1_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I228_MN3 (VSS XI1_I608_I228_Bn XI1_I608_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I228_MN0 (XI1_I608_I228_An I1_I608_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I234_MN1 (XI1_I608_I234_Bn I1_c1_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I234_MN5 (XI1_I608_I234_n2 I1_c1_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I234_MN4 (I1_p1_31 XI1_I608_I234_An XI1_I608_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I234_MN2 (XI1_I608_I234_n1 I1_I608_pn31 I1_p1_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I234_MN3 (VSS XI1_I608_I234_Bn XI1_I608_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I234_MN0 (XI1_I608_I234_An I1_I608_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I58_MN1 (XI1_I654_I58_Bn I1_b2_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I58_MN5 (XI1_I654_I58_n2 I1_b2_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I58_MN4 (I1_I654_pn26 XI1_I654_I58_An XI1_I654_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I58_MN2 (XI1_I654_I58_n1 I1_p1_25 I1_I654_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I58_MN3 (VSS XI1_I654_I58_Bn XI1_I654_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I58_MN0 (XI1_I654_I58_An I1_p1_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I63_MN1 (XI1_I654_I63_Bn I1_b2_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I63_MN5 (XI1_I654_I63_n2 I1_b2_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I63_MN4 (I1_I654_pn31 XI1_I654_I63_An XI1_I654_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I63_MN2 (XI1_I654_I63_n1 I1_p1_30 I1_I654_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I63_MN3 (VSS XI1_I654_I63_Bn XI1_I654_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I63_MN0 (XI1_I654_I63_An I1_p1_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I234_MN1 (XI1_I1436_I234_Bn I1_c19_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I234_MN5 (XI1_I1436_I234_n2 I1_c19_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I234_MN4 (I1_p19_31 XI1_I1436_I234_An XI1_I1436_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I234_MN2 (XI1_I1436_I234_n1 I1_I1436_pn31 I1_p19_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I234_MN3 (VSS XI1_I1436_I234_Bn XI1_I1436_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I234_MN0 (XI1_I1436_I234_An I1_I1436_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I231_MN1 (XI1_I1436_I231_Bn I1_I1436_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I231_MN5 (XI1_I1436_I231_n2 I1_I1436_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I231_MN4 (I1_p19_28 XI1_I1436_I231_An XI1_I1436_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I231_MN2 (XI1_I1436_I231_n1 I1_I1436_pn28 I1_p19_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I231_MN3 (VSS XI1_I1436_I231_Bn XI1_I1436_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I231_MN0 (XI1_I1436_I231_An I1_I1436_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I227_MN1 (XI1_I1436_I227_Bn I1_I1436_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I227_MN5 (XI1_I1436_I227_n2 I1_I1436_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I227_MN4 (I1_p19_24 XI1_I1436_I227_An XI1_I1436_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I227_MN2 (XI1_I1436_I227_n1 I1_I1436_pn24 I1_p19_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I227_MN3 (VSS XI1_I1436_I227_Bn XI1_I1436_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I227_MN0 (XI1_I1436_I227_An I1_I1436_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I225_MN1 (XI1_I1436_I225_Bn I1_I1436_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I225_MN5 (XI1_I1436_I225_n2 I1_I1436_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I225_MN4 (I1_p19_22 XI1_I1436_I225_An XI1_I1436_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I225_MN2 (XI1_I1436_I225_n1 I1_I1436_pn22 I1_p19_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I225_MN3 (VSS XI1_I1436_I225_Bn XI1_I1436_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I225_MN0 (XI1_I1436_I225_An I1_I1436_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I50_MN1 (XI1_I1482_I50_Bn I1_b20_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I50_MN5 (XI1_I1482_I50_n2 I1_b20_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I50_MN4 (I1_I1482_pn18 XI1_I1482_I50_An XI1_I1482_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I50_MN2 (XI1_I1482_I50_n1 I1_p19_17 I1_I1482_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I50_MN3 (VSS XI1_I1482_I50_Bn XI1_I1482_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I50_MN0 (XI1_I1482_I50_An I1_p19_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I48_MN1 (XI1_I1482_I48_Bn I1_b20_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I48_MN5 (XI1_I1482_I48_n2 I1_b20_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I48_MN4 (I1_I1482_pn16 XI1_I1482_I48_An XI1_I1482_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I48_MN2 (XI1_I1482_I48_n1 I1_p19_15 I1_I1482_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I48_MN3 (VSS XI1_I1482_I48_Bn XI1_I1482_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I48_MN0 (XI1_I1482_I48_An I1_p19_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I46_MN1 (XI1_I1482_I46_Bn I1_b20_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I46_MN5 (XI1_I1482_I46_n2 I1_b20_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I46_MN4 (I1_I1482_pn14 XI1_I1482_I46_An XI1_I1482_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I46_MN2 (XI1_I1482_I46_n1 I1_p19_13 I1_I1482_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I46_MN3 (VSS XI1_I1482_I46_Bn XI1_I1482_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I46_MN0 (XI1_I1482_I46_An I1_p19_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I43_MN1 (XI1_I1482_I43_Bn I1_b20_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I43_MN5 (XI1_I1482_I43_n2 I1_b20_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I43_MN4 (I1_I1482_pn11 XI1_I1482_I43_An XI1_I1482_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I43_MN2 (XI1_I1482_I43_n1 I1_p19_10 I1_I1482_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I43_MN3 (VSS XI1_I1482_I43_Bn XI1_I1482_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I43_MN0 (XI1_I1482_I43_An I1_p19_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I40_MN1 (XI1_I1482_I40_Bn I1_b20_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I40_MN5 (XI1_I1482_I40_n2 I1_b20_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I40_MN4 (I1_I1482_pn8 XI1_I1482_I40_An XI1_I1482_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I40_MN2 (XI1_I1482_I40_n1 I1_p19_7 I1_I1482_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I40_MN3 (VSS XI1_I1482_I40_Bn XI1_I1482_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I40_MN0 (XI1_I1482_I40_An I1_p19_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I203_MN1 (XI1_I1436_I203_Bn I1_qu13_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I203_MN5 (XI1_I1436_I203_n2 I1_qu13_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I203_MN4 (I1_p19_0 XI1_I1436_I203_An XI1_I1436_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I203_MN2 (XI1_I1436_I203_n1 I1_I1436_pn0 I1_p19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I203_MN3 (VSS XI1_I1436_I203_Bn XI1_I1436_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I203_MN0 (XI1_I1436_I203_An I1_I1436_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I47_MN1 (XI1_I1114_I47_Bn I1_b12_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I47_MN5 (XI1_I1114_I47_n2 I1_b12_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I47_MN4 (I1_I1114_pn15 XI1_I1114_I47_An XI1_I1114_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I47_MN2 (XI1_I1114_I47_n1 I1_p11_14 I1_I1114_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I47_MN3 (VSS XI1_I1114_I47_Bn XI1_I1114_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I47_MN0 (XI1_I1114_I47_An I1_p11_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I46_MN1 (XI1_I1114_I46_Bn I1_b12_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I46_MN5 (XI1_I1114_I46_n2 I1_b12_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I46_MN4 (I1_I1114_pn14 XI1_I1114_I46_An XI1_I1114_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I46_MN2 (XI1_I1114_I46_n1 I1_p11_13 I1_I1114_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I46_MN3 (VSS XI1_I1114_I46_Bn XI1_I1114_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I46_MN0 (XI1_I1114_I46_An I1_p11_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I221_MN1 (XI1_I1068_I221_Bn I1_I1068_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I221_MN5 (XI1_I1068_I221_n2 I1_I1068_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I221_MN4 (I1_p11_18 XI1_I1068_I221_An XI1_I1068_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I221_MN2 (XI1_I1068_I221_n1 I1_I1068_pn18 I1_p11_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I221_MN3 (VSS XI1_I1068_I221_Bn XI1_I1068_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I221_MN0 (XI1_I1068_I221_An I1_I1068_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I51_MN1 (XI1_I1068_I51_Bn I1_b11_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I51_MN5 (XI1_I1068_I51_n2 I1_b11_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I51_MN4 (I1_I1068_pn19 XI1_I1068_I51_An XI1_I1068_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I51_MN2 (XI1_I1068_I51_n1 I1_p10_18 I1_I1068_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I51_MN3 (VSS XI1_I1068_I51_Bn XI1_I1068_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I51_MN0 (XI1_I1068_I51_An I1_p10_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I228_MN1 (XI1_I1022_I228_Bn I1_I1022_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I228_MN5 (XI1_I1022_I228_n2 I1_I1022_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I228_MN4 (I1_p10_25 XI1_I1022_I228_An XI1_I1022_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I228_MN2 (XI1_I1022_I228_n1 I1_I1022_pn25 I1_p10_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I228_MN3 (VSS XI1_I1022_I228_Bn XI1_I1022_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I228_MN0 (XI1_I1022_I228_An I1_I1022_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I234_MN1 (XI1_I976_I234_Bn I1_c9_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I234_MN5 (XI1_I976_I234_n2 I1_c9_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I234_MN4 (I1_p9_31 XI1_I976_I234_An XI1_I976_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I234_MN2 (XI1_I976_I234_n1 I1_I976_pn31 I1_p9_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I234_MN3 (VSS XI1_I976_I234_Bn XI1_I976_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I234_MN0 (XI1_I976_I234_An I1_I976_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I225_MN1 (XI1_I1022_I225_Bn I1_I1022_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I225_MN5 (XI1_I1022_I225_n2 I1_I1022_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I225_MN4 (I1_p10_22 XI1_I1022_I225_An XI1_I1022_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I225_MN2 (XI1_I1022_I225_n1 I1_I1022_pn22 I1_p10_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I225_MN3 (VSS XI1_I1022_I225_Bn XI1_I1022_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I225_MN0 (XI1_I1022_I225_An I1_I1022_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I54_MN1 (XI1_I1022_I54_Bn I1_b10_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I54_MN5 (XI1_I1022_I54_n2 I1_b10_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I54_MN4 (I1_I1022_pn22 XI1_I1022_I54_An XI1_I1022_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I54_MN2 (XI1_I1022_I54_n1 I1_p9_21 I1_I1022_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I54_MN3 (VSS XI1_I1022_I54_Bn XI1_I1022_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I54_MN0 (XI1_I1022_I54_An I1_p9_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I53_MN1 (XI1_I1022_I53_Bn I1_b10_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I53_MN5 (XI1_I1022_I53_n2 I1_b10_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I53_MN4 (I1_I1022_pn21 XI1_I1022_I53_An XI1_I1022_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I53_MN2 (XI1_I1022_I53_n1 I1_p9_20 I1_I1022_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I53_MN3 (VSS XI1_I1022_I53_Bn XI1_I1022_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I53_MN0 (XI1_I1022_I53_An I1_p9_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I209_MN1 (XI1_I976_I209_Bn I1_I976_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I209_MN5 (XI1_I976_I209_n2 I1_I976_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I209_MN4 (I1_p9_6 XI1_I976_I209_An XI1_I976_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I209_MN2 (XI1_I976_I209_n1 I1_I976_pn6 I1_p9_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I209_MN3 (VSS XI1_I976_I209_Bn XI1_I976_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I209_MN0 (XI1_I976_I209_An I1_I976_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I36_MN1 (XI1_I976_I36_Bn I1_b9_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I36_MN5 (XI1_I976_I36_n2 I1_b9_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I36_MN4 (I1_I976_pn4 XI1_I976_I36_An XI1_I976_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I36_MN2 (XI1_I976_I36_n1 I1_p8_3 I1_I976_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I36_MN3 (VSS XI1_I976_I36_Bn XI1_I976_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I36_MN0 (XI1_I976_I36_An I1_p8_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I33_MN1 (XI1_I608_I33_Bn I1_b1_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I33_MN5 (XI1_I608_I33_n2 I1_b1_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I33_MN4 (I1_I608_pn1 XI1_I608_I33_An XI1_I608_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I33_MN2 (XI1_I608_I33_n1 I1_p0_0 I1_I608_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I33_MN3 (VSS XI1_I608_I33_Bn XI1_I608_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I33_MN0 (XI1_I608_I33_An I1_p0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I230_MN1 (XI1_I608_I230_Bn I1_I608_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I230_MN5 (XI1_I608_I230_n2 I1_I608_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I230_MN4 (I1_p1_27 XI1_I608_I230_An XI1_I608_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I230_MN2 (XI1_I608_I230_n1 I1_I608_pn27 I1_p1_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I230_MN3 (VSS XI1_I608_I230_Bn XI1_I608_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I230_MN0 (XI1_I608_I230_An I1_I608_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I232_MN1 (XI1_I608_I232_Bn I1_I608_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I232_MN5 (XI1_I608_I232_n2 I1_I608_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I232_MN4 (I1_p1_29 XI1_I608_I232_An XI1_I608_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I232_MN2 (XI1_I608_I232_n1 I1_I608_pn29 I1_p1_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I232_MN3 (VSS XI1_I608_I232_Bn XI1_I608_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I232_MN0 (XI1_I608_I232_An I1_I608_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I233_MN1 (XI1_I608_I233_Bn I1_I608_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I233_MN5 (XI1_I608_I233_n2 I1_I608_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I233_MN4 (I1_p1_30 XI1_I608_I233_An XI1_I608_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I233_MN2 (XI1_I608_I233_n1 I1_I608_pn30 I1_p1_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I233_MN3 (VSS XI1_I608_I233_Bn XI1_I608_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I233_MN0 (XI1_I608_I233_An I1_I608_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I56_MN1 (XI1_I1482_I56_Bn I1_b20_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I56_MN5 (XI1_I1482_I56_n2 I1_b20_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I56_MN4 (I1_I1482_pn24 XI1_I1482_I56_An XI1_I1482_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I56_MN2 (XI1_I1482_I56_n1 I1_p19_23 I1_I1482_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I56_MN3 (VSS XI1_I1482_I56_Bn XI1_I1482_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I56_MN0 (XI1_I1482_I56_An I1_p19_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I55_MN1 (XI1_I1482_I55_Bn I1_b20_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I55_MN5 (XI1_I1482_I55_n2 I1_b20_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I55_MN4 (I1_I1482_pn23 XI1_I1482_I55_An XI1_I1482_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I55_MN2 (XI1_I1482_I55_n1 I1_p19_22 I1_I1482_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I55_MN3 (VSS XI1_I1482_I55_Bn XI1_I1482_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I55_MN0 (XI1_I1482_I55_An I1_p19_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I54_MN1 (XI1_I1482_I54_Bn I1_b20_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I54_MN5 (XI1_I1482_I54_n2 I1_b20_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I54_MN4 (I1_I1482_pn22 XI1_I1482_I54_An XI1_I1482_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I54_MN2 (XI1_I1482_I54_n1 I1_p19_21 I1_I1482_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I54_MN3 (VSS XI1_I1482_I54_Bn XI1_I1482_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I54_MN0 (XI1_I1482_I54_An I1_p19_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I52_MN1 (XI1_I1482_I52_Bn I1_b20_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I52_MN5 (XI1_I1482_I52_n2 I1_b20_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I52_MN4 (I1_I1482_pn20 XI1_I1482_I52_An XI1_I1482_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I52_MN2 (XI1_I1482_I52_n1 I1_p19_19 I1_I1482_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I52_MN3 (VSS XI1_I1482_I52_Bn XI1_I1482_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I52_MN0 (XI1_I1482_I52_An I1_p19_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I53_MN1 (XI1_I1482_I53_Bn I1_b20_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I53_MN5 (XI1_I1482_I53_n2 I1_b20_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I53_MN4 (I1_I1482_pn21 XI1_I1482_I53_An XI1_I1482_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I53_MN2 (XI1_I1482_I53_n1 I1_p19_20 I1_I1482_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I53_MN3 (VSS XI1_I1482_I53_Bn XI1_I1482_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I53_MN0 (XI1_I1482_I53_An I1_p19_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I51_MN1 (XI1_I1482_I51_Bn I1_b20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I51_MN5 (XI1_I1482_I51_n2 I1_b20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I51_MN4 (I1_I1482_pn19 XI1_I1482_I51_An XI1_I1482_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I51_MN2 (XI1_I1482_I51_n1 I1_p19_18 I1_I1482_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I51_MN3 (VSS XI1_I1482_I51_Bn XI1_I1482_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I51_MN0 (XI1_I1482_I51_An I1_p19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I49_MN1 (XI1_I1482_I49_Bn I1_b20_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I49_MN5 (XI1_I1482_I49_n2 I1_b20_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I49_MN4 (I1_I1482_pn17 XI1_I1482_I49_An XI1_I1482_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I49_MN2 (XI1_I1482_I49_n1 I1_p19_16 I1_I1482_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I49_MN3 (VSS XI1_I1482_I49_Bn XI1_I1482_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I49_MN0 (XI1_I1482_I49_An I1_p19_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I47_MN1 (XI1_I1482_I47_Bn I1_b20_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I47_MN5 (XI1_I1482_I47_n2 I1_b20_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I47_MN4 (I1_I1482_pn15 XI1_I1482_I47_An XI1_I1482_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I47_MN2 (XI1_I1482_I47_n1 I1_p19_14 I1_I1482_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I47_MN3 (VSS XI1_I1482_I47_Bn XI1_I1482_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I47_MN0 (XI1_I1482_I47_An I1_p19_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I45_MN1 (XI1_I1482_I45_Bn I1_b20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I45_MN5 (XI1_I1482_I45_n2 I1_b20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I45_MN4 (I1_I1482_pn13 XI1_I1482_I45_An XI1_I1482_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I45_MN2 (XI1_I1482_I45_n1 I1_p19_12 I1_I1482_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I45_MN3 (VSS XI1_I1482_I45_Bn XI1_I1482_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I45_MN0 (XI1_I1482_I45_An I1_p19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I44_MN1 (XI1_I1482_I44_Bn I1_b20_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I44_MN5 (XI1_I1482_I44_n2 I1_b20_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I44_MN4 (I1_I1482_pn12 XI1_I1482_I44_An XI1_I1482_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I44_MN2 (XI1_I1482_I44_n1 I1_p19_11 I1_I1482_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I44_MN3 (VSS XI1_I1482_I44_Bn XI1_I1482_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I44_MN0 (XI1_I1482_I44_An I1_p19_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I42_MN1 (XI1_I1482_I42_Bn I1_b20_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I42_MN5 (XI1_I1482_I42_n2 I1_b20_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I42_MN4 (I1_I1482_pn10 XI1_I1482_I42_An XI1_I1482_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I42_MN2 (XI1_I1482_I42_n1 I1_p19_9 I1_I1482_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I42_MN3 (VSS XI1_I1482_I42_Bn XI1_I1482_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I42_MN0 (XI1_I1482_I42_An I1_p19_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I41_MN1 (XI1_I1482_I41_Bn I1_b20_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I41_MN5 (XI1_I1482_I41_n2 I1_b20_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I41_MN4 (I1_I1482_pn9 XI1_I1482_I41_An XI1_I1482_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I41_MN2 (XI1_I1482_I41_n1 I1_p19_8 I1_I1482_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I41_MN3 (VSS XI1_I1482_I41_Bn XI1_I1482_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I41_MN0 (XI1_I1482_I41_An I1_p19_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I39_MN1 (XI1_I1482_I39_Bn I1_b20_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I39_MN5 (XI1_I1482_I39_n2 I1_b20_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I39_MN4 (I1_I1482_pn7 XI1_I1482_I39_An XI1_I1482_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I39_MN2 (XI1_I1482_I39_n1 I1_p19_6 I1_I1482_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I39_MN3 (VSS XI1_I1482_I39_Bn XI1_I1482_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I39_MN0 (XI1_I1482_I39_An I1_p19_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I37_MN1 (XI1_I1482_I37_Bn I1_b20_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I37_MN5 (XI1_I1482_I37_n2 I1_b20_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I37_MN4 (I1_I1482_pn5 XI1_I1482_I37_An XI1_I1482_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I37_MN2 (XI1_I1482_I37_n1 I1_p19_4 I1_I1482_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I37_MN3 (VSS XI1_I1482_I37_Bn XI1_I1482_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I37_MN0 (XI1_I1482_I37_An I1_p19_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I35_MN1 (XI1_I1482_I35_Bn I1_b20_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I35_MN5 (XI1_I1482_I35_n2 I1_b20_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I35_MN4 (I1_I1482_pn3 XI1_I1482_I35_An XI1_I1482_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I35_MN2 (XI1_I1482_I35_n1 I1_p19_2 I1_I1482_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I35_MN3 (VSS XI1_I1482_I35_Bn XI1_I1482_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I35_MN0 (XI1_I1482_I35_An I1_p19_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I34_MN1 (XI1_I1482_I34_Bn I1_b20_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I34_MN5 (XI1_I1482_I34_n2 I1_b20_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I34_MN4 (I1_I1482_pn2 XI1_I1482_I34_An XI1_I1482_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I34_MN2 (XI1_I1482_I34_n1 I1_p19_1 I1_I1482_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I34_MN3 (VSS XI1_I1482_I34_Bn XI1_I1482_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I34_MN0 (XI1_I1482_I34_An I1_p19_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I211_MN1 (XI1_I1114_I211_Bn I1_I1114_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I211_MN5 (XI1_I1114_I211_n2 I1_I1114_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I211_MN4 (I1_p12_8 XI1_I1114_I211_An XI1_I1114_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I211_MN2 (XI1_I1114_I211_n1 I1_I1114_pn8 I1_p12_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I211_MN3 (VSS XI1_I1114_I211_Bn XI1_I1114_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I211_MN0 (XI1_I1114_I211_An I1_I1114_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I210_MN1 (XI1_I1114_I210_Bn I1_I1114_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I210_MN5 (XI1_I1114_I210_n2 I1_I1114_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I210_MN4 (I1_p12_7 XI1_I1114_I210_An XI1_I1114_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I210_MN2 (XI1_I1114_I210_n1 I1_I1114_pn7 I1_p12_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I210_MN3 (VSS XI1_I1114_I210_Bn XI1_I1114_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I210_MN0 (XI1_I1114_I210_An I1_I1114_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I45_MN1 (XI1_I1114_I45_Bn I1_b12_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I45_MN5 (XI1_I1114_I45_n2 I1_b12_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I45_MN4 (I1_I1114_pn13 XI1_I1114_I45_An XI1_I1114_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I45_MN2 (XI1_I1114_I45_n1 I1_p11_12 I1_I1114_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I45_MN3 (VSS XI1_I1114_I45_Bn XI1_I1114_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I45_MN0 (XI1_I1114_I45_An I1_p11_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I220_MN1 (XI1_I1068_I220_Bn I1_I1068_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I220_MN5 (XI1_I1068_I220_n2 I1_I1068_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I220_MN4 (I1_p11_17 XI1_I1068_I220_An XI1_I1068_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I220_MN2 (XI1_I1068_I220_n1 I1_I1068_pn17 I1_p11_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I220_MN3 (VSS XI1_I1068_I220_Bn XI1_I1068_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I220_MN0 (XI1_I1068_I220_An I1_I1068_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I49_MN1 (XI1_I1068_I49_Bn I1_b11_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I49_MN5 (XI1_I1068_I49_n2 I1_b11_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I49_MN4 (I1_I1068_pn17 XI1_I1068_I49_An XI1_I1068_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I49_MN2 (XI1_I1068_I49_n1 I1_p10_16 I1_I1068_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I49_MN3 (VSS XI1_I1068_I49_Bn XI1_I1068_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I49_MN0 (XI1_I1068_I49_An I1_p10_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I50_MN1 (XI1_I1068_I50_Bn I1_b11_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I50_MN5 (XI1_I1068_I50_n2 I1_b11_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I50_MN4 (I1_I1068_pn18 XI1_I1068_I50_An XI1_I1068_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I50_MN2 (XI1_I1068_I50_n1 I1_p10_17 I1_I1068_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I50_MN3 (VSS XI1_I1068_I50_Bn XI1_I1068_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I50_MN0 (XI1_I1068_I50_An I1_p10_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I224_MN1 (XI1_I1022_I224_Bn I1_I1022_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I224_MN5 (XI1_I1022_I224_n2 I1_I1022_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I224_MN4 (I1_p10_21 XI1_I1022_I224_An XI1_I1022_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I224_MN2 (XI1_I1022_I224_n1 I1_I1022_pn21 I1_p10_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I224_MN3 (VSS XI1_I1022_I224_Bn XI1_I1022_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I224_MN0 (XI1_I1022_I224_An I1_I1022_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I52_MN1 (XI1_I1022_I52_Bn I1_b10_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I52_MN5 (XI1_I1022_I52_n2 I1_b10_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I52_MN4 (I1_I1022_pn20 XI1_I1022_I52_An XI1_I1022_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I52_MN2 (XI1_I1022_I52_n1 I1_p9_19 I1_I1022_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I52_MN3 (VSS XI1_I1022_I52_Bn XI1_I1022_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I52_MN0 (XI1_I1022_I52_An I1_p9_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I51_MN1 (XI1_I1022_I51_Bn I1_b10_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I51_MN5 (XI1_I1022_I51_n2 I1_b10_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I51_MN4 (I1_I1022_pn19 XI1_I1022_I51_An XI1_I1022_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I51_MN2 (XI1_I1022_I51_n1 I1_p9_18 I1_I1022_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I51_MN3 (VSS XI1_I1022_I51_Bn XI1_I1022_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I51_MN0 (XI1_I1022_I51_An I1_p9_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I222_MN1 (XI1_I976_I222_Bn I1_I976_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I222_MN5 (XI1_I976_I222_n2 I1_I976_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I222_MN4 (I1_p9_19 XI1_I976_I222_An XI1_I976_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I222_MN2 (XI1_I976_I222_n1 I1_I976_pn19 I1_p9_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I222_MN3 (VSS XI1_I976_I222_Bn XI1_I976_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I222_MN0 (XI1_I976_I222_An I1_I976_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I35_MN1 (XI1_I976_I35_Bn I1_b9_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I35_MN5 (XI1_I976_I35_n2 I1_b9_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I35_MN4 (I1_I976_pn3 XI1_I976_I35_An XI1_I976_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I35_MN2 (XI1_I976_I35_n1 I1_p8_2 I1_I976_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I35_MN3 (VSS XI1_I976_I35_Bn XI1_I976_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I35_MN0 (XI1_I976_I35_An I1_p8_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I34_MN1 (XI1_I608_I34_Bn I1_b1_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I34_MN5 (XI1_I608_I34_n2 I1_b1_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I34_MN4 (I1_I608_pn2 XI1_I608_I34_An XI1_I608_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I34_MN2 (XI1_I608_I34_n1 I1_p0_1 I1_I608_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I34_MN3 (VSS XI1_I608_I34_Bn XI1_I608_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I34_MN0 (XI1_I608_I34_An I1_p0_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I209_MN1 (XI1_I608_I209_Bn I1_I608_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I209_MN5 (XI1_I608_I209_n2 I1_I608_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I209_MN4 (I1_p1_6 XI1_I608_I209_An XI1_I608_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I209_MN2 (XI1_I608_I209_n1 I1_I608_pn6 I1_p1_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I209_MN3 (VSS XI1_I608_I209_Bn XI1_I608_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I209_MN0 (XI1_I608_I209_An I1_I608_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I211_MN1 (XI1_I608_I211_Bn I1_I608_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I211_MN5 (XI1_I608_I211_n2 I1_I608_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I211_MN4 (I1_p1_8 XI1_I608_I211_An XI1_I608_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I211_MN2 (XI1_I608_I211_n1 I1_I608_pn8 I1_p1_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I211_MN3 (VSS XI1_I608_I211_Bn XI1_I608_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I211_MN0 (XI1_I608_I211_An I1_I608_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I221_MN1 (XI1_I608_I221_Bn I1_I608_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I221_MN5 (XI1_I608_I221_n2 I1_I608_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I221_MN4 (I1_p1_18 XI1_I608_I221_An XI1_I608_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I221_MN2 (XI1_I608_I221_n1 I1_I608_pn18 I1_p1_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I221_MN3 (VSS XI1_I608_I221_Bn XI1_I608_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I221_MN0 (XI1_I608_I221_An I1_I608_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I223_MN1 (XI1_I608_I223_Bn I1_I608_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I223_MN5 (XI1_I608_I223_n2 I1_I608_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I223_MN4 (I1_p1_20 XI1_I608_I223_An XI1_I608_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I223_MN2 (XI1_I608_I223_n1 I1_I608_pn20 I1_p1_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I223_MN3 (VSS XI1_I608_I223_Bn XI1_I608_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I223_MN0 (XI1_I608_I223_An I1_I608_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I227_MN1 (XI1_I608_I227_Bn I1_I608_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I227_MN5 (XI1_I608_I227_n2 I1_I608_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I227_MN4 (I1_p1_24 XI1_I608_I227_An XI1_I608_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I227_MN2 (XI1_I608_I227_n1 I1_I608_pn24 I1_p1_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I227_MN3 (VSS XI1_I608_I227_Bn XI1_I608_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I227_MN0 (XI1_I608_I227_An I1_I608_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I229_MN1 (XI1_I608_I229_Bn I1_I608_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I229_MN5 (XI1_I608_I229_n2 I1_I608_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I229_MN4 (I1_p1_26 XI1_I608_I229_An XI1_I608_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I229_MN2 (XI1_I608_I229_n1 I1_I608_pn26 I1_p1_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I229_MN3 (VSS XI1_I608_I229_Bn XI1_I608_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I229_MN0 (XI1_I608_I229_An I1_I608_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I231_MN1 (XI1_I608_I231_Bn I1_I608_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I231_MN5 (XI1_I608_I231_n2 I1_I608_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I231_MN4 (I1_p1_28 XI1_I608_I231_An XI1_I608_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I231_MN2 (XI1_I608_I231_n1 I1_I608_pn28 I1_p1_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I231_MN3 (VSS XI1_I608_I231_Bn XI1_I608_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I231_MN0 (XI1_I608_I231_An I1_I608_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I62_MN1 (XI1_I608_I62_Bn I1_b1_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I62_MN5 (XI1_I608_I62_n2 I1_b1_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I62_MN4 (I1_I608_pn30 XI1_I608_I62_An XI1_I608_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I62_MN2 (XI1_I608_I62_n1 I1_p0_29 I1_I608_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I62_MN3 (VSS XI1_I608_I62_Bn XI1_I608_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I62_MN0 (XI1_I608_I62_An I1_p0_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I57_MN1 (XI1_I1482_I57_Bn I1_b20_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I57_MN5 (XI1_I1482_I57_n2 I1_b20_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I57_MN4 (I1_I1482_pn25 XI1_I1482_I57_An XI1_I1482_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I57_MN2 (XI1_I1482_I57_n1 I1_p19_24 I1_I1482_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I57_MN3 (VSS XI1_I1482_I57_Bn XI1_I1482_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I57_MN0 (XI1_I1482_I57_An I1_p19_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I33_MN1 (XI1_I1482_I33_Bn I1_b20_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I33_MN5 (XI1_I1482_I33_n2 I1_b20_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I33_MN4 (I1_I1482_pn1 XI1_I1482_I33_An XI1_I1482_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I33_MN2 (XI1_I1482_I33_n1 I1_p19_0 I1_I1482_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I33_MN3 (VSS XI1_I1482_I33_Bn XI1_I1482_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I33_MN0 (XI1_I1482_I33_An I1_p19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I209_MN1 (XI1_I1114_I209_Bn I1_I1114_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I209_MN5 (XI1_I1114_I209_n2 I1_I1114_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I209_MN4 (I1_p12_6 XI1_I1114_I209_An XI1_I1114_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I209_MN2 (XI1_I1114_I209_n1 I1_I1114_pn6 I1_p12_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I209_MN3 (VSS XI1_I1114_I209_Bn XI1_I1114_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I209_MN0 (XI1_I1114_I209_An I1_I1114_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I208_MN1 (XI1_I1114_I208_Bn I1_I1114_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I208_MN5 (XI1_I1114_I208_n2 I1_I1114_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I208_MN4 (I1_p12_5 XI1_I1114_I208_An XI1_I1114_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I208_MN2 (XI1_I1114_I208_n1 I1_I1114_pn5 I1_p12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I208_MN3 (VSS XI1_I1114_I208_Bn XI1_I1114_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I208_MN0 (XI1_I1114_I208_An I1_I1114_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I43_MN1 (XI1_I1114_I43_Bn I1_b12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I43_MN5 (XI1_I1114_I43_n2 I1_b12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I43_MN4 (I1_I1114_pn11 XI1_I1114_I43_An XI1_I1114_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I43_MN2 (XI1_I1114_I43_n1 I1_p11_10 I1_I1114_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I43_MN3 (VSS XI1_I1114_I43_Bn XI1_I1114_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I43_MN0 (XI1_I1114_I43_An I1_p11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I44_MN1 (XI1_I1114_I44_Bn I1_b12_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I44_MN5 (XI1_I1114_I44_n2 I1_b12_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I44_MN4 (I1_I1114_pn12 XI1_I1114_I44_An XI1_I1114_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I44_MN2 (XI1_I1114_I44_n1 I1_p11_11 I1_I1114_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I44_MN3 (VSS XI1_I1114_I44_Bn XI1_I1114_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I44_MN0 (XI1_I1114_I44_An I1_p11_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I48_MN1 (XI1_I1068_I48_Bn I1_b11_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I48_MN5 (XI1_I1068_I48_n2 I1_b11_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I48_MN4 (I1_I1068_pn16 XI1_I1068_I48_An XI1_I1068_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I48_MN2 (XI1_I1068_I48_n1 I1_p10_15 I1_I1068_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I48_MN3 (VSS XI1_I1068_I48_Bn XI1_I1068_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I48_MN0 (XI1_I1068_I48_An I1_p10_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I47_MN1 (XI1_I1068_I47_Bn I1_b11_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I47_MN5 (XI1_I1068_I47_n2 I1_b11_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I47_MN4 (I1_I1068_pn15 XI1_I1068_I47_An XI1_I1068_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I47_MN2 (XI1_I1068_I47_n1 I1_p10_14 I1_I1068_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I47_MN3 (VSS XI1_I1068_I47_Bn XI1_I1068_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I47_MN0 (XI1_I1068_I47_An I1_p10_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I222_MN1 (XI1_I1022_I222_Bn I1_I1022_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I222_MN5 (XI1_I1022_I222_n2 I1_I1022_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I222_MN4 (I1_p10_19 XI1_I1022_I222_An XI1_I1022_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I222_MN2 (XI1_I1022_I222_n1 I1_I1022_pn19 I1_p10_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I222_MN3 (VSS XI1_I1022_I222_Bn XI1_I1022_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I222_MN0 (XI1_I1022_I222_An I1_I1022_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I220_MN1 (XI1_I1022_I220_Bn I1_I1022_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I220_MN5 (XI1_I1022_I220_n2 I1_I1022_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I220_MN4 (I1_p10_17 XI1_I1022_I220_An XI1_I1022_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I220_MN2 (XI1_I1022_I220_n1 I1_I1022_pn17 I1_p10_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I220_MN3 (VSS XI1_I1022_I220_Bn XI1_I1022_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I220_MN0 (XI1_I1022_I220_An I1_I1022_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I221_MN1 (XI1_I1022_I221_Bn I1_I1022_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I221_MN5 (XI1_I1022_I221_n2 I1_I1022_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I221_MN4 (I1_p10_18 XI1_I1022_I221_An XI1_I1022_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I221_MN2 (XI1_I1022_I221_n1 I1_I1022_pn18 I1_p10_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I221_MN3 (VSS XI1_I1022_I221_Bn XI1_I1022_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I221_MN0 (XI1_I1022_I221_An I1_I1022_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I223_MN1 (XI1_I1022_I223_Bn I1_I1022_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I223_MN5 (XI1_I1022_I223_n2 I1_I1022_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I223_MN4 (I1_p10_20 XI1_I1022_I223_An XI1_I1022_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I223_MN2 (XI1_I1022_I223_n1 I1_I1022_pn20 I1_p10_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I223_MN3 (VSS XI1_I1022_I223_Bn XI1_I1022_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I223_MN0 (XI1_I1022_I223_An I1_I1022_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I50_MN1 (XI1_I1022_I50_Bn I1_b10_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I50_MN5 (XI1_I1022_I50_n2 I1_b10_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I50_MN4 (I1_I1022_pn18 XI1_I1022_I50_An XI1_I1022_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I50_MN2 (XI1_I1022_I50_n1 I1_p9_17 I1_I1022_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I50_MN3 (VSS XI1_I1022_I50_Bn XI1_I1022_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I50_MN0 (XI1_I1022_I50_An I1_p9_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I49_MN1 (XI1_I1022_I49_Bn I1_b10_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I49_MN5 (XI1_I1022_I49_n2 I1_b10_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I49_MN4 (I1_I1022_pn17 XI1_I1022_I49_An XI1_I1022_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I49_MN2 (XI1_I1022_I49_n1 I1_p9_16 I1_I1022_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I49_MN3 (VSS XI1_I1022_I49_Bn XI1_I1022_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I49_MN0 (XI1_I1022_I49_An I1_p9_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I220_MN1 (XI1_I976_I220_Bn I1_I976_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I220_MN5 (XI1_I976_I220_n2 I1_I976_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I220_MN4 (I1_p9_17 XI1_I976_I220_An XI1_I976_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I220_MN2 (XI1_I976_I220_n1 I1_I976_pn17 I1_p9_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I220_MN3 (VSS XI1_I976_I220_Bn XI1_I976_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I220_MN0 (XI1_I976_I220_An I1_I976_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I34_MN1 (XI1_I976_I34_Bn I1_b9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I34_MN5 (XI1_I976_I34_n2 I1_b9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I34_MN4 (I1_I976_pn2 XI1_I976_I34_An XI1_I976_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I34_MN2 (XI1_I976_I34_n1 I1_p8_1 I1_I976_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I34_MN3 (VSS XI1_I976_I34_Bn XI1_I976_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I34_MN0 (XI1_I976_I34_An I1_p8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I203_MN1 (XI1_I608_I203_Bn I1_qu31_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I203_MN5 (XI1_I608_I203_n2 I1_qu31_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I203_MN4 (I1_p1_0 XI1_I608_I203_An XI1_I608_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I203_MN2 (XI1_I608_I203_n1 I1_I608_pn0 I1_p1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I203_MN3 (VSS XI1_I608_I203_Bn XI1_I608_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I203_MN0 (XI1_I608_I203_An I1_I608_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I35_MN1 (XI1_I608_I35_Bn I1_b1_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I35_MN5 (XI1_I608_I35_n2 I1_b1_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I35_MN4 (I1_I608_pn3 XI1_I608_I35_An XI1_I608_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I35_MN2 (XI1_I608_I35_n1 I1_p0_2 I1_I608_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I35_MN3 (VSS XI1_I608_I35_Bn XI1_I608_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I35_MN0 (XI1_I608_I35_An I1_p0_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I225_MN1 (XI1_I608_I225_Bn I1_I608_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I225_MN5 (XI1_I608_I225_n2 I1_I608_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I225_MN4 (I1_p1_22 XI1_I608_I225_An XI1_I608_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I225_MN2 (XI1_I608_I225_n1 I1_I608_pn22 I1_p1_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I225_MN3 (VSS XI1_I608_I225_Bn XI1_I608_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I225_MN0 (XI1_I608_I225_An I1_I608_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I221_MN1 (XI1_I1482_I221_Bn I1_I1482_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I221_MN5 (XI1_I1482_I221_n2 I1_I1482_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I221_MN4 (I1_p20_18 XI1_I1482_I221_An XI1_I1482_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I221_MN2 (XI1_I1482_I221_n1 I1_I1482_pn18 I1_p20_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I221_MN3 (VSS XI1_I1482_I221_Bn XI1_I1482_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I221_MN0 (XI1_I1482_I221_An I1_I1482_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I211_MN1 (XI1_I1482_I211_Bn I1_I1482_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I211_MN5 (XI1_I1482_I211_n2 I1_I1482_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I211_MN4 (I1_p20_8 XI1_I1482_I211_An XI1_I1482_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I211_MN2 (XI1_I1482_I211_n1 I1_I1482_pn8 I1_p20_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I211_MN3 (VSS XI1_I1482_I211_Bn XI1_I1482_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I211_MN0 (XI1_I1482_I211_An I1_I1482_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I209_MN1 (XI1_I1482_I209_Bn I1_I1482_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I209_MN5 (XI1_I1482_I209_n2 I1_I1482_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I209_MN4 (I1_p20_6 XI1_I1482_I209_An XI1_I1482_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I209_MN2 (XI1_I1482_I209_n1 I1_I1482_pn6 I1_p20_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I209_MN3 (VSS XI1_I1482_I209_Bn XI1_I1482_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I209_MN0 (XI1_I1482_I209_An I1_I1482_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I205_MN1 (XI1_I1482_I205_Bn I1_I1482_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I205_MN5 (XI1_I1482_I205_n2 I1_I1482_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I205_MN4 (I1_p20_2 XI1_I1482_I205_An XI1_I1482_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I205_MN2 (XI1_I1482_I205_n1 I1_I1482_pn2 I1_p20_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I205_MN3 (VSS XI1_I1482_I205_Bn XI1_I1482_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I205_MN0 (XI1_I1482_I205_An I1_I1482_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I39_MN1 (XI1_I1528_I39_Bn I1_b21_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I39_MN5 (XI1_I1528_I39_n2 I1_b21_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I39_MN4 (I1_I1528_pn7 XI1_I1528_I39_An XI1_I1528_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I39_MN2 (XI1_I1528_I39_n1 I1_p20_6 I1_I1528_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I39_MN3 (VSS XI1_I1528_I39_Bn XI1_I1528_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I39_MN0 (XI1_I1528_I39_An I1_p20_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I204_MN1 (XI1_I1482_I204_Bn I1_I1482_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I204_MN5 (XI1_I1482_I204_n2 I1_I1482_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I204_MN4 (I1_p20_1 XI1_I1482_I204_An XI1_I1482_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I204_MN2 (XI1_I1482_I204_n1 I1_I1482_pn1 I1_p20_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I204_MN3 (VSS XI1_I1482_I204_Bn XI1_I1482_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I204_MN0 (XI1_I1482_I204_An I1_I1482_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I205_MN1 (XI1_I1114_I205_Bn I1_I1114_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I205_MN5 (XI1_I1114_I205_n2 I1_I1114_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I205_MN4 (I1_p12_2 XI1_I1114_I205_An XI1_I1114_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I205_MN2 (XI1_I1114_I205_n1 I1_I1114_pn2 I1_p12_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I205_MN3 (VSS XI1_I1114_I205_Bn XI1_I1114_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I205_MN0 (XI1_I1114_I205_An I1_I1114_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I204_MN1 (XI1_I1114_I204_Bn I1_I1114_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I204_MN5 (XI1_I1114_I204_n2 I1_I1114_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I204_MN4 (I1_p12_1 XI1_I1114_I204_An XI1_I1114_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I204_MN2 (XI1_I1114_I204_n1 I1_I1114_pn1 I1_p12_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I204_MN3 (VSS XI1_I1114_I204_Bn XI1_I1114_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I204_MN0 (XI1_I1114_I204_An I1_I1114_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I46_MN1 (XI1_I1068_I46_Bn I1_b11_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I46_MN5 (XI1_I1068_I46_n2 I1_b11_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I46_MN4 (I1_I1068_pn14 XI1_I1068_I46_An XI1_I1068_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I46_MN2 (XI1_I1068_I46_n1 I1_p10_13 I1_I1068_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I46_MN3 (VSS XI1_I1068_I46_Bn XI1_I1068_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I46_MN0 (XI1_I1068_I46_An I1_p10_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I48_MN1 (XI1_I1022_I48_Bn I1_b10_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I48_MN5 (XI1_I1022_I48_n2 I1_b10_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I48_MN4 (I1_I1022_pn16 XI1_I1022_I48_An XI1_I1022_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I48_MN2 (XI1_I1022_I48_n1 I1_p9_15 I1_I1022_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I48_MN3 (VSS XI1_I1022_I48_Bn XI1_I1022_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I48_MN0 (XI1_I1022_I48_An I1_p9_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I47_MN1 (XI1_I1022_I47_Bn I1_b10_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I47_MN5 (XI1_I1022_I47_n2 I1_b10_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I47_MN4 (I1_I1022_pn15 XI1_I1022_I47_An XI1_I1022_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I47_MN2 (XI1_I1022_I47_n1 I1_p9_14 I1_I1022_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I47_MN3 (VSS XI1_I1022_I47_Bn XI1_I1022_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I47_MN0 (XI1_I1022_I47_An I1_p9_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I210_MN1 (XI1_I976_I210_Bn I1_I976_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I210_MN5 (XI1_I976_I210_n2 I1_I976_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I210_MN4 (I1_p9_7 XI1_I976_I210_An XI1_I976_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I210_MN2 (XI1_I976_I210_n1 I1_I976_pn7 I1_p9_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I210_MN3 (VSS XI1_I976_I210_Bn XI1_I976_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I210_MN0 (XI1_I976_I210_An I1_I976_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I208_MN1 (XI1_I976_I208_Bn I1_I976_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I208_MN5 (XI1_I976_I208_n2 I1_I976_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I208_MN4 (I1_p9_5 XI1_I976_I208_An XI1_I976_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I208_MN2 (XI1_I976_I208_n1 I1_I976_pn5 I1_p9_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I208_MN3 (VSS XI1_I976_I208_Bn XI1_I976_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I208_MN0 (XI1_I976_I208_An I1_I976_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I203_MN1 (XI1_I930_I203_Bn I1_qu24_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I203_MN5 (XI1_I930_I203_n2 I1_qu24_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I203_MN4 (I1_p8_0 XI1_I930_I203_An XI1_I930_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I203_MN2 (XI1_I930_I203_n1 I1_I930_pn0 I1_p8_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I203_MN3 (VSS XI1_I930_I203_Bn XI1_I930_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I203_MN0 (XI1_I930_I203_An I1_I930_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I32_MN1 (XI1_I608_I32_Bn I1_b1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I32_MN5 (XI1_I608_I32_n2 I1_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I32_MN4 (I1_I608_pn0 XI1_I608_I32_An XI1_I608_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I32_MN2 (XI1_I608_I32_n1 I1_aa30 I1_I608_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I32_MN3 (VSS XI1_I608_I32_Bn XI1_I608_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I32_MN0 (XI1_I608_I32_An I1_aa30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I36_MN1 (XI1_I608_I36_Bn I1_b1_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I36_MN5 (XI1_I608_I36_n2 I1_b1_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I36_MN4 (I1_I608_pn4 XI1_I608_I36_An XI1_I608_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I36_MN2 (XI1_I608_I36_n1 I1_p0_3 I1_I608_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I36_MN3 (VSS XI1_I608_I36_Bn XI1_I608_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I36_MN0 (XI1_I608_I36_An I1_p0_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I38_MN1 (XI1_I608_I38_Bn I1_b1_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I38_MN5 (XI1_I608_I38_n2 I1_b1_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I38_MN4 (I1_I608_pn6 XI1_I608_I38_An XI1_I608_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I38_MN2 (XI1_I608_I38_n1 I1_p0_5 I1_I608_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I38_MN3 (VSS XI1_I608_I38_Bn XI1_I608_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I38_MN0 (XI1_I608_I38_An I1_p0_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I63_MN1 (XI1_I608_I63_Bn I1_b1_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I63_MN5 (XI1_I608_I63_n2 I1_b1_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I63_MN4 (I1_I608_pn31 XI1_I608_I63_An XI1_I608_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I63_MN2 (XI1_I608_I63_n1 I1_p0_30 I1_I608_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I63_MN3 (VSS XI1_I608_I63_Bn XI1_I608_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I63_MN0 (XI1_I608_I63_An I1_p0_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I58_MN1 (XI1_I1482_I58_Bn I1_b20_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I58_MN5 (XI1_I1482_I58_n2 I1_b20_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I58_MN4 (I1_I1482_pn26 XI1_I1482_I58_An XI1_I1482_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I58_MN2 (XI1_I1482_I58_n1 I1_p19_25 I1_I1482_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I58_MN3 (VSS XI1_I1482_I58_Bn XI1_I1482_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I58_MN0 (XI1_I1482_I58_An I1_p19_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I225_MN1 (XI1_I1482_I225_Bn I1_I1482_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I225_MN5 (XI1_I1482_I225_n2 I1_I1482_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I225_MN4 (I1_p20_22 XI1_I1482_I225_An XI1_I1482_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I225_MN2 (XI1_I1482_I225_n1 I1_I1482_pn22 I1_p20_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I225_MN3 (VSS XI1_I1482_I225_Bn XI1_I1482_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I225_MN0 (XI1_I1482_I225_An I1_I1482_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I223_MN1 (XI1_I1482_I223_Bn I1_I1482_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I223_MN5 (XI1_I1482_I223_n2 I1_I1482_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I223_MN4 (I1_p20_20 XI1_I1482_I223_An XI1_I1482_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I223_MN2 (XI1_I1482_I223_n1 I1_I1482_pn20 I1_p20_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I223_MN3 (VSS XI1_I1482_I223_Bn XI1_I1482_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I223_MN0 (XI1_I1482_I223_An I1_I1482_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I208_MN1 (XI1_I1482_I208_Bn I1_I1482_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I208_MN5 (XI1_I1482_I208_n2 I1_I1482_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I208_MN4 (I1_p20_5 XI1_I1482_I208_An XI1_I1482_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I208_MN2 (XI1_I1482_I208_n1 I1_I1482_pn5 I1_p20_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I208_MN3 (VSS XI1_I1482_I208_Bn XI1_I1482_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I208_MN0 (XI1_I1482_I208_An I1_I1482_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I41_MN1 (XI1_I1528_I41_Bn I1_b21_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I41_MN5 (XI1_I1528_I41_n2 I1_b21_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I41_MN4 (I1_I1528_pn9 XI1_I1528_I41_An XI1_I1528_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I41_MN2 (XI1_I1528_I41_n1 I1_p20_8 I1_I1528_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I41_MN3 (VSS XI1_I1528_I41_Bn XI1_I1528_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I41_MN0 (XI1_I1528_I41_An I1_p20_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I41_MN1 (XI1_I1114_I41_Bn I1_b12_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I41_MN5 (XI1_I1114_I41_n2 I1_b12_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I41_MN4 (I1_I1114_pn9 XI1_I1114_I41_An XI1_I1114_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I41_MN2 (XI1_I1114_I41_n1 I1_p11_8 I1_I1114_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I41_MN3 (VSS XI1_I1114_I41_Bn XI1_I1114_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I41_MN0 (XI1_I1114_I41_An I1_p11_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I42_MN1 (XI1_I1114_I42_Bn I1_b12_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I42_MN5 (XI1_I1114_I42_n2 I1_b12_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I42_MN4 (I1_I1114_pn10 XI1_I1114_I42_An XI1_I1114_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I42_MN2 (XI1_I1114_I42_n1 I1_p11_9 I1_I1114_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I42_MN3 (VSS XI1_I1114_I42_Bn XI1_I1114_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I42_MN0 (XI1_I1114_I42_An I1_p11_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I39_MN1 (XI1_I1114_I39_Bn I1_b12_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I39_MN5 (XI1_I1114_I39_n2 I1_b12_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I39_MN4 (I1_I1114_pn7 XI1_I1114_I39_An XI1_I1114_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I39_MN2 (XI1_I1114_I39_n1 I1_p11_6 I1_I1114_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I39_MN3 (VSS XI1_I1114_I39_Bn XI1_I1114_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I39_MN0 (XI1_I1114_I39_An I1_p11_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I33_MN1 (XI1_I1114_I33_Bn I1_b12_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I33_MN5 (XI1_I1114_I33_n2 I1_b12_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I33_MN4 (I1_I1114_pn1 XI1_I1114_I33_An XI1_I1114_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I33_MN2 (XI1_I1114_I33_n1 I1_p11_0 I1_I1114_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I33_MN3 (VSS XI1_I1114_I33_Bn XI1_I1114_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I33_MN0 (XI1_I1114_I33_An I1_p11_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I211_MN1 (XI1_I1068_I211_Bn I1_I1068_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I211_MN5 (XI1_I1068_I211_n2 I1_I1068_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I211_MN4 (I1_p11_8 XI1_I1068_I211_An XI1_I1068_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I211_MN2 (XI1_I1068_I211_n1 I1_I1068_pn8 I1_p11_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I211_MN3 (VSS XI1_I1068_I211_Bn XI1_I1068_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I211_MN0 (XI1_I1068_I211_An I1_I1068_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I42_MN1 (XI1_I1068_I42_Bn I1_b11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I42_MN5 (XI1_I1068_I42_n2 I1_b11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I42_MN4 (I1_I1068_pn10 XI1_I1068_I42_An XI1_I1068_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I42_MN2 (XI1_I1068_I42_n1 I1_p10_9 I1_I1068_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I42_MN3 (VSS XI1_I1068_I42_Bn XI1_I1068_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I42_MN0 (XI1_I1068_I42_An I1_p10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I44_MN1 (XI1_I1068_I44_Bn I1_b11_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I44_MN5 (XI1_I1068_I44_n2 I1_b11_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I44_MN4 (I1_I1068_pn12 XI1_I1068_I44_An XI1_I1068_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I44_MN2 (XI1_I1068_I44_n1 I1_p10_11 I1_I1068_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I44_MN3 (VSS XI1_I1068_I44_Bn XI1_I1068_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I44_MN0 (XI1_I1068_I44_An I1_p10_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I45_MN1 (XI1_I1068_I45_Bn I1_b11_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I45_MN5 (XI1_I1068_I45_n2 I1_b11_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I45_MN4 (I1_I1068_pn13 XI1_I1068_I45_An XI1_I1068_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I45_MN2 (XI1_I1068_I45_n1 I1_p10_12 I1_I1068_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I45_MN3 (VSS XI1_I1068_I45_Bn XI1_I1068_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I45_MN0 (XI1_I1068_I45_An I1_p10_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I46_MN1 (XI1_I1022_I46_Bn I1_b10_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I46_MN5 (XI1_I1022_I46_n2 I1_b10_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I46_MN4 (I1_I1022_pn14 XI1_I1022_I46_An XI1_I1022_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I46_MN2 (XI1_I1022_I46_n1 I1_p9_13 I1_I1022_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I46_MN3 (VSS XI1_I1022_I46_Bn XI1_I1022_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I46_MN0 (XI1_I1022_I46_An I1_p9_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I45_MN1 (XI1_I1022_I45_Bn I1_b10_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I45_MN5 (XI1_I1022_I45_n2 I1_b10_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I45_MN4 (I1_I1022_pn13 XI1_I1022_I45_An XI1_I1022_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I45_MN2 (XI1_I1022_I45_n1 I1_p9_12 I1_I1022_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I45_MN3 (VSS XI1_I1022_I45_Bn XI1_I1022_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I45_MN0 (XI1_I1022_I45_An I1_p9_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I43_MN1 (XI1_I1022_I43_Bn I1_b10_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I43_MN5 (XI1_I1022_I43_n2 I1_b10_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I43_MN4 (I1_I1022_pn11 XI1_I1022_I43_An XI1_I1022_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I43_MN2 (XI1_I1022_I43_n1 I1_p9_10 I1_I1022_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I43_MN3 (VSS XI1_I1022_I43_Bn XI1_I1022_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I43_MN0 (XI1_I1022_I43_An I1_p9_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I204_MN1 (XI1_I976_I204_Bn I1_I976_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I204_MN5 (XI1_I976_I204_n2 I1_I976_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I204_MN4 (I1_p9_1 XI1_I976_I204_An XI1_I976_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I204_MN2 (XI1_I976_I204_n1 I1_I976_pn1 I1_p9_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I204_MN3 (VSS XI1_I976_I204_Bn XI1_I976_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I204_MN0 (XI1_I976_I204_An I1_I976_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I205_MN1 (XI1_I976_I205_Bn I1_I976_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I205_MN5 (XI1_I976_I205_n2 I1_I976_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I205_MN4 (I1_p9_2 XI1_I976_I205_An XI1_I976_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I205_MN2 (XI1_I976_I205_n1 I1_I976_pn2 I1_p9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I205_MN3 (VSS XI1_I976_I205_Bn XI1_I976_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I205_MN0 (XI1_I976_I205_An I1_I976_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I33_MN1 (XI1_I976_I33_Bn I1_b9_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I33_MN5 (XI1_I976_I33_n2 I1_b9_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I33_MN4 (I1_I976_pn1 XI1_I976_I33_An XI1_I976_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I33_MN2 (XI1_I976_I33_n1 I1_p8_0 I1_I976_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I33_MN3 (VSS XI1_I976_I33_Bn XI1_I976_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I33_MN0 (XI1_I976_I33_An I1_p8_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I32_MN1 (XI1_I930_I32_Bn I1_b8_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I32_MN5 (XI1_I930_I32_n2 I1_b8_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I32_MN4 (I1_I930_pn0 XI1_I930_I32_An XI1_I930_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I32_MN2 (XI1_I930_I32_n1 I1_aa23 I1_I930_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I32_MN3 (VSS XI1_I930_I32_Bn XI1_I930_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I32_MN0 (XI1_I930_I32_An I1_aa23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I203_MN1 (XI1_I562_I203_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I203_MN5 (XI1_I562_I203_n2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I203_MN4 (I1_p0_0 XI1_I562_I203_An XI1_I562_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I203_MN2 (XI1_I562_I203_n1 I1_I562_pn0 I1_p0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I203_MN3 (VSS XI1_I562_I203_Bn XI1_I562_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I203_MN0 (XI1_I562_I203_An I1_I562_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I37_MN1 (XI1_I608_I37_Bn I1_b1_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I37_MN5 (XI1_I608_I37_n2 I1_b1_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I37_MN4 (I1_I608_pn5 XI1_I608_I37_An XI1_I608_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I37_MN2 (XI1_I608_I37_n1 I1_p0_4 I1_I608_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I37_MN3 (VSS XI1_I608_I37_Bn XI1_I608_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I37_MN0 (XI1_I608_I37_An I1_p0_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I39_MN1 (XI1_I608_I39_Bn I1_b1_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I39_MN5 (XI1_I608_I39_n2 I1_b1_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I39_MN4 (I1_I608_pn7 XI1_I608_I39_An XI1_I608_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I39_MN2 (XI1_I608_I39_n1 I1_p0_6 I1_I608_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I39_MN3 (VSS XI1_I608_I39_Bn XI1_I608_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I39_MN0 (XI1_I608_I39_An I1_p0_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I41_MN1 (XI1_I608_I41_Bn I1_b1_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I41_MN5 (XI1_I608_I41_n2 I1_b1_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I41_MN4 (I1_I608_pn9 XI1_I608_I41_An XI1_I608_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I41_MN2 (XI1_I608_I41_n1 I1_p0_8 I1_I608_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I41_MN3 (VSS XI1_I608_I41_Bn XI1_I608_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I41_MN0 (XI1_I608_I41_An I1_p0_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I42_MN1 (XI1_I608_I42_Bn I1_b1_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I42_MN5 (XI1_I608_I42_n2 I1_b1_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I42_MN4 (I1_I608_pn10 XI1_I608_I42_An XI1_I608_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I42_MN2 (XI1_I608_I42_n1 I1_p0_9 I1_I608_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I42_MN3 (VSS XI1_I608_I42_Bn XI1_I608_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I42_MN0 (XI1_I608_I42_An I1_p0_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I44_MN1 (XI1_I608_I44_Bn I1_b1_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I44_MN5 (XI1_I608_I44_n2 I1_b1_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I44_MN4 (I1_I608_pn12 XI1_I608_I44_An XI1_I608_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I44_MN2 (XI1_I608_I44_n1 I1_p0_11 I1_I608_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I44_MN3 (VSS XI1_I608_I44_Bn XI1_I608_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I44_MN0 (XI1_I608_I44_An I1_p0_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I46_MN1 (XI1_I608_I46_Bn I1_b1_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I46_MN5 (XI1_I608_I46_n2 I1_b1_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I46_MN4 (I1_I608_pn14 XI1_I608_I46_An XI1_I608_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I46_MN2 (XI1_I608_I46_n1 I1_p0_13 I1_I608_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I46_MN3 (VSS XI1_I608_I46_Bn XI1_I608_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I46_MN0 (XI1_I608_I46_An I1_p0_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I55_MN1 (XI1_I608_I55_Bn I1_b1_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I55_MN5 (XI1_I608_I55_n2 I1_b1_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I55_MN4 (I1_I608_pn23 XI1_I608_I55_An XI1_I608_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I55_MN2 (XI1_I608_I55_n1 I1_p0_22 I1_I608_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I55_MN3 (VSS XI1_I608_I55_Bn XI1_I608_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I55_MN0 (XI1_I608_I55_An I1_p0_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I57_MN1 (XI1_I608_I57_Bn I1_b1_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I57_MN5 (XI1_I608_I57_n2 I1_b1_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I57_MN4 (I1_I608_pn25 XI1_I608_I57_An XI1_I608_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I57_MN2 (XI1_I608_I57_n1 I1_p0_24 I1_I608_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I57_MN3 (VSS XI1_I608_I57_Bn XI1_I608_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I57_MN0 (XI1_I608_I57_An I1_p0_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I60_MN1 (XI1_I608_I60_Bn I1_b1_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I60_MN5 (XI1_I608_I60_n2 I1_b1_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I60_MN4 (I1_I608_pn28 XI1_I608_I60_An XI1_I608_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I60_MN2 (XI1_I608_I60_n1 I1_p0_27 I1_I608_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I60_MN3 (VSS XI1_I608_I60_Bn XI1_I608_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I60_MN0 (XI1_I608_I60_An I1_p0_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I61_MN1 (XI1_I608_I61_Bn I1_b1_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I61_MN5 (XI1_I608_I61_n2 I1_b1_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I61_MN4 (I1_I608_pn29 XI1_I608_I61_An XI1_I608_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I61_MN2 (XI1_I608_I61_n1 I1_p0_28 I1_I608_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I61_MN3 (VSS XI1_I608_I61_Bn XI1_I608_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I61_MN0 (XI1_I608_I61_An I1_p0_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I59_MN1 (XI1_I1482_I59_Bn I1_b20_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I59_MN5 (XI1_I1482_I59_n2 I1_b20_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I59_MN4 (I1_I1482_pn27 XI1_I1482_I59_An XI1_I1482_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I59_MN2 (XI1_I1482_I59_n1 I1_p19_26 I1_I1482_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I59_MN3 (VSS XI1_I1482_I59_Bn XI1_I1482_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I59_MN0 (XI1_I1482_I59_An I1_p19_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I227_MN1 (XI1_I1482_I227_Bn I1_I1482_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I227_MN5 (XI1_I1482_I227_n2 I1_I1482_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I227_MN4 (I1_p20_24 XI1_I1482_I227_An XI1_I1482_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I227_MN2 (XI1_I1482_I227_n1 I1_I1482_pn24 I1_p20_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I227_MN3 (VSS XI1_I1482_I227_Bn XI1_I1482_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I227_MN0 (XI1_I1482_I227_An I1_I1482_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I229_MN1 (XI1_I1482_I229_Bn I1_I1482_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I229_MN5 (XI1_I1482_I229_n2 I1_I1482_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I229_MN4 (I1_p20_26 XI1_I1482_I229_An XI1_I1482_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I229_MN2 (XI1_I1482_I229_n1 I1_I1482_pn26 I1_p20_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I229_MN3 (VSS XI1_I1482_I229_Bn XI1_I1482_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I229_MN0 (XI1_I1482_I229_An I1_I1482_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I220_MN1 (XI1_I1482_I220_Bn I1_I1482_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I220_MN5 (XI1_I1482_I220_n2 I1_I1482_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I220_MN4 (I1_p20_17 XI1_I1482_I220_An XI1_I1482_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I220_MN2 (XI1_I1482_I220_n1 I1_I1482_pn17 I1_p20_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I220_MN3 (VSS XI1_I1482_I220_Bn XI1_I1482_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I220_MN0 (XI1_I1482_I220_An I1_I1482_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I210_MN1 (XI1_I1482_I210_Bn I1_I1482_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I210_MN5 (XI1_I1482_I210_n2 I1_I1482_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I210_MN4 (I1_p20_7 XI1_I1482_I210_An XI1_I1482_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I210_MN2 (XI1_I1482_I210_n1 I1_I1482_pn7 I1_p20_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I210_MN3 (VSS XI1_I1482_I210_Bn XI1_I1482_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I210_MN0 (XI1_I1482_I210_An I1_I1482_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I45_MN1 (XI1_I1528_I45_Bn I1_b21_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I45_MN5 (XI1_I1528_I45_n2 I1_b21_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I45_MN4 (I1_I1528_pn13 XI1_I1528_I45_An XI1_I1528_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I45_MN2 (XI1_I1528_I45_n1 I1_p20_12 I1_I1528_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I45_MN3 (VSS XI1_I1528_I45_Bn XI1_I1528_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I45_MN0 (XI1_I1528_I45_An I1_p20_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I43_MN1 (XI1_I1528_I43_Bn I1_b21_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I43_MN5 (XI1_I1528_I43_n2 I1_b21_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I43_MN4 (I1_I1528_pn11 XI1_I1528_I43_An XI1_I1528_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I43_MN2 (XI1_I1528_I43_n1 I1_p20_10 I1_I1528_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I43_MN3 (VSS XI1_I1528_I43_Bn XI1_I1528_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I43_MN0 (XI1_I1528_I43_An I1_p20_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I42_MN1 (XI1_I1528_I42_Bn I1_b21_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I42_MN5 (XI1_I1528_I42_n2 I1_b21_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I42_MN4 (I1_I1528_pn10 XI1_I1528_I42_An XI1_I1528_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I42_MN2 (XI1_I1528_I42_n1 I1_p20_9 I1_I1528_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I42_MN3 (VSS XI1_I1528_I42_Bn XI1_I1528_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I42_MN0 (XI1_I1528_I42_An I1_p20_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I38_MN1 (XI1_I1528_I38_Bn I1_b21_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I38_MN5 (XI1_I1528_I38_n2 I1_b21_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I38_MN4 (I1_I1528_pn6 XI1_I1528_I38_An XI1_I1528_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I38_MN2 (XI1_I1528_I38_n1 I1_p20_5 I1_I1528_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I38_MN3 (VSS XI1_I1528_I38_Bn XI1_I1528_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I38_MN0 (XI1_I1528_I38_An I1_p20_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I40_MN1 (XI1_I1528_I40_Bn I1_b21_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I40_MN5 (XI1_I1528_I40_n2 I1_b21_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I40_MN4 (I1_I1528_pn8 XI1_I1528_I40_An XI1_I1528_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I40_MN2 (XI1_I1528_I40_n1 I1_p20_7 I1_I1528_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I40_MN3 (VSS XI1_I1528_I40_Bn XI1_I1528_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I40_MN0 (XI1_I1528_I40_An I1_p20_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I32_MN1 (XI1_I1482_I32_Bn I1_b20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I32_MN5 (XI1_I1482_I32_n2 I1_b20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I32_MN4 (I1_I1482_pn0 XI1_I1482_I32_An XI1_I1482_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I32_MN2 (XI1_I1482_I32_n1 I1_aa11 I1_I1482_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I32_MN3 (VSS XI1_I1482_I32_Bn XI1_I1482_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I32_MN0 (XI1_I1482_I32_An I1_aa11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I40_MN1 (XI1_I1114_I40_Bn I1_b12_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I40_MN5 (XI1_I1114_I40_n2 I1_b12_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I40_MN4 (I1_I1114_pn8 XI1_I1114_I40_An XI1_I1114_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I40_MN2 (XI1_I1114_I40_n1 I1_p11_7 I1_I1114_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I40_MN3 (VSS XI1_I1114_I40_Bn XI1_I1114_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I40_MN0 (XI1_I1114_I40_An I1_p11_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I210_MN1 (XI1_I1068_I210_Bn I1_I1068_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I210_MN5 (XI1_I1068_I210_n2 I1_I1068_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I210_MN4 (I1_p11_7 XI1_I1068_I210_An XI1_I1068_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I210_MN2 (XI1_I1068_I210_n1 I1_I1068_pn7 I1_p11_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I210_MN3 (VSS XI1_I1068_I210_Bn XI1_I1068_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I210_MN0 (XI1_I1068_I210_An I1_I1068_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I209_MN1 (XI1_I1068_I209_Bn I1_I1068_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I209_MN5 (XI1_I1068_I209_n2 I1_I1068_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I209_MN4 (I1_p11_6 XI1_I1068_I209_An XI1_I1068_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I209_MN2 (XI1_I1068_I209_n1 I1_I1068_pn6 I1_p11_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I209_MN3 (VSS XI1_I1068_I209_Bn XI1_I1068_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I209_MN0 (XI1_I1068_I209_An I1_I1068_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I41_MN1 (XI1_I1068_I41_Bn I1_b11_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I41_MN5 (XI1_I1068_I41_n2 I1_b11_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I41_MN4 (I1_I1068_pn9 XI1_I1068_I41_An XI1_I1068_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I41_MN2 (XI1_I1068_I41_n1 I1_p10_8 I1_I1068_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I41_MN3 (VSS XI1_I1068_I41_Bn XI1_I1068_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I41_MN0 (XI1_I1068_I41_An I1_p10_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I43_MN1 (XI1_I1068_I43_Bn I1_b11_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I43_MN5 (XI1_I1068_I43_n2 I1_b11_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I43_MN4 (I1_I1068_pn11 XI1_I1068_I43_An XI1_I1068_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I43_MN2 (XI1_I1068_I43_n1 I1_p10_10 I1_I1068_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I43_MN3 (VSS XI1_I1068_I43_Bn XI1_I1068_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I43_MN0 (XI1_I1068_I43_An I1_p10_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I32_MN1 (XI1_I1114_I32_Bn I1_b12_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I32_MN5 (XI1_I1114_I32_n2 I1_b12_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I32_MN4 (I1_I1114_pn0 XI1_I1114_I32_An XI1_I1114_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I32_MN2 (XI1_I1114_I32_n1 I1_aa19 I1_I1114_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I32_MN3 (VSS XI1_I1114_I32_Bn XI1_I1114_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I32_MN0 (XI1_I1114_I32_An I1_aa19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I211_MN1 (XI1_I1022_I211_Bn I1_I1022_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I211_MN5 (XI1_I1022_I211_n2 I1_I1022_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I211_MN4 (I1_p10_8 XI1_I1022_I211_An XI1_I1022_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I211_MN2 (XI1_I1022_I211_n1 I1_I1022_pn8 I1_p10_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I211_MN3 (VSS XI1_I1022_I211_Bn XI1_I1022_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I211_MN0 (XI1_I1022_I211_An I1_I1022_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I40_MN1 (XI1_I1022_I40_Bn I1_b10_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I40_MN5 (XI1_I1022_I40_n2 I1_b10_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I40_MN4 (I1_I1022_pn8 XI1_I1022_I40_An XI1_I1022_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I40_MN2 (XI1_I1022_I40_n1 I1_p9_7 I1_I1022_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I40_MN3 (VSS XI1_I1022_I40_Bn XI1_I1022_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I40_MN0 (XI1_I1022_I40_An I1_p9_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I44_MN1 (XI1_I1022_I44_Bn I1_b10_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I44_MN5 (XI1_I1022_I44_n2 I1_b10_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I44_MN4 (I1_I1022_pn12 XI1_I1022_I44_An XI1_I1022_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I44_MN2 (XI1_I1022_I44_n1 I1_p9_11 I1_I1022_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I44_MN3 (VSS XI1_I1022_I44_Bn XI1_I1022_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I44_MN0 (XI1_I1022_I44_An I1_p9_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I41_MN1 (XI1_I1022_I41_Bn I1_b10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I41_MN5 (XI1_I1022_I41_n2 I1_b10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I41_MN4 (I1_I1022_pn9 XI1_I1022_I41_An XI1_I1022_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I41_MN2 (XI1_I1022_I41_n1 I1_p9_8 I1_I1022_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I41_MN3 (VSS XI1_I1022_I41_Bn XI1_I1022_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I41_MN0 (XI1_I1022_I41_An I1_p9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I42_MN1 (XI1_I1022_I42_Bn I1_b10_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I42_MN5 (XI1_I1022_I42_n2 I1_b10_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I42_MN4 (I1_I1022_pn10 XI1_I1022_I42_An XI1_I1022_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I42_MN2 (XI1_I1022_I42_n1 I1_p9_9 I1_I1022_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I42_MN3 (VSS XI1_I1022_I42_Bn XI1_I1022_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I42_MN0 (XI1_I1022_I42_An I1_p9_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I33_MN1 (XI1_I562_I33_Bn I1_b0_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I33_MN5 (XI1_I562_I33_n2 I1_b0_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I33_MN4 (I1_I562_pn1 XI1_I562_I33_An XI1_I562_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I33_MN2 (XI1_I562_I33_n1 VSS I1_I562_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I33_MN3 (VSS XI1_I562_I33_Bn XI1_I562_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I33_MN0 (XI1_I562_I33_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I204_MN1 (XI1_I562_I204_Bn I1_I562_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I204_MN5 (XI1_I562_I204_n2 I1_I562_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I204_MN4 (I1_p0_1 XI1_I562_I204_An XI1_I562_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I204_MN2 (XI1_I562_I204_n1 I1_I562_pn1 I1_p0_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I204_MN3 (VSS XI1_I562_I204_Bn XI1_I562_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I204_MN0 (XI1_I562_I204_An I1_I562_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I43_MN1 (XI1_I608_I43_Bn I1_b1_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I43_MN5 (XI1_I608_I43_n2 I1_b1_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I43_MN4 (I1_I608_pn11 XI1_I608_I43_An XI1_I608_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I43_MN2 (XI1_I608_I43_n1 I1_p0_10 I1_I608_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I43_MN3 (VSS XI1_I608_I43_Bn XI1_I608_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I43_MN0 (XI1_I608_I43_An I1_p0_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I45_MN1 (XI1_I608_I45_Bn I1_b1_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I45_MN5 (XI1_I608_I45_n2 I1_b1_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I45_MN4 (I1_I608_pn13 XI1_I608_I45_An XI1_I608_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I45_MN2 (XI1_I608_I45_n1 I1_p0_12 I1_I608_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I45_MN3 (VSS XI1_I608_I45_Bn XI1_I608_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I45_MN0 (XI1_I608_I45_An I1_p0_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I47_MN1 (XI1_I608_I47_Bn I1_b1_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I47_MN5 (XI1_I608_I47_n2 I1_b1_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I47_MN4 (I1_I608_pn15 XI1_I608_I47_An XI1_I608_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I47_MN2 (XI1_I608_I47_n1 I1_p0_14 I1_I608_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I47_MN3 (VSS XI1_I608_I47_Bn XI1_I608_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I47_MN0 (XI1_I608_I47_An I1_p0_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I48_MN1 (XI1_I608_I48_Bn I1_b1_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I48_MN5 (XI1_I608_I48_n2 I1_b1_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I48_MN4 (I1_I608_pn16 XI1_I608_I48_An XI1_I608_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I48_MN2 (XI1_I608_I48_n1 I1_p0_15 I1_I608_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I48_MN3 (VSS XI1_I608_I48_Bn XI1_I608_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I48_MN0 (XI1_I608_I48_An I1_p0_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I50_MN1 (XI1_I608_I50_Bn I1_b1_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I50_MN5 (XI1_I608_I50_n2 I1_b1_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I50_MN4 (I1_I608_pn18 XI1_I608_I50_An XI1_I608_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I50_MN2 (XI1_I608_I50_n1 I1_p0_17 I1_I608_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I50_MN3 (VSS XI1_I608_I50_Bn XI1_I608_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I50_MN0 (XI1_I608_I50_An I1_p0_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I51_MN1 (XI1_I608_I51_Bn I1_b1_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I51_MN5 (XI1_I608_I51_n2 I1_b1_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I51_MN4 (I1_I608_pn19 XI1_I608_I51_An XI1_I608_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I51_MN2 (XI1_I608_I51_n1 I1_p0_18 I1_I608_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I51_MN3 (VSS XI1_I608_I51_Bn XI1_I608_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I51_MN0 (XI1_I608_I51_An I1_p0_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I52_MN1 (XI1_I608_I52_Bn I1_b1_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I52_MN5 (XI1_I608_I52_n2 I1_b1_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I52_MN4 (I1_I608_pn20 XI1_I608_I52_An XI1_I608_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I52_MN2 (XI1_I608_I52_n1 I1_p0_19 I1_I608_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I52_MN3 (VSS XI1_I608_I52_Bn XI1_I608_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I52_MN0 (XI1_I608_I52_An I1_p0_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I53_MN1 (XI1_I608_I53_Bn I1_b1_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I53_MN5 (XI1_I608_I53_n2 I1_b1_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I53_MN4 (I1_I608_pn21 XI1_I608_I53_An XI1_I608_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I53_MN2 (XI1_I608_I53_n1 I1_p0_20 I1_I608_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I53_MN3 (VSS XI1_I608_I53_Bn XI1_I608_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I53_MN0 (XI1_I608_I53_An I1_p0_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I54_MN1 (XI1_I608_I54_Bn I1_b1_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I54_MN5 (XI1_I608_I54_n2 I1_b1_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I54_MN4 (I1_I608_pn22 XI1_I608_I54_An XI1_I608_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I54_MN2 (XI1_I608_I54_n1 I1_p0_21 I1_I608_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I54_MN3 (VSS XI1_I608_I54_Bn XI1_I608_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I54_MN0 (XI1_I608_I54_An I1_p0_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I56_MN1 (XI1_I608_I56_Bn I1_b1_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I56_MN5 (XI1_I608_I56_n2 I1_b1_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I56_MN4 (I1_I608_pn24 XI1_I608_I56_An XI1_I608_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I56_MN2 (XI1_I608_I56_n1 I1_p0_23 I1_I608_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I56_MN3 (VSS XI1_I608_I56_Bn XI1_I608_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I56_MN0 (XI1_I608_I56_An I1_p0_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I59_MN1 (XI1_I608_I59_Bn I1_b1_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I59_MN5 (XI1_I608_I59_n2 I1_b1_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I59_MN4 (I1_I608_pn27 XI1_I608_I59_An XI1_I608_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I59_MN2 (XI1_I608_I59_n1 I1_p0_26 I1_I608_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I59_MN3 (VSS XI1_I608_I59_Bn XI1_I608_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I59_MN0 (XI1_I608_I59_An I1_p0_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I60_MN1 (XI1_I1482_I60_Bn I1_b20_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I60_MN5 (XI1_I1482_I60_n2 I1_b20_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I60_MN4 (I1_I1482_pn28 XI1_I1482_I60_An XI1_I1482_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I60_MN2 (XI1_I1482_I60_n1 I1_p19_27 I1_I1482_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I60_MN3 (VSS XI1_I1482_I60_Bn XI1_I1482_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I60_MN0 (XI1_I1482_I60_An I1_p19_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I228_MN1 (XI1_I1482_I228_Bn I1_I1482_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I228_MN5 (XI1_I1482_I228_n2 I1_I1482_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I228_MN4 (I1_p20_25 XI1_I1482_I228_An XI1_I1482_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I228_MN2 (XI1_I1482_I228_n1 I1_I1482_pn25 I1_p20_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I228_MN3 (VSS XI1_I1482_I228_Bn XI1_I1482_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I228_MN0 (XI1_I1482_I228_An I1_I1482_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I49_MN1 (XI1_I1528_I49_Bn I1_b21_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I49_MN5 (XI1_I1528_I49_n2 I1_b21_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I49_MN4 (I1_I1528_pn17 XI1_I1528_I49_An XI1_I1528_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I49_MN2 (XI1_I1528_I49_n1 I1_p20_16 I1_I1528_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I49_MN3 (VSS XI1_I1528_I49_Bn XI1_I1528_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I49_MN0 (XI1_I1528_I49_An I1_p20_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I47_MN1 (XI1_I1528_I47_Bn I1_b21_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I47_MN5 (XI1_I1528_I47_n2 I1_b21_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I47_MN4 (I1_I1528_pn15 XI1_I1528_I47_An XI1_I1528_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I47_MN2 (XI1_I1528_I47_n1 I1_p20_14 I1_I1528_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I47_MN3 (VSS XI1_I1528_I47_Bn XI1_I1528_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I47_MN0 (XI1_I1528_I47_An I1_p20_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I46_MN1 (XI1_I1528_I46_Bn I1_b21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I46_MN5 (XI1_I1528_I46_n2 I1_b21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I46_MN4 (I1_I1528_pn14 XI1_I1528_I46_An XI1_I1528_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I46_MN2 (XI1_I1528_I46_n1 I1_p20_13 I1_I1528_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I46_MN3 (VSS XI1_I1528_I46_Bn XI1_I1528_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I46_MN0 (XI1_I1528_I46_An I1_p20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I44_MN1 (XI1_I1528_I44_Bn I1_b21_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I44_MN5 (XI1_I1528_I44_n2 I1_b21_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I44_MN4 (I1_I1528_pn12 XI1_I1528_I44_An XI1_I1528_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I44_MN2 (XI1_I1528_I44_n1 I1_p20_11 I1_I1528_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I44_MN3 (VSS XI1_I1528_I44_Bn XI1_I1528_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I44_MN0 (XI1_I1528_I44_An I1_p20_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I37_MN1 (XI1_I1528_I37_Bn I1_b21_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I37_MN5 (XI1_I1528_I37_n2 I1_b21_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I37_MN4 (I1_I1528_pn5 XI1_I1528_I37_An XI1_I1528_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I37_MN2 (XI1_I1528_I37_n1 I1_p20_4 I1_I1528_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I37_MN3 (VSS XI1_I1528_I37_Bn XI1_I1528_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I37_MN0 (XI1_I1528_I37_An I1_p20_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I36_MN1 (XI1_I1528_I36_Bn I1_b21_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I36_MN5 (XI1_I1528_I36_n2 I1_b21_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I36_MN4 (I1_I1528_pn4 XI1_I1528_I36_An XI1_I1528_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I36_MN2 (XI1_I1528_I36_n1 I1_p20_3 I1_I1528_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I36_MN3 (VSS XI1_I1528_I36_Bn XI1_I1528_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I36_MN0 (XI1_I1528_I36_An I1_p20_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I35_MN1 (XI1_I1528_I35_Bn I1_b21_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I35_MN5 (XI1_I1528_I35_n2 I1_b21_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I35_MN4 (I1_I1528_pn3 XI1_I1528_I35_An XI1_I1528_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I35_MN2 (XI1_I1528_I35_n1 I1_p20_2 I1_I1528_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I35_MN3 (VSS XI1_I1528_I35_Bn XI1_I1528_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I35_MN0 (XI1_I1528_I35_An I1_p20_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I203_MN1 (XI1_I1482_I203_Bn I1_qu12_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I203_MN5 (XI1_I1482_I203_n2 I1_qu12_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I203_MN4 (I1_p20_0 XI1_I1482_I203_An XI1_I1482_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I203_MN2 (XI1_I1482_I203_n1 I1_I1482_pn0 I1_p20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I203_MN3 (VSS XI1_I1482_I203_Bn XI1_I1482_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I203_MN0 (XI1_I1482_I203_An I1_I1482_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I38_MN1 (XI1_I1114_I38_Bn I1_b12_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I38_MN5 (XI1_I1114_I38_n2 I1_b12_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I38_MN4 (I1_I1114_pn6 XI1_I1114_I38_An XI1_I1114_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I38_MN2 (XI1_I1114_I38_n1 I1_p11_5 I1_I1114_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I38_MN3 (VSS XI1_I1114_I38_Bn XI1_I1114_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I38_MN0 (XI1_I1114_I38_An I1_p11_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I37_MN1 (XI1_I1114_I37_Bn I1_b12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I37_MN5 (XI1_I1114_I37_n2 I1_b12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I37_MN4 (I1_I1114_pn5 XI1_I1114_I37_An XI1_I1114_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I37_MN2 (XI1_I1114_I37_n1 I1_p11_4 I1_I1114_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I37_MN3 (VSS XI1_I1114_I37_Bn XI1_I1114_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I37_MN0 (XI1_I1114_I37_An I1_p11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I36_MN1 (XI1_I1114_I36_Bn I1_b12_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I36_MN5 (XI1_I1114_I36_n2 I1_b12_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I36_MN4 (I1_I1114_pn4 XI1_I1114_I36_An XI1_I1114_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I36_MN2 (XI1_I1114_I36_n1 I1_p11_3 I1_I1114_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I36_MN3 (VSS XI1_I1114_I36_Bn XI1_I1114_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I36_MN0 (XI1_I1114_I36_An I1_p11_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I34_MN1 (XI1_I1114_I34_Bn I1_b12_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I34_MN5 (XI1_I1114_I34_n2 I1_b12_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I34_MN4 (I1_I1114_pn2 XI1_I1114_I34_An XI1_I1114_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I34_MN2 (XI1_I1114_I34_n1 I1_p11_1 I1_I1114_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I34_MN3 (VSS XI1_I1114_I34_Bn XI1_I1114_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I34_MN0 (XI1_I1114_I34_An I1_p11_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I208_MN1 (XI1_I1068_I208_Bn I1_I1068_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I208_MN5 (XI1_I1068_I208_n2 I1_I1068_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I208_MN4 (I1_p11_5 XI1_I1068_I208_An XI1_I1068_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I208_MN2 (XI1_I1068_I208_n1 I1_I1068_pn5 I1_p11_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I208_MN3 (VSS XI1_I1068_I208_Bn XI1_I1068_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I208_MN0 (XI1_I1068_I208_An I1_I1068_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I39_MN1 (XI1_I1068_I39_Bn I1_b11_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I39_MN5 (XI1_I1068_I39_n2 I1_b11_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I39_MN4 (I1_I1068_pn7 XI1_I1068_I39_An XI1_I1068_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I39_MN2 (XI1_I1068_I39_n1 I1_p10_6 I1_I1068_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I39_MN3 (VSS XI1_I1068_I39_Bn XI1_I1068_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I39_MN0 (XI1_I1068_I39_An I1_p10_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I203_MN1 (XI1_I1068_I203_Bn I1_qu21_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I203_MN5 (XI1_I1068_I203_n2 I1_qu21_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I203_MN4 (I1_p11_0 XI1_I1068_I203_An XI1_I1068_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I203_MN2 (XI1_I1068_I203_n1 I1_I1068_pn0 I1_p11_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I203_MN3 (VSS XI1_I1068_I203_Bn XI1_I1068_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I203_MN0 (XI1_I1068_I203_An I1_I1068_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I210_MN1 (XI1_I1022_I210_Bn I1_I1022_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I210_MN5 (XI1_I1022_I210_n2 I1_I1022_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I210_MN4 (I1_p10_7 XI1_I1022_I210_An XI1_I1022_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I210_MN2 (XI1_I1022_I210_n1 I1_I1022_pn7 I1_p10_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I210_MN3 (VSS XI1_I1022_I210_Bn XI1_I1022_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I210_MN0 (XI1_I1022_I210_An I1_I1022_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I209_MN1 (XI1_I1022_I209_Bn I1_I1022_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I209_MN5 (XI1_I1022_I209_n2 I1_I1022_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I209_MN4 (I1_p10_6 XI1_I1022_I209_An XI1_I1022_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I209_MN2 (XI1_I1022_I209_n1 I1_I1022_pn6 I1_p10_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I209_MN3 (VSS XI1_I1022_I209_Bn XI1_I1022_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I209_MN0 (XI1_I1022_I209_An I1_I1022_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I38_MN1 (XI1_I1022_I38_Bn I1_b10_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I38_MN5 (XI1_I1022_I38_n2 I1_b10_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I38_MN4 (I1_I1022_pn6 XI1_I1022_I38_An XI1_I1022_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I38_MN2 (XI1_I1022_I38_n1 I1_p9_5 I1_I1022_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I38_MN3 (VSS XI1_I1022_I38_Bn XI1_I1022_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I38_MN0 (XI1_I1022_I38_An I1_p9_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I39_MN1 (XI1_I1022_I39_Bn I1_b10_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I39_MN5 (XI1_I1022_I39_n2 I1_b10_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I39_MN4 (I1_I1022_pn7 XI1_I1022_I39_An XI1_I1022_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I39_MN2 (XI1_I1022_I39_n1 I1_p9_6 I1_I1022_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I39_MN3 (VSS XI1_I1022_I39_Bn XI1_I1022_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I39_MN0 (XI1_I1022_I39_An I1_p9_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I37_MN1 (XI1_I1022_I37_Bn I1_b10_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I37_MN5 (XI1_I1022_I37_n2 I1_b10_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I37_MN4 (I1_I1022_pn5 XI1_I1022_I37_An XI1_I1022_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I37_MN2 (XI1_I1022_I37_n1 I1_p9_4 I1_I1022_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I37_MN3 (VSS XI1_I1022_I37_Bn XI1_I1022_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I37_MN0 (XI1_I1022_I37_An I1_p9_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I34_MN1 (XI1_I562_I34_Bn I1_b0_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I34_MN5 (XI1_I562_I34_n2 I1_b0_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I34_MN4 (I1_I562_pn2 XI1_I562_I34_An XI1_I562_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I34_MN2 (XI1_I562_I34_n1 VSS I1_I562_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I34_MN3 (VSS XI1_I562_I34_Bn XI1_I562_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I34_MN0 (XI1_I562_I34_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I205_MN1 (XI1_I562_I205_Bn I1_I562_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I205_MN5 (XI1_I562_I205_n2 I1_I562_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I205_MN4 (I1_p0_2 XI1_I562_I205_An XI1_I562_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I205_MN2 (XI1_I562_I205_n1 I1_I562_pn2 I1_p0_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I205_MN3 (VSS XI1_I562_I205_Bn XI1_I562_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I205_MN0 (XI1_I562_I205_An I1_I562_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I40_MN1 (XI1_I608_I40_Bn I1_b1_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I40_MN5 (XI1_I608_I40_n2 I1_b1_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I40_MN4 (I1_I608_pn8 XI1_I608_I40_An XI1_I608_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I40_MN2 (XI1_I608_I40_n1 I1_p0_7 I1_I608_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I40_MN3 (VSS XI1_I608_I40_Bn XI1_I608_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I40_MN0 (XI1_I608_I40_An I1_p0_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I43_MN1 (XI1_I562_I43_Bn I1_b0_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I43_MN5 (XI1_I562_I43_n2 I1_b0_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I43_MN4 (I1_I562_pn11 XI1_I562_I43_An XI1_I562_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I43_MN2 (XI1_I562_I43_n1 VSS I1_I562_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I43_MN3 (VSS XI1_I562_I43_Bn XI1_I562_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I43_MN0 (XI1_I562_I43_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I49_MN1 (XI1_I608_I49_Bn I1_b1_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I49_MN5 (XI1_I608_I49_n2 I1_b1_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I49_MN4 (I1_I608_pn17 XI1_I608_I49_An XI1_I608_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I49_MN2 (XI1_I608_I49_n1 I1_p0_16 I1_I608_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I49_MN3 (VSS XI1_I608_I49_Bn XI1_I608_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I49_MN0 (XI1_I608_I49_An I1_p0_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I58_MN1 (XI1_I608_I58_Bn I1_b1_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I608_I58_MN5 (XI1_I608_I58_n2 I1_b1_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I58_MN4 (I1_I608_pn26 XI1_I608_I58_An XI1_I608_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I58_MN2 (XI1_I608_I58_n1 I1_p0_25 I1_I608_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I58_MN3 (VSS XI1_I608_I58_Bn XI1_I608_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I58_MN0 (XI1_I608_I58_An I1_p0_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I61_MN1 (XI1_I1482_I61_Bn I1_b20_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I61_MN5 (XI1_I1482_I61_n2 I1_b20_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I61_MN4 (I1_I1482_pn29 XI1_I1482_I61_An XI1_I1482_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I61_MN2 (XI1_I1482_I61_n1 I1_p19_28 I1_I1482_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I61_MN3 (VSS XI1_I1482_I61_Bn XI1_I1482_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I61_MN0 (XI1_I1482_I61_An I1_p19_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I231_MN1 (XI1_I1482_I231_Bn I1_I1482_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I231_MN5 (XI1_I1482_I231_n2 I1_I1482_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I231_MN4 (I1_p20_28 XI1_I1482_I231_An XI1_I1482_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I231_MN2 (XI1_I1482_I231_n1 I1_I1482_pn28 I1_p20_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I231_MN3 (VSS XI1_I1482_I231_Bn XI1_I1482_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I231_MN0 (XI1_I1482_I231_An I1_I1482_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I230_MN1 (XI1_I1482_I230_Bn I1_I1482_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I230_MN5 (XI1_I1482_I230_n2 I1_I1482_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I230_MN4 (I1_p20_27 XI1_I1482_I230_An XI1_I1482_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I230_MN2 (XI1_I1482_I230_n1 I1_I1482_pn27 I1_p20_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I230_MN3 (VSS XI1_I1482_I230_Bn XI1_I1482_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I230_MN0 (XI1_I1482_I230_An I1_I1482_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I224_MN1 (XI1_I1482_I224_Bn I1_I1482_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I224_MN5 (XI1_I1482_I224_n2 I1_I1482_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I224_MN4 (I1_p20_21 XI1_I1482_I224_An XI1_I1482_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I224_MN2 (XI1_I1482_I224_n1 I1_I1482_pn21 I1_p20_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I224_MN3 (VSS XI1_I1482_I224_Bn XI1_I1482_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I224_MN0 (XI1_I1482_I224_An I1_I1482_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I222_MN1 (XI1_I1482_I222_Bn I1_I1482_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I222_MN5 (XI1_I1482_I222_n2 I1_I1482_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I222_MN4 (I1_p20_19 XI1_I1482_I222_An XI1_I1482_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I222_MN2 (XI1_I1482_I222_n1 I1_I1482_pn19 I1_p20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I222_MN3 (VSS XI1_I1482_I222_Bn XI1_I1482_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I222_MN0 (XI1_I1482_I222_An I1_I1482_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I50_MN1 (XI1_I1528_I50_Bn I1_b21_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I50_MN5 (XI1_I1528_I50_n2 I1_b21_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I50_MN4 (I1_I1528_pn18 XI1_I1528_I50_An XI1_I1528_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I50_MN2 (XI1_I1528_I50_n1 I1_p20_17 I1_I1528_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I50_MN3 (VSS XI1_I1528_I50_Bn XI1_I1528_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I50_MN0 (XI1_I1528_I50_An I1_p20_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I48_MN1 (XI1_I1528_I48_Bn I1_b21_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I48_MN5 (XI1_I1528_I48_n2 I1_b21_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I48_MN4 (I1_I1528_pn16 XI1_I1528_I48_An XI1_I1528_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I48_MN2 (XI1_I1528_I48_n1 I1_p20_15 I1_I1528_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I48_MN3 (VSS XI1_I1528_I48_Bn XI1_I1528_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I48_MN0 (XI1_I1528_I48_An I1_p20_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I34_MN1 (XI1_I1528_I34_Bn I1_b21_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I34_MN5 (XI1_I1528_I34_n2 I1_b21_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I34_MN4 (I1_I1528_pn2 XI1_I1528_I34_An XI1_I1528_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I34_MN2 (XI1_I1528_I34_n1 I1_p20_1 I1_I1528_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I34_MN3 (VSS XI1_I1528_I34_Bn XI1_I1528_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I34_MN0 (XI1_I1528_I34_An I1_p20_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I35_MN1 (XI1_I1114_I35_Bn I1_b12_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I35_MN5 (XI1_I1114_I35_n2 I1_b12_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I35_MN4 (I1_I1114_pn3 XI1_I1114_I35_An XI1_I1114_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I35_MN2 (XI1_I1114_I35_n1 I1_p11_2 I1_I1114_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I35_MN3 (VSS XI1_I1114_I35_Bn XI1_I1114_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I35_MN0 (XI1_I1114_I35_An I1_p11_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I205_MN1 (XI1_I1068_I205_Bn I1_I1068_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I205_MN5 (XI1_I1068_I205_n2 I1_I1068_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I205_MN4 (I1_p11_2 XI1_I1068_I205_An XI1_I1068_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I205_MN2 (XI1_I1068_I205_n1 I1_I1068_pn2 I1_p11_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I205_MN3 (VSS XI1_I1068_I205_Bn XI1_I1068_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I205_MN0 (XI1_I1068_I205_An I1_I1068_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I204_MN1 (XI1_I1068_I204_Bn I1_I1068_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I204_MN5 (XI1_I1068_I204_n2 I1_I1068_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I204_MN4 (I1_p11_1 XI1_I1068_I204_An XI1_I1068_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I204_MN2 (XI1_I1068_I204_n1 I1_I1068_pn1 I1_p11_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I204_MN3 (VSS XI1_I1068_I204_Bn XI1_I1068_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I204_MN0 (XI1_I1068_I204_An I1_I1068_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I37_MN1 (XI1_I1068_I37_Bn I1_b11_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I37_MN5 (XI1_I1068_I37_n2 I1_b11_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I37_MN4 (I1_I1068_pn5 XI1_I1068_I37_An XI1_I1068_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I37_MN2 (XI1_I1068_I37_n1 I1_p10_4 I1_I1068_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I37_MN3 (VSS XI1_I1068_I37_Bn XI1_I1068_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I37_MN0 (XI1_I1068_I37_An I1_p10_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I40_MN1 (XI1_I1068_I40_Bn I1_b11_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I40_MN5 (XI1_I1068_I40_n2 I1_b11_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I40_MN4 (I1_I1068_pn8 XI1_I1068_I40_An XI1_I1068_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I40_MN2 (XI1_I1068_I40_n1 I1_p10_7 I1_I1068_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I40_MN3 (VSS XI1_I1068_I40_Bn XI1_I1068_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I40_MN0 (XI1_I1068_I40_An I1_p10_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I38_MN1 (XI1_I1068_I38_Bn I1_b11_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I38_MN5 (XI1_I1068_I38_n2 I1_b11_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I38_MN4 (I1_I1068_pn6 XI1_I1068_I38_An XI1_I1068_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I38_MN2 (XI1_I1068_I38_n1 I1_p10_5 I1_I1068_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I38_MN3 (VSS XI1_I1068_I38_Bn XI1_I1068_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I38_MN0 (XI1_I1068_I38_An I1_p10_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I32_MN1 (XI1_I1068_I32_Bn I1_b11_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I32_MN5 (XI1_I1068_I32_n2 I1_b11_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I32_MN4 (I1_I1068_pn0 XI1_I1068_I32_An XI1_I1068_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I32_MN2 (XI1_I1068_I32_n1 I1_aa20 I1_I1068_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I32_MN3 (VSS XI1_I1068_I32_Bn XI1_I1068_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I32_MN0 (XI1_I1068_I32_An I1_aa20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I208_MN1 (XI1_I1022_I208_Bn I1_I1022_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I208_MN5 (XI1_I1022_I208_n2 I1_I1022_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I208_MN4 (I1_p10_5 XI1_I1022_I208_An XI1_I1022_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I208_MN2 (XI1_I1022_I208_n1 I1_I1022_pn5 I1_p10_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I208_MN3 (VSS XI1_I1022_I208_Bn XI1_I1022_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I208_MN0 (XI1_I1022_I208_An I1_I1022_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I33_MN1 (XI1_I1022_I33_Bn I1_b10_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I33_MN5 (XI1_I1022_I33_n2 I1_b10_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I33_MN4 (I1_I1022_pn1 XI1_I1022_I33_An XI1_I1022_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I33_MN2 (XI1_I1022_I33_n1 I1_p9_0 I1_I1022_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I33_MN3 (VSS XI1_I1022_I33_Bn XI1_I1022_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I33_MN0 (XI1_I1022_I33_An I1_p9_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I203_MN1 (XI1_I976_I203_Bn I1_qu23_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I203_MN5 (XI1_I976_I203_n2 I1_qu23_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I203_MN4 (I1_p9_0 XI1_I976_I203_An XI1_I976_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I203_MN2 (XI1_I976_I203_n1 I1_I976_pn0 I1_p9_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I203_MN3 (VSS XI1_I976_I203_Bn XI1_I976_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I203_MN0 (XI1_I976_I203_An I1_I976_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I34_MN1 (XI1_I1022_I34_Bn I1_b10_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I34_MN5 (XI1_I1022_I34_n2 I1_b10_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I34_MN4 (I1_I1022_pn2 XI1_I1022_I34_An XI1_I1022_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I34_MN2 (XI1_I1022_I34_n1 I1_p9_1 I1_I1022_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I34_MN3 (VSS XI1_I1022_I34_Bn XI1_I1022_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I34_MN0 (XI1_I1022_I34_An I1_p9_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I32_MN1 (XI1_I976_I32_Bn I1_b9_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I32_MN5 (XI1_I976_I32_n2 I1_b9_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I32_MN4 (I1_I976_pn0 XI1_I976_I32_An XI1_I976_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I32_MN2 (XI1_I976_I32_n1 I1_aa22 I1_I976_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I32_MN3 (VSS XI1_I976_I32_Bn XI1_I976_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I32_MN0 (XI1_I976_I32_An I1_aa22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I36_MN1 (XI1_I1022_I36_Bn I1_b10_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I36_MN5 (XI1_I1022_I36_n2 I1_b10_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I36_MN4 (I1_I1022_pn4 XI1_I1022_I36_An XI1_I1022_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I36_MN2 (XI1_I1022_I36_n1 I1_p9_3 I1_I1022_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I36_MN3 (VSS XI1_I1022_I36_Bn XI1_I1022_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I36_MN0 (XI1_I1022_I36_An I1_p9_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I35_MN1 (XI1_I1022_I35_Bn I1_b10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I35_MN5 (XI1_I1022_I35_n2 I1_b10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I35_MN4 (I1_I1022_pn3 XI1_I1022_I35_An XI1_I1022_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I35_MN2 (XI1_I1022_I35_n1 I1_p9_2 I1_I1022_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I35_MN3 (VSS XI1_I1022_I35_Bn XI1_I1022_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I35_MN0 (XI1_I1022_I35_An I1_p9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2169_MN1 (XI1_I2169_Bn I1_nqkn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2169_MN5 (XI1_I2169_n2 I1_nqkn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2169_MN4 (DIVQ_31 XI1_I2169_An XI1_I2169_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2169_MN2 (XI1_I2169_n1 I1_qu31_b3_5 DIVQ_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2169_MN3 (VSS XI1_I2169_Bn XI1_I2169_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2169_MN0 (XI1_I2169_An I1_qu31_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I127_MN1 (XI1_I127_Bn I1_nakn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I127_MN5 (XI1_I127_n2 I1_nakn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I127_MN4 (I1_aa31 XI1_I127_An XI1_I127_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I127_MN2 (XI1_I127_n1 I1_A_31_b3_5 I1_aa31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I127_MN3 (VSS XI1_I127_Bn XI1_I127_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I127_MN0 (XI1_I127_An I1_A_31_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I32_MN1 (XI1_I562_I32_Bn I1_b0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I32_MN5 (XI1_I562_I32_n2 I1_b0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I32_MN4 (I1_I562_pn0 XI1_I562_I32_An XI1_I562_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I32_MN2 (XI1_I562_I32_n1 I1_aa31 I1_I562_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I32_MN3 (VSS XI1_I562_I32_Bn XI1_I562_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I32_MN0 (XI1_I562_I32_An I1_aa31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I35_MN1 (XI1_I562_I35_Bn I1_b0_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I35_MN5 (XI1_I562_I35_n2 I1_b0_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I35_MN4 (I1_I562_pn3 XI1_I562_I35_An XI1_I562_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I35_MN2 (XI1_I562_I35_n1 VSS I1_I562_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I35_MN3 (VSS XI1_I562_I35_Bn XI1_I562_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I35_MN0 (XI1_I562_I35_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I208_MN1 (XI1_I562_I208_Bn I1_I562_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I208_MN5 (XI1_I562_I208_n2 I1_I562_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I208_MN4 (I1_p0_5 XI1_I562_I208_An XI1_I562_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I208_MN2 (XI1_I562_I208_n1 I1_I562_pn5 I1_p0_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I208_MN3 (VSS XI1_I562_I208_Bn XI1_I562_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I208_MN0 (XI1_I562_I208_An I1_I562_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I39_MN1 (XI1_I562_I39_Bn I1_b0_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I39_MN5 (XI1_I562_I39_n2 I1_b0_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I39_MN4 (I1_I562_pn7 XI1_I562_I39_An XI1_I562_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I39_MN2 (XI1_I562_I39_n1 VSS I1_I562_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I39_MN3 (VSS XI1_I562_I39_Bn XI1_I562_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I39_MN0 (XI1_I562_I39_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I210_MN1 (XI1_I562_I210_Bn I1_I562_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I210_MN5 (XI1_I562_I210_n2 I1_I562_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I210_MN4 (I1_p0_7 XI1_I562_I210_An XI1_I562_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I210_MN2 (XI1_I562_I210_n1 I1_I562_pn7 I1_p0_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I210_MN3 (VSS XI1_I562_I210_Bn XI1_I562_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I210_MN0 (XI1_I562_I210_An I1_I562_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I41_MN1 (XI1_I562_I41_Bn I1_b0_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I41_MN5 (XI1_I562_I41_n2 I1_b0_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I41_MN4 (I1_I562_pn9 XI1_I562_I41_An XI1_I562_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I41_MN2 (XI1_I562_I41_n1 VSS I1_I562_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I41_MN3 (VSS XI1_I562_I41_Bn XI1_I562_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I41_MN0 (XI1_I562_I41_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I45_MN1 (XI1_I562_I45_Bn I1_b0_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I45_MN5 (XI1_I562_I45_n2 I1_b0_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I45_MN4 (I1_I562_pn13 XI1_I562_I45_An XI1_I562_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I45_MN2 (XI1_I562_I45_n1 VSS I1_I562_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I45_MN3 (VSS XI1_I562_I45_Bn XI1_I562_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I45_MN0 (XI1_I562_I45_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I47_MN1 (XI1_I562_I47_Bn I1_b0_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I47_MN5 (XI1_I562_I47_n2 I1_b0_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I47_MN4 (I1_I562_pn15 XI1_I562_I47_An XI1_I562_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I47_MN2 (XI1_I562_I47_n1 VSS I1_I562_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I47_MN3 (VSS XI1_I562_I47_Bn XI1_I562_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I47_MN0 (XI1_I562_I47_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I220_MN1 (XI1_I562_I220_Bn I1_I562_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I220_MN5 (XI1_I562_I220_n2 I1_I562_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I220_MN4 (I1_p0_17 XI1_I562_I220_An XI1_I562_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I220_MN2 (XI1_I562_I220_n1 I1_I562_pn17 I1_p0_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I220_MN3 (VSS XI1_I562_I220_Bn XI1_I562_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I220_MN0 (XI1_I562_I220_An I1_I562_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I49_MN1 (XI1_I562_I49_Bn I1_b0_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I49_MN5 (XI1_I562_I49_n2 I1_b0_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I49_MN4 (I1_I562_pn17 XI1_I562_I49_An XI1_I562_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I49_MN2 (XI1_I562_I49_n1 VSS I1_I562_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I49_MN3 (VSS XI1_I562_I49_Bn XI1_I562_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I49_MN0 (XI1_I562_I49_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I222_MN1 (XI1_I562_I222_Bn I1_I562_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I222_MN5 (XI1_I562_I222_n2 I1_I562_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I222_MN4 (I1_p0_19 XI1_I562_I222_An XI1_I562_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I222_MN2 (XI1_I562_I222_n1 I1_I562_pn19 I1_p0_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I222_MN3 (VSS XI1_I562_I222_Bn XI1_I562_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I222_MN0 (XI1_I562_I222_An I1_I562_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I51_MN1 (XI1_I562_I51_Bn I1_b0_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I51_MN5 (XI1_I562_I51_n2 I1_b0_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I51_MN4 (I1_I562_pn19 XI1_I562_I51_An XI1_I562_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I51_MN2 (XI1_I562_I51_n1 VSS I1_I562_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I51_MN3 (VSS XI1_I562_I51_Bn XI1_I562_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I51_MN0 (XI1_I562_I51_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I53_MN1 (XI1_I562_I53_Bn I1_b0_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I53_MN5 (XI1_I562_I53_n2 I1_b0_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I53_MN4 (I1_I562_pn21 XI1_I562_I53_An XI1_I562_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I53_MN2 (XI1_I562_I53_n1 VSS I1_I562_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I53_MN3 (VSS XI1_I562_I53_Bn XI1_I562_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I53_MN0 (XI1_I562_I53_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I61_MN1 (XI1_I562_I61_Bn I1_b0_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I61_MN5 (XI1_I562_I61_n2 I1_b0_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I61_MN4 (I1_I562_pn29 XI1_I562_I61_An XI1_I562_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I61_MN2 (XI1_I562_I61_n1 VSS I1_I562_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I61_MN3 (VSS XI1_I562_I61_Bn XI1_I562_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I61_MN0 (XI1_I562_I61_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I62_MN1 (XI1_I1482_I62_Bn I1_b20_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I62_MN5 (XI1_I1482_I62_n2 I1_b20_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I62_MN4 (I1_I1482_pn30 XI1_I1482_I62_An XI1_I1482_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I62_MN2 (XI1_I1482_I62_n1 I1_p19_29 I1_I1482_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I62_MN3 (VSS XI1_I1482_I62_Bn XI1_I1482_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I62_MN0 (XI1_I1482_I62_An I1_p19_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I232_MN1 (XI1_I1482_I232_Bn I1_I1482_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I232_MN5 (XI1_I1482_I232_n2 I1_I1482_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I232_MN4 (I1_p20_29 XI1_I1482_I232_An XI1_I1482_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I232_MN2 (XI1_I1482_I232_n1 I1_I1482_pn29 I1_p20_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I232_MN3 (VSS XI1_I1482_I232_Bn XI1_I1482_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I232_MN0 (XI1_I1482_I232_An I1_I1482_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I234_MN1 (XI1_I1482_I234_Bn I1_c20_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I234_MN5 (XI1_I1482_I234_n2 I1_c20_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I234_MN4 (I1_p20_31 XI1_I1482_I234_An XI1_I1482_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I234_MN2 (XI1_I1482_I234_n1 I1_I1482_pn31 I1_p20_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I234_MN3 (VSS XI1_I1482_I234_Bn XI1_I1482_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I234_MN0 (XI1_I1482_I234_An I1_I1482_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I226_MN1 (XI1_I1482_I226_Bn I1_I1482_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I226_MN5 (XI1_I1482_I226_n2 I1_I1482_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I226_MN4 (I1_p20_23 XI1_I1482_I226_An XI1_I1482_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I226_MN2 (XI1_I1482_I226_n1 I1_I1482_pn23 I1_p20_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I226_MN3 (VSS XI1_I1482_I226_Bn XI1_I1482_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I226_MN0 (XI1_I1482_I226_An I1_I1482_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I55_MN1 (XI1_I1528_I55_Bn I1_b21_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I55_MN5 (XI1_I1528_I55_n2 I1_b21_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I55_MN4 (I1_I1528_pn23 XI1_I1528_I55_An XI1_I1528_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I55_MN2 (XI1_I1528_I55_n1 I1_p20_22 I1_I1528_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I55_MN3 (VSS XI1_I1528_I55_Bn XI1_I1528_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I55_MN0 (XI1_I1528_I55_An I1_p20_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I53_MN1 (XI1_I1528_I53_Bn I1_b21_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I53_MN5 (XI1_I1528_I53_n2 I1_b21_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I53_MN4 (I1_I1528_pn21 XI1_I1528_I53_An XI1_I1528_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I53_MN2 (XI1_I1528_I53_n1 I1_p20_20 I1_I1528_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I53_MN3 (VSS XI1_I1528_I53_Bn XI1_I1528_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I53_MN0 (XI1_I1528_I53_An I1_p20_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I52_MN1 (XI1_I1528_I52_Bn I1_b21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I52_MN5 (XI1_I1528_I52_n2 I1_b21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I52_MN4 (I1_I1528_pn20 XI1_I1528_I52_An XI1_I1528_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I52_MN2 (XI1_I1528_I52_n1 I1_p20_19 I1_I1528_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I52_MN3 (VSS XI1_I1528_I52_Bn XI1_I1528_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I52_MN0 (XI1_I1528_I52_An I1_p20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I51_MN1 (XI1_I1528_I51_Bn I1_b21_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I51_MN5 (XI1_I1528_I51_n2 I1_b21_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I51_MN4 (I1_I1528_pn19 XI1_I1528_I51_An XI1_I1528_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I51_MN2 (XI1_I1528_I51_n1 I1_p20_18 I1_I1528_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I51_MN3 (VSS XI1_I1528_I51_Bn XI1_I1528_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I51_MN0 (XI1_I1528_I51_An I1_p20_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I33_MN1 (XI1_I1528_I33_Bn I1_b21_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I33_MN5 (XI1_I1528_I33_n2 I1_b21_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I33_MN4 (I1_I1528_pn1 XI1_I1528_I33_An XI1_I1528_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I33_MN2 (XI1_I1528_I33_n1 I1_p20_0 I1_I1528_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I33_MN3 (VSS XI1_I1528_I33_Bn XI1_I1528_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I33_MN0 (XI1_I1528_I33_An I1_p20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I33_MN1 (XI1_I1068_I33_Bn I1_b11_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I33_MN5 (XI1_I1068_I33_n2 I1_b11_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I33_MN4 (I1_I1068_pn1 XI1_I1068_I33_An XI1_I1068_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I33_MN2 (XI1_I1068_I33_n1 I1_p10_0 I1_I1068_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I33_MN3 (VSS XI1_I1068_I33_Bn XI1_I1068_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I33_MN0 (XI1_I1068_I33_An I1_p10_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I34_MN1 (XI1_I1068_I34_Bn I1_b11_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I34_MN5 (XI1_I1068_I34_n2 I1_b11_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I34_MN4 (I1_I1068_pn2 XI1_I1068_I34_An XI1_I1068_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I34_MN2 (XI1_I1068_I34_n1 I1_p10_1 I1_I1068_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I34_MN3 (VSS XI1_I1068_I34_Bn XI1_I1068_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I34_MN0 (XI1_I1068_I34_An I1_p10_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I35_MN1 (XI1_I1068_I35_Bn I1_b11_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I35_MN5 (XI1_I1068_I35_n2 I1_b11_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I35_MN4 (I1_I1068_pn3 XI1_I1068_I35_An XI1_I1068_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I35_MN2 (XI1_I1068_I35_n1 I1_p10_2 I1_I1068_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I35_MN3 (VSS XI1_I1068_I35_Bn XI1_I1068_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I35_MN0 (XI1_I1068_I35_An I1_p10_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I36_MN1 (XI1_I1068_I36_Bn I1_b11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I36_MN5 (XI1_I1068_I36_n2 I1_b11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I36_MN4 (I1_I1068_pn4 XI1_I1068_I36_An XI1_I1068_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I36_MN2 (XI1_I1068_I36_n1 I1_p10_3 I1_I1068_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I36_MN3 (VSS XI1_I1068_I36_Bn XI1_I1068_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I36_MN0 (XI1_I1068_I36_An I1_p10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2136_MN1 (XI1_I2136_Bn I1_nqkn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2136_MN5 (XI1_I2136_n2 I1_nqkn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2136_MN4 (DIVQ_20 XI1_I2136_An XI1_I2136_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2136_MN2 (XI1_I2136_n1 I1_qu20_b3_5 DIVQ_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2136_MN3 (VSS XI1_I2136_Bn XI1_I2136_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2136_MN0 (XI1_I2136_An I1_qu20_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2139_MN1 (XI1_I2139_Bn I1_nqkn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2139_MN5 (XI1_I2139_n2 I1_nqkn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2139_MN4 (DIVQ_21 XI1_I2139_An XI1_I2139_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2139_MN2 (XI1_I2139_n1 I1_qu21_b3_5 DIVQ_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2139_MN3 (VSS XI1_I2139_Bn XI1_I2139_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2139_MN0 (XI1_I2139_An I1_qu21_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I91_MN1 (XI1_I91_Bn I1_nakn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I91_MN5 (XI1_I91_n2 I1_nakn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I91_MN4 (I1_aa19 XI1_I91_An XI1_I91_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I91_MN2 (XI1_I91_n1 A_19 I1_aa19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I91_MN3 (VSS XI1_I91_Bn XI1_I91_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I91_MN0 (XI1_I91_An A_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I203_MN1 (XI1_I1022_I203_Bn I1_qu22_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I203_MN5 (XI1_I1022_I203_n2 I1_qu22_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I203_MN4 (I1_p10_0 XI1_I1022_I203_An XI1_I1022_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I203_MN2 (XI1_I1022_I203_n1 I1_I1022_pn0 I1_p10_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I203_MN3 (VSS XI1_I1022_I203_Bn XI1_I1022_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I203_MN0 (XI1_I1022_I203_An I1_I1022_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I94_MN1 (XI1_I94_Bn I1_nakn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I94_MN5 (XI1_I94_n2 I1_nakn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I94_MN4 (I1_aa20 XI1_I94_An XI1_I94_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I94_MN2 (XI1_I94_n1 A_20 I1_aa20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I94_MN3 (VSS XI1_I94_Bn XI1_I94_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I94_MN0 (XI1_I94_An A_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I204_MN1 (XI1_I1022_I204_Bn I1_I1022_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I204_MN5 (XI1_I1022_I204_n2 I1_I1022_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I204_MN4 (I1_p10_1 XI1_I1022_I204_An XI1_I1022_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I204_MN2 (XI1_I1022_I204_n1 I1_I1022_pn1 I1_p10_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I204_MN3 (VSS XI1_I1022_I204_Bn XI1_I1022_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I204_MN0 (XI1_I1022_I204_An I1_I1022_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I205_MN1 (XI1_I1022_I205_Bn I1_I1022_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I205_MN5 (XI1_I1022_I205_n2 I1_I1022_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I205_MN4 (I1_p10_2 XI1_I1022_I205_An XI1_I1022_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I205_MN2 (XI1_I1022_I205_n1 I1_I1022_pn2 I1_p10_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I205_MN3 (VSS XI1_I1022_I205_Bn XI1_I1022_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I205_MN0 (XI1_I1022_I205_An I1_I1022_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I32_MN1 (XI1_I1022_I32_Bn I1_b10_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I32_MN5 (XI1_I1022_I32_n2 I1_b10_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I32_MN4 (I1_I1022_pn0 XI1_I1022_I32_An XI1_I1022_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I32_MN2 (XI1_I1022_I32_n1 I1_aa21 I1_I1022_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I32_MN3 (VSS XI1_I1022_I32_Bn XI1_I1022_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I32_MN0 (XI1_I1022_I32_An I1_aa21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2142_MN1 (XI1_I2142_Bn I1_nqkn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2142_MN5 (XI1_I2142_n2 I1_nqkn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2142_MN4 (DIVQ_22 XI1_I2142_An XI1_I2142_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2142_MN2 (XI1_I2142_n1 I1_qu22_b3_5 DIVQ_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2142_MN3 (VSS XI1_I2142_Bn XI1_I2142_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2142_MN0 (XI1_I2142_An I1_qu22_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2145_MN1 (XI1_I2145_Bn I1_nqkn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2145_MN5 (XI1_I2145_n2 I1_nqkn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2145_MN4 (DIVQ_23 XI1_I2145_An XI1_I2145_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2145_MN2 (XI1_I2145_n1 I1_qu23_b3_5 DIVQ_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2145_MN3 (VSS XI1_I2145_Bn XI1_I2145_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2145_MN0 (XI1_I2145_An I1_qu23_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2148_MN1 (XI1_I2148_Bn I1_nqkn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2148_MN5 (XI1_I2148_n2 I1_nqkn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2148_MN4 (DIVQ_24 XI1_I2148_An XI1_I2148_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2148_MN2 (XI1_I2148_n1 I1_qu24_b3_5 DIVQ_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2148_MN3 (VSS XI1_I2148_Bn XI1_I2148_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2148_MN0 (XI1_I2148_An I1_qu24_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2151_MN1 (XI1_I2151_Bn I1_nqkn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2151_MN5 (XI1_I2151_n2 I1_nqkn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2151_MN4 (DIVQ_25 XI1_I2151_An XI1_I2151_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2151_MN2 (XI1_I2151_n1 I1_qu25_b3_5 DIVQ_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2151_MN3 (VSS XI1_I2151_Bn XI1_I2151_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2151_MN0 (XI1_I2151_An I1_qu25_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2154_MN1 (XI1_I2154_Bn I1_nqkn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2154_MN5 (XI1_I2154_n2 I1_nqkn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2154_MN4 (DIVQ_26 XI1_I2154_An XI1_I2154_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2154_MN2 (XI1_I2154_n1 I1_qu26_b3_5 DIVQ_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2154_MN3 (VSS XI1_I2154_Bn XI1_I2154_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2154_MN0 (XI1_I2154_An I1_qu26_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2157_MN1 (XI1_I2157_Bn I1_nqkn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2157_MN5 (XI1_I2157_n2 I1_nqkn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2157_MN4 (DIVQ_27 XI1_I2157_An XI1_I2157_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2157_MN2 (XI1_I2157_n1 I1_qu27_b3_5 DIVQ_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2157_MN3 (VSS XI1_I2157_Bn XI1_I2157_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2157_MN0 (XI1_I2157_An I1_qu27_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2160_MN1 (XI1_I2160_Bn I1_nqkn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2160_MN5 (XI1_I2160_n2 I1_nqkn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2160_MN4 (DIVQ_28 XI1_I2160_An XI1_I2160_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2160_MN2 (XI1_I2160_n1 I1_qu28_b3_5 DIVQ_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2160_MN3 (VSS XI1_I2160_Bn XI1_I2160_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2160_MN0 (XI1_I2160_An I1_qu28_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2163_MN1 (XI1_I2163_Bn I1_nqkn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2163_MN5 (XI1_I2163_n2 I1_nqkn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2163_MN4 (DIVQ_29 XI1_I2163_An XI1_I2163_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2163_MN2 (XI1_I2163_n1 I1_qu29_b3_5 DIVQ_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2163_MN3 (VSS XI1_I2163_Bn XI1_I2163_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2163_MN0 (XI1_I2163_An I1_qu29_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I103_MN1 (XI1_I103_Bn I1_nakn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I103_MN5 (XI1_I103_n2 I1_nakn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I103_MN4 (I1_aa23 XI1_I103_An XI1_I103_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I103_MN2 (XI1_I103_n1 A_23 I1_aa23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I103_MN3 (VSS XI1_I103_Bn XI1_I103_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I103_MN0 (XI1_I103_An A_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2166_MN1 (XI1_I2166_Bn I1_nqkn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2166_MN5 (XI1_I2166_n2 I1_nqkn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2166_MN4 (DIVQ_30 XI1_I2166_An XI1_I2166_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2166_MN2 (XI1_I2166_n1 I1_qu30_b3_5 DIVQ_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2166_MN3 (VSS XI1_I2166_Bn XI1_I2166_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2166_MN0 (XI1_I2166_An I1_qu30_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I106_MN1 (XI1_I106_Bn I1_nakn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I106_MN5 (XI1_I106_n2 I1_nakn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I106_MN4 (I1_aa24 XI1_I106_An XI1_I106_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I106_MN2 (XI1_I106_n1 A_24 I1_aa24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I106_MN3 (VSS XI1_I106_Bn XI1_I106_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I106_MN0 (XI1_I106_An A_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I124_MN1 (XI1_I124_Bn I1_nakn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I124_MN5 (XI1_I124_n2 I1_nakn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I124_MN4 (I1_aa30 XI1_I124_An XI1_I124_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I124_MN2 (XI1_I124_n1 A_30 I1_aa30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I124_MN3 (VSS XI1_I124_Bn XI1_I124_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I124_MN0 (XI1_I124_An A_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I121_MN1 (XI1_I121_Bn I1_nakn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I121_MN5 (XI1_I121_n2 I1_nakn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I121_MN4 (I1_aa29 XI1_I121_An XI1_I121_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I121_MN2 (XI1_I121_n1 A_29 I1_aa29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I121_MN3 (VSS XI1_I121_Bn XI1_I121_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I121_MN0 (XI1_I121_An A_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I36_MN1 (XI1_I562_I36_Bn I1_b0_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I36_MN5 (XI1_I562_I36_n2 I1_b0_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I36_MN4 (I1_I562_pn4 XI1_I562_I36_An XI1_I562_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I36_MN2 (XI1_I562_I36_n1 VSS I1_I562_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I36_MN3 (VSS XI1_I562_I36_Bn XI1_I562_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I36_MN0 (XI1_I562_I36_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I224_MN1 (XI1_I562_I224_Bn I1_I562_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I224_MN5 (XI1_I562_I224_n2 I1_I562_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I224_MN4 (I1_p0_21 XI1_I562_I224_An XI1_I562_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I224_MN2 (XI1_I562_I224_n1 I1_I562_pn21 I1_p0_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I224_MN3 (VSS XI1_I562_I224_Bn XI1_I562_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I224_MN0 (XI1_I562_I224_An I1_I562_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I226_MN1 (XI1_I562_I226_Bn I1_I562_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I226_MN5 (XI1_I562_I226_n2 I1_I562_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I226_MN4 (I1_p0_23 XI1_I562_I226_An XI1_I562_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I226_MN2 (XI1_I562_I226_n1 I1_I562_pn23 I1_p0_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I226_MN3 (VSS XI1_I562_I226_Bn XI1_I562_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I226_MN0 (XI1_I562_I226_An I1_I562_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I234_MN1 (XI1_I562_I234_Bn I1_c0_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I234_MN5 (XI1_I562_I234_n2 I1_c0_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I234_MN4 (I1_p0_31 XI1_I562_I234_An XI1_I562_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I234_MN2 (XI1_I562_I234_n1 I1_I562_pn31 I1_p0_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I234_MN3 (VSS XI1_I562_I234_Bn XI1_I562_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I234_MN0 (XI1_I562_I234_An I1_I562_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I228_MN1 (XI1_I562_I228_Bn I1_I562_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I228_MN5 (XI1_I562_I228_n2 I1_I562_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I228_MN4 (I1_p0_25 XI1_I562_I228_An XI1_I562_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I228_MN2 (XI1_I562_I228_n1 I1_I562_pn25 I1_p0_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I228_MN3 (VSS XI1_I562_I228_Bn XI1_I562_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I228_MN0 (XI1_I562_I228_An I1_I562_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I230_MN1 (XI1_I562_I230_Bn I1_I562_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I230_MN5 (XI1_I562_I230_n2 I1_I562_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I230_MN4 (I1_p0_27 XI1_I562_I230_An XI1_I562_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I230_MN2 (XI1_I562_I230_n1 I1_I562_pn27 I1_p0_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I230_MN3 (VSS XI1_I562_I230_Bn XI1_I562_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I230_MN0 (XI1_I562_I230_An I1_I562_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I232_MN1 (XI1_I562_I232_Bn I1_I562_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I232_MN5 (XI1_I562_I232_n2 I1_I562_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I232_MN4 (I1_p0_29 XI1_I562_I232_An XI1_I562_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I232_MN2 (XI1_I562_I232_n1 I1_I562_pn29 I1_p0_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I232_MN3 (VSS XI1_I562_I232_Bn XI1_I562_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I232_MN0 (XI1_I562_I232_An I1_I562_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I59_MN1 (XI1_I562_I59_Bn I1_b0_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I59_MN5 (XI1_I562_I59_n2 I1_b0_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I59_MN4 (I1_I562_pn27 XI1_I562_I59_An XI1_I562_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I59_MN2 (XI1_I562_I59_n1 VSS I1_I562_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I59_MN3 (VSS XI1_I562_I59_Bn XI1_I562_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I59_MN0 (XI1_I562_I59_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I63_MN1 (XI1_I562_I63_Bn I1_b0_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I63_MN5 (XI1_I562_I63_n2 I1_b0_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I63_MN4 (I1_I562_pn31 XI1_I562_I63_An XI1_I562_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I63_MN2 (XI1_I562_I63_n1 VSS I1_I562_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I63_MN3 (VSS XI1_I562_I63_Bn XI1_I562_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I63_MN0 (XI1_I562_I63_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I63_MN1 (XI1_I1482_I63_Bn I1_b20_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I63_MN5 (XI1_I1482_I63_n2 I1_b20_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I63_MN4 (I1_I1482_pn31 XI1_I1482_I63_An XI1_I1482_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I63_MN2 (XI1_I1482_I63_n1 I1_p19_30 I1_I1482_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I63_MN3 (VSS XI1_I1482_I63_Bn XI1_I1482_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I63_MN0 (XI1_I1482_I63_An I1_p19_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I233_MN1 (XI1_I1482_I233_Bn I1_I1482_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1482_I233_MN5 (XI1_I1482_I233_n2 I1_I1482_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I233_MN4 (I1_p20_30 XI1_I1482_I233_An XI1_I1482_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I233_MN2 (XI1_I1482_I233_n1 I1_I1482_pn30 I1_p20_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I233_MN3 (VSS XI1_I1482_I233_Bn XI1_I1482_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I233_MN0 (XI1_I1482_I233_An I1_I1482_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I57_MN1 (XI1_I1528_I57_Bn I1_b21_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I57_MN5 (XI1_I1528_I57_n2 I1_b21_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I57_MN4 (I1_I1528_pn25 XI1_I1528_I57_An XI1_I1528_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I57_MN2 (XI1_I1528_I57_n1 I1_p20_24 I1_I1528_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I57_MN3 (VSS XI1_I1528_I57_Bn XI1_I1528_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I57_MN0 (XI1_I1528_I57_An I1_p20_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I56_MN1 (XI1_I1528_I56_Bn I1_b21_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I56_MN5 (XI1_I1528_I56_n2 I1_b21_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I56_MN4 (I1_I1528_pn24 XI1_I1528_I56_An XI1_I1528_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I56_MN2 (XI1_I1528_I56_n1 I1_p20_23 I1_I1528_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I56_MN3 (VSS XI1_I1528_I56_Bn XI1_I1528_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I56_MN0 (XI1_I1528_I56_An I1_p20_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I58_MN1 (XI1_I1528_I58_Bn I1_b21_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I58_MN5 (XI1_I1528_I58_n2 I1_b21_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I58_MN4 (I1_I1528_pn26 XI1_I1528_I58_An XI1_I1528_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I58_MN2 (XI1_I1528_I58_n1 I1_p20_25 I1_I1528_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I58_MN3 (VSS XI1_I1528_I58_Bn XI1_I1528_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I58_MN0 (XI1_I1528_I58_An I1_p20_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I54_MN1 (XI1_I1528_I54_Bn I1_b21_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I54_MN5 (XI1_I1528_I54_n2 I1_b21_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I54_MN4 (I1_I1528_pn22 XI1_I1528_I54_An XI1_I1528_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I54_MN2 (XI1_I1528_I54_n1 I1_p20_21 I1_I1528_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I54_MN3 (VSS XI1_I1528_I54_Bn XI1_I1528_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I54_MN0 (XI1_I1528_I54_An I1_p20_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I210_MN1 (XI1_I1528_I210_Bn I1_I1528_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I210_MN5 (XI1_I1528_I210_n2 I1_I1528_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I210_MN4 (I1_p21_7 XI1_I1528_I210_An XI1_I1528_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I210_MN2 (XI1_I1528_I210_n1 I1_I1528_pn7 I1_p21_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I210_MN3 (VSS XI1_I1528_I210_Bn XI1_I1528_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I210_MN0 (XI1_I1528_I210_An I1_I1528_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I222_MN1 (XI1_I1528_I222_Bn I1_I1528_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I222_MN5 (XI1_I1528_I222_n2 I1_I1528_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I222_MN4 (I1_p21_19 XI1_I1528_I222_An XI1_I1528_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I222_MN2 (XI1_I1528_I222_n1 I1_I1528_pn19 I1_p21_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I222_MN3 (VSS XI1_I1528_I222_Bn XI1_I1528_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I222_MN0 (XI1_I1528_I222_An I1_I1528_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I208_MN1 (XI1_I1528_I208_Bn I1_I1528_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I208_MN5 (XI1_I1528_I208_n2 I1_I1528_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I208_MN4 (I1_p21_5 XI1_I1528_I208_An XI1_I1528_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I208_MN2 (XI1_I1528_I208_n1 I1_I1528_pn5 I1_p21_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I208_MN3 (VSS XI1_I1528_I208_Bn XI1_I1528_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I208_MN0 (XI1_I1528_I208_An I1_I1528_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I43_MN1 (XI1_I1574_I43_Bn I1_b22_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I43_MN5 (XI1_I1574_I43_n2 I1_b22_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I43_MN4 (I1_I1574_pn11 XI1_I1574_I43_An XI1_I1574_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I43_MN2 (XI1_I1574_I43_n1 I1_p21_10 I1_I1574_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I43_MN3 (VSS XI1_I1574_I43_Bn XI1_I1574_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I43_MN0 (XI1_I1574_I43_An I1_p21_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I204_MN1 (XI1_I1528_I204_Bn I1_I1528_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I204_MN5 (XI1_I1528_I204_n2 I1_I1528_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I204_MN4 (I1_p21_1 XI1_I1528_I204_An XI1_I1528_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I204_MN2 (XI1_I1528_I204_n1 I1_I1528_pn1 I1_p21_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I204_MN3 (VSS XI1_I1528_I204_Bn XI1_I1528_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I204_MN0 (XI1_I1528_I204_An I1_I1528_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I42_MN1 (XI1_I1574_I42_Bn I1_b22_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I42_MN5 (XI1_I1574_I42_n2 I1_b22_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I42_MN4 (I1_I1574_pn10 XI1_I1574_I42_An XI1_I1574_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I42_MN2 (XI1_I1574_I42_n1 I1_p21_9 I1_I1574_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I42_MN3 (VSS XI1_I1574_I42_Bn XI1_I1574_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I42_MN0 (XI1_I1574_I42_An I1_p21_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I40_MN1 (XI1_I1574_I40_Bn I1_b22_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I40_MN5 (XI1_I1574_I40_n2 I1_b22_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I40_MN4 (I1_I1574_pn8 XI1_I1574_I40_An XI1_I1574_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I40_MN2 (XI1_I1574_I40_n1 I1_p21_7 I1_I1574_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I40_MN3 (VSS XI1_I1574_I40_Bn XI1_I1574_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I40_MN0 (XI1_I1574_I40_An I1_p21_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I79_MN1 (XI1_I79_Bn I1_nakn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I79_MN5 (XI1_I79_n2 I1_nakn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I79_MN4 (I1_aa15 XI1_I79_An XI1_I79_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I79_MN2 (XI1_I79_n1 A_15 I1_aa15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I79_MN3 (VSS XI1_I79_Bn XI1_I79_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I79_MN0 (XI1_I79_An A_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I32_MN1 (XI1_I1528_I32_Bn I1_b21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I32_MN5 (XI1_I1528_I32_n2 I1_b21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I32_MN4 (I1_I1528_pn0 XI1_I1528_I32_An XI1_I1528_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I32_MN2 (XI1_I1528_I32_n1 I1_aa10 I1_I1528_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I32_MN3 (VSS XI1_I1528_I32_Bn XI1_I1528_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I32_MN0 (XI1_I1528_I32_An I1_aa10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I203_MN1 (XI1_I1528_I203_Bn I1_qu11_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I203_MN5 (XI1_I1528_I203_n2 I1_qu11_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I203_MN4 (I1_p21_0 XI1_I1528_I203_An XI1_I1528_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I203_MN2 (XI1_I1528_I203_n1 I1_I1528_pn0 I1_p21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I203_MN3 (VSS XI1_I1528_I203_Bn XI1_I1528_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I203_MN0 (XI1_I1528_I203_An I1_I1528_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2118_MN1 (XI1_I2118_Bn I1_nqkn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2118_MN5 (XI1_I2118_n2 I1_nqkn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2118_MN4 (DIVQ_14 XI1_I2118_An XI1_I2118_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2118_MN2 (XI1_I2118_n1 I1_qu14_b3_5 DIVQ_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2118_MN3 (VSS XI1_I2118_Bn XI1_I2118_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2118_MN0 (XI1_I2118_An I1_qu14_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2121_MN1 (XI1_I2121_Bn I1_nqkn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2121_MN5 (XI1_I2121_n2 I1_nqkn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2121_MN4 (DIVQ_15 XI1_I2121_An XI1_I2121_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2121_MN2 (XI1_I2121_n1 I1_qu15_b3_5 DIVQ_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2121_MN3 (VSS XI1_I2121_Bn XI1_I2121_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2121_MN0 (XI1_I2121_An I1_qu15_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2124_MN1 (XI1_I2124_Bn I1_nqkn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2124_MN5 (XI1_I2124_n2 I1_nqkn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2124_MN4 (DIVQ_16 XI1_I2124_An XI1_I2124_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2124_MN2 (XI1_I2124_n1 I1_qu16_b3_5 DIVQ_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2124_MN3 (VSS XI1_I2124_Bn XI1_I2124_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2124_MN0 (XI1_I2124_An I1_qu16_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2127_MN1 (XI1_I2127_Bn I1_nqkn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2127_MN5 (XI1_I2127_n2 I1_nqkn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2127_MN4 (DIVQ_17 XI1_I2127_An XI1_I2127_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2127_MN2 (XI1_I2127_n1 I1_qu17_b3_5 DIVQ_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2127_MN3 (VSS XI1_I2127_Bn XI1_I2127_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2127_MN0 (XI1_I2127_An I1_qu17_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2130_MN1 (XI1_I2130_Bn I1_nqkn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2130_MN5 (XI1_I2130_n2 I1_nqkn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2130_MN4 (DIVQ_18 XI1_I2130_An XI1_I2130_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2130_MN2 (XI1_I2130_n1 I1_qu18_b3_5 DIVQ_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2130_MN3 (VSS XI1_I2130_Bn XI1_I2130_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2130_MN0 (XI1_I2130_An I1_qu18_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2133_MN1 (XI1_I2133_Bn I1_nqkn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2133_MN5 (XI1_I2133_n2 I1_nqkn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2133_MN4 (DIVQ_19 XI1_I2133_An XI1_I2133_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2133_MN2 (XI1_I2133_n1 I1_qu19_b3_5 DIVQ_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2133_MN3 (VSS XI1_I2133_Bn XI1_I2133_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2133_MN0 (XI1_I2133_An I1_qu19_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I85_MN1 (XI1_I85_Bn I1_nakn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I85_MN5 (XI1_I85_n2 I1_nakn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I85_MN4 (I1_aa17 XI1_I85_An XI1_I85_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I85_MN2 (XI1_I85_n1 A_17 I1_aa17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I85_MN3 (VSS XI1_I85_Bn XI1_I85_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I85_MN0 (XI1_I85_An A_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I88_MN1 (XI1_I88_Bn I1_nakn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I88_MN5 (XI1_I88_n2 I1_nakn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I88_MN4 (I1_aa18 XI1_I88_An XI1_I88_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I88_MN2 (XI1_I88_n1 A_18 I1_aa18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I88_MN3 (VSS XI1_I88_Bn XI1_I88_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I88_MN0 (XI1_I88_An A_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I376_MN1 (XI1_I376_Bn I1_nbkn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I376_MN5 (XI1_I376_n2 I1_nbkn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I376_MN4 (I1_dd20 XI1_I376_An XI1_I376_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I376_MN2 (XI1_I376_n1 B_20 I1_dd20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I376_MN3 (VSS XI1_I376_Bn XI1_I376_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I376_MN0 (XI1_I376_An B_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I389_MN1 (XI1_I389_Bn I1_nbkn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I389_MN5 (XI1_I389_n2 I1_nbkn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I389_MN4 (I1_dd21 XI1_I389_An XI1_I389_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I389_MN2 (XI1_I389_n1 B_21 I1_dd21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I389_MN3 (VSS XI1_I389_Bn XI1_I389_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I389_MN0 (XI1_I389_An B_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I402_MN1 (XI1_I402_Bn I1_nbkn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I402_MN5 (XI1_I402_n2 I1_nbkn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I402_MN4 (I1_dd22 XI1_I402_An XI1_I402_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I402_MN2 (XI1_I402_n1 B_22 I1_dd22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I402_MN3 (VSS XI1_I402_Bn XI1_I402_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I402_MN0 (XI1_I402_An B_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I97_MN1 (XI1_I97_Bn I1_nakn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I97_MN5 (XI1_I97_n2 I1_nakn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I97_MN4 (I1_aa21 XI1_I97_An XI1_I97_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I97_MN2 (XI1_I97_n1 A_21 I1_aa21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I97_MN3 (VSS XI1_I97_Bn XI1_I97_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I97_MN0 (XI1_I97_An A_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I519_MN1 (XI1_I519_Bn I1_nbkn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I519_MN5 (XI1_I519_n2 I1_nbkn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I519_MN4 (I1_dd31 XI1_I519_An XI1_I519_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I519_MN2 (XI1_I519_n1 I1_B_31_b3_5 I1_dd31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I519_MN3 (VSS XI1_I519_Bn XI1_I519_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I519_MN0 (XI1_I519_An I1_B_31_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I506_MN1 (XI1_I506_Bn I1_nbkn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I506_MN5 (XI1_I506_n2 I1_nbkn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I506_MN4 (I1_dd30 XI1_I506_An XI1_I506_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I506_MN2 (XI1_I506_n1 B_30 I1_dd30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I506_MN3 (VSS XI1_I506_Bn XI1_I506_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I506_MN0 (XI1_I506_An B_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I493_MN1 (XI1_I493_Bn I1_nbkn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I493_MN5 (XI1_I493_n2 I1_nbkn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I493_MN4 (I1_dd29 XI1_I493_An XI1_I493_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I493_MN2 (XI1_I493_n1 B_29 I1_dd29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I493_MN3 (VSS XI1_I493_Bn XI1_I493_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I493_MN0 (XI1_I493_An B_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I480_MN1 (XI1_I480_Bn I1_nbkn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I480_MN5 (XI1_I480_n2 I1_nbkn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I480_MN4 (I1_dd28 XI1_I480_An XI1_I480_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I480_MN2 (XI1_I480_n1 B_28 I1_dd28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I480_MN3 (VSS XI1_I480_Bn XI1_I480_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I480_MN0 (XI1_I480_An B_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I100_MN1 (XI1_I100_Bn I1_nakn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I100_MN5 (XI1_I100_n2 I1_nakn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I100_MN4 (I1_aa22 XI1_I100_An XI1_I100_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I100_MN2 (XI1_I100_n1 A_22 I1_aa22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I100_MN3 (VSS XI1_I100_Bn XI1_I100_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I100_MN0 (XI1_I100_An A_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I109_MN1 (XI1_I109_Bn I1_nakn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I109_MN5 (XI1_I109_n2 I1_nakn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I109_MN4 (I1_aa25 XI1_I109_An XI1_I109_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I109_MN2 (XI1_I109_n1 A_25 I1_aa25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I109_MN3 (VSS XI1_I109_Bn XI1_I109_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I109_MN0 (XI1_I109_An A_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I112_MN1 (XI1_I112_Bn I1_nakn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I112_MN5 (XI1_I112_n2 I1_nakn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I112_MN4 (I1_aa26 XI1_I112_An XI1_I112_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I112_MN2 (XI1_I112_n1 A_26 I1_aa26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I112_MN3 (VSS XI1_I112_Bn XI1_I112_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I112_MN0 (XI1_I112_An A_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I115_MN1 (XI1_I115_Bn I1_nakn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I115_MN5 (XI1_I115_n2 I1_nakn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I115_MN4 (I1_aa27 XI1_I115_An XI1_I115_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I115_MN2 (XI1_I115_n1 A_27 I1_aa27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I115_MN3 (VSS XI1_I115_Bn XI1_I115_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I115_MN0 (XI1_I115_An A_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I118_MN1 (XI1_I118_Bn I1_nakn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I118_MN5 (XI1_I118_n2 I1_nakn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I118_MN4 (I1_aa28 XI1_I118_An XI1_I118_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I118_MN2 (XI1_I118_n1 A_28 I1_aa28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I118_MN3 (VSS XI1_I118_Bn XI1_I118_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I118_MN0 (XI1_I118_An A_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I37_MN1 (XI1_I562_I37_Bn I1_b0_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I37_MN5 (XI1_I562_I37_n2 I1_b0_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I37_MN4 (I1_I562_pn5 XI1_I562_I37_An XI1_I562_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I37_MN2 (XI1_I562_I37_n1 VSS I1_I562_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I37_MN3 (VSS XI1_I562_I37_Bn XI1_I562_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I37_MN0 (XI1_I562_I37_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I233_MN1 (XI1_I562_I233_Bn I1_I562_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I233_MN5 (XI1_I562_I233_n2 I1_I562_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I233_MN4 (I1_p0_30 XI1_I562_I233_An XI1_I562_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I233_MN2 (XI1_I562_I233_n1 I1_I562_pn30 I1_p0_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I233_MN3 (VSS XI1_I562_I233_Bn XI1_I562_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I233_MN0 (XI1_I562_I233_An I1_I562_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I57_MN1 (XI1_I562_I57_Bn I1_b0_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I57_MN5 (XI1_I562_I57_n2 I1_b0_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I57_MN4 (I1_I562_pn25 XI1_I562_I57_An XI1_I562_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I57_MN2 (XI1_I562_I57_n1 VSS I1_I562_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I57_MN3 (VSS XI1_I562_I57_Bn XI1_I562_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I57_MN0 (XI1_I562_I57_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I62_MN1 (XI1_I1528_I62_Bn I1_b21_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I62_MN5 (XI1_I1528_I62_n2 I1_b21_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I62_MN4 (I1_I1528_pn30 XI1_I1528_I62_An XI1_I1528_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I62_MN2 (XI1_I1528_I62_n1 I1_p20_29 I1_I1528_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I62_MN3 (VSS XI1_I1528_I62_Bn XI1_I1528_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I62_MN0 (XI1_I1528_I62_An I1_p20_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I61_MN1 (XI1_I1528_I61_Bn I1_b21_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I61_MN5 (XI1_I1528_I61_n2 I1_b21_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I61_MN4 (I1_I1528_pn29 XI1_I1528_I61_An XI1_I1528_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I61_MN2 (XI1_I1528_I61_n1 I1_p20_28 I1_I1528_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I61_MN3 (VSS XI1_I1528_I61_Bn XI1_I1528_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I61_MN0 (XI1_I1528_I61_An I1_p20_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I60_MN1 (XI1_I1528_I60_Bn I1_b21_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I60_MN5 (XI1_I1528_I60_n2 I1_b21_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I60_MN4 (I1_I1528_pn28 XI1_I1528_I60_An XI1_I1528_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I60_MN2 (XI1_I1528_I60_n1 I1_p20_27 I1_I1528_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I60_MN3 (VSS XI1_I1528_I60_Bn XI1_I1528_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I60_MN0 (XI1_I1528_I60_An I1_p20_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I59_MN1 (XI1_I1528_I59_Bn I1_b21_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I59_MN5 (XI1_I1528_I59_n2 I1_b21_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I59_MN4 (I1_I1528_pn27 XI1_I1528_I59_An XI1_I1528_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I59_MN2 (XI1_I1528_I59_n1 I1_p20_26 I1_I1528_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I59_MN3 (VSS XI1_I1528_I59_Bn XI1_I1528_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I59_MN0 (XI1_I1528_I59_An I1_p20_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I226_MN1 (XI1_I1528_I226_Bn I1_I1528_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I226_MN5 (XI1_I1528_I226_n2 I1_I1528_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I226_MN4 (I1_p21_23 XI1_I1528_I226_An XI1_I1528_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I226_MN2 (XI1_I1528_I226_n1 I1_I1528_pn23 I1_p21_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I226_MN3 (VSS XI1_I1528_I226_Bn XI1_I1528_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I226_MN0 (XI1_I1528_I226_An I1_I1528_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I230_MN1 (XI1_I1528_I230_Bn I1_I1528_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I230_MN5 (XI1_I1528_I230_n2 I1_I1528_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I230_MN4 (I1_p21_27 XI1_I1528_I230_An XI1_I1528_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I230_MN2 (XI1_I1528_I230_n1 I1_I1528_pn27 I1_p21_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I230_MN3 (VSS XI1_I1528_I230_Bn XI1_I1528_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I230_MN0 (XI1_I1528_I230_An I1_I1528_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I224_MN1 (XI1_I1528_I224_Bn I1_I1528_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I224_MN5 (XI1_I1528_I224_n2 I1_I1528_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I224_MN4 (I1_p21_21 XI1_I1528_I224_An XI1_I1528_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I224_MN2 (XI1_I1528_I224_n1 I1_I1528_pn21 I1_p21_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I224_MN3 (VSS XI1_I1528_I224_Bn XI1_I1528_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I224_MN0 (XI1_I1528_I224_An I1_I1528_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I205_MN1 (XI1_I1528_I205_Bn I1_I1528_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I205_MN5 (XI1_I1528_I205_n2 I1_I1528_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I205_MN4 (I1_p21_2 XI1_I1528_I205_An XI1_I1528_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I205_MN2 (XI1_I1528_I205_n1 I1_I1528_pn2 I1_p21_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I205_MN3 (VSS XI1_I1528_I205_Bn XI1_I1528_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I205_MN0 (XI1_I1528_I205_An I1_I1528_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I44_MN1 (XI1_I1574_I44_Bn I1_b22_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I44_MN5 (XI1_I1574_I44_n2 I1_b22_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I44_MN4 (I1_I1574_pn12 XI1_I1574_I44_An XI1_I1574_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I44_MN2 (XI1_I1574_I44_n1 I1_p21_11 I1_I1574_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I44_MN3 (VSS XI1_I1574_I44_Bn XI1_I1574_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I44_MN0 (XI1_I1574_I44_An I1_p21_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I39_MN1 (XI1_I1574_I39_Bn I1_b22_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I39_MN5 (XI1_I1574_I39_n2 I1_b22_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I39_MN4 (I1_I1574_pn7 XI1_I1574_I39_An XI1_I1574_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I39_MN2 (XI1_I1574_I39_n1 I1_p21_6 I1_I1574_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I39_MN3 (VSS XI1_I1574_I39_Bn XI1_I1574_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I39_MN0 (XI1_I1574_I39_An I1_p21_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I76_MN1 (XI1_I76_Bn I1_nakn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I76_MN5 (XI1_I76_n2 I1_nakn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I76_MN4 (I1_aa14 XI1_I76_An XI1_I76_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I76_MN2 (XI1_I76_n1 A_14 I1_aa14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I76_MN3 (VSS XI1_I76_Bn XI1_I76_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I76_MN0 (XI1_I76_An A_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I73_MN1 (XI1_I73_Bn I1_nakn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I73_MN5 (XI1_I73_n2 I1_nakn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I73_MN4 (I1_aa13 XI1_I73_An XI1_I73_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I73_MN2 (XI1_I73_n1 A_13 I1_aa13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I73_MN3 (VSS XI1_I73_Bn XI1_I73_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I73_MN0 (XI1_I73_An A_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2115_MN1 (XI1_I2115_Bn I1_nqkn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2115_MN5 (XI1_I2115_n2 I1_nqkn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2115_MN4 (DIVQ_13 XI1_I2115_An XI1_I2115_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2115_MN2 (XI1_I2115_n1 I1_qu13_b3_5 DIVQ_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2115_MN3 (VSS XI1_I2115_Bn XI1_I2115_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2115_MN0 (XI1_I2115_An I1_qu13_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I246_MN1 (XI1_I246_Bn I1_nbkn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I246_MN5 (XI1_I246_n2 I1_nbkn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I246_MN4 (I1_dd10 XI1_I246_An XI1_I246_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I246_MN2 (XI1_I246_n1 B_10 I1_dd10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I246_MN3 (VSS XI1_I246_Bn XI1_I246_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I246_MN0 (XI1_I246_An B_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I259_MN1 (XI1_I259_Bn I1_nbkn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I259_MN5 (XI1_I259_n2 I1_nbkn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I259_MN4 (I1_dd11 XI1_I259_An XI1_I259_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I259_MN2 (XI1_I259_n1 B_11 I1_dd11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I259_MN3 (VSS XI1_I259_Bn XI1_I259_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I259_MN0 (XI1_I259_An B_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I82_MN1 (XI1_I82_Bn I1_nakn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I82_MN5 (XI1_I82_n2 I1_nakn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I82_MN4 (I1_aa16 XI1_I82_An XI1_I82_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I82_MN2 (XI1_I82_n1 A_16 I1_aa16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I82_MN3 (VSS XI1_I82_Bn XI1_I82_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I82_MN0 (XI1_I82_An A_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I272_MN1 (XI1_I272_Bn I1_nbkn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I272_MN5 (XI1_I272_n2 I1_nbkn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I272_MN4 (I1_dd12 XI1_I272_An XI1_I272_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I272_MN2 (XI1_I272_n1 B_12 I1_dd12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I272_MN3 (VSS XI1_I272_Bn XI1_I272_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I272_MN0 (XI1_I272_An B_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I168_MN1 (XI1_I168_Bn I1_nbkn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I168_MN5 (XI1_I168_n2 I1_nbkn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I168_MN4 (I1_dd4 XI1_I168_An XI1_I168_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I168_MN2 (XI1_I168_n1 B_4 I1_dd4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I168_MN3 (VSS XI1_I168_Bn XI1_I168_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I168_MN0 (XI1_I168_An B_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I285_MN1 (XI1_I285_Bn I1_nbkn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I285_MN5 (XI1_I285_n2 I1_nbkn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I285_MN4 (I1_dd13 XI1_I285_An XI1_I285_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I285_MN2 (XI1_I285_n1 B_13 I1_dd13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I285_MN3 (VSS XI1_I285_Bn XI1_I285_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I285_MN0 (XI1_I285_An B_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I298_MN1 (XI1_I298_Bn I1_nbkn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I298_MN5 (XI1_I298_n2 I1_nbkn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I298_MN4 (I1_dd14 XI1_I298_An XI1_I298_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I298_MN2 (XI1_I298_n1 B_14 I1_dd14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I298_MN3 (VSS XI1_I298_Bn XI1_I298_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I298_MN0 (XI1_I298_An B_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I311_MN1 (XI1_I311_Bn I1_nbkn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I311_MN5 (XI1_I311_n2 I1_nbkn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I311_MN4 (I1_dd15 XI1_I311_An XI1_I311_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I311_MN2 (XI1_I311_n1 B_15 I1_dd15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I311_MN3 (VSS XI1_I311_Bn XI1_I311_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I311_MN0 (XI1_I311_An B_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I324_MN1 (XI1_I324_Bn I1_nbkn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I324_MN5 (XI1_I324_n2 I1_nbkn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I324_MN4 (I1_dd16 XI1_I324_An XI1_I324_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I324_MN2 (XI1_I324_n1 B_16 I1_dd16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I324_MN3 (VSS XI1_I324_Bn XI1_I324_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I324_MN0 (XI1_I324_An B_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I350_MN1 (XI1_I350_Bn I1_nbkn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I350_MN5 (XI1_I350_n2 I1_nbkn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I350_MN4 (I1_dd18 XI1_I350_An XI1_I350_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I350_MN2 (XI1_I350_n1 B_18 I1_dd18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I350_MN3 (VSS XI1_I350_Bn XI1_I350_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I350_MN0 (XI1_I350_An B_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I363_MN1 (XI1_I363_Bn I1_nbkn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I363_MN5 (XI1_I363_n2 I1_nbkn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I363_MN4 (I1_dd19 XI1_I363_An XI1_I363_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I363_MN2 (XI1_I363_n1 B_19 I1_dd19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I363_MN3 (VSS XI1_I363_Bn XI1_I363_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I363_MN0 (XI1_I363_An B_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I415_MN1 (XI1_I415_Bn I1_nbkn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I415_MN5 (XI1_I415_n2 I1_nbkn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I415_MN4 (I1_dd23 XI1_I415_An XI1_I415_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I415_MN2 (XI1_I415_n1 B_23 I1_dd23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I415_MN3 (VSS XI1_I415_Bn XI1_I415_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I415_MN0 (XI1_I415_An B_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I454_MN1 (XI1_I454_Bn I1_nbkn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I454_MN5 (XI1_I454_n2 I1_nbkn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I454_MN4 (I1_dd26 XI1_I454_An XI1_I454_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I454_MN2 (XI1_I454_n1 B_26 I1_dd26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I454_MN3 (VSS XI1_I454_Bn XI1_I454_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I454_MN0 (XI1_I454_An B_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I467_MN1 (XI1_I467_Bn I1_nbkn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I467_MN5 (XI1_I467_n2 I1_nbkn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I467_MN4 (I1_dd27 XI1_I467_An XI1_I467_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I467_MN2 (XI1_I467_n1 B_27 I1_dd27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I467_MN3 (VSS XI1_I467_Bn XI1_I467_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I467_MN0 (XI1_I467_An B_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I38_MN1 (XI1_I562_I38_Bn I1_b0_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I38_MN5 (XI1_I562_I38_n2 I1_b0_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I38_MN4 (I1_I562_pn6 XI1_I562_I38_An XI1_I562_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I38_MN2 (XI1_I562_I38_n1 VSS I1_I562_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I38_MN3 (VSS XI1_I562_I38_Bn XI1_I562_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I38_MN0 (XI1_I562_I38_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I40_MN1 (XI1_I562_I40_Bn I1_b0_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I40_MN5 (XI1_I562_I40_n2 I1_b0_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I40_MN4 (I1_I562_pn8 XI1_I562_I40_An XI1_I562_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I40_MN2 (XI1_I562_I40_n1 VSS I1_I562_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I40_MN3 (VSS XI1_I562_I40_Bn XI1_I562_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I40_MN0 (XI1_I562_I40_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I42_MN1 (XI1_I562_I42_Bn I1_b0_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I42_MN5 (XI1_I562_I42_n2 I1_b0_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I42_MN4 (I1_I562_pn10 XI1_I562_I42_An XI1_I562_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I42_MN2 (XI1_I562_I42_n1 VSS I1_I562_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I42_MN3 (VSS XI1_I562_I42_Bn XI1_I562_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I42_MN0 (XI1_I562_I42_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I55_MN1 (XI1_I562_I55_Bn I1_b0_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I55_MN5 (XI1_I562_I55_n2 I1_b0_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I55_MN4 (I1_I562_pn23 XI1_I562_I55_An XI1_I562_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I55_MN2 (XI1_I562_I55_n1 VSS I1_I562_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I55_MN3 (VSS XI1_I562_I55_Bn XI1_I562_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I55_MN0 (XI1_I562_I55_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I62_MN1 (XI1_I562_I62_Bn I1_b0_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I62_MN5 (XI1_I562_I62_n2 I1_b0_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I62_MN4 (I1_I562_pn30 XI1_I562_I62_An XI1_I562_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I62_MN2 (XI1_I562_I62_n1 VSS I1_I562_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I62_MN3 (VSS XI1_I562_I62_Bn XI1_I562_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I62_MN0 (XI1_I562_I62_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I63_MN1 (XI1_I1528_I63_Bn I1_b21_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I63_MN5 (XI1_I1528_I63_n2 I1_b21_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I63_MN4 (I1_I1528_pn31 XI1_I1528_I63_An XI1_I1528_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I63_MN2 (XI1_I1528_I63_n1 I1_p20_30 I1_I1528_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I63_MN3 (VSS XI1_I1528_I63_Bn XI1_I1528_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I63_MN0 (XI1_I1528_I63_An I1_p20_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I234_MN1 (XI1_I1528_I234_Bn I1_c21_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I234_MN5 (XI1_I1528_I234_n2 I1_c21_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I234_MN4 (I1_p21_31 XI1_I1528_I234_An XI1_I1528_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I234_MN2 (XI1_I1528_I234_n1 I1_I1528_pn31 I1_p21_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I234_MN3 (VSS XI1_I1528_I234_Bn XI1_I1528_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I234_MN0 (XI1_I1528_I234_An I1_I1528_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I232_MN1 (XI1_I1528_I232_Bn I1_I1528_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I232_MN5 (XI1_I1528_I232_n2 I1_I1528_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I232_MN4 (I1_p21_29 XI1_I1528_I232_An XI1_I1528_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I232_MN2 (XI1_I1528_I232_n1 I1_I1528_pn29 I1_p21_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I232_MN3 (VSS XI1_I1528_I232_Bn XI1_I1528_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I232_MN0 (XI1_I1528_I232_An I1_I1528_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I228_MN1 (XI1_I1528_I228_Bn I1_I1528_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I228_MN5 (XI1_I1528_I228_n2 I1_I1528_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I228_MN4 (I1_p21_25 XI1_I1528_I228_An XI1_I1528_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I228_MN2 (XI1_I1528_I228_n1 I1_I1528_pn25 I1_p21_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I228_MN3 (VSS XI1_I1528_I228_Bn XI1_I1528_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I228_MN0 (XI1_I1528_I228_An I1_I1528_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I211_MN1 (XI1_I1528_I211_Bn I1_I1528_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I211_MN5 (XI1_I1528_I211_n2 I1_I1528_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I211_MN4 (I1_p21_8 XI1_I1528_I211_An XI1_I1528_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I211_MN2 (XI1_I1528_I211_n1 I1_I1528_pn8 I1_p21_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I211_MN3 (VSS XI1_I1528_I211_Bn XI1_I1528_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I211_MN0 (XI1_I1528_I211_An I1_I1528_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I209_MN1 (XI1_I1528_I209_Bn I1_I1528_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I209_MN5 (XI1_I1528_I209_n2 I1_I1528_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I209_MN4 (I1_p21_6 XI1_I1528_I209_An XI1_I1528_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I209_MN2 (XI1_I1528_I209_n1 I1_I1528_pn6 I1_p21_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I209_MN3 (VSS XI1_I1528_I209_Bn XI1_I1528_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I209_MN0 (XI1_I1528_I209_An I1_I1528_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I220_MN1 (XI1_I1528_I220_Bn I1_I1528_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I220_MN5 (XI1_I1528_I220_n2 I1_I1528_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I220_MN4 (I1_p21_17 XI1_I1528_I220_An XI1_I1528_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I220_MN2 (XI1_I1528_I220_n1 I1_I1528_pn17 I1_p21_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I220_MN3 (VSS XI1_I1528_I220_Bn XI1_I1528_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I220_MN0 (XI1_I1528_I220_An I1_I1528_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I41_MN1 (XI1_I1574_I41_Bn I1_b22_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I41_MN5 (XI1_I1574_I41_n2 I1_b22_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I41_MN4 (I1_I1574_pn9 XI1_I1574_I41_An XI1_I1574_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I41_MN2 (XI1_I1574_I41_n1 I1_p21_8 I1_I1574_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I41_MN3 (VSS XI1_I1574_I41_Bn XI1_I1574_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I41_MN0 (XI1_I1574_I41_An I1_p21_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I38_MN1 (XI1_I1574_I38_Bn I1_b22_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I38_MN5 (XI1_I1574_I38_n2 I1_b22_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I38_MN4 (I1_I1574_pn6 XI1_I1574_I38_An XI1_I1574_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I38_MN2 (XI1_I1574_I38_n1 I1_p21_5 I1_I1574_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I38_MN3 (VSS XI1_I1574_I38_Bn XI1_I1574_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I38_MN0 (XI1_I1574_I38_An I1_p21_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I70_MN1 (XI1_I70_Bn I1_nakn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I70_MN5 (XI1_I70_n2 I1_nakn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I70_MN4 (I1_aa12 XI1_I70_An XI1_I70_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I70_MN2 (XI1_I70_n1 A_12 I1_aa12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I70_MN3 (VSS XI1_I70_Bn XI1_I70_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I70_MN0 (XI1_I70_An A_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I220_MN1 (XI1_I220_Bn I1_nbkn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I220_MN5 (XI1_I220_n2 I1_nbkn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I220_MN4 (I1_dd8 XI1_I220_An XI1_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I220_MN2 (XI1_I220_n1 B_8 I1_dd8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I220_MN3 (VSS XI1_I220_Bn XI1_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I220_MN0 (XI1_I220_An B_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I181_MN1 (XI1_I181_Bn I1_nbkn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I181_MN5 (XI1_I181_n2 I1_nbkn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I181_MN4 (I1_dd5 XI1_I181_An XI1_I181_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I181_MN2 (XI1_I181_n1 B_5 I1_dd5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I181_MN3 (VSS XI1_I181_Bn XI1_I181_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I181_MN0 (XI1_I181_An B_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I155_MN1 (XI1_I155_Bn I1_nbkn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I155_MN5 (XI1_I155_n2 I1_nbkn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I155_MN4 (I1_dd3 XI1_I155_An XI1_I155_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I155_MN2 (XI1_I155_n1 B_3 I1_dd3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I155_MN3 (VSS XI1_I155_Bn XI1_I155_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I155_MN0 (XI1_I155_An B_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I142_MN1 (XI1_I142_Bn I1_nbkn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I142_MN5 (XI1_I142_n2 I1_nbkn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I142_MN4 (I1_dd2 XI1_I142_An XI1_I142_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I142_MN2 (XI1_I142_n1 B_2 I1_dd2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I142_MN3 (VSS XI1_I142_Bn XI1_I142_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I142_MN0 (XI1_I142_An B_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I129_MN1 (XI1_I129_Bn I1_nbkn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I129_MN5 (XI1_I129_n2 I1_nbkn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I129_MN4 (I1_dd1 XI1_I129_An XI1_I129_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I129_MN2 (XI1_I129_n1 B_1 I1_dd1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I129_MN3 (VSS XI1_I129_Bn XI1_I129_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I129_MN0 (XI1_I129_An B_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I48_MN1 (XI2_I1_I42_I48_Bn I2_I1_bx16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I48_MN5 (XI2_I1_I42_I48_n2 I2_I1_bx16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I48_MN4 (I2_I1_I42_pn16 XI2_I1_I42_I48_An XI2_I1_I42_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I48_MN2 (XI2_I1_I42_I48_n1 A_16 I2_I1_I42_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I48_MN3 (VSS XI2_I1_I42_I48_Bn XI2_I1_I42_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I48_MN0 (XI2_I1_I42_I48_An A_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I337_MN1 (XI1_I337_Bn I1_nbkn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I337_MN5 (XI1_I337_n2 I1_nbkn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I337_MN4 (I1_dd17 XI1_I337_An XI1_I337_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I337_MN2 (XI1_I337_n1 B_17 I1_dd17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I337_MN3 (VSS XI1_I337_Bn XI1_I337_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I337_MN0 (XI1_I337_An B_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I49_MN1 (XI2_I1_I42_I49_Bn I2_I1_bx17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I49_MN5 (XI2_I1_I42_I49_n2 I2_I1_bx17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I49_MN4 (I2_I1_I42_pn17 XI2_I1_I42_I49_An XI2_I1_I42_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I49_MN2 (XI2_I1_I42_I49_n1 A_17 I2_I1_I42_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I49_MN3 (VSS XI2_I1_I42_I49_Bn XI2_I1_I42_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I49_MN0 (XI2_I1_I42_I49_An A_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I223_MN1 (XI2_I1_I42_I223_Bn I2_I1_I42_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I223_MN5 (XI2_I1_I42_I223_n2 I2_I1_I42_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I223_MN4 (I2_S_20 XI2_I1_I42_I223_An XI2_I1_I42_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I223_MN2 (XI2_I1_I42_I223_n1 I2_I1_I42_pn20 I2_S_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I223_MN3 (VSS XI2_I1_I42_I223_Bn XI2_I1_I42_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I223_MN0 (XI2_I1_I42_I223_An I2_I1_I42_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
