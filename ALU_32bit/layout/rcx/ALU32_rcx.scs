    I_MXI0_I1660_I187_XP_MN1 (VSS I0_I1660_pn56 I0_I1660_P57_56 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I183_XP_MN0 (I0_I1660_P53_52 I0_I1660_pn53 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I183_XP_MN1 (VSS I0_I1660_pn52 I0_I1660_P53_52 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I153_XP_MN0 (I1_I1850_P28_21 I1_I1850_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I153_XP_MN1 (VSS I1_I1850_P24_21n I1_I1850_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I91_XP_MN0 (I1_I1896_P25_24 I1_I1896_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I91_XP_MN1 (VSS I1_I1896_pn24 I1_I1896_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I156_XP_MN0 (I1_I1896_P31_24 I1_I1896_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I156_XP_MN1 (VSS I1_I1896_P27_24n I1_I1896_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I92_XP_MN0 (I1_I1896_P26_25 I1_I1896_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I92_XP_MN1 (VSS I1_I1896_pn25 I1_I1896_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I155_XP_MN0 (I1_I1896_P30_23 I1_I1896_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I155_XP_MN1 (VSS I1_I1896_P26_23n I1_I1896_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I93_XP_MN0 (I1_I1942_P27_26 I1_I1942_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I93_XP_MN1 (VSS I1_I1942_pn26 I1_I1942_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I92_XP_MN0 (I1_I1942_P26_25 I1_I1942_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I92_XP_MN1 (VSS I1_I1942_pn25 I1_I1942_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I93_XP_MN0 (I1_I1988_P27_26 I1_I1988_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I93_XP_MN1 (VSS I1_I1988_pn26 I1_I1988_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I92_XP_MN0 (I1_I1988_P26_25 I1_I1988_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I92_XP_MN1 (VSS I1_I1988_pn25 I1_I1988_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I90_XP_MN0 (I1_I2066_P24_23 I1_I2066_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I90_XP_MN1 (VSS I1_I2066_pn23 I1_I2066_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I155_XP_MN0 (I1_I2066_P30_23 I1_I2066_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I155_XP_MN1 (VSS I1_I2066_P26_23n I1_I2066_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I91_XP_MN0 (I1_I2066_P25_24 I1_I2066_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I91_XP_MN1 (VSS I1_I2066_pn24 I1_I2066_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I154_XP_MN0 (I1_I2066_P29_22 I1_I2066_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I154_XP_MN1 (VSS I1_I2066_P25_22n I1_I2066_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I152_XP_MN0 (I1_I2066_P27_20 I1_I2066_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I152_XP_MN1 (VSS I1_I2066_P23_20n I1_I2066_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I53_MN0 (I2_I4_z2_5 I2_I4_z1_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I53_MN1 (VSS I2_I4_z1_11 I2_I4_z2_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I25_MN0 (I2_I4_z0_25 Y_50 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I25_MN1 (VSS Y_51 I2_I4_z0_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I23_MN0 (I2_I4_z0_23 Y_46 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I23_MN1 (VSS Y_47 I2_I4_z0_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I315_XP_MN0 (I0_I1660_P62_55 I0_I1660_P62_59n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I315_XP_MN1 (VSS I0_I1660_P58_55n I0_I1660_P62_55 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I184_XP_MN0 (I0_I1660_P54_53 I0_I1660_pn54 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I184_XP_MN1 (VSS I0_I1660_pn53 I0_I1660_P54_53 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I188_XP_MN0 (I0_I1660_P58_57 I0_I1660_pn58 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I188_XP_MN1 (VSS I0_I1660_pn57 I0_I1660_P58_57 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I186_XP_MN0 (I0_I1660_P56_55 I0_I1660_pn56 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I186_XP_MN1 (VSS I0_I1660_pn55 I0_I1660_P56_55 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I191_XP_MN0 (I0_I1660_P61_60 I0_I1660_pn61 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I191_XP_MN1 (VSS I0_I1660_pn60 I0_I1660_P61_60 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I185_XP_MN0 (I0_I1660_P55_54 I0_I1660_pn55 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I185_XP_MN1 (VSS I0_I1660_pn54 I0_I1660_P55_54 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I97_XP_MN0 (I1_I1850_P31_30 I1_I1850_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I97_XP_MN1 (VSS I1_I1850_pn30 I1_I1850_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I95_XP_MN0 (I1_I1850_P29_28 I1_I1850_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I95_XP_MN1 (VSS I1_I1850_pn28 I1_I1850_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I96_XP_MN0 (I1_I1850_P30_29 I1_I1850_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I96_XP_MN1 (VSS I1_I1850_pn29 I1_I1850_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I93_XP_MN0 (I1_I1850_P27_26 I1_I1850_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I93_XP_MN1 (VSS I1_I1850_pn26 I1_I1850_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I92_XP_MN0 (I1_I1850_P26_25 I1_I1850_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I92_XP_MN1 (VSS I1_I1850_pn25 I1_I1850_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I155_XP_MN0 (I1_I1850_P30_23 I1_I1850_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I155_XP_MN1 (VSS I1_I1850_P26_23n I1_I1850_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I93_XP_MN0 (I1_I1896_P27_26 I1_I1896_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I93_XP_MN1 (VSS I1_I1896_pn26 I1_I1896_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I95_XP_MN0 (I1_I1942_P29_28 I1_I1942_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I95_XP_MN1 (VSS I1_I1942_pn28 I1_I1942_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I97_XP_MN0 (I1_I1942_P31_30 I1_I1942_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I97_XP_MN1 (VSS I1_I1942_pn30 I1_I1942_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I94_XP_MN0 (I1_I1942_P28_27 I1_I1942_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I94_XP_MN1 (VSS I1_I1942_pn27 I1_I1942_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I96_XP_MN0 (I1_I1942_P30_29 I1_I1942_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I96_XP_MN1 (VSS I1_I1942_pn29 I1_I1942_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I95_XP_MN0 (I1_I1988_P29_28 I1_I1988_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I95_XP_MN1 (VSS I1_I1988_pn28 I1_I1988_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I94_XP_MN0 (I1_I1988_P28_27 I1_I1988_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I94_XP_MN1 (VSS I1_I1988_pn27 I1_I1988_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I96_XP_MN0 (I1_I1988_P30_29 I1_I1988_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I96_XP_MN1 (VSS I1_I1988_pn29 I1_I1988_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I92_XP_MN0 (I1_I2066_P26_25 I1_I2066_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I92_XP_MN1 (VSS I1_I2066_pn25 I1_I2066_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I94_XP_MN0 (I1_I2066_P28_27 I1_I2066_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I94_XP_MN1 (VSS I1_I2066_pn27 I1_I2066_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I93_XP_MN0 (I1_I2066_P27_26 I1_I2066_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I93_XP_MN1 (VSS I1_I2066_pn26 I1_I2066_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I156_XP_MN0 (I1_I2066_P31_24 I1_I2066_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I156_XP_MN1 (VSS I1_I2066_P27_24n I1_I2066_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I16_MN0 (I2_I4_z0_16 Y_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I16_MN1 (VSS Y_33 I2_I4_z0_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I52_MN0 (I2_I4_z2_4 I2_I4_z1_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I52_MN1 (VSS I2_I4_z1_9 I2_I4_z2_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I24_MN0 (I2_I4_z0_24 Y_48 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I24_MN1 (VSS Y_49 I2_I4_z0_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I54_MN0 (I2_I4_z2_6 I2_I4_z1_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I54_MN1 (VSS I2_I4_z1_13 I2_I4_z2_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I26_MN0 (I2_I4_z0_26 Y_52 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I26_MN1 (VSS Y_53 I2_I4_z0_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I27_MN0 (I2_I4_z0_27 Y_54 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I27_MN1 (VSS Y_55 I2_I4_z0_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I190_XP_MN0 (I0_I1660_P60_59 I0_I1660_pn60 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I190_XP_MN1 (VSS I0_I1660_pn59 I0_I1660_P60_59 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I94_XP_MN0 (I1_I1850_P28_27 I1_I1850_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I94_XP_MN1 (VSS I1_I1850_pn27 I1_I1850_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I95_XP_MN0 (I1_I1896_P29_28 I1_I1896_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I95_XP_MN1 (VSS I1_I1896_pn28 I1_I1896_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I97_XP_MN0 (I1_I1896_P31_30 I1_I1896_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I97_XP_MN1 (VSS I1_I1896_pn30 I1_I1896_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I96_XP_MN0 (I1_I1896_P30_29 I1_I1896_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I96_XP_MN1 (VSS I1_I1896_pn29 I1_I1896_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I94_XP_MN0 (I1_I1896_P28_27 I1_I1896_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I94_XP_MN1 (VSS I1_I1896_pn27 I1_I1896_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I97_XP_MN0 (I1_I1988_P31_30 I1_I1988_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I97_XP_MN1 (VSS I1_I1988_pn30 I1_I1988_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I96_XP_MN0 (I1_I2066_P30_29 I1_I2066_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I96_XP_MN1 (VSS I1_I2066_pn29 I1_I2066_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I97_XP_MN0 (I1_I2066_P31_30 I1_I2066_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I97_XP_MN1 (VSS I1_I2066_pn30 I1_I2066_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I95_XP_MN0 (I1_I2066_P29_28 I1_I2066_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I95_XP_MN1 (VSS I1_I2066_pn28 I1_I2066_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I17_MN0 (I2_I4_z0_17 Y_34 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I17_MN1 (VSS Y_35 I2_I4_z0_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I19_MN0 (I2_I4_z0_19 Y_38 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I19_MN1 (VSS Y_39 I2_I4_z0_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I18_MN0 (I2_I4_z0_18 Y_36 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I18_MN1 (VSS Y_37 I2_I4_z0_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I61_MN0 (I2_I4_z4_1 I2_I4_z3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I61_MN1 (VSS I2_I4_z3_3 I2_I4_z4_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I28_MN0 (I2_I4_z0_28 Y_56 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I28_MN1 (VSS Y_57 I2_I4_z0_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I55_MN0 (I2_I4_z2_7 I2_I4_z1_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I55_MN1 (VSS I2_I4_z1_15 I2_I4_z2_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I29_MN0 (I2_I4_z0_29 Y_58 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I29_MN1 (VSS Y_59 I2_I4_z0_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I31_MN0 (I2_I4_z0_31 Y_62 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I31_MN1 (VSS Y_63 I2_I4_z0_31 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I30_MN0 (I2_I4_z0_30 Y_60 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I30_MN1 (VSS Y_61 I2_I4_z0_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I192_XP_MN0 (I0_I1660_P62_61 I0_I1660_pn62 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I192_XP_MN1 (VSS I0_I1660_pn61 I0_I1660_P62_61 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I193_XP_MN0 (I0_I1660_P63_62 I0_I1660_pn63 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I193_XP_MN1 (VSS I0_I1660_pn62 I0_I1660_P63_62 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1438_MN34 (XI0_I1438_bn3 XI0_I1438_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1438_MN35 (VSS I0_pp3_28 XI0_I1438_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1438_MN36 (XI0_I1438_bn3 I0_cm73_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1438_MN37 (XI0_I1438_bsn XI0_I1438_bcon XI0_I1438_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1438_MN40 (XI0_I1438_bn5 I0_cm73_2 XI0_I1438_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1438_MN39 (XI0_I1438_bn4 I0_pp3_28 XI0_I1438_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1438_MN39_1 (XI0_I1438_bn5 I0_pp3_28 XI0_I1438_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1438_MN40_1 (XI0_I1438_bsn I0_cm73_2 XI0_I1438_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1438_MN53 (VSS XI0_I1438_bsn I0_cm77_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1438_MN29 (XI0_I1438_bn1 XI0_I1438_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1438_MN30 (XI0_I1438_bcon I0_pp3_28 XI0_I1438_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1438_MN33 (XI0_I1438_bn2 I0_cm73_2 XI0_I1438_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1438_MN31 (VSS XI0_I1438_s1 XI0_I1438_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1438_MN32 (XI0_I1438_bn2 I0_pp3_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1438_MN55 (VSS XI0_I1438_bcon I0_cm77_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1438_MN38 (XI0_I1438_bn4 XI0_I1438_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1438_MN38_1 (VSS XI0_I1438_s1 XI0_I1438_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1438_MN25 (VSS XI0_I1438_asn XI0_I1438_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1438_MN10 (VSS I0_pp0_32 XI0_I1438_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1438_MN6 (XI0_I1438_an3 I0_pp0_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1438_MN9 (XI0_I1438_asn XI0_I1438_acon XI0_I1438_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1438_MN12 (XI0_I1438_an5 I0_pp2_30 XI0_I1438_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1438_MN11 (XI0_I1438_an4 I0_pp1_32 XI0_I1438_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1438_MN11_1 (XI0_I1438_an5 I0_pp1_32 XI0_I1438_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1438_MN12_1 (XI0_I1438_asn I0_pp2_30 XI0_I1438_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1438_MN10_1 (XI0_I1438_an4 I0_pp0_32 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1438_MN5 (XI0_I1438_acon I0_pp2_30 XI0_I1438_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1438_MN2 (XI0_I1438_an1 I0_pp1_32 XI0_I1438_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1438_MN1 (VSS I0_pp0_32 XI0_I1438_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1438_MN3 (XI0_I1438_an2 I0_pp0_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1438_MN4 (VSS I0_pp1_32 XI0_I1438_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1438_MN27 (I0_cm77_2 XI0_I1438_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1438_MN7 (XI0_I1438_an3 I0_pp1_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1438_MN8 (VSS I0_pp2_30 XI0_I1438_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1442_MN34 (XI0_I1442_bn3 XI0_I1442_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1442_MN35 (VSS I0_pp3_29 XI0_I1442_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1442_MN36 (XI0_I1442_bn3 I0_cm77_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1442_MN37 (XI0_I1442_bsn XI0_I1442_bcon XI0_I1442_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1442_MN40 (XI0_I1442_bn5 I0_cm77_2 XI0_I1442_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1442_MN39 (XI0_I1442_bn4 I0_pp3_29 XI0_I1442_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1442_MN39_1 (XI0_I1442_bn5 I0_pp3_29 XI0_I1442_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1442_MN40_1 (XI0_I1442_bsn I0_cm77_2 XI0_I1442_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1442_MN53 (VSS XI0_I1442_bsn I0_cm81_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1442_MN29 (XI0_I1442_bn1 XI0_I1442_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1442_MN30 (XI0_I1442_bcon I0_pp3_29 XI0_I1442_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1442_MN33 (XI0_I1442_bn2 I0_cm77_2 XI0_I1442_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1442_MN31 (VSS XI0_I1442_s1 XI0_I1442_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1442_MN32 (XI0_I1442_bn2 I0_pp3_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1442_MN55 (VSS XI0_I1442_bcon I0_cm81_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1442_MN38 (XI0_I1442_bn4 XI0_I1442_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1442_MN38_1 (VSS XI0_I1442_s1 XI0_I1442_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1442_MN25 (VSS XI0_I1442_asn XI0_I1442_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1442_MN10 (VSS I0_sn0 XI0_I1442_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1442_MN6 (XI0_I1442_an3 I0_sn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1442_MN9 (XI0_I1442_asn XI0_I1442_acon XI0_I1442_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1442_MN12 (XI0_I1442_an5 I0_pp2_31 XI0_I1442_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1442_MN11 (XI0_I1442_an4 I0_sn1 XI0_I1442_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1442_MN11_1 (XI0_I1442_an5 I0_sn1 XI0_I1442_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1442_MN12_1 (XI0_I1442_asn I0_pp2_31 XI0_I1442_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1442_MN10_1 (XI0_I1442_an4 I0_sn0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1442_MN5 (XI0_I1442_acon I0_pp2_31 XI0_I1442_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1442_MN2 (XI0_I1442_an1 I0_sn1 XI0_I1442_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1442_MN1 (VSS I0_sn0 XI0_I1442_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1442_MN3 (XI0_I1442_an2 I0_sn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1442_MN4 (VSS I0_sn1 XI0_I1442_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1442_MN27 (I0_cm81_2 XI0_I1442_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1442_MN7 (XI0_I1442_an3 I0_sn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1442_MN8 (VSS I0_pp2_31 XI0_I1442_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1407_MN34 (XI0_I1407_bn3 XI0_I1407_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1407_MN35 (VSS I0_pp3_20 XI0_I1407_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1407_MN36 (XI0_I1407_bn3 I0_cm43_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1407_MN37 (XI0_I1407_bsn XI0_I1407_bcon XI0_I1407_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1407_MN40 (XI0_I1407_bn5 I0_cm43_2 XI0_I1407_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1407_MN39 (XI0_I1407_bn4 I0_pp3_20 XI0_I1407_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1407_MN39_1 (XI0_I1407_bn5 I0_pp3_20 XI0_I1407_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1407_MN40_1 (XI0_I1407_bsn I0_cm43_2 XI0_I1407_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1407_MN53 (VSS XI0_I1407_bsn I0_cm46_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1407_MN29 (XI0_I1407_bn1 XI0_I1407_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1407_MN30 (XI0_I1407_bcon I0_pp3_20 XI0_I1407_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1407_MN33 (XI0_I1407_bn2 I0_cm43_2 XI0_I1407_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1407_MN31 (VSS XI0_I1407_s1 XI0_I1407_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1407_MN32 (XI0_I1407_bn2 I0_pp3_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1407_MN55 (VSS XI0_I1407_bcon I0_cm46_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1407_MN38 (XI0_I1407_bn4 XI0_I1407_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1407_MN38_1 (VSS XI0_I1407_s1 XI0_I1407_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1407_MN25 (VSS XI0_I1407_asn XI0_I1407_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1407_MN10 (VSS I0_pp0_26 XI0_I1407_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1407_MN6 (XI0_I1407_an3 I0_pp0_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1407_MN9 (XI0_I1407_asn XI0_I1407_acon XI0_I1407_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1407_MN12 (XI0_I1407_an5 I0_pp2_22 XI0_I1407_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1407_MN11 (XI0_I1407_an4 I0_pp1_24 XI0_I1407_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1407_MN11_1 (XI0_I1407_an5 I0_pp1_24 XI0_I1407_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1407_MN12_1 (XI0_I1407_asn I0_pp2_22 XI0_I1407_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1407_MN10_1 (XI0_I1407_an4 I0_pp0_26 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1407_MN5 (XI0_I1407_acon I0_pp2_22 XI0_I1407_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1407_MN2 (XI0_I1407_an1 I0_pp1_24 XI0_I1407_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1407_MN1 (VSS I0_pp0_26 XI0_I1407_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1407_MN3 (XI0_I1407_an2 I0_pp0_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1407_MN4 (VSS I0_pp1_24 XI0_I1407_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1407_MN27 (I0_cm46_2 XI0_I1407_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1407_MN7 (XI0_I1407_an3 I0_pp1_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1407_MN8 (VSS I0_pp2_22 XI0_I1407_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1426_MN34 (XI0_I1426_bn3 XI0_I1426_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1426_MN35 (VSS I0_pp3_25 XI0_I1426_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1426_MN36 (XI0_I1426_bn3 I0_cm61_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1426_MN37 (XI0_I1426_bsn XI0_I1426_bcon XI0_I1426_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1426_MN40 (XI0_I1426_bn5 I0_cm61_2 XI0_I1426_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1426_MN39 (XI0_I1426_bn4 I0_pp3_25 XI0_I1426_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1426_MN39_1 (XI0_I1426_bn5 I0_pp3_25 XI0_I1426_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1426_MN40_1 (XI0_I1426_bsn I0_cm61_2 XI0_I1426_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1426_MN53 (VSS XI0_I1426_bsn I0_cm65_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1426_MN29 (XI0_I1426_bn1 XI0_I1426_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1426_MN30 (XI0_I1426_bcon I0_pp3_25 XI0_I1426_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1426_MN33 (XI0_I1426_bn2 I0_cm61_2 XI0_I1426_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1426_MN31 (VSS XI0_I1426_s1 XI0_I1426_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1426_MN32 (XI0_I1426_bn2 I0_pp3_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1426_MN55 (VSS XI0_I1426_bcon I0_cm65_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1426_MN38 (XI0_I1426_bn4 XI0_I1426_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1426_MN38_1 (VSS XI0_I1426_s1 XI0_I1426_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1426_MN25 (VSS XI0_I1426_asn XI0_I1426_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1426_MN10 (VSS I0_pp0_31 XI0_I1426_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1426_MN6 (XI0_I1426_an3 I0_pp0_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1426_MN9 (XI0_I1426_asn XI0_I1426_acon XI0_I1426_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1426_MN12 (XI0_I1426_an5 I0_pp2_27 XI0_I1426_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1426_MN11 (XI0_I1426_an4 I0_pp1_29 XI0_I1426_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1426_MN11_1 (XI0_I1426_an5 I0_pp1_29 XI0_I1426_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1426_MN12_1 (XI0_I1426_asn I0_pp2_27 XI0_I1426_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1426_MN10_1 (XI0_I1426_an4 I0_pp0_31 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1426_MN5 (XI0_I1426_acon I0_pp2_27 XI0_I1426_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1426_MN2 (XI0_I1426_an1 I0_pp1_29 XI0_I1426_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1426_MN1 (VSS I0_pp0_31 XI0_I1426_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1426_MN3 (XI0_I1426_an2 I0_pp0_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1426_MN4 (VSS I0_pp1_29 XI0_I1426_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1426_MN27 (I0_cm65_2 XI0_I1426_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1426_MN7 (XI0_I1426_an3 I0_pp1_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1426_MN8 (VSS I0_pp2_27 XI0_I1426_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1430_MN34 (XI0_I1430_bn3 XI0_I1430_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1430_MN35 (VSS I0_pp3_26 XI0_I1430_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1430_MN36 (XI0_I1430_bn3 I0_cm65_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1430_MN37 (XI0_I1430_bsn XI0_I1430_bcon XI0_I1430_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1430_MN40 (XI0_I1430_bn5 I0_cm65_2 XI0_I1430_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1430_MN39 (XI0_I1430_bn4 I0_pp3_26 XI0_I1430_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1430_MN39_1 (XI0_I1430_bn5 I0_pp3_26 XI0_I1430_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1430_MN40_1 (XI0_I1430_bsn I0_cm65_2 XI0_I1430_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1430_MN53 (VSS XI0_I1430_bsn I0_cm69_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1430_MN29 (XI0_I1430_bn1 XI0_I1430_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1430_MN30 (XI0_I1430_bcon I0_pp3_26 XI0_I1430_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1430_MN33 (XI0_I1430_bn2 I0_cm65_2 XI0_I1430_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1430_MN31 (VSS XI0_I1430_s1 XI0_I1430_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1430_MN32 (XI0_I1430_bn2 I0_pp3_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1430_MN55 (VSS XI0_I1430_bcon I0_cm69_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1430_MN38 (XI0_I1430_bn4 XI0_I1430_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1430_MN38_1 (VSS XI0_I1430_s1 XI0_I1430_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1430_MN25 (VSS XI0_I1430_asn XI0_I1430_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1430_MN10 (VSS I0_pp0_32 XI0_I1430_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1430_MN6 (XI0_I1430_an3 I0_pp0_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1430_MN9 (XI0_I1430_asn XI0_I1430_acon XI0_I1430_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1430_MN12 (XI0_I1430_an5 I0_pp2_28 XI0_I1430_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1430_MN11 (XI0_I1430_an4 I0_pp1_30 XI0_I1430_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1430_MN11_1 (XI0_I1430_an5 I0_pp1_30 XI0_I1430_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1430_MN12_1 (XI0_I1430_asn I0_pp2_28 XI0_I1430_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1430_MN10_1 (XI0_I1430_an4 I0_pp0_32 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1430_MN5 (XI0_I1430_acon I0_pp2_28 XI0_I1430_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1430_MN2 (XI0_I1430_an1 I0_pp1_30 XI0_I1430_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1430_MN1 (VSS I0_pp0_32 XI0_I1430_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1430_MN3 (XI0_I1430_an2 I0_pp0_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1430_MN4 (VSS I0_pp1_30 XI0_I1430_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1430_MN27 (I0_cm69_2 XI0_I1430_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1430_MN7 (XI0_I1430_an3 I0_pp1_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1430_MN8 (VSS I0_pp2_28 XI0_I1430_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1434_MN34 (XI0_I1434_bn3 XI0_I1434_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1434_MN35 (VSS I0_pp3_27 XI0_I1434_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1434_MN36 (XI0_I1434_bn3 I0_cm69_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1434_MN37 (XI0_I1434_bsn XI0_I1434_bcon XI0_I1434_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1434_MN40 (XI0_I1434_bn5 I0_cm69_2 XI0_I1434_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1434_MN39 (XI0_I1434_bn4 I0_pp3_27 XI0_I1434_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1434_MN39_1 (XI0_I1434_bn5 I0_pp3_27 XI0_I1434_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1434_MN40_1 (XI0_I1434_bsn I0_cm69_2 XI0_I1434_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1434_MN53 (VSS XI0_I1434_bsn I0_cm73_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1434_MN29 (XI0_I1434_bn1 XI0_I1434_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1434_MN30 (XI0_I1434_bcon I0_pp3_27 XI0_I1434_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1434_MN33 (XI0_I1434_bn2 I0_cm69_2 XI0_I1434_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1434_MN31 (VSS XI0_I1434_s1 XI0_I1434_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1434_MN32 (XI0_I1434_bn2 I0_pp3_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1434_MN55 (VSS XI0_I1434_bcon I0_cm73_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1434_MN38 (XI0_I1434_bn4 XI0_I1434_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1434_MN38_1 (VSS XI0_I1434_s1 XI0_I1434_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1434_MN25 (VSS XI0_I1434_asn XI0_I1434_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1434_MN10 (VSS I0_pp0_32 XI0_I1434_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1434_MN6 (XI0_I1434_an3 I0_pp0_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1434_MN9 (XI0_I1434_asn XI0_I1434_acon XI0_I1434_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1434_MN12 (XI0_I1434_an5 I0_pp2_29 XI0_I1434_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1434_MN11 (XI0_I1434_an4 I0_pp1_31 XI0_I1434_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1434_MN11_1 (XI0_I1434_an5 I0_pp1_31 XI0_I1434_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1434_MN12_1 (XI0_I1434_asn I0_pp2_29 XI0_I1434_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1434_MN10_1 (XI0_I1434_an4 I0_pp0_32 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1434_MN5 (XI0_I1434_acon I0_pp2_29 XI0_I1434_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1434_MN2 (XI0_I1434_an1 I0_pp1_31 XI0_I1434_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1434_MN1 (VSS I0_pp0_32 XI0_I1434_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1434_MN3 (XI0_I1434_an2 I0_pp0_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1434_MN4 (VSS I0_pp1_31 XI0_I1434_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1434_MN27 (I0_cm73_2 XI0_I1434_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1434_MN7 (XI0_I1434_an3 I0_pp1_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1434_MN8 (VSS I0_pp2_29 XI0_I1434_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1387_MN34 (XI0_I1387_bn3 XI0_I1387_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1387_MN35 (VSS I0_pp3_13 XI0_I1387_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1387_MN36 (XI0_I1387_bn3 I0_cm23_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1387_MN37 (XI0_I1387_bsn XI0_I1387_bcon XI0_I1387_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1387_MN40 (XI0_I1387_bn5 I0_cm23_2 XI0_I1387_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1387_MN39 (XI0_I1387_bn4 I0_pp3_13 XI0_I1387_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1387_MN39_1 (XI0_I1387_bn5 I0_pp3_13 XI0_I1387_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1387_MN40_1 (XI0_I1387_bsn I0_cm23_2 XI0_I1387_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1387_MN53 (VSS XI0_I1387_bsn I0_cm26_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1387_MN29 (XI0_I1387_bn1 XI0_I1387_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1387_MN30 (XI0_I1387_bcon I0_pp3_13 XI0_I1387_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1387_MN33 (XI0_I1387_bn2 I0_cm23_2 XI0_I1387_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1387_MN31 (VSS XI0_I1387_s1 XI0_I1387_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1387_MN32 (XI0_I1387_bn2 I0_pp3_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1387_MN55 (VSS XI0_I1387_bcon I0_cm26_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1387_MN38 (XI0_I1387_bn4 XI0_I1387_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1387_MN38_1 (VSS XI0_I1387_s1 XI0_I1387_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1387_MN25 (VSS XI0_I1387_asn XI0_I1387_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1387_MN10 (VSS I0_pp0_19 XI0_I1387_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1387_MN6 (XI0_I1387_an3 I0_pp0_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1387_MN9 (XI0_I1387_asn XI0_I1387_acon XI0_I1387_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1387_MN12 (XI0_I1387_an5 I0_pp2_15 XI0_I1387_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1387_MN11 (XI0_I1387_an4 I0_pp1_17 XI0_I1387_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1387_MN11_1 (XI0_I1387_an5 I0_pp1_17 XI0_I1387_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1387_MN12_1 (XI0_I1387_asn I0_pp2_15 XI0_I1387_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1387_MN10_1 (XI0_I1387_an4 I0_pp0_19 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1387_MN5 (XI0_I1387_acon I0_pp2_15 XI0_I1387_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1387_MN2 (XI0_I1387_an1 I0_pp1_17 XI0_I1387_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1387_MN1 (VSS I0_pp0_19 XI0_I1387_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1387_MN3 (XI0_I1387_an2 I0_pp0_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1387_MN4 (VSS I0_pp1_17 XI0_I1387_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1387_MN27 (I0_cm26_2 XI0_I1387_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1387_MN7 (XI0_I1387_an3 I0_pp1_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1387_MN8 (VSS I0_pp2_15 XI0_I1387_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1389_MN34 (XI0_I1389_bn3 XI0_I1389_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1389_MN35 (VSS I0_pp3_14 XI0_I1389_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1389_MN36 (XI0_I1389_bn3 I0_cm26_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1389_MN37 (XI0_I1389_bsn XI0_I1389_bcon XI0_I1389_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1389_MN40 (XI0_I1389_bn5 I0_cm26_2 XI0_I1389_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1389_MN39 (XI0_I1389_bn4 I0_pp3_14 XI0_I1389_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1389_MN39_1 (XI0_I1389_bn5 I0_pp3_14 XI0_I1389_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1389_MN40_1 (XI0_I1389_bsn I0_cm26_2 XI0_I1389_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1389_MN53 (VSS XI0_I1389_bsn I0_cm28_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1389_MN29 (XI0_I1389_bn1 XI0_I1389_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1389_MN30 (XI0_I1389_bcon I0_pp3_14 XI0_I1389_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1389_MN33 (XI0_I1389_bn2 I0_cm26_2 XI0_I1389_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1389_MN31 (VSS XI0_I1389_s1 XI0_I1389_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1389_MN32 (XI0_I1389_bn2 I0_pp3_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1389_MN55 (VSS XI0_I1389_bcon I0_cm28_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1389_MN38 (XI0_I1389_bn4 XI0_I1389_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1389_MN38_1 (VSS XI0_I1389_s1 XI0_I1389_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1389_MN25 (VSS XI0_I1389_asn XI0_I1389_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1389_MN10 (VSS I0_pp0_20 XI0_I1389_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1389_MN6 (XI0_I1389_an3 I0_pp0_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1389_MN9 (XI0_I1389_asn XI0_I1389_acon XI0_I1389_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1389_MN12 (XI0_I1389_an5 I0_pp2_16 XI0_I1389_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1389_MN11 (XI0_I1389_an4 I0_pp1_18 XI0_I1389_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1389_MN11_1 (XI0_I1389_an5 I0_pp1_18 XI0_I1389_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1389_MN12_1 (XI0_I1389_asn I0_pp2_16 XI0_I1389_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1389_MN10_1 (XI0_I1389_an4 I0_pp0_20 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1389_MN5 (XI0_I1389_acon I0_pp2_16 XI0_I1389_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1389_MN2 (XI0_I1389_an1 I0_pp1_18 XI0_I1389_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1389_MN1 (VSS I0_pp0_20 XI0_I1389_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1389_MN3 (XI0_I1389_an2 I0_pp0_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1389_MN4 (VSS I0_pp1_18 XI0_I1389_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1389_MN27 (I0_cm28_2 XI0_I1389_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1389_MN7 (XI0_I1389_an3 I0_pp1_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1389_MN8 (VSS I0_pp2_16 XI0_I1389_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1418_MN34 (XI0_I1418_bn3 XI0_I1418_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1418_MN35 (VSS I0_pp3_23 XI0_I1418_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1418_MN36 (XI0_I1418_bn3 I0_cm53_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1418_MN37 (XI0_I1418_bsn XI0_I1418_bcon XI0_I1418_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1418_MN40 (XI0_I1418_bn5 I0_cm53_2 XI0_I1418_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1418_MN39 (XI0_I1418_bn4 I0_pp3_23 XI0_I1418_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1418_MN39_1 (XI0_I1418_bn5 I0_pp3_23 XI0_I1418_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1418_MN40_1 (XI0_I1418_bsn I0_cm53_2 XI0_I1418_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1418_MN53 (VSS XI0_I1418_bsn I0_cm57_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1418_MN29 (XI0_I1418_bn1 XI0_I1418_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1418_MN30 (XI0_I1418_bcon I0_pp3_23 XI0_I1418_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1418_MN33 (XI0_I1418_bn2 I0_cm53_2 XI0_I1418_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1418_MN31 (VSS XI0_I1418_s1 XI0_I1418_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1418_MN32 (XI0_I1418_bn2 I0_pp3_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1418_MN55 (VSS XI0_I1418_bcon I0_cm57_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1418_MN38 (XI0_I1418_bn4 XI0_I1418_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1418_MN38_1 (VSS XI0_I1418_s1 XI0_I1418_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1418_MN25 (VSS XI0_I1418_asn XI0_I1418_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1418_MN10 (VSS I0_pp0_29 XI0_I1418_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1418_MN6 (XI0_I1418_an3 I0_pp0_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1418_MN9 (XI0_I1418_asn XI0_I1418_acon XI0_I1418_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1418_MN12 (XI0_I1418_an5 I0_pp2_25 XI0_I1418_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1418_MN11 (XI0_I1418_an4 I0_pp1_27 XI0_I1418_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1418_MN11_1 (XI0_I1418_an5 I0_pp1_27 XI0_I1418_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1418_MN12_1 (XI0_I1418_asn I0_pp2_25 XI0_I1418_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1418_MN10_1 (XI0_I1418_an4 I0_pp0_29 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1418_MN5 (XI0_I1418_acon I0_pp2_25 XI0_I1418_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1418_MN2 (XI0_I1418_an1 I0_pp1_27 XI0_I1418_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1418_MN1 (VSS I0_pp0_29 XI0_I1418_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1418_MN3 (XI0_I1418_an2 I0_pp0_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1418_MN4 (VSS I0_pp1_27 XI0_I1418_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1418_MN27 (I0_cm57_2 XI0_I1418_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1418_MN7 (XI0_I1418_an3 I0_pp1_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1418_MN8 (VSS I0_pp2_25 XI0_I1418_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1422_MN34 (XI0_I1422_bn3 XI0_I1422_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1422_MN35 (VSS I0_pp3_24 XI0_I1422_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1422_MN36 (XI0_I1422_bn3 I0_cm57_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1422_MN37 (XI0_I1422_bsn XI0_I1422_bcon XI0_I1422_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1422_MN40 (XI0_I1422_bn5 I0_cm57_2 XI0_I1422_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1422_MN39 (XI0_I1422_bn4 I0_pp3_24 XI0_I1422_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1422_MN39_1 (XI0_I1422_bn5 I0_pp3_24 XI0_I1422_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1422_MN40_1 (XI0_I1422_bsn I0_cm57_2 XI0_I1422_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1422_MN53 (VSS XI0_I1422_bsn I0_cm61_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1422_MN29 (XI0_I1422_bn1 XI0_I1422_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1422_MN30 (XI0_I1422_bcon I0_pp3_24 XI0_I1422_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1422_MN33 (XI0_I1422_bn2 I0_cm57_2 XI0_I1422_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1422_MN31 (VSS XI0_I1422_s1 XI0_I1422_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1422_MN32 (XI0_I1422_bn2 I0_pp3_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1422_MN55 (VSS XI0_I1422_bcon I0_cm61_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1422_MN38 (XI0_I1422_bn4 XI0_I1422_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1422_MN38_1 (VSS XI0_I1422_s1 XI0_I1422_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1422_MN25 (VSS XI0_I1422_asn XI0_I1422_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1422_MN10 (VSS I0_pp0_30 XI0_I1422_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1422_MN6 (XI0_I1422_an3 I0_pp0_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1422_MN9 (XI0_I1422_asn XI0_I1422_acon XI0_I1422_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1422_MN12 (XI0_I1422_an5 I0_pp2_26 XI0_I1422_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1422_MN11 (XI0_I1422_an4 I0_pp1_28 XI0_I1422_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1422_MN11_1 (XI0_I1422_an5 I0_pp1_28 XI0_I1422_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1422_MN12_1 (XI0_I1422_asn I0_pp2_26 XI0_I1422_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1422_MN10_1 (XI0_I1422_an4 I0_pp0_30 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1422_MN5 (XI0_I1422_acon I0_pp2_26 XI0_I1422_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1422_MN2 (XI0_I1422_an1 I0_pp1_28 XI0_I1422_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1422_MN1 (VSS I0_pp0_30 XI0_I1422_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1422_MN3 (XI0_I1422_an2 I0_pp0_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1422_MN4 (VSS I0_pp1_28 XI0_I1422_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1422_MN27 (I0_cm61_2 XI0_I1422_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1422_MN7 (XI0_I1422_an3 I0_pp1_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1422_MN8 (VSS I0_pp2_26 XI0_I1422_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1411_MN34 (XI0_I1411_bn3 XI0_I1411_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1411_MN35 (VSS I0_pp3_21 XI0_I1411_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1411_MN36 (XI0_I1411_bn3 I0_cm46_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1411_MN37 (XI0_I1411_bsn XI0_I1411_bcon XI0_I1411_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1411_MN40 (XI0_I1411_bn5 I0_cm46_2 XI0_I1411_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1411_MN39 (XI0_I1411_bn4 I0_pp3_21 XI0_I1411_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1411_MN39_1 (XI0_I1411_bn5 I0_pp3_21 XI0_I1411_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1411_MN40_1 (XI0_I1411_bsn I0_cm46_2 XI0_I1411_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1411_MN53 (VSS XI0_I1411_bsn I0_cm50_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1411_MN29 (XI0_I1411_bn1 XI0_I1411_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1411_MN30 (XI0_I1411_bcon I0_pp3_21 XI0_I1411_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1411_MN33 (XI0_I1411_bn2 I0_cm46_2 XI0_I1411_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1411_MN31 (VSS XI0_I1411_s1 XI0_I1411_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1411_MN32 (XI0_I1411_bn2 I0_pp3_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1411_MN55 (VSS XI0_I1411_bcon I0_cm50_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1411_MN38 (XI0_I1411_bn4 XI0_I1411_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1411_MN38_1 (VSS XI0_I1411_s1 XI0_I1411_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1411_MN25 (VSS XI0_I1411_asn XI0_I1411_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1411_MN10 (VSS I0_pp0_27 XI0_I1411_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1411_MN6 (XI0_I1411_an3 I0_pp0_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1411_MN9 (XI0_I1411_asn XI0_I1411_acon XI0_I1411_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1411_MN12 (XI0_I1411_an5 I0_pp2_23 XI0_I1411_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1411_MN11 (XI0_I1411_an4 I0_pp1_25 XI0_I1411_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1411_MN11_1 (XI0_I1411_an5 I0_pp1_25 XI0_I1411_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1411_MN12_1 (XI0_I1411_asn I0_pp2_23 XI0_I1411_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1411_MN10_1 (XI0_I1411_an4 I0_pp0_27 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1411_MN5 (XI0_I1411_acon I0_pp2_23 XI0_I1411_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1411_MN2 (XI0_I1411_an1 I0_pp1_25 XI0_I1411_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1411_MN1 (VSS I0_pp0_27 XI0_I1411_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1411_MN3 (XI0_I1411_an2 I0_pp0_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1411_MN4 (VSS I0_pp1_25 XI0_I1411_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1411_MN27 (I0_cm50_2 XI0_I1411_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1411_MN7 (XI0_I1411_an3 I0_pp1_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1411_MN8 (VSS I0_pp2_23 XI0_I1411_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1446_MN34 (XI0_I1446_bn3 XI0_I1446_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1446_MN35 (VSS I0_pp4_28 XI0_I1446_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1446_MN36 (XI0_I1446_bn3 I0_cm81_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1446_MN37 (XI0_I1446_bsn XI0_I1446_bcon XI0_I1446_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1446_MN40 (XI0_I1446_bn5 I0_cm81_2 XI0_I1446_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1446_MN39 (XI0_I1446_bn4 I0_pp4_28 XI0_I1446_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1446_MN39_1 (XI0_I1446_bn5 I0_pp4_28 XI0_I1446_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1446_MN40_1 (XI0_I1446_bsn I0_cm81_2 XI0_I1446_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1446_MN53 (VSS XI0_I1446_bsn I0_cm85_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1446_MN29 (XI0_I1446_bn1 XI0_I1446_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1446_MN30 (XI0_I1446_bcon I0_pp4_28 XI0_I1446_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1446_MN33 (XI0_I1446_bn2 I0_cm81_2 XI0_I1446_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1446_MN31 (VSS XI0_I1446_s1 XI0_I1446_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1446_MN32 (XI0_I1446_bn2 I0_pp4_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1446_MN55 (VSS XI0_I1446_bcon I0_cm85_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1446_MN38 (XI0_I1446_bn4 XI0_I1446_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1446_MN38_1 (VSS XI0_I1446_s1 XI0_I1446_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1446_MN25 (VSS XI0_I1446_asn XI0_I1446_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1446_MN10 (VSS VDD XI0_I1446_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1446_MN6 (XI0_I1446_an3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1446_MN9 (XI0_I1446_asn XI0_I1446_acon XI0_I1446_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1446_MN12 (XI0_I1446_an5 I0_pp3_30 XI0_I1446_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1446_MN11 (XI0_I1446_an4 I0_pp2_32 XI0_I1446_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1446_MN11_1 (XI0_I1446_an5 I0_pp2_32 XI0_I1446_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1446_MN12_1 (XI0_I1446_asn I0_pp3_30 XI0_I1446_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1446_MN10_1 (XI0_I1446_an4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1446_MN5 (XI0_I1446_acon I0_pp3_30 XI0_I1446_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1446_MN2 (XI0_I1446_an1 I0_pp2_32 XI0_I1446_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1446_MN1 (VSS VDD XI0_I1446_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1446_MN3 (XI0_I1446_an2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1446_MN4 (VSS I0_pp2_32 XI0_I1446_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1446_MN27 (I0_cm85_2 XI0_I1446_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1446_MN7 (XI0_I1446_an3 I0_pp2_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1446_MN8 (VSS I0_pp3_30 XI0_I1446_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1453_MN34 (XI0_I1453_bn3 XI0_I1453_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1453_MN35 (VSS I0_pp5_28 XI0_I1453_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1453_MN36 (XI0_I1453_bn3 I0_cm89_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1453_MN37 (XI0_I1453_bsn XI0_I1453_bcon XI0_I1453_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1453_MN40 (XI0_I1453_bn5 I0_cm89_2 XI0_I1453_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1453_MN39 (XI0_I1453_bn4 I0_pp5_28 XI0_I1453_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1453_MN39_1 (XI0_I1453_bn5 I0_pp5_28 XI0_I1453_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1453_MN40_1 (XI0_I1453_bsn I0_cm89_2 XI0_I1453_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1453_MN53 (VSS XI0_I1453_bsn I0_cm92_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1453_MN29 (XI0_I1453_bn1 XI0_I1453_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1453_MN30 (XI0_I1453_bcon I0_pp5_28 XI0_I1453_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1453_MN33 (XI0_I1453_bn2 I0_cm89_2 XI0_I1453_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1453_MN31 (VSS XI0_I1453_s1 XI0_I1453_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1453_MN32 (XI0_I1453_bn2 I0_pp5_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1453_MN55 (VSS XI0_I1453_bcon I0_cm92_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1453_MN38 (XI0_I1453_bn4 XI0_I1453_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1453_MN38_1 (VSS XI0_I1453_s1 XI0_I1453_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1453_MN25 (VSS XI0_I1453_asn XI0_I1453_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1453_MN10 (VSS VDD XI0_I1453_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1453_MN6 (XI0_I1453_an3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1453_MN9 (XI0_I1453_asn XI0_I1453_acon XI0_I1453_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1453_MN12 (XI0_I1453_an5 I0_pp4_30 XI0_I1453_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1453_MN11 (XI0_I1453_an4 I0_pp3_32 XI0_I1453_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1453_MN11_1 (XI0_I1453_an5 I0_pp3_32 XI0_I1453_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1453_MN12_1 (XI0_I1453_asn I0_pp4_30 XI0_I1453_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1453_MN10_1 (XI0_I1453_an4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1453_MN5 (XI0_I1453_acon I0_pp4_30 XI0_I1453_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1453_MN2 (XI0_I1453_an1 I0_pp3_32 XI0_I1453_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1453_MN1 (VSS VDD XI0_I1453_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1453_MN3 (XI0_I1453_an2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1453_MN4 (VSS I0_pp3_32 XI0_I1453_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1453_MN27 (I0_cm92_2 XI0_I1453_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1453_MN7 (XI0_I1453_an3 I0_pp3_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1453_MN8 (VSS I0_pp4_30 XI0_I1453_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1384_MN34 (XI0_I1384_bn3 XI0_I1384_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1384_MN35 (VSS I0_pp3_12 XI0_I1384_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1384_MN36 (XI0_I1384_bn3 I0_cm21_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1384_MN37 (XI0_I1384_bsn XI0_I1384_bcon XI0_I1384_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1384_MN40 (XI0_I1384_bn5 I0_cm21_2 XI0_I1384_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1384_MN39 (XI0_I1384_bn4 I0_pp3_12 XI0_I1384_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1384_MN39_1 (XI0_I1384_bn5 I0_pp3_12 XI0_I1384_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1384_MN40_1 (XI0_I1384_bsn I0_cm21_2 XI0_I1384_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1384_MN53 (VSS XI0_I1384_bsn I0_cm23_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1384_MN29 (XI0_I1384_bn1 XI0_I1384_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1384_MN30 (XI0_I1384_bcon I0_pp3_12 XI0_I1384_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1384_MN33 (XI0_I1384_bn2 I0_cm21_2 XI0_I1384_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1384_MN31 (VSS XI0_I1384_s1 XI0_I1384_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1384_MN32 (XI0_I1384_bn2 I0_pp3_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1384_MN55 (VSS XI0_I1384_bcon I0_cm23_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1384_MN38 (XI0_I1384_bn4 XI0_I1384_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1384_MN38_1 (VSS XI0_I1384_s1 XI0_I1384_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1384_MN25 (VSS XI0_I1384_asn XI0_I1384_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1384_MN10 (VSS I0_pp0_18 XI0_I1384_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1384_MN6 (XI0_I1384_an3 I0_pp0_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1384_MN9 (XI0_I1384_asn XI0_I1384_acon XI0_I1384_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1384_MN12 (XI0_I1384_an5 I0_pp2_14 XI0_I1384_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1384_MN11 (XI0_I1384_an4 I0_pp1_16 XI0_I1384_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1384_MN11_1 (XI0_I1384_an5 I0_pp1_16 XI0_I1384_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1384_MN12_1 (XI0_I1384_asn I0_pp2_14 XI0_I1384_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1384_MN10_1 (XI0_I1384_an4 I0_pp0_18 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1384_MN5 (XI0_I1384_acon I0_pp2_14 XI0_I1384_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1384_MN2 (XI0_I1384_an1 I0_pp1_16 XI0_I1384_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1384_MN1 (VSS I0_pp0_18 XI0_I1384_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1384_MN3 (XI0_I1384_an2 I0_pp0_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1384_MN4 (VSS I0_pp1_16 XI0_I1384_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1384_MN27 (I0_cm23_2 XI0_I1384_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1384_MN7 (XI0_I1384_an3 I0_pp1_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1384_MN8 (VSS I0_pp2_14 XI0_I1384_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1404_MN34 (XI0_I1404_bn3 XI0_I1404_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1404_MN35 (VSS I0_pp3_19 XI0_I1404_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1404_MN36 (XI0_I1404_bn3 I0_cm40_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1404_MN37 (XI0_I1404_bsn XI0_I1404_bcon XI0_I1404_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1404_MN40 (XI0_I1404_bn5 I0_cm40_2 XI0_I1404_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1404_MN39 (XI0_I1404_bn4 I0_pp3_19 XI0_I1404_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1404_MN39_1 (XI0_I1404_bn5 I0_pp3_19 XI0_I1404_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1404_MN40_1 (XI0_I1404_bsn I0_cm40_2 XI0_I1404_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1404_MN53 (VSS XI0_I1404_bsn I0_cm43_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1404_MN29 (XI0_I1404_bn1 XI0_I1404_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1404_MN30 (XI0_I1404_bcon I0_pp3_19 XI0_I1404_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1404_MN33 (XI0_I1404_bn2 I0_cm40_2 XI0_I1404_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1404_MN31 (VSS XI0_I1404_s1 XI0_I1404_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1404_MN32 (XI0_I1404_bn2 I0_pp3_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1404_MN55 (VSS XI0_I1404_bcon I0_cm43_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1404_MN38 (XI0_I1404_bn4 XI0_I1404_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1404_MN38_1 (VSS XI0_I1404_s1 XI0_I1404_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1404_MN25 (VSS XI0_I1404_asn XI0_I1404_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1404_MN10 (VSS I0_pp0_25 XI0_I1404_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1404_MN6 (XI0_I1404_an3 I0_pp0_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1404_MN9 (XI0_I1404_asn XI0_I1404_acon XI0_I1404_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1404_MN12 (XI0_I1404_an5 I0_pp2_21 XI0_I1404_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1404_MN11 (XI0_I1404_an4 I0_pp1_23 XI0_I1404_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1404_MN11_1 (XI0_I1404_an5 I0_pp1_23 XI0_I1404_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1404_MN12_1 (XI0_I1404_asn I0_pp2_21 XI0_I1404_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1404_MN10_1 (XI0_I1404_an4 I0_pp0_25 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1404_MN5 (XI0_I1404_acon I0_pp2_21 XI0_I1404_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1404_MN2 (XI0_I1404_an1 I0_pp1_23 XI0_I1404_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1404_MN1 (VSS I0_pp0_25 XI0_I1404_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1404_MN3 (XI0_I1404_an2 I0_pp0_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1404_MN4 (VSS I0_pp1_23 XI0_I1404_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1404_MN27 (I0_cm43_2 XI0_I1404_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1404_MN7 (XI0_I1404_an3 I0_pp1_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1404_MN8 (VSS I0_pp2_21 XI0_I1404_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1392_MN34 (XI0_I1392_bn3 XI0_I1392_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1392_MN35 (VSS I0_pp3_15 XI0_I1392_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1392_MN36 (XI0_I1392_bn3 I0_cm28_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1392_MN37 (XI0_I1392_bsn XI0_I1392_bcon XI0_I1392_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1392_MN40 (XI0_I1392_bn5 I0_cm28_2 XI0_I1392_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1392_MN39 (XI0_I1392_bn4 I0_pp3_15 XI0_I1392_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1392_MN39_1 (XI0_I1392_bn5 I0_pp3_15 XI0_I1392_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1392_MN40_1 (XI0_I1392_bsn I0_cm28_2 XI0_I1392_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1392_MN53 (VSS XI0_I1392_bsn I0_cm31_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1392_MN29 (XI0_I1392_bn1 XI0_I1392_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1392_MN30 (XI0_I1392_bcon I0_pp3_15 XI0_I1392_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1392_MN33 (XI0_I1392_bn2 I0_cm28_2 XI0_I1392_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1392_MN31 (VSS XI0_I1392_s1 XI0_I1392_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1392_MN32 (XI0_I1392_bn2 I0_pp3_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1392_MN55 (VSS XI0_I1392_bcon I0_cm31_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1392_MN38 (XI0_I1392_bn4 XI0_I1392_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1392_MN38_1 (VSS XI0_I1392_s1 XI0_I1392_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1392_MN25 (VSS XI0_I1392_asn XI0_I1392_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1392_MN10 (VSS I0_pp0_21 XI0_I1392_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1392_MN6 (XI0_I1392_an3 I0_pp0_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1392_MN9 (XI0_I1392_asn XI0_I1392_acon XI0_I1392_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1392_MN12 (XI0_I1392_an5 I0_pp2_17 XI0_I1392_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1392_MN11 (XI0_I1392_an4 I0_pp1_19 XI0_I1392_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1392_MN11_1 (XI0_I1392_an5 I0_pp1_19 XI0_I1392_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1392_MN12_1 (XI0_I1392_asn I0_pp2_17 XI0_I1392_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1392_MN10_1 (XI0_I1392_an4 I0_pp0_21 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1392_MN5 (XI0_I1392_acon I0_pp2_17 XI0_I1392_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1392_MN2 (XI0_I1392_an1 I0_pp1_19 XI0_I1392_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1392_MN1 (VSS I0_pp0_21 XI0_I1392_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1392_MN3 (XI0_I1392_an2 I0_pp0_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1392_MN4 (VSS I0_pp1_19 XI0_I1392_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1392_MN27 (I0_cm31_2 XI0_I1392_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1392_MN7 (XI0_I1392_an3 I0_pp1_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1392_MN8 (VSS I0_pp2_17 XI0_I1392_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1395_MN34 (XI0_I1395_bn3 XI0_I1395_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1395_MN35 (VSS I0_pp3_16 XI0_I1395_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1395_MN36 (XI0_I1395_bn3 I0_cm31_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1395_MN37 (XI0_I1395_bsn XI0_I1395_bcon XI0_I1395_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1395_MN40 (XI0_I1395_bn5 I0_cm31_2 XI0_I1395_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1395_MN39 (XI0_I1395_bn4 I0_pp3_16 XI0_I1395_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1395_MN39_1 (XI0_I1395_bn5 I0_pp3_16 XI0_I1395_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1395_MN40_1 (XI0_I1395_bsn I0_cm31_2 XI0_I1395_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1395_MN53 (VSS XI0_I1395_bsn I0_cm34_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1395_MN29 (XI0_I1395_bn1 XI0_I1395_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1395_MN30 (XI0_I1395_bcon I0_pp3_16 XI0_I1395_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1395_MN33 (XI0_I1395_bn2 I0_cm31_2 XI0_I1395_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1395_MN31 (VSS XI0_I1395_s1 XI0_I1395_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1395_MN32 (XI0_I1395_bn2 I0_pp3_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1395_MN55 (VSS XI0_I1395_bcon I0_cm34_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1395_MN38 (XI0_I1395_bn4 XI0_I1395_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1395_MN38_1 (VSS XI0_I1395_s1 XI0_I1395_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1395_MN25 (VSS XI0_I1395_asn XI0_I1395_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1395_MN10 (VSS I0_pp0_22 XI0_I1395_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1395_MN6 (XI0_I1395_an3 I0_pp0_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1395_MN9 (XI0_I1395_asn XI0_I1395_acon XI0_I1395_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1395_MN12 (XI0_I1395_an5 I0_pp2_18 XI0_I1395_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1395_MN11 (XI0_I1395_an4 I0_pp1_20 XI0_I1395_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1395_MN11_1 (XI0_I1395_an5 I0_pp1_20 XI0_I1395_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1395_MN12_1 (XI0_I1395_asn I0_pp2_18 XI0_I1395_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1395_MN10_1 (XI0_I1395_an4 I0_pp0_22 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1395_MN5 (XI0_I1395_acon I0_pp2_18 XI0_I1395_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1395_MN2 (XI0_I1395_an1 I0_pp1_20 XI0_I1395_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1395_MN1 (VSS I0_pp0_22 XI0_I1395_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1395_MN3 (XI0_I1395_an2 I0_pp0_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1395_MN4 (VSS I0_pp1_20 XI0_I1395_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1395_MN27 (I0_cm34_2 XI0_I1395_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1395_MN7 (XI0_I1395_an3 I0_pp1_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1395_MN8 (VSS I0_pp2_18 XI0_I1395_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1414_MN34 (XI0_I1414_bn3 XI0_I1414_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1414_MN35 (VSS I0_pp3_22 XI0_I1414_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1414_MN36 (XI0_I1414_bn3 I0_cm50_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1414_MN37 (XI0_I1414_bsn XI0_I1414_bcon XI0_I1414_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1414_MN40 (XI0_I1414_bn5 I0_cm50_2 XI0_I1414_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1414_MN39 (XI0_I1414_bn4 I0_pp3_22 XI0_I1414_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1414_MN39_1 (XI0_I1414_bn5 I0_pp3_22 XI0_I1414_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1414_MN40_1 (XI0_I1414_bsn I0_cm50_2 XI0_I1414_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1414_MN53 (VSS XI0_I1414_bsn I0_cm53_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1414_MN29 (XI0_I1414_bn1 XI0_I1414_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1414_MN30 (XI0_I1414_bcon I0_pp3_22 XI0_I1414_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1414_MN33 (XI0_I1414_bn2 I0_cm50_2 XI0_I1414_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1414_MN31 (VSS XI0_I1414_s1 XI0_I1414_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1414_MN32 (XI0_I1414_bn2 I0_pp3_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1414_MN55 (VSS XI0_I1414_bcon I0_cm53_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1414_MN38 (XI0_I1414_bn4 XI0_I1414_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1414_MN38_1 (VSS XI0_I1414_s1 XI0_I1414_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1414_MN25 (VSS XI0_I1414_asn XI0_I1414_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1414_MN10 (VSS I0_pp0_28 XI0_I1414_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1414_MN6 (XI0_I1414_an3 I0_pp0_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1414_MN9 (XI0_I1414_asn XI0_I1414_acon XI0_I1414_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1414_MN12 (XI0_I1414_an5 I0_pp2_24 XI0_I1414_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1414_MN11 (XI0_I1414_an4 I0_pp1_26 XI0_I1414_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1414_MN11_1 (XI0_I1414_an5 I0_pp1_26 XI0_I1414_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1414_MN12_1 (XI0_I1414_asn I0_pp2_24 XI0_I1414_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1414_MN10_1 (XI0_I1414_an4 I0_pp0_28 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1414_MN5 (XI0_I1414_acon I0_pp2_24 XI0_I1414_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1414_MN2 (XI0_I1414_an1 I0_pp1_26 XI0_I1414_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1414_MN1 (VSS I0_pp0_28 XI0_I1414_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1414_MN3 (XI0_I1414_an2 I0_pp0_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1414_MN4 (VSS I0_pp1_26 XI0_I1414_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1414_MN27 (I0_cm53_2 XI0_I1414_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1414_MN7 (XI0_I1414_an3 I0_pp1_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1414_MN8 (VSS I0_pp2_24 XI0_I1414_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1450_MN34 (XI0_I1450_bn3 XI0_I1450_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1450_MN35 (VSS I0_pp5_27 XI0_I1450_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1450_MN36 (XI0_I1450_bn3 I0_cm85_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1450_MN37 (XI0_I1450_bsn XI0_I1450_bcon XI0_I1450_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1450_MN40 (XI0_I1450_bn5 I0_cm85_2 XI0_I1450_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1450_MN39 (XI0_I1450_bn4 I0_pp5_27 XI0_I1450_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1450_MN39_1 (XI0_I1450_bn5 I0_pp5_27 XI0_I1450_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1450_MN40_1 (XI0_I1450_bsn I0_cm85_2 XI0_I1450_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1450_MN53 (VSS XI0_I1450_bsn I0_cm89_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1450_MN29 (XI0_I1450_bn1 XI0_I1450_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1450_MN30 (XI0_I1450_bcon I0_pp5_27 XI0_I1450_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1450_MN33 (XI0_I1450_bn2 I0_cm85_2 XI0_I1450_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1450_MN31 (VSS XI0_I1450_s1 XI0_I1450_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1450_MN32 (XI0_I1450_bn2 I0_pp5_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1450_MN55 (VSS XI0_I1450_bcon I0_cm89_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1450_MN38 (XI0_I1450_bn4 XI0_I1450_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1450_MN38_1 (VSS XI0_I1450_s1 XI0_I1450_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1450_MN25 (VSS XI0_I1450_asn XI0_I1450_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1450_MN10 (VSS I0_sn2 XI0_I1450_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1450_MN6 (XI0_I1450_an3 I0_sn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1450_MN9 (XI0_I1450_asn XI0_I1450_acon XI0_I1450_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1450_MN12 (XI0_I1450_an5 I0_pp4_29 XI0_I1450_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1450_MN11 (XI0_I1450_an4 I0_pp3_31 XI0_I1450_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1450_MN11_1 (XI0_I1450_an5 I0_pp3_31 XI0_I1450_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1450_MN12_1 (XI0_I1450_asn I0_pp4_29 XI0_I1450_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1450_MN10_1 (XI0_I1450_an4 I0_sn2 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1450_MN5 (XI0_I1450_acon I0_pp4_29 XI0_I1450_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1450_MN2 (XI0_I1450_an1 I0_pp3_31 XI0_I1450_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1450_MN1 (VSS I0_sn2 XI0_I1450_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1450_MN3 (XI0_I1450_an2 I0_sn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1450_MN4 (VSS I0_pp3_31 XI0_I1450_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1450_MN27 (I0_cm89_2 XI0_I1450_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1450_MN7 (XI0_I1450_an3 I0_pp3_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1450_MN8 (VSS I0_pp4_29 XI0_I1450_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1382_MN34 (XI0_I1382_bn3 XI0_I1382_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1382_MN35 (VSS I0_pp3_11 XI0_I1382_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1382_MN36 (XI0_I1382_bn3 I0_cm19_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1382_MN37 (XI0_I1382_bsn XI0_I1382_bcon XI0_I1382_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1382_MN40 (XI0_I1382_bn5 I0_cm19_2 XI0_I1382_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1382_MN39 (XI0_I1382_bn4 I0_pp3_11 XI0_I1382_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1382_MN39_1 (XI0_I1382_bn5 I0_pp3_11 XI0_I1382_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1382_MN40_1 (XI0_I1382_bsn I0_cm19_2 XI0_I1382_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1382_MN53 (VSS XI0_I1382_bsn I0_cm21_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1382_MN29 (XI0_I1382_bn1 XI0_I1382_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1382_MN30 (XI0_I1382_bcon I0_pp3_11 XI0_I1382_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1382_MN33 (XI0_I1382_bn2 I0_cm19_2 XI0_I1382_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1382_MN31 (VSS XI0_I1382_s1 XI0_I1382_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1382_MN32 (XI0_I1382_bn2 I0_pp3_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1382_MN55 (VSS XI0_I1382_bcon I0_cm21_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1382_MN38 (XI0_I1382_bn4 XI0_I1382_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1382_MN38_1 (VSS XI0_I1382_s1 XI0_I1382_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1382_MN25 (VSS XI0_I1382_asn XI0_I1382_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1382_MN10 (VSS I0_pp0_17 XI0_I1382_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1382_MN6 (XI0_I1382_an3 I0_pp0_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1382_MN9 (XI0_I1382_asn XI0_I1382_acon XI0_I1382_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1382_MN12 (XI0_I1382_an5 I0_pp2_13 XI0_I1382_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1382_MN11 (XI0_I1382_an4 I0_pp1_15 XI0_I1382_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1382_MN11_1 (XI0_I1382_an5 I0_pp1_15 XI0_I1382_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1382_MN12_1 (XI0_I1382_asn I0_pp2_13 XI0_I1382_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1382_MN10_1 (XI0_I1382_an4 I0_pp0_17 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1382_MN5 (XI0_I1382_acon I0_pp2_13 XI0_I1382_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1382_MN2 (XI0_I1382_an1 I0_pp1_15 XI0_I1382_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1382_MN1 (VSS I0_pp0_17 XI0_I1382_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1382_MN3 (XI0_I1382_an2 I0_pp0_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1382_MN4 (VSS I0_pp1_15 XI0_I1382_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1382_MN27 (I0_cm21_2 XI0_I1382_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1382_MN7 (XI0_I1382_an3 I0_pp1_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1382_MN8 (VSS I0_pp2_13 XI0_I1382_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1398_MN34 (XI0_I1398_bn3 XI0_I1398_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1398_MN35 (VSS I0_pp3_17 XI0_I1398_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1398_MN36 (XI0_I1398_bn3 I0_cm34_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1398_MN37 (XI0_I1398_bsn XI0_I1398_bcon XI0_I1398_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1398_MN40 (XI0_I1398_bn5 I0_cm34_2 XI0_I1398_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1398_MN39 (XI0_I1398_bn4 I0_pp3_17 XI0_I1398_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1398_MN39_1 (XI0_I1398_bn5 I0_pp3_17 XI0_I1398_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1398_MN40_1 (XI0_I1398_bsn I0_cm34_2 XI0_I1398_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1398_MN53 (VSS XI0_I1398_bsn I0_cm37_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1398_MN29 (XI0_I1398_bn1 XI0_I1398_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1398_MN30 (XI0_I1398_bcon I0_pp3_17 XI0_I1398_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1398_MN33 (XI0_I1398_bn2 I0_cm34_2 XI0_I1398_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1398_MN31 (VSS XI0_I1398_s1 XI0_I1398_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1398_MN32 (XI0_I1398_bn2 I0_pp3_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1398_MN55 (VSS XI0_I1398_bcon I0_cm37_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1398_MN38 (XI0_I1398_bn4 XI0_I1398_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1398_MN38_1 (VSS XI0_I1398_s1 XI0_I1398_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1398_MN25 (VSS XI0_I1398_asn XI0_I1398_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1398_MN10 (VSS I0_pp0_23 XI0_I1398_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1398_MN6 (XI0_I1398_an3 I0_pp0_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1398_MN9 (XI0_I1398_asn XI0_I1398_acon XI0_I1398_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1398_MN12 (XI0_I1398_an5 I0_pp2_19 XI0_I1398_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1398_MN11 (XI0_I1398_an4 I0_pp1_21 XI0_I1398_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1398_MN11_1 (XI0_I1398_an5 I0_pp1_21 XI0_I1398_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1398_MN12_1 (XI0_I1398_asn I0_pp2_19 XI0_I1398_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1398_MN10_1 (XI0_I1398_an4 I0_pp0_23 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1398_MN5 (XI0_I1398_acon I0_pp2_19 XI0_I1398_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1398_MN2 (XI0_I1398_an1 I0_pp1_21 XI0_I1398_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1398_MN1 (VSS I0_pp0_23 XI0_I1398_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1398_MN3 (XI0_I1398_an2 I0_pp0_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1398_MN4 (VSS I0_pp1_21 XI0_I1398_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1398_MN27 (I0_cm37_2 XI0_I1398_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1398_MN7 (XI0_I1398_an3 I0_pp1_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1398_MN8 (VSS I0_pp2_19 XI0_I1398_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1401_MN34 (XI0_I1401_bn3 XI0_I1401_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1401_MN35 (VSS I0_pp3_18 XI0_I1401_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1401_MN36 (XI0_I1401_bn3 I0_cm37_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1401_MN37 (XI0_I1401_bsn XI0_I1401_bcon XI0_I1401_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1401_MN40 (XI0_I1401_bn5 I0_cm37_2 XI0_I1401_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1401_MN39 (XI0_I1401_bn4 I0_pp3_18 XI0_I1401_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1401_MN39_1 (XI0_I1401_bn5 I0_pp3_18 XI0_I1401_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1401_MN40_1 (XI0_I1401_bsn I0_cm37_2 XI0_I1401_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1401_MN53 (VSS XI0_I1401_bsn I0_cm40_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1401_MN29 (XI0_I1401_bn1 XI0_I1401_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1401_MN30 (XI0_I1401_bcon I0_pp3_18 XI0_I1401_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1401_MN33 (XI0_I1401_bn2 I0_cm37_2 XI0_I1401_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1401_MN31 (VSS XI0_I1401_s1 XI0_I1401_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1401_MN32 (XI0_I1401_bn2 I0_pp3_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1401_MN55 (VSS XI0_I1401_bcon I0_cm40_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1401_MN38 (XI0_I1401_bn4 XI0_I1401_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1401_MN38_1 (VSS XI0_I1401_s1 XI0_I1401_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1401_MN25 (VSS XI0_I1401_asn XI0_I1401_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1401_MN10 (VSS I0_pp0_24 XI0_I1401_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1401_MN6 (XI0_I1401_an3 I0_pp0_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1401_MN9 (XI0_I1401_asn XI0_I1401_acon XI0_I1401_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1401_MN12 (XI0_I1401_an5 I0_pp2_20 XI0_I1401_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1401_MN11 (XI0_I1401_an4 I0_pp1_22 XI0_I1401_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1401_MN11_1 (XI0_I1401_an5 I0_pp1_22 XI0_I1401_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1401_MN12_1 (XI0_I1401_asn I0_pp2_20 XI0_I1401_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1401_MN10_1 (XI0_I1401_an4 I0_pp0_24 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1401_MN5 (XI0_I1401_acon I0_pp2_20 XI0_I1401_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1401_MN2 (XI0_I1401_an1 I0_pp1_22 XI0_I1401_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1401_MN1 (VSS I0_pp0_24 XI0_I1401_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1401_MN3 (XI0_I1401_an2 I0_pp0_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1401_MN4 (VSS I0_pp1_22 XI0_I1401_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1401_MN27 (I0_cm40_2 XI0_I1401_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1401_MN7 (XI0_I1401_an3 I0_pp1_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1401_MN8 (VSS I0_pp2_20 XI0_I1401_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1456_MN34 (XI0_I1456_bn3 XI0_I1456_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1456_MN35 (VSS I0_pp6_27 XI0_I1456_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1456_MN36 (XI0_I1456_bn3 I0_cm92_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1456_MN37 (XI0_I1456_bsn XI0_I1456_bcon XI0_I1456_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1456_MN40 (XI0_I1456_bn5 I0_cm92_2 XI0_I1456_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1456_MN39 (XI0_I1456_bn4 I0_pp6_27 XI0_I1456_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1456_MN39_1 (XI0_I1456_bn5 I0_pp6_27 XI0_I1456_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1456_MN40_1 (XI0_I1456_bsn I0_cm92_2 XI0_I1456_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1456_MN53 (VSS XI0_I1456_bsn I0_cm95_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1456_MN29 (XI0_I1456_bn1 XI0_I1456_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1456_MN30 (XI0_I1456_bcon I0_pp6_27 XI0_I1456_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1456_MN33 (XI0_I1456_bn2 I0_cm92_2 XI0_I1456_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1456_MN31 (VSS XI0_I1456_s1 XI0_I1456_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1456_MN32 (XI0_I1456_bn2 I0_pp6_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1456_MN55 (VSS XI0_I1456_bcon I0_cm95_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1456_MN38 (XI0_I1456_bn4 XI0_I1456_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1456_MN38_1 (VSS XI0_I1456_s1 XI0_I1456_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1456_MN25 (VSS XI0_I1456_asn XI0_I1456_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1456_MN10 (VSS I0_sn3 XI0_I1456_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1456_MN6 (XI0_I1456_an3 I0_sn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1456_MN9 (XI0_I1456_asn XI0_I1456_acon XI0_I1456_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1456_MN12 (XI0_I1456_an5 I0_pp5_29 XI0_I1456_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1456_MN11 (XI0_I1456_an4 I0_pp4_31 XI0_I1456_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1456_MN11_1 (XI0_I1456_an5 I0_pp4_31 XI0_I1456_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1456_MN12_1 (XI0_I1456_asn I0_pp5_29 XI0_I1456_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1456_MN10_1 (XI0_I1456_an4 I0_sn3 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1456_MN5 (XI0_I1456_acon I0_pp5_29 XI0_I1456_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1456_MN2 (XI0_I1456_an1 I0_pp4_31 XI0_I1456_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1456_MN1 (VSS I0_sn3 XI0_I1456_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1456_MN3 (XI0_I1456_an2 I0_sn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1456_MN4 (VSS I0_pp4_31 XI0_I1456_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1456_MN27 (I0_cm95_2 XI0_I1456_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1456_MN7 (XI0_I1456_an3 I0_pp4_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1456_MN8 (VSS I0_pp5_29 XI0_I1456_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1378_MN34 (XI0_I1378_bn3 XI0_I1378_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1378_MN35 (VSS I0_pp3_9 XI0_I1378_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1378_MN36 (XI0_I1378_bn3 I0_cm15_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1378_MN37 (XI0_I1378_bsn XI0_I1378_bcon XI0_I1378_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1378_MN40 (XI0_I1378_bn5 I0_cm15_2 XI0_I1378_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1378_MN39 (XI0_I1378_bn4 I0_pp3_9 XI0_I1378_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1378_MN39_1 (XI0_I1378_bn5 I0_pp3_9 XI0_I1378_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1378_MN40_1 (XI0_I1378_bsn I0_cm15_2 XI0_I1378_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1378_MN53 (VSS XI0_I1378_bsn I0_cm17_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1378_MN29 (XI0_I1378_bn1 XI0_I1378_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1378_MN30 (XI0_I1378_bcon I0_pp3_9 XI0_I1378_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1378_MN33 (XI0_I1378_bn2 I0_cm15_2 XI0_I1378_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1378_MN31 (VSS XI0_I1378_s1 XI0_I1378_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1378_MN32 (XI0_I1378_bn2 I0_pp3_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1378_MN55 (VSS XI0_I1378_bcon I0_cm17_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1378_MN38 (XI0_I1378_bn4 XI0_I1378_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1378_MN38_1 (VSS XI0_I1378_s1 XI0_I1378_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1378_MN25 (VSS XI0_I1378_asn XI0_I1378_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1378_MN10 (VSS I0_pp0_15 XI0_I1378_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1378_MN6 (XI0_I1378_an3 I0_pp0_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1378_MN9 (XI0_I1378_asn XI0_I1378_acon XI0_I1378_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1378_MN12 (XI0_I1378_an5 I0_pp2_11 XI0_I1378_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1378_MN11 (XI0_I1378_an4 I0_pp1_13 XI0_I1378_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1378_MN11_1 (XI0_I1378_an5 I0_pp1_13 XI0_I1378_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1378_MN12_1 (XI0_I1378_asn I0_pp2_11 XI0_I1378_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1378_MN10_1 (XI0_I1378_an4 I0_pp0_15 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1378_MN5 (XI0_I1378_acon I0_pp2_11 XI0_I1378_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1378_MN2 (XI0_I1378_an1 I0_pp1_13 XI0_I1378_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1378_MN1 (VSS I0_pp0_15 XI0_I1378_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1378_MN3 (XI0_I1378_an2 I0_pp0_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1378_MN4 (VSS I0_pp1_13 XI0_I1378_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1378_MN27 (I0_cm17_2 XI0_I1378_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1378_MN7 (XI0_I1378_an3 I0_pp1_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1378_MN8 (VSS I0_pp2_11 XI0_I1378_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1376_MN34 (XI0_I1376_bn3 XI0_I1376_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1376_MN35 (VSS I0_pp3_8 XI0_I1376_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1376_MN36 (XI0_I1376_bn3 I0_cm13_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1376_MN37 (XI0_I1376_bsn XI0_I1376_bcon XI0_I1376_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1376_MN40 (XI0_I1376_bn5 I0_cm13_2 XI0_I1376_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1376_MN39 (XI0_I1376_bn4 I0_pp3_8 XI0_I1376_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1376_MN39_1 (XI0_I1376_bn5 I0_pp3_8 XI0_I1376_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1376_MN40_1 (XI0_I1376_bsn I0_cm13_2 XI0_I1376_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1376_MN53 (VSS XI0_I1376_bsn I0_cm15_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1376_MN29 (XI0_I1376_bn1 XI0_I1376_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1376_MN30 (XI0_I1376_bcon I0_pp3_8 XI0_I1376_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1376_MN33 (XI0_I1376_bn2 I0_cm13_2 XI0_I1376_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1376_MN31 (VSS XI0_I1376_s1 XI0_I1376_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1376_MN32 (XI0_I1376_bn2 I0_pp3_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1376_MN55 (VSS XI0_I1376_bcon I0_cm15_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1376_MN38 (XI0_I1376_bn4 XI0_I1376_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1376_MN38_1 (VSS XI0_I1376_s1 XI0_I1376_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1376_MN25 (VSS XI0_I1376_asn XI0_I1376_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1376_MN10 (VSS I0_pp0_14 XI0_I1376_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1376_MN6 (XI0_I1376_an3 I0_pp0_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1376_MN9 (XI0_I1376_asn XI0_I1376_acon XI0_I1376_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1376_MN12 (XI0_I1376_an5 I0_pp2_10 XI0_I1376_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1376_MN11 (XI0_I1376_an4 I0_pp1_12 XI0_I1376_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1376_MN11_1 (XI0_I1376_an5 I0_pp1_12 XI0_I1376_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1376_MN12_1 (XI0_I1376_asn I0_pp2_10 XI0_I1376_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1376_MN10_1 (XI0_I1376_an4 I0_pp0_14 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1376_MN5 (XI0_I1376_acon I0_pp2_10 XI0_I1376_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1376_MN2 (XI0_I1376_an1 I0_pp1_12 XI0_I1376_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1376_MN1 (VSS I0_pp0_14 XI0_I1376_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1376_MN3 (XI0_I1376_an2 I0_pp0_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1376_MN4 (VSS I0_pp1_12 XI0_I1376_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1376_MN27 (I0_cm15_2 XI0_I1376_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1376_MN7 (XI0_I1376_an3 I0_pp1_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1376_MN8 (VSS I0_pp2_10 XI0_I1376_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1423_MN34 (XI0_I1423_bn3 XI0_I1423_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1423_MN35 (VSS I0_pp7_16 XI0_I1423_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1423_MN36 (XI0_I1423_bn3 I0_cm58_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1423_MN37 (XI0_I1423_bsn XI0_I1423_bcon XI0_I1423_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1423_MN40 (XI0_I1423_bn5 I0_cm58_2 XI0_I1423_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1423_MN39 (XI0_I1423_bn4 I0_pp7_16 XI0_I1423_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1423_MN39_1 (XI0_I1423_bn5 I0_pp7_16 XI0_I1423_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1423_MN40_1 (XI0_I1423_bsn I0_cm58_2 XI0_I1423_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1423_MN53 (VSS XI0_I1423_bsn I0_cm62_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1423_MN29 (XI0_I1423_bn1 XI0_I1423_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1423_MN30 (XI0_I1423_bcon I0_pp7_16 XI0_I1423_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1423_MN33 (XI0_I1423_bn2 I0_cm58_2 XI0_I1423_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1423_MN31 (VSS XI0_I1423_s1 XI0_I1423_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1423_MN32 (XI0_I1423_bn2 I0_pp7_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1423_MN55 (VSS XI0_I1423_bcon I0_cm62_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1423_MN38 (XI0_I1423_bn4 XI0_I1423_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1423_MN38_1 (VSS XI0_I1423_s1 XI0_I1423_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1423_MN25 (VSS XI0_I1423_asn XI0_I1423_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1423_MN10 (VSS I0_pp4_22 XI0_I1423_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1423_MN6 (XI0_I1423_an3 I0_pp4_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1423_MN9 (XI0_I1423_asn XI0_I1423_acon XI0_I1423_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1423_MN12 (XI0_I1423_an5 I0_pp6_18 XI0_I1423_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1423_MN11 (XI0_I1423_an4 I0_pp5_20 XI0_I1423_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1423_MN11_1 (XI0_I1423_an5 I0_pp5_20 XI0_I1423_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1423_MN12_1 (XI0_I1423_asn I0_pp6_18 XI0_I1423_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1423_MN10_1 (XI0_I1423_an4 I0_pp4_22 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1423_MN5 (XI0_I1423_acon I0_pp6_18 XI0_I1423_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1423_MN2 (XI0_I1423_an1 I0_pp5_20 XI0_I1423_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1423_MN1 (VSS I0_pp4_22 XI0_I1423_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1423_MN3 (XI0_I1423_an2 I0_pp4_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1423_MN4 (VSS I0_pp5_20 XI0_I1423_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1423_MN27 (I0_cm62_2 XI0_I1423_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1423_MN7 (XI0_I1423_an3 I0_pp5_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1423_MN8 (VSS I0_pp6_18 XI0_I1423_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1459_MN34 (XI0_I1459_bn3 XI0_I1459_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1459_MN35 (VSS I0_pp6_28 XI0_I1459_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1459_MN36 (XI0_I1459_bn3 I0_cm95_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1459_MN37 (XI0_I1459_bsn XI0_I1459_bcon XI0_I1459_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1459_MN40 (XI0_I1459_bn5 I0_cm95_2 XI0_I1459_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1459_MN39 (XI0_I1459_bn4 I0_pp6_28 XI0_I1459_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1459_MN39_1 (XI0_I1459_bn5 I0_pp6_28 XI0_I1459_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1459_MN40_1 (XI0_I1459_bsn I0_cm95_2 XI0_I1459_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1459_MN53 (VSS XI0_I1459_bsn I0_cm98_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1459_MN29 (XI0_I1459_bn1 XI0_I1459_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1459_MN30 (XI0_I1459_bcon I0_pp6_28 XI0_I1459_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1459_MN33 (XI0_I1459_bn2 I0_cm95_2 XI0_I1459_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1459_MN31 (VSS XI0_I1459_s1 XI0_I1459_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1459_MN32 (XI0_I1459_bn2 I0_pp6_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1459_MN55 (VSS XI0_I1459_bcon I0_cm98_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1459_MN38 (XI0_I1459_bn4 XI0_I1459_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1459_MN38_1 (VSS XI0_I1459_s1 XI0_I1459_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1459_MN25 (VSS XI0_I1459_asn XI0_I1459_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1459_MN10 (VSS VDD XI0_I1459_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1459_MN6 (XI0_I1459_an3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1459_MN9 (XI0_I1459_asn XI0_I1459_acon XI0_I1459_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1459_MN12 (XI0_I1459_an5 I0_pp5_30 XI0_I1459_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1459_MN11 (XI0_I1459_an4 I0_pp4_32 XI0_I1459_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1459_MN11_1 (XI0_I1459_an5 I0_pp4_32 XI0_I1459_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1459_MN12_1 (XI0_I1459_asn I0_pp5_30 XI0_I1459_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1459_MN10_1 (XI0_I1459_an4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1459_MN5 (XI0_I1459_acon I0_pp5_30 XI0_I1459_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1459_MN2 (XI0_I1459_an1 I0_pp4_32 XI0_I1459_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1459_MN1 (VSS VDD XI0_I1459_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1459_MN3 (XI0_I1459_an2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1459_MN4 (VSS I0_pp4_32 XI0_I1459_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1459_MN27 (I0_cm98_2 XI0_I1459_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1459_MN7 (XI0_I1459_an3 I0_pp4_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1459_MN8 (VSS I0_pp5_30 XI0_I1459_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1374_MN34 (XI0_I1374_bn3 XI0_I1374_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1374_MN35 (VSS I0_pp3_7 XI0_I1374_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1374_MN36 (XI0_I1374_bn3 I0_cm11_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1374_MN37 (XI0_I1374_bsn XI0_I1374_bcon XI0_I1374_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1374_MN40 (XI0_I1374_bn5 I0_cm11_2 XI0_I1374_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1374_MN39 (XI0_I1374_bn4 I0_pp3_7 XI0_I1374_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1374_MN39_1 (XI0_I1374_bn5 I0_pp3_7 XI0_I1374_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1374_MN40_1 (XI0_I1374_bsn I0_cm11_2 XI0_I1374_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1374_MN53 (VSS XI0_I1374_bsn I0_cm13_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1374_MN29 (XI0_I1374_bn1 XI0_I1374_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1374_MN30 (XI0_I1374_bcon I0_pp3_7 XI0_I1374_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1374_MN33 (XI0_I1374_bn2 I0_cm11_2 XI0_I1374_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1374_MN31 (VSS XI0_I1374_s1 XI0_I1374_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1374_MN32 (XI0_I1374_bn2 I0_pp3_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1374_MN55 (VSS XI0_I1374_bcon I0_cm13_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1374_MN38 (XI0_I1374_bn4 XI0_I1374_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1374_MN38_1 (VSS XI0_I1374_s1 XI0_I1374_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1374_MN25 (VSS XI0_I1374_asn XI0_I1374_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1374_MN10 (VSS I0_pp0_13 XI0_I1374_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1374_MN6 (XI0_I1374_an3 I0_pp0_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1374_MN9 (XI0_I1374_asn XI0_I1374_acon XI0_I1374_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1374_MN12 (XI0_I1374_an5 I0_pp2_9 XI0_I1374_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1374_MN11 (XI0_I1374_an4 I0_pp1_11 XI0_I1374_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1374_MN11_1 (XI0_I1374_an5 I0_pp1_11 XI0_I1374_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1374_MN12_1 (XI0_I1374_asn I0_pp2_9 XI0_I1374_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1374_MN10_1 (XI0_I1374_an4 I0_pp0_13 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1374_MN5 (XI0_I1374_acon I0_pp2_9 XI0_I1374_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1374_MN2 (XI0_I1374_an1 I0_pp1_11 XI0_I1374_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1374_MN1 (VSS I0_pp0_13 XI0_I1374_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1374_MN3 (XI0_I1374_an2 I0_pp0_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1374_MN4 (VSS I0_pp1_11 XI0_I1374_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1374_MN27 (I0_cm13_2 XI0_I1374_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1374_MN7 (XI0_I1374_an3 I0_pp1_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1374_MN8 (VSS I0_pp2_9 XI0_I1374_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1380_MN34 (XI0_I1380_bn3 XI0_I1380_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1380_MN35 (VSS I0_pp3_10 XI0_I1380_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1380_MN36 (XI0_I1380_bn3 I0_cm17_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1380_MN37 (XI0_I1380_bsn XI0_I1380_bcon XI0_I1380_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1380_MN40 (XI0_I1380_bn5 I0_cm17_2 XI0_I1380_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1380_MN39 (XI0_I1380_bn4 I0_pp3_10 XI0_I1380_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1380_MN39_1 (XI0_I1380_bn5 I0_pp3_10 XI0_I1380_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1380_MN40_1 (XI0_I1380_bsn I0_cm17_2 XI0_I1380_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1380_MN53 (VSS XI0_I1380_bsn I0_cm19_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1380_MN29 (XI0_I1380_bn1 XI0_I1380_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1380_MN30 (XI0_I1380_bcon I0_pp3_10 XI0_I1380_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1380_MN33 (XI0_I1380_bn2 I0_cm17_2 XI0_I1380_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1380_MN31 (VSS XI0_I1380_s1 XI0_I1380_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1380_MN32 (XI0_I1380_bn2 I0_pp3_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1380_MN55 (VSS XI0_I1380_bcon I0_cm19_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1380_MN38 (XI0_I1380_bn4 XI0_I1380_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1380_MN38_1 (VSS XI0_I1380_s1 XI0_I1380_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1380_MN25 (VSS XI0_I1380_asn XI0_I1380_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1380_MN10 (VSS I0_pp0_16 XI0_I1380_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1380_MN6 (XI0_I1380_an3 I0_pp0_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1380_MN9 (XI0_I1380_asn XI0_I1380_acon XI0_I1380_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1380_MN12 (XI0_I1380_an5 I0_pp2_12 XI0_I1380_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1380_MN11 (XI0_I1380_an4 I0_pp1_14 XI0_I1380_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1380_MN11_1 (XI0_I1380_an5 I0_pp1_14 XI0_I1380_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1380_MN12_1 (XI0_I1380_asn I0_pp2_12 XI0_I1380_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1380_MN10_1 (XI0_I1380_an4 I0_pp0_16 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1380_MN5 (XI0_I1380_acon I0_pp2_12 XI0_I1380_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1380_MN2 (XI0_I1380_an1 I0_pp1_14 XI0_I1380_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1380_MN1 (VSS I0_pp0_16 XI0_I1380_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1380_MN3 (XI0_I1380_an2 I0_pp0_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1380_MN4 (VSS I0_pp1_14 XI0_I1380_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1380_MN27 (I0_cm19_2 XI0_I1380_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1380_MN7 (XI0_I1380_an3 I0_pp1_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1380_MN8 (VSS I0_pp2_12 XI0_I1380_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1412_MN34 (XI0_I1412_bn3 XI0_I1412_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1412_MN35 (VSS I0_pp7_13 XI0_I1412_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1412_MN36 (XI0_I1412_bn3 I0_cm47_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1412_MN37 (XI0_I1412_bsn XI0_I1412_bcon XI0_I1412_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1412_MN40 (XI0_I1412_bn5 I0_cm47_2 XI0_I1412_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1412_MN39 (XI0_I1412_bn4 I0_pp7_13 XI0_I1412_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1412_MN39_1 (XI0_I1412_bn5 I0_pp7_13 XI0_I1412_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1412_MN40_1 (XI0_I1412_bsn I0_cm47_2 XI0_I1412_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1412_MN53 (VSS XI0_I1412_bsn I0_cm51_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1412_MN29 (XI0_I1412_bn1 XI0_I1412_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1412_MN30 (XI0_I1412_bcon I0_pp7_13 XI0_I1412_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1412_MN33 (XI0_I1412_bn2 I0_cm47_2 XI0_I1412_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1412_MN31 (VSS XI0_I1412_s1 XI0_I1412_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1412_MN32 (XI0_I1412_bn2 I0_pp7_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1412_MN55 (VSS XI0_I1412_bcon I0_cm51_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1412_MN38 (XI0_I1412_bn4 XI0_I1412_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1412_MN38_1 (VSS XI0_I1412_s1 XI0_I1412_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1412_MN25 (VSS XI0_I1412_asn XI0_I1412_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1412_MN10 (VSS I0_pp4_19 XI0_I1412_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1412_MN6 (XI0_I1412_an3 I0_pp4_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1412_MN9 (XI0_I1412_asn XI0_I1412_acon XI0_I1412_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1412_MN12 (XI0_I1412_an5 I0_pp6_15 XI0_I1412_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1412_MN11 (XI0_I1412_an4 I0_pp5_17 XI0_I1412_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1412_MN11_1 (XI0_I1412_an5 I0_pp5_17 XI0_I1412_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1412_MN12_1 (XI0_I1412_asn I0_pp6_15 XI0_I1412_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1412_MN10_1 (XI0_I1412_an4 I0_pp4_19 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1412_MN5 (XI0_I1412_acon I0_pp6_15 XI0_I1412_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1412_MN2 (XI0_I1412_an1 I0_pp5_17 XI0_I1412_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1412_MN1 (VSS I0_pp4_19 XI0_I1412_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1412_MN3 (XI0_I1412_an2 I0_pp4_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1412_MN4 (VSS I0_pp5_17 XI0_I1412_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1412_MN27 (I0_cm51_2 XI0_I1412_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1412_MN7 (XI0_I1412_an3 I0_pp5_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1412_MN8 (VSS I0_pp6_15 XI0_I1412_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1415_MN34 (XI0_I1415_bn3 XI0_I1415_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1415_MN35 (VSS I0_pp7_14 XI0_I1415_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1415_MN36 (XI0_I1415_bn3 I0_cm51_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1415_MN37 (XI0_I1415_bsn XI0_I1415_bcon XI0_I1415_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1415_MN40 (XI0_I1415_bn5 I0_cm51_2 XI0_I1415_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1415_MN39 (XI0_I1415_bn4 I0_pp7_14 XI0_I1415_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1415_MN39_1 (XI0_I1415_bn5 I0_pp7_14 XI0_I1415_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1415_MN40_1 (XI0_I1415_bsn I0_cm51_2 XI0_I1415_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1415_MN53 (VSS XI0_I1415_bsn I0_cm54_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1415_MN29 (XI0_I1415_bn1 XI0_I1415_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1415_MN30 (XI0_I1415_bcon I0_pp7_14 XI0_I1415_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1415_MN33 (XI0_I1415_bn2 I0_cm51_2 XI0_I1415_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1415_MN31 (VSS XI0_I1415_s1 XI0_I1415_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1415_MN32 (XI0_I1415_bn2 I0_pp7_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1415_MN55 (VSS XI0_I1415_bcon I0_cm54_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1415_MN38 (XI0_I1415_bn4 XI0_I1415_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1415_MN38_1 (VSS XI0_I1415_s1 XI0_I1415_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1415_MN25 (VSS XI0_I1415_asn XI0_I1415_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1415_MN10 (VSS I0_pp4_20 XI0_I1415_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1415_MN6 (XI0_I1415_an3 I0_pp4_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1415_MN9 (XI0_I1415_asn XI0_I1415_acon XI0_I1415_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1415_MN12 (XI0_I1415_an5 I0_pp6_16 XI0_I1415_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1415_MN11 (XI0_I1415_an4 I0_pp5_18 XI0_I1415_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1415_MN11_1 (XI0_I1415_an5 I0_pp5_18 XI0_I1415_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1415_MN12_1 (XI0_I1415_asn I0_pp6_16 XI0_I1415_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1415_MN10_1 (XI0_I1415_an4 I0_pp4_20 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1415_MN5 (XI0_I1415_acon I0_pp6_16 XI0_I1415_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1415_MN2 (XI0_I1415_an1 I0_pp5_18 XI0_I1415_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1415_MN1 (VSS I0_pp4_20 XI0_I1415_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1415_MN3 (XI0_I1415_an2 I0_pp4_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1415_MN4 (VSS I0_pp5_18 XI0_I1415_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1415_MN27 (I0_cm54_2 XI0_I1415_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1415_MN7 (XI0_I1415_an3 I0_pp5_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1415_MN8 (VSS I0_pp6_16 XI0_I1415_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1419_MN34 (XI0_I1419_bn3 XI0_I1419_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1419_MN35 (VSS I0_pp7_15 XI0_I1419_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1419_MN36 (XI0_I1419_bn3 I0_cm54_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1419_MN37 (XI0_I1419_bsn XI0_I1419_bcon XI0_I1419_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1419_MN40 (XI0_I1419_bn5 I0_cm54_2 XI0_I1419_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1419_MN39 (XI0_I1419_bn4 I0_pp7_15 XI0_I1419_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1419_MN39_1 (XI0_I1419_bn5 I0_pp7_15 XI0_I1419_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1419_MN40_1 (XI0_I1419_bsn I0_cm54_2 XI0_I1419_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1419_MN53 (VSS XI0_I1419_bsn I0_cm58_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1419_MN29 (XI0_I1419_bn1 XI0_I1419_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1419_MN30 (XI0_I1419_bcon I0_pp7_15 XI0_I1419_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1419_MN33 (XI0_I1419_bn2 I0_cm54_2 XI0_I1419_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1419_MN31 (VSS XI0_I1419_s1 XI0_I1419_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1419_MN32 (XI0_I1419_bn2 I0_pp7_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1419_MN55 (VSS XI0_I1419_bcon I0_cm58_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1419_MN38 (XI0_I1419_bn4 XI0_I1419_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1419_MN38_1 (VSS XI0_I1419_s1 XI0_I1419_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1419_MN25 (VSS XI0_I1419_asn XI0_I1419_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1419_MN10 (VSS I0_pp4_21 XI0_I1419_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1419_MN6 (XI0_I1419_an3 I0_pp4_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1419_MN9 (XI0_I1419_asn XI0_I1419_acon XI0_I1419_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1419_MN12 (XI0_I1419_an5 I0_pp6_17 XI0_I1419_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1419_MN11 (XI0_I1419_an4 I0_pp5_19 XI0_I1419_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1419_MN11_1 (XI0_I1419_an5 I0_pp5_19 XI0_I1419_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1419_MN12_1 (XI0_I1419_asn I0_pp6_17 XI0_I1419_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1419_MN10_1 (XI0_I1419_an4 I0_pp4_21 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1419_MN5 (XI0_I1419_acon I0_pp6_17 XI0_I1419_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1419_MN2 (XI0_I1419_an1 I0_pp5_19 XI0_I1419_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1419_MN1 (VSS I0_pp4_21 XI0_I1419_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1419_MN3 (XI0_I1419_an2 I0_pp4_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1419_MN4 (VSS I0_pp5_19 XI0_I1419_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1419_MN27 (I0_cm58_2 XI0_I1419_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1419_MN7 (XI0_I1419_an3 I0_pp5_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1419_MN8 (VSS I0_pp6_17 XI0_I1419_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1427_MN34 (XI0_I1427_bn3 XI0_I1427_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1427_MN35 (VSS I0_pp7_17 XI0_I1427_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1427_MN36 (XI0_I1427_bn3 I0_cm62_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1427_MN37 (XI0_I1427_bsn XI0_I1427_bcon XI0_I1427_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1427_MN40 (XI0_I1427_bn5 I0_cm62_2 XI0_I1427_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1427_MN39 (XI0_I1427_bn4 I0_pp7_17 XI0_I1427_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1427_MN39_1 (XI0_I1427_bn5 I0_pp7_17 XI0_I1427_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1427_MN40_1 (XI0_I1427_bsn I0_cm62_2 XI0_I1427_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1427_MN53 (VSS XI0_I1427_bsn I0_cm66_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1427_MN29 (XI0_I1427_bn1 XI0_I1427_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1427_MN30 (XI0_I1427_bcon I0_pp7_17 XI0_I1427_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1427_MN33 (XI0_I1427_bn2 I0_cm62_2 XI0_I1427_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1427_MN31 (VSS XI0_I1427_s1 XI0_I1427_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1427_MN32 (XI0_I1427_bn2 I0_pp7_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1427_MN55 (VSS XI0_I1427_bcon I0_cm66_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1427_MN38 (XI0_I1427_bn4 XI0_I1427_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1427_MN38_1 (VSS XI0_I1427_s1 XI0_I1427_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1427_MN25 (VSS XI0_I1427_asn XI0_I1427_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1427_MN10 (VSS I0_pp4_23 XI0_I1427_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1427_MN6 (XI0_I1427_an3 I0_pp4_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1427_MN9 (XI0_I1427_asn XI0_I1427_acon XI0_I1427_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1427_MN12 (XI0_I1427_an5 I0_pp6_19 XI0_I1427_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1427_MN11 (XI0_I1427_an4 I0_pp5_21 XI0_I1427_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1427_MN11_1 (XI0_I1427_an5 I0_pp5_21 XI0_I1427_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1427_MN12_1 (XI0_I1427_asn I0_pp6_19 XI0_I1427_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1427_MN10_1 (XI0_I1427_an4 I0_pp4_23 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1427_MN5 (XI0_I1427_acon I0_pp6_19 XI0_I1427_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1427_MN2 (XI0_I1427_an1 I0_pp5_21 XI0_I1427_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1427_MN1 (VSS I0_pp4_23 XI0_I1427_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1427_MN3 (XI0_I1427_an2 I0_pp4_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1427_MN4 (VSS I0_pp5_21 XI0_I1427_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1427_MN27 (I0_cm66_2 XI0_I1427_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1427_MN7 (XI0_I1427_an3 I0_pp5_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1427_MN8 (VSS I0_pp6_19 XI0_I1427_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1435_MN34 (XI0_I1435_bn3 XI0_I1435_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1435_MN35 (VSS I0_pp7_19 XI0_I1435_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1435_MN36 (XI0_I1435_bn3 I0_cm70_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1435_MN37 (XI0_I1435_bsn XI0_I1435_bcon XI0_I1435_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1435_MN40 (XI0_I1435_bn5 I0_cm70_2 XI0_I1435_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1435_MN39 (XI0_I1435_bn4 I0_pp7_19 XI0_I1435_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1435_MN39_1 (XI0_I1435_bn5 I0_pp7_19 XI0_I1435_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1435_MN40_1 (XI0_I1435_bsn I0_cm70_2 XI0_I1435_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1435_MN53 (VSS XI0_I1435_bsn I0_cm74_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1435_MN29 (XI0_I1435_bn1 XI0_I1435_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1435_MN30 (XI0_I1435_bcon I0_pp7_19 XI0_I1435_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1435_MN33 (XI0_I1435_bn2 I0_cm70_2 XI0_I1435_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1435_MN31 (VSS XI0_I1435_s1 XI0_I1435_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1435_MN32 (XI0_I1435_bn2 I0_pp7_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1435_MN55 (VSS XI0_I1435_bcon I0_cm74_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1435_MN38 (XI0_I1435_bn4 XI0_I1435_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1435_MN38_1 (VSS XI0_I1435_s1 XI0_I1435_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1435_MN25 (VSS XI0_I1435_asn XI0_I1435_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1435_MN10 (VSS I0_pp4_25 XI0_I1435_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1435_MN6 (XI0_I1435_an3 I0_pp4_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1435_MN9 (XI0_I1435_asn XI0_I1435_acon XI0_I1435_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1435_MN12 (XI0_I1435_an5 I0_pp6_21 XI0_I1435_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1435_MN11 (XI0_I1435_an4 I0_pp5_23 XI0_I1435_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1435_MN11_1 (XI0_I1435_an5 I0_pp5_23 XI0_I1435_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1435_MN12_1 (XI0_I1435_asn I0_pp6_21 XI0_I1435_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1435_MN10_1 (XI0_I1435_an4 I0_pp4_25 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1435_MN5 (XI0_I1435_acon I0_pp6_21 XI0_I1435_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1435_MN2 (XI0_I1435_an1 I0_pp5_23 XI0_I1435_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1435_MN1 (VSS I0_pp4_25 XI0_I1435_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1435_MN3 (XI0_I1435_an2 I0_pp4_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1435_MN4 (VSS I0_pp5_23 XI0_I1435_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1435_MN27 (I0_cm74_2 XI0_I1435_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1435_MN7 (XI0_I1435_an3 I0_pp5_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1435_MN8 (VSS I0_pp6_21 XI0_I1435_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1439_MN34 (XI0_I1439_bn3 XI0_I1439_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1439_MN35 (VSS I0_pp7_20 XI0_I1439_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1439_MN36 (XI0_I1439_bn3 I0_cm74_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1439_MN37 (XI0_I1439_bsn XI0_I1439_bcon XI0_I1439_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1439_MN40 (XI0_I1439_bn5 I0_cm74_2 XI0_I1439_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1439_MN39 (XI0_I1439_bn4 I0_pp7_20 XI0_I1439_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1439_MN39_1 (XI0_I1439_bn5 I0_pp7_20 XI0_I1439_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1439_MN40_1 (XI0_I1439_bsn I0_cm74_2 XI0_I1439_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1439_MN53 (VSS XI0_I1439_bsn I0_cm78_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1439_MN29 (XI0_I1439_bn1 XI0_I1439_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1439_MN30 (XI0_I1439_bcon I0_pp7_20 XI0_I1439_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1439_MN33 (XI0_I1439_bn2 I0_cm74_2 XI0_I1439_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1439_MN31 (VSS XI0_I1439_s1 XI0_I1439_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1439_MN32 (XI0_I1439_bn2 I0_pp7_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1439_MN55 (VSS XI0_I1439_bcon I0_cm78_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1439_MN38 (XI0_I1439_bn4 XI0_I1439_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1439_MN38_1 (VSS XI0_I1439_s1 XI0_I1439_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1439_MN25 (VSS XI0_I1439_asn XI0_I1439_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1439_MN10 (VSS I0_pp4_26 XI0_I1439_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1439_MN6 (XI0_I1439_an3 I0_pp4_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1439_MN9 (XI0_I1439_asn XI0_I1439_acon XI0_I1439_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1439_MN12 (XI0_I1439_an5 I0_pp6_22 XI0_I1439_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1439_MN11 (XI0_I1439_an4 I0_pp5_24 XI0_I1439_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1439_MN11_1 (XI0_I1439_an5 I0_pp5_24 XI0_I1439_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1439_MN12_1 (XI0_I1439_asn I0_pp6_22 XI0_I1439_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1439_MN10_1 (XI0_I1439_an4 I0_pp4_26 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1439_MN5 (XI0_I1439_acon I0_pp6_22 XI0_I1439_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1439_MN2 (XI0_I1439_an1 I0_pp5_24 XI0_I1439_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1439_MN1 (VSS I0_pp4_26 XI0_I1439_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1439_MN3 (XI0_I1439_an2 I0_pp4_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1439_MN4 (VSS I0_pp5_24 XI0_I1439_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1439_MN27 (I0_cm78_2 XI0_I1439_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1439_MN7 (XI0_I1439_an3 I0_pp5_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1439_MN8 (VSS I0_pp6_22 XI0_I1439_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1443_MN34 (XI0_I1443_bn3 XI0_I1443_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1443_MN35 (VSS I0_pp7_21 XI0_I1443_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1443_MN36 (XI0_I1443_bn3 I0_cm78_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1443_MN37 (XI0_I1443_bsn XI0_I1443_bcon XI0_I1443_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1443_MN40 (XI0_I1443_bn5 I0_cm78_2 XI0_I1443_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1443_MN39 (XI0_I1443_bn4 I0_pp7_21 XI0_I1443_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1443_MN39_1 (XI0_I1443_bn5 I0_pp7_21 XI0_I1443_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1443_MN40_1 (XI0_I1443_bsn I0_cm78_2 XI0_I1443_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1443_MN53 (VSS XI0_I1443_bsn I0_cm82_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1443_MN29 (XI0_I1443_bn1 XI0_I1443_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1443_MN30 (XI0_I1443_bcon I0_pp7_21 XI0_I1443_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1443_MN33 (XI0_I1443_bn2 I0_cm78_2 XI0_I1443_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1443_MN31 (VSS XI0_I1443_s1 XI0_I1443_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1443_MN32 (XI0_I1443_bn2 I0_pp7_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1443_MN55 (VSS XI0_I1443_bcon I0_cm82_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1443_MN38 (XI0_I1443_bn4 XI0_I1443_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1443_MN38_1 (VSS XI0_I1443_s1 XI0_I1443_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1443_MN25 (VSS XI0_I1443_asn XI0_I1443_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1443_MN10 (VSS I0_pp4_27 XI0_I1443_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1443_MN6 (XI0_I1443_an3 I0_pp4_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1443_MN9 (XI0_I1443_asn XI0_I1443_acon XI0_I1443_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1443_MN12 (XI0_I1443_an5 I0_pp6_23 XI0_I1443_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1443_MN11 (XI0_I1443_an4 I0_pp5_25 XI0_I1443_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1443_MN11_1 (XI0_I1443_an5 I0_pp5_25 XI0_I1443_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1443_MN12_1 (XI0_I1443_asn I0_pp6_23 XI0_I1443_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1443_MN10_1 (XI0_I1443_an4 I0_pp4_27 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1443_MN5 (XI0_I1443_acon I0_pp6_23 XI0_I1443_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1443_MN2 (XI0_I1443_an1 I0_pp5_25 XI0_I1443_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1443_MN1 (VSS I0_pp4_27 XI0_I1443_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1443_MN3 (XI0_I1443_an2 I0_pp4_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1443_MN4 (VSS I0_pp5_25 XI0_I1443_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1443_MN27 (I0_cm82_2 XI0_I1443_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1443_MN7 (XI0_I1443_an3 I0_pp5_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1443_MN8 (VSS I0_pp6_23 XI0_I1443_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1462_MN34 (XI0_I1462_bn3 XI0_I1462_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1462_MN35 (VSS I0_pp7_27 XI0_I1462_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1462_MN36 (XI0_I1462_bn3 I0_cm98_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1462_MN37 (XI0_I1462_bsn XI0_I1462_bcon XI0_I1462_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1462_MN40 (XI0_I1462_bn5 I0_cm98_2 XI0_I1462_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1462_MN39 (XI0_I1462_bn4 I0_pp7_27 XI0_I1462_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1462_MN39_1 (XI0_I1462_bn5 I0_pp7_27 XI0_I1462_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1462_MN40_1 (XI0_I1462_bsn I0_cm98_2 XI0_I1462_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1462_MN53 (VSS XI0_I1462_bsn I0_cm101_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1462_MN29 (XI0_I1462_bn1 XI0_I1462_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1462_MN30 (XI0_I1462_bcon I0_pp7_27 XI0_I1462_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1462_MN33 (XI0_I1462_bn2 I0_cm98_2 XI0_I1462_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1462_MN31 (VSS XI0_I1462_s1 XI0_I1462_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1462_MN32 (XI0_I1462_bn2 I0_pp7_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1462_MN55 (VSS XI0_I1462_bcon I0_cm101_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1462_MN38 (XI0_I1462_bn4 XI0_I1462_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1462_MN38_1 (VSS XI0_I1462_s1 XI0_I1462_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1462_MN25 (VSS XI0_I1462_asn XI0_I1462_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1462_MN10 (VSS I0_sn4 XI0_I1462_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1462_MN6 (XI0_I1462_an3 I0_sn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1462_MN9 (XI0_I1462_asn XI0_I1462_acon XI0_I1462_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1462_MN12 (XI0_I1462_an5 I0_pp6_29 XI0_I1462_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1462_MN11 (XI0_I1462_an4 I0_pp5_31 XI0_I1462_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1462_MN11_1 (XI0_I1462_an5 I0_pp5_31 XI0_I1462_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1462_MN12_1 (XI0_I1462_asn I0_pp6_29 XI0_I1462_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1462_MN10_1 (XI0_I1462_an4 I0_sn4 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1462_MN5 (XI0_I1462_acon I0_pp6_29 XI0_I1462_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1462_MN2 (XI0_I1462_an1 I0_pp5_31 XI0_I1462_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1462_MN1 (VSS I0_sn4 XI0_I1462_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1462_MN3 (XI0_I1462_an2 I0_sn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1462_MN4 (VSS I0_pp5_31 XI0_I1462_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1462_MN27 (I0_cm101_2 XI0_I1462_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1462_MN7 (XI0_I1462_an3 I0_pp5_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1462_MN8 (VSS I0_pp6_29 XI0_I1462_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1372_MN34 (XI0_I1372_bn3 XI0_I1372_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1372_MN35 (VSS I0_pp3_6 XI0_I1372_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1372_MN36 (XI0_I1372_bn3 I0_cm10_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1372_MN37 (XI0_I1372_bsn XI0_I1372_bcon XI0_I1372_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1372_MN40 (XI0_I1372_bn5 I0_cm10_2 XI0_I1372_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1372_MN39 (XI0_I1372_bn4 I0_pp3_6 XI0_I1372_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1372_MN39_1 (XI0_I1372_bn5 I0_pp3_6 XI0_I1372_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1372_MN40_1 (XI0_I1372_bsn I0_cm10_2 XI0_I1372_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1372_MN53 (VSS XI0_I1372_bsn I0_cm11_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1372_MN29 (XI0_I1372_bn1 XI0_I1372_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1372_MN30 (XI0_I1372_bcon I0_pp3_6 XI0_I1372_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1372_MN33 (XI0_I1372_bn2 I0_cm10_2 XI0_I1372_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1372_MN31 (VSS XI0_I1372_s1 XI0_I1372_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1372_MN32 (XI0_I1372_bn2 I0_pp3_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1372_MN55 (VSS XI0_I1372_bcon I0_cm11_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1372_MN38 (XI0_I1372_bn4 XI0_I1372_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1372_MN38_1 (VSS XI0_I1372_s1 XI0_I1372_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1372_MN25 (VSS XI0_I1372_asn XI0_I1372_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1372_MN10 (VSS I0_pp0_12 XI0_I1372_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1372_MN6 (XI0_I1372_an3 I0_pp0_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1372_MN9 (XI0_I1372_asn XI0_I1372_acon XI0_I1372_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1372_MN12 (XI0_I1372_an5 I0_pp2_8 XI0_I1372_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1372_MN11 (XI0_I1372_an4 I0_pp1_10 XI0_I1372_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1372_MN11_1 (XI0_I1372_an5 I0_pp1_10 XI0_I1372_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1372_MN12_1 (XI0_I1372_asn I0_pp2_8 XI0_I1372_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1372_MN10_1 (XI0_I1372_an4 I0_pp0_12 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1372_MN5 (XI0_I1372_acon I0_pp2_8 XI0_I1372_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1372_MN2 (XI0_I1372_an1 I0_pp1_10 XI0_I1372_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1372_MN1 (VSS I0_pp0_12 XI0_I1372_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1372_MN3 (XI0_I1372_an2 I0_pp0_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1372_MN4 (VSS I0_pp1_10 XI0_I1372_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1372_MN27 (I0_cm11_2 XI0_I1372_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1372_MN7 (XI0_I1372_an3 I0_pp1_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1372_MN8 (VSS I0_pp2_8 XI0_I1372_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1405_MN34 (XI0_I1405_bn3 XI0_I1405_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1405_MN35 (VSS I0_pp7_11 XI0_I1405_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1405_MN36 (XI0_I1405_bn3 I0_cm41_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1405_MN37 (XI0_I1405_bsn XI0_I1405_bcon XI0_I1405_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1405_MN40 (XI0_I1405_bn5 I0_cm41_2 XI0_I1405_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1405_MN39 (XI0_I1405_bn4 I0_pp7_11 XI0_I1405_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1405_MN39_1 (XI0_I1405_bn5 I0_pp7_11 XI0_I1405_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1405_MN40_1 (XI0_I1405_bsn I0_cm41_2 XI0_I1405_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1405_MN53 (VSS XI0_I1405_bsn I0_cm44_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1405_MN29 (XI0_I1405_bn1 XI0_I1405_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1405_MN30 (XI0_I1405_bcon I0_pp7_11 XI0_I1405_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1405_MN33 (XI0_I1405_bn2 I0_cm41_2 XI0_I1405_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1405_MN31 (VSS XI0_I1405_s1 XI0_I1405_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1405_MN32 (XI0_I1405_bn2 I0_pp7_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1405_MN55 (VSS XI0_I1405_bcon I0_cm44_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1405_MN38 (XI0_I1405_bn4 XI0_I1405_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1405_MN38_1 (VSS XI0_I1405_s1 XI0_I1405_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1405_MN25 (VSS XI0_I1405_asn XI0_I1405_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1405_MN10 (VSS I0_pp4_17 XI0_I1405_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1405_MN6 (XI0_I1405_an3 I0_pp4_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1405_MN9 (XI0_I1405_asn XI0_I1405_acon XI0_I1405_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1405_MN12 (XI0_I1405_an5 I0_pp6_13 XI0_I1405_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1405_MN11 (XI0_I1405_an4 I0_pp5_15 XI0_I1405_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1405_MN11_1 (XI0_I1405_an5 I0_pp5_15 XI0_I1405_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1405_MN12_1 (XI0_I1405_asn I0_pp6_13 XI0_I1405_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1405_MN10_1 (XI0_I1405_an4 I0_pp4_17 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1405_MN5 (XI0_I1405_acon I0_pp6_13 XI0_I1405_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1405_MN2 (XI0_I1405_an1 I0_pp5_15 XI0_I1405_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1405_MN1 (VSS I0_pp4_17 XI0_I1405_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1405_MN3 (XI0_I1405_an2 I0_pp4_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1405_MN4 (VSS I0_pp5_15 XI0_I1405_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1405_MN27 (I0_cm44_2 XI0_I1405_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1405_MN7 (XI0_I1405_an3 I0_pp5_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1405_MN8 (VSS I0_pp6_13 XI0_I1405_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1524_MN34 (XI0_I1524_bn3 XI0_I1524_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1524_MN35 (VSS I0_cm53_0 XI0_I1524_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1524_MN36 (XI0_I1524_bn3 I0_cm161_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1524_MN37 (XI0_I1524_bsn XI0_I1524_bcon XI0_I1524_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1524_MN40 (XI0_I1524_bn5 I0_cm161_2 XI0_I1524_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1524_MN39 (XI0_I1524_bn4 I0_cm53_0 XI0_I1524_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1524_MN39_1 (XI0_I1524_bn5 I0_cm53_0 XI0_I1524_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1524_MN40_1 (XI0_I1524_bsn I0_cm161_2 XI0_I1524_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1524_MN53 (VSS XI0_I1524_bsn I0_cm163_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1524_MN29 (XI0_I1524_bn1 XI0_I1524_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1524_MN30 (XI0_I1524_bcon I0_cm53_0 XI0_I1524_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1524_MN33 (XI0_I1524_bn2 I0_cm161_2 XI0_I1524_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1524_MN31 (VSS XI0_I1524_s1 XI0_I1524_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1524_MN32 (XI0_I1524_bn2 I0_cm53_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1524_MN55 (VSS XI0_I1524_bcon I0_cm163_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1524_MN38 (XI0_I1524_bn4 XI0_I1524_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1524_MN38_1 (VSS XI0_I1524_s1 XI0_I1524_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1524_MN25 (VSS XI0_I1524_asn XI0_I1524_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1524_MN10 (VSS I0_cm50_1 XI0_I1524_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1524_MN6 (XI0_I1524_an3 I0_cm50_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1524_MN9 (XI0_I1524_asn XI0_I1524_acon XI0_I1524_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1524_MN12 (XI0_I1524_an5 I0_cm52_1 XI0_I1524_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1524_MN11 (XI0_I1524_an4 I0_cm51_1 XI0_I1524_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1524_MN11_1 (XI0_I1524_an5 I0_cm51_1 XI0_I1524_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1524_MN12_1 (XI0_I1524_asn I0_cm52_1 XI0_I1524_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1524_MN10_1 (XI0_I1524_an4 I0_cm50_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1524_MN5 (XI0_I1524_acon I0_cm52_1 XI0_I1524_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1524_MN2 (XI0_I1524_an1 I0_cm51_1 XI0_I1524_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1524_MN1 (VSS I0_cm50_1 XI0_I1524_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1524_MN3 (XI0_I1524_an2 I0_cm50_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1524_MN4 (VSS I0_cm51_1 XI0_I1524_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1524_MN27 (I0_cm163_2 XI0_I1524_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1524_MN7 (XI0_I1524_an3 I0_cm51_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1524_MN8 (VSS I0_cm52_1 XI0_I1524_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1526_MN34 (XI0_I1526_bn3 XI0_I1526_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1526_MN35 (VSS I0_fa56_1 XI0_I1526_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1526_MN36 (XI0_I1526_bn3 I0_cm163_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1526_MN37 (XI0_I1526_bsn XI0_I1526_bcon XI0_I1526_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1526_MN40 (XI0_I1526_bn5 I0_cm163_2 XI0_I1526_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1526_MN39 (XI0_I1526_bn4 I0_fa56_1 XI0_I1526_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1526_MN39_1 (XI0_I1526_bn5 I0_fa56_1 XI0_I1526_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1526_MN40_1 (XI0_I1526_bsn I0_cm163_2 XI0_I1526_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1526_MN53 (VSS XI0_I1526_bsn I0_cm165_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1526_MN29 (XI0_I1526_bn1 XI0_I1526_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1526_MN30 (XI0_I1526_bcon I0_fa56_1 XI0_I1526_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1526_MN33 (XI0_I1526_bn2 I0_cm163_2 XI0_I1526_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1526_MN31 (VSS XI0_I1526_s1 XI0_I1526_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1526_MN32 (XI0_I1526_bn2 I0_fa56_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1526_MN55 (VSS XI0_I1526_bcon I0_cm165_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1526_MN38 (XI0_I1526_bn4 XI0_I1526_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1526_MN38_1 (VSS XI0_I1526_s1 XI0_I1526_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1526_MN25 (VSS XI0_I1526_asn XI0_I1526_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1526_MN10 (VSS I0_cm53_1 XI0_I1526_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1526_MN6 (XI0_I1526_an3 I0_cm53_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1526_MN9 (XI0_I1526_asn XI0_I1526_acon XI0_I1526_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1526_MN12 (XI0_I1526_an5 I0_cm55_1 XI0_I1526_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1526_MN11 (XI0_I1526_an4 I0_cm54_1 XI0_I1526_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1526_MN11_1 (XI0_I1526_an5 I0_cm54_1 XI0_I1526_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1526_MN12_1 (XI0_I1526_asn I0_cm55_1 XI0_I1526_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1526_MN10_1 (XI0_I1526_an4 I0_cm53_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1526_MN5 (XI0_I1526_acon I0_cm55_1 XI0_I1526_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1526_MN2 (XI0_I1526_an1 I0_cm54_1 XI0_I1526_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1526_MN1 (VSS I0_cm53_1 XI0_I1526_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1526_MN3 (XI0_I1526_an2 I0_cm53_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1526_MN4 (VSS I0_cm54_1 XI0_I1526_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1526_MN27 (I0_cm165_2 XI0_I1526_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1526_MN7 (XI0_I1526_an3 I0_cm54_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1526_MN8 (VSS I0_cm55_1 XI0_I1526_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1528_MN34 (XI0_I1528_bn3 XI0_I1528_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1528_MN35 (VSS I0_fa60_1 XI0_I1528_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1528_MN36 (XI0_I1528_bn3 I0_cm165_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1528_MN37 (XI0_I1528_bsn XI0_I1528_bcon XI0_I1528_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1528_MN40 (XI0_I1528_bn5 I0_cm165_2 XI0_I1528_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1528_MN39 (XI0_I1528_bn4 I0_fa60_1 XI0_I1528_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1528_MN39_1 (XI0_I1528_bn5 I0_fa60_1 XI0_I1528_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1528_MN40_1 (XI0_I1528_bsn I0_cm165_2 XI0_I1528_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1528_MN53 (VSS XI0_I1528_bsn I0_cm167_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1528_MN29 (XI0_I1528_bn1 XI0_I1528_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1528_MN30 (XI0_I1528_bcon I0_fa60_1 XI0_I1528_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1528_MN33 (XI0_I1528_bn2 I0_cm165_2 XI0_I1528_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1528_MN31 (VSS XI0_I1528_s1 XI0_I1528_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1528_MN32 (XI0_I1528_bn2 I0_fa60_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1528_MN55 (VSS XI0_I1528_bcon I0_cm167_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1528_MN38 (XI0_I1528_bn4 XI0_I1528_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1528_MN38_1 (VSS XI0_I1528_s1 XI0_I1528_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1528_MN25 (VSS XI0_I1528_asn XI0_I1528_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1528_MN10 (VSS I0_cm57_1 XI0_I1528_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1528_MN6 (XI0_I1528_an3 I0_cm57_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1528_MN9 (XI0_I1528_asn XI0_I1528_acon XI0_I1528_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1528_MN12 (XI0_I1528_an5 I0_cm59_1 XI0_I1528_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1528_MN11 (XI0_I1528_an4 I0_cm58_1 XI0_I1528_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1528_MN11_1 (XI0_I1528_an5 I0_cm58_1 XI0_I1528_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1528_MN12_1 (XI0_I1528_asn I0_cm59_1 XI0_I1528_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1528_MN10_1 (XI0_I1528_an4 I0_cm57_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1528_MN5 (XI0_I1528_acon I0_cm59_1 XI0_I1528_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1528_MN2 (XI0_I1528_an1 I0_cm58_1 XI0_I1528_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1528_MN1 (VSS I0_cm57_1 XI0_I1528_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1528_MN3 (XI0_I1528_an2 I0_cm57_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1528_MN4 (VSS I0_cm58_1 XI0_I1528_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1528_MN27 (I0_cm167_2 XI0_I1528_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1528_MN7 (XI0_I1528_an3 I0_cm58_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1528_MN8 (VSS I0_cm59_1 XI0_I1528_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1431_MN34 (XI0_I1431_bn3 XI0_I1431_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1431_MN35 (VSS I0_pp7_18 XI0_I1431_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1431_MN36 (XI0_I1431_bn3 I0_cm66_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1431_MN37 (XI0_I1431_bsn XI0_I1431_bcon XI0_I1431_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1431_MN40 (XI0_I1431_bn5 I0_cm66_2 XI0_I1431_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1431_MN39 (XI0_I1431_bn4 I0_pp7_18 XI0_I1431_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1431_MN39_1 (XI0_I1431_bn5 I0_pp7_18 XI0_I1431_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1431_MN40_1 (XI0_I1431_bsn I0_cm66_2 XI0_I1431_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1431_MN53 (VSS XI0_I1431_bsn I0_cm70_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1431_MN29 (XI0_I1431_bn1 XI0_I1431_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1431_MN30 (XI0_I1431_bcon I0_pp7_18 XI0_I1431_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1431_MN33 (XI0_I1431_bn2 I0_cm66_2 XI0_I1431_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1431_MN31 (VSS XI0_I1431_s1 XI0_I1431_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1431_MN32 (XI0_I1431_bn2 I0_pp7_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1431_MN55 (VSS XI0_I1431_bcon I0_cm70_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1431_MN38 (XI0_I1431_bn4 XI0_I1431_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1431_MN38_1 (VSS XI0_I1431_s1 XI0_I1431_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1431_MN25 (VSS XI0_I1431_asn XI0_I1431_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1431_MN10 (VSS I0_pp4_24 XI0_I1431_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1431_MN6 (XI0_I1431_an3 I0_pp4_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1431_MN9 (XI0_I1431_asn XI0_I1431_acon XI0_I1431_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1431_MN12 (XI0_I1431_an5 I0_pp6_20 XI0_I1431_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1431_MN11 (XI0_I1431_an4 I0_pp5_22 XI0_I1431_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1431_MN11_1 (XI0_I1431_an5 I0_pp5_22 XI0_I1431_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1431_MN12_1 (XI0_I1431_asn I0_pp6_20 XI0_I1431_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1431_MN10_1 (XI0_I1431_an4 I0_pp4_24 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1431_MN5 (XI0_I1431_acon I0_pp6_20 XI0_I1431_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1431_MN2 (XI0_I1431_an1 I0_pp5_22 XI0_I1431_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1431_MN1 (VSS I0_pp4_24 XI0_I1431_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1431_MN3 (XI0_I1431_an2 I0_pp4_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1431_MN4 (VSS I0_pp5_22 XI0_I1431_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1431_MN27 (I0_cm70_2 XI0_I1431_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1431_MN7 (XI0_I1431_an3 I0_pp5_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1431_MN8 (VSS I0_pp6_20 XI0_I1431_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1534_MN34 (XI0_I1534_bn3 XI0_I1534_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1534_MN35 (VSS I0_cm72_1 XI0_I1534_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1534_MN36 (XI0_I1534_bn3 I0_cm171_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1534_MN37 (XI0_I1534_bsn XI0_I1534_bcon XI0_I1534_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1534_MN40 (XI0_I1534_bn5 I0_cm171_2 XI0_I1534_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1534_MN39 (XI0_I1534_bn4 I0_cm72_1 XI0_I1534_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1534_MN39_1 (XI0_I1534_bn5 I0_cm72_1 XI0_I1534_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1534_MN40_1 (XI0_I1534_bsn I0_cm171_2 XI0_I1534_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1534_MN53 (VSS XI0_I1534_bsn I0_cm173_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1534_MN29 (XI0_I1534_bn1 XI0_I1534_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1534_MN30 (XI0_I1534_bcon I0_cm72_1 XI0_I1534_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1534_MN33 (XI0_I1534_bn2 I0_cm171_2 XI0_I1534_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1534_MN31 (VSS XI0_I1534_s1 XI0_I1534_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1534_MN32 (XI0_I1534_bn2 I0_cm72_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1534_MN55 (VSS XI0_I1534_bcon I0_cm173_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1534_MN38 (XI0_I1534_bn4 XI0_I1534_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1534_MN38_1 (VSS XI0_I1534_s1 XI0_I1534_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1534_MN25 (VSS XI0_I1534_asn XI0_I1534_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1534_MN10 (VSS I0_cm69_1 XI0_I1534_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1534_MN6 (XI0_I1534_an3 I0_cm69_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1534_MN9 (XI0_I1534_asn XI0_I1534_acon XI0_I1534_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1534_MN12 (XI0_I1534_an5 I0_cm71_1 XI0_I1534_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1534_MN11 (XI0_I1534_an4 I0_cm70_1 XI0_I1534_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1534_MN11_1 (XI0_I1534_an5 I0_cm70_1 XI0_I1534_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1534_MN12_1 (XI0_I1534_asn I0_cm71_1 XI0_I1534_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1534_MN10_1 (XI0_I1534_an4 I0_cm69_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1534_MN5 (XI0_I1534_acon I0_cm71_1 XI0_I1534_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1534_MN2 (XI0_I1534_an1 I0_cm70_1 XI0_I1534_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1534_MN1 (VSS I0_cm69_1 XI0_I1534_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1534_MN3 (XI0_I1534_an2 I0_cm69_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1534_MN4 (VSS I0_cm70_1 XI0_I1534_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1534_MN27 (I0_cm173_2 XI0_I1534_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1534_MN7 (XI0_I1534_an3 I0_cm70_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1534_MN8 (VSS I0_cm71_1 XI0_I1534_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1465_MN34 (XI0_I1465_bn3 XI0_I1465_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1465_MN35 (VSS I0_pp7_28 XI0_I1465_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1465_MN36 (XI0_I1465_bn3 I0_cm101_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1465_MN37 (XI0_I1465_bsn XI0_I1465_bcon XI0_I1465_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1465_MN40 (XI0_I1465_bn5 I0_cm101_2 XI0_I1465_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1465_MN39 (XI0_I1465_bn4 I0_pp7_28 XI0_I1465_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1465_MN39_1 (XI0_I1465_bn5 I0_pp7_28 XI0_I1465_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1465_MN40_1 (XI0_I1465_bsn I0_cm101_2 XI0_I1465_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1465_MN53 (VSS XI0_I1465_bsn I0_cm104_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1465_MN29 (XI0_I1465_bn1 XI0_I1465_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1465_MN30 (XI0_I1465_bcon I0_pp7_28 XI0_I1465_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1465_MN33 (XI0_I1465_bn2 I0_cm101_2 XI0_I1465_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1465_MN31 (VSS XI0_I1465_s1 XI0_I1465_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1465_MN32 (XI0_I1465_bn2 I0_pp7_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1465_MN55 (VSS XI0_I1465_bcon I0_cm104_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1465_MN38 (XI0_I1465_bn4 XI0_I1465_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1465_MN38_1 (VSS XI0_I1465_s1 XI0_I1465_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1465_MN25 (VSS XI0_I1465_asn XI0_I1465_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1465_MN10 (VSS VDD XI0_I1465_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1465_MN6 (XI0_I1465_an3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1465_MN9 (XI0_I1465_asn XI0_I1465_acon XI0_I1465_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1465_MN12 (XI0_I1465_an5 I0_pp6_30 XI0_I1465_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1465_MN11 (XI0_I1465_an4 I0_pp5_32 XI0_I1465_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1465_MN11_1 (XI0_I1465_an5 I0_pp5_32 XI0_I1465_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1465_MN12_1 (XI0_I1465_asn I0_pp6_30 XI0_I1465_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1465_MN10_1 (XI0_I1465_an4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1465_MN5 (XI0_I1465_acon I0_pp6_30 XI0_I1465_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1465_MN2 (XI0_I1465_an1 I0_pp5_32 XI0_I1465_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1465_MN1 (VSS VDD XI0_I1465_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1465_MN3 (XI0_I1465_an2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1465_MN4 (VSS I0_pp5_32 XI0_I1465_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1465_MN27 (I0_cm104_2 XI0_I1465_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1465_MN7 (XI0_I1465_an3 I0_pp5_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1465_MN8 (VSS I0_pp6_30 XI0_I1465_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1402_MN34 (XI0_I1402_bn3 XI0_I1402_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1402_MN35 (VSS I0_pp7_10 XI0_I1402_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1402_MN36 (XI0_I1402_bn3 I0_cm38_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1402_MN37 (XI0_I1402_bsn XI0_I1402_bcon XI0_I1402_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1402_MN40 (XI0_I1402_bn5 I0_cm38_2 XI0_I1402_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1402_MN39 (XI0_I1402_bn4 I0_pp7_10 XI0_I1402_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1402_MN39_1 (XI0_I1402_bn5 I0_pp7_10 XI0_I1402_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1402_MN40_1 (XI0_I1402_bsn I0_cm38_2 XI0_I1402_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1402_MN53 (VSS XI0_I1402_bsn I0_cm41_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1402_MN29 (XI0_I1402_bn1 XI0_I1402_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1402_MN30 (XI0_I1402_bcon I0_pp7_10 XI0_I1402_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1402_MN33 (XI0_I1402_bn2 I0_cm38_2 XI0_I1402_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1402_MN31 (VSS XI0_I1402_s1 XI0_I1402_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1402_MN32 (XI0_I1402_bn2 I0_pp7_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1402_MN55 (VSS XI0_I1402_bcon I0_cm41_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1402_MN38 (XI0_I1402_bn4 XI0_I1402_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1402_MN38_1 (VSS XI0_I1402_s1 XI0_I1402_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1402_MN25 (VSS XI0_I1402_asn XI0_I1402_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1402_MN10 (VSS I0_pp4_16 XI0_I1402_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1402_MN6 (XI0_I1402_an3 I0_pp4_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1402_MN9 (XI0_I1402_asn XI0_I1402_acon XI0_I1402_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1402_MN12 (XI0_I1402_an5 I0_pp6_12 XI0_I1402_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1402_MN11 (XI0_I1402_an4 I0_pp5_14 XI0_I1402_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1402_MN11_1 (XI0_I1402_an5 I0_pp5_14 XI0_I1402_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1402_MN12_1 (XI0_I1402_asn I0_pp6_12 XI0_I1402_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1402_MN10_1 (XI0_I1402_an4 I0_pp4_16 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1402_MN5 (XI0_I1402_acon I0_pp6_12 XI0_I1402_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1402_MN2 (XI0_I1402_an1 I0_pp5_14 XI0_I1402_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1402_MN1 (VSS I0_pp4_16 XI0_I1402_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1402_MN3 (XI0_I1402_an2 I0_pp4_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1402_MN4 (VSS I0_pp5_14 XI0_I1402_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1402_MN27 (I0_cm41_2 XI0_I1402_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1402_MN7 (XI0_I1402_an3 I0_pp5_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1402_MN8 (VSS I0_pp6_12 XI0_I1402_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1396_MN34 (XI0_I1396_bn3 XI0_I1396_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1396_MN35 (VSS I0_pp7_8 XI0_I1396_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1396_MN36 (XI0_I1396_bn3 I0_cm32_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1396_MN37 (XI0_I1396_bsn XI0_I1396_bcon XI0_I1396_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1396_MN40 (XI0_I1396_bn5 I0_cm32_2 XI0_I1396_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1396_MN39 (XI0_I1396_bn4 I0_pp7_8 XI0_I1396_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1396_MN39_1 (XI0_I1396_bn5 I0_pp7_8 XI0_I1396_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1396_MN40_1 (XI0_I1396_bsn I0_cm32_2 XI0_I1396_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1396_MN53 (VSS XI0_I1396_bsn I0_cm35_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1396_MN29 (XI0_I1396_bn1 XI0_I1396_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1396_MN30 (XI0_I1396_bcon I0_pp7_8 XI0_I1396_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1396_MN33 (XI0_I1396_bn2 I0_cm32_2 XI0_I1396_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1396_MN31 (VSS XI0_I1396_s1 XI0_I1396_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1396_MN32 (XI0_I1396_bn2 I0_pp7_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1396_MN55 (VSS XI0_I1396_bcon I0_cm35_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1396_MN38 (XI0_I1396_bn4 XI0_I1396_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1396_MN38_1 (VSS XI0_I1396_s1 XI0_I1396_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1396_MN25 (VSS XI0_I1396_asn XI0_I1396_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1396_MN10 (VSS I0_pp4_14 XI0_I1396_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1396_MN6 (XI0_I1396_an3 I0_pp4_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1396_MN9 (XI0_I1396_asn XI0_I1396_acon XI0_I1396_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1396_MN12 (XI0_I1396_an5 I0_pp6_10 XI0_I1396_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1396_MN11 (XI0_I1396_an4 I0_pp5_12 XI0_I1396_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1396_MN11_1 (XI0_I1396_an5 I0_pp5_12 XI0_I1396_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1396_MN12_1 (XI0_I1396_asn I0_pp6_10 XI0_I1396_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1396_MN10_1 (XI0_I1396_an4 I0_pp4_14 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1396_MN5 (XI0_I1396_acon I0_pp6_10 XI0_I1396_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1396_MN2 (XI0_I1396_an1 I0_pp5_12 XI0_I1396_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1396_MN1 (VSS I0_pp4_14 XI0_I1396_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1396_MN3 (XI0_I1396_an2 I0_pp4_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1396_MN4 (VSS I0_pp5_12 XI0_I1396_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1396_MN27 (I0_cm35_2 XI0_I1396_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1396_MN7 (XI0_I1396_an3 I0_pp5_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1396_MN8 (VSS I0_pp6_10 XI0_I1396_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1520_MN34 (XI0_I1520_bn3 XI0_I1520_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1520_MN35 (VSS I0_cm46_0 XI0_I1520_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1520_MN36 (XI0_I1520_bn3 I0_cm157_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1520_MN37 (XI0_I1520_bsn XI0_I1520_bcon XI0_I1520_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1520_MN40 (XI0_I1520_bn5 I0_cm157_2 XI0_I1520_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1520_MN39 (XI0_I1520_bn4 I0_cm46_0 XI0_I1520_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1520_MN39_1 (XI0_I1520_bn5 I0_cm46_0 XI0_I1520_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1520_MN40_1 (XI0_I1520_bsn I0_cm157_2 XI0_I1520_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1520_MN53 (VSS XI0_I1520_bsn I0_cm159_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1520_MN29 (XI0_I1520_bn1 XI0_I1520_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1520_MN30 (XI0_I1520_bcon I0_cm46_0 XI0_I1520_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1520_MN33 (XI0_I1520_bn2 I0_cm157_2 XI0_I1520_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1520_MN31 (VSS XI0_I1520_s1 XI0_I1520_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1520_MN32 (XI0_I1520_bn2 I0_cm46_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1520_MN55 (VSS XI0_I1520_bcon I0_cm159_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1520_MN38 (XI0_I1520_bn4 XI0_I1520_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1520_MN38_1 (VSS XI0_I1520_s1 XI0_I1520_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1520_MN25 (VSS XI0_I1520_asn XI0_I1520_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1520_MN10 (VSS I0_cm43_1 XI0_I1520_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1520_MN6 (XI0_I1520_an3 I0_cm43_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1520_MN9 (XI0_I1520_asn XI0_I1520_acon XI0_I1520_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1520_MN12 (XI0_I1520_an5 I0_cm45_1 XI0_I1520_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1520_MN11 (XI0_I1520_an4 I0_cm44_1 XI0_I1520_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1520_MN11_1 (XI0_I1520_an5 I0_cm44_1 XI0_I1520_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1520_MN12_1 (XI0_I1520_asn I0_cm45_1 XI0_I1520_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1520_MN10_1 (XI0_I1520_an4 I0_cm43_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1520_MN5 (XI0_I1520_acon I0_cm45_1 XI0_I1520_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1520_MN2 (XI0_I1520_an1 I0_cm44_1 XI0_I1520_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1520_MN1 (VSS I0_cm43_1 XI0_I1520_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1520_MN3 (XI0_I1520_an2 I0_cm43_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1520_MN4 (VSS I0_cm44_1 XI0_I1520_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1520_MN27 (I0_cm159_2 XI0_I1520_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1520_MN7 (XI0_I1520_an3 I0_cm44_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1520_MN8 (VSS I0_cm45_1 XI0_I1520_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1584_MN34 (XI0_I1584_bn3 XI0_I1584_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1584_MN35 (VSS I0_cm166_0 XI0_I1584_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1584_MN36 (XI0_I1584_bn3 I0_cm222_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1584_MN37 (XI0_I1584_bsn XI0_I1584_bcon XI0_I1584_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1584_MN40 (XI0_I1584_bn5 I0_cm222_2 XI0_I1584_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1584_MN39 (XI0_I1584_bn4 I0_cm166_0 XI0_I1584_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1584_MN39_1 (XI0_I1584_bn5 I0_cm166_0 XI0_I1584_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1584_MN40_1 (XI0_I1584_bsn I0_cm222_2 XI0_I1584_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1584_MN53 (VSS XI0_I1584_bsn I0_cm223_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1584_MN29 (XI0_I1584_bn1 XI0_I1584_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1584_MN30 (XI0_I1584_bcon I0_cm166_0 XI0_I1584_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1584_MN33 (XI0_I1584_bn2 I0_cm222_2 XI0_I1584_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1584_MN31 (VSS XI0_I1584_s1 XI0_I1584_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1584_MN32 (XI0_I1584_bn2 I0_cm166_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1584_MN55 (VSS XI0_I1584_bcon I0_cm223_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1584_MN38 (XI0_I1584_bn4 XI0_I1584_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1584_MN38_1 (VSS XI0_I1584_s1 XI0_I1584_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1584_MN25 (VSS XI0_I1584_asn XI0_I1584_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1584_MN10 (VSS I0_cm163_1 XI0_I1584_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1584_MN6 (XI0_I1584_an3 I0_cm163_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1584_MN9 (XI0_I1584_asn XI0_I1584_acon XI0_I1584_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1584_MN12 (XI0_I1584_an5 I0_cm165_0 XI0_I1584_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1584_MN11 (XI0_I1584_an4 I0_cm164_1 XI0_I1584_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1584_MN11_1 (XI0_I1584_an5 I0_cm164_1 XI0_I1584_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1584_MN12_1 (XI0_I1584_asn I0_cm165_0 XI0_I1584_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1584_MN10_1 (XI0_I1584_an4 I0_cm163_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1584_MN5 (XI0_I1584_acon I0_cm165_0 XI0_I1584_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1584_MN2 (XI0_I1584_an1 I0_cm164_1 XI0_I1584_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1584_MN1 (VSS I0_cm163_1 XI0_I1584_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1584_MN3 (XI0_I1584_an2 I0_cm163_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1584_MN4 (VSS I0_cm164_1 XI0_I1584_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1584_MN27 (I0_cm223_2 XI0_I1584_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1584_MN7 (XI0_I1584_an3 I0_cm164_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1584_MN8 (VSS I0_cm165_0 XI0_I1584_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1408_MN34 (XI0_I1408_bn3 XI0_I1408_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1408_MN35 (VSS I0_pp7_12 XI0_I1408_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1408_MN36 (XI0_I1408_bn3 I0_cm44_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1408_MN37 (XI0_I1408_bsn XI0_I1408_bcon XI0_I1408_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1408_MN40 (XI0_I1408_bn5 I0_cm44_2 XI0_I1408_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1408_MN39 (XI0_I1408_bn4 I0_pp7_12 XI0_I1408_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1408_MN39_1 (XI0_I1408_bn5 I0_pp7_12 XI0_I1408_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1408_MN40_1 (XI0_I1408_bsn I0_cm44_2 XI0_I1408_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1408_MN53 (VSS XI0_I1408_bsn I0_cm47_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1408_MN29 (XI0_I1408_bn1 XI0_I1408_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1408_MN30 (XI0_I1408_bcon I0_pp7_12 XI0_I1408_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1408_MN33 (XI0_I1408_bn2 I0_cm44_2 XI0_I1408_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1408_MN31 (VSS XI0_I1408_s1 XI0_I1408_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1408_MN32 (XI0_I1408_bn2 I0_pp7_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1408_MN55 (VSS XI0_I1408_bcon I0_cm47_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1408_MN38 (XI0_I1408_bn4 XI0_I1408_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1408_MN38_1 (VSS XI0_I1408_s1 XI0_I1408_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1408_MN25 (VSS XI0_I1408_asn XI0_I1408_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1408_MN10 (VSS I0_pp4_18 XI0_I1408_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1408_MN6 (XI0_I1408_an3 I0_pp4_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1408_MN9 (XI0_I1408_asn XI0_I1408_acon XI0_I1408_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1408_MN12 (XI0_I1408_an5 I0_pp6_14 XI0_I1408_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1408_MN11 (XI0_I1408_an4 I0_pp5_16 XI0_I1408_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1408_MN11_1 (XI0_I1408_an5 I0_pp5_16 XI0_I1408_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1408_MN12_1 (XI0_I1408_asn I0_pp6_14 XI0_I1408_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1408_MN10_1 (XI0_I1408_an4 I0_pp4_18 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1408_MN5 (XI0_I1408_acon I0_pp6_14 XI0_I1408_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1408_MN2 (XI0_I1408_an1 I0_pp5_16 XI0_I1408_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1408_MN1 (VSS I0_pp4_18 XI0_I1408_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1408_MN3 (XI0_I1408_an2 I0_pp4_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1408_MN4 (VSS I0_pp5_16 XI0_I1408_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1408_MN27 (I0_cm47_2 XI0_I1408_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1408_MN7 (XI0_I1408_an3 I0_pp5_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1408_MN8 (VSS I0_pp6_14 XI0_I1408_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1532_MN34 (XI0_I1532_bn3 XI0_I1532_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1532_MN35 (VSS I0_cm68_1 XI0_I1532_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1532_MN36 (XI0_I1532_bn3 I0_cm169_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1532_MN37 (XI0_I1532_bsn XI0_I1532_bcon XI0_I1532_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1532_MN40 (XI0_I1532_bn5 I0_cm169_2 XI0_I1532_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1532_MN39 (XI0_I1532_bn4 I0_cm68_1 XI0_I1532_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1532_MN39_1 (XI0_I1532_bn5 I0_cm68_1 XI0_I1532_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1532_MN40_1 (XI0_I1532_bsn I0_cm169_2 XI0_I1532_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1532_MN53 (VSS XI0_I1532_bsn I0_cm171_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1532_MN29 (XI0_I1532_bn1 XI0_I1532_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1532_MN30 (XI0_I1532_bcon I0_cm68_1 XI0_I1532_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1532_MN33 (XI0_I1532_bn2 I0_cm169_2 XI0_I1532_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1532_MN31 (VSS XI0_I1532_s1 XI0_I1532_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1532_MN32 (XI0_I1532_bn2 I0_cm68_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1532_MN55 (VSS XI0_I1532_bcon I0_cm171_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1532_MN38 (XI0_I1532_bn4 XI0_I1532_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1532_MN38_1 (VSS XI0_I1532_s1 XI0_I1532_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1532_MN25 (VSS XI0_I1532_asn XI0_I1532_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1532_MN10 (VSS I0_cm65_1 XI0_I1532_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1532_MN6 (XI0_I1532_an3 I0_cm65_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1532_MN9 (XI0_I1532_asn XI0_I1532_acon XI0_I1532_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1532_MN12 (XI0_I1532_an5 I0_cm67_1 XI0_I1532_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1532_MN11 (XI0_I1532_an4 I0_cm66_1 XI0_I1532_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1532_MN11_1 (XI0_I1532_an5 I0_cm66_1 XI0_I1532_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1532_MN12_1 (XI0_I1532_asn I0_cm67_1 XI0_I1532_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1532_MN10_1 (XI0_I1532_an4 I0_cm65_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1532_MN5 (XI0_I1532_acon I0_cm67_1 XI0_I1532_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1532_MN2 (XI0_I1532_an1 I0_cm66_1 XI0_I1532_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1532_MN1 (VSS I0_cm65_1 XI0_I1532_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1532_MN3 (XI0_I1532_an2 I0_cm65_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1532_MN4 (VSS I0_cm66_1 XI0_I1532_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1532_MN27 (I0_cm171_2 XI0_I1532_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1532_MN7 (XI0_I1532_an3 I0_cm66_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1532_MN8 (VSS I0_cm67_1 XI0_I1532_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1530_MN34 (XI0_I1530_bn3 XI0_I1530_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1530_MN35 (VSS I0_cm64_1 XI0_I1530_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1530_MN36 (XI0_I1530_bn3 I0_cm167_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1530_MN37 (XI0_I1530_bsn XI0_I1530_bcon XI0_I1530_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1530_MN40 (XI0_I1530_bn5 I0_cm167_2 XI0_I1530_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1530_MN39 (XI0_I1530_bn4 I0_cm64_1 XI0_I1530_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1530_MN39_1 (XI0_I1530_bn5 I0_cm64_1 XI0_I1530_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1530_MN40_1 (XI0_I1530_bsn I0_cm167_2 XI0_I1530_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1530_MN53 (VSS XI0_I1530_bsn I0_cm169_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1530_MN29 (XI0_I1530_bn1 XI0_I1530_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1530_MN30 (XI0_I1530_bcon I0_cm64_1 XI0_I1530_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1530_MN33 (XI0_I1530_bn2 I0_cm167_2 XI0_I1530_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1530_MN31 (VSS XI0_I1530_s1 XI0_I1530_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1530_MN32 (XI0_I1530_bn2 I0_cm64_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1530_MN55 (VSS XI0_I1530_bcon I0_cm169_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1530_MN38 (XI0_I1530_bn4 XI0_I1530_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1530_MN38_1 (VSS XI0_I1530_s1 XI0_I1530_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1530_MN25 (VSS XI0_I1530_asn XI0_I1530_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1530_MN10 (VSS I0_cm61_1 XI0_I1530_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1530_MN6 (XI0_I1530_an3 I0_cm61_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1530_MN9 (XI0_I1530_asn XI0_I1530_acon XI0_I1530_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1530_MN12 (XI0_I1530_an5 I0_cm63_1 XI0_I1530_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1530_MN11 (XI0_I1530_an4 I0_cm62_1 XI0_I1530_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1530_MN11_1 (XI0_I1530_an5 I0_cm62_1 XI0_I1530_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1530_MN12_1 (XI0_I1530_asn I0_cm63_1 XI0_I1530_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1530_MN10_1 (XI0_I1530_an4 I0_cm61_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1530_MN5 (XI0_I1530_acon I0_cm63_1 XI0_I1530_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1530_MN2 (XI0_I1530_an1 I0_cm62_1 XI0_I1530_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1530_MN1 (VSS I0_cm61_1 XI0_I1530_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1530_MN3 (XI0_I1530_an2 I0_cm61_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1530_MN4 (VSS I0_cm62_1 XI0_I1530_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1530_MN27 (I0_cm169_2 XI0_I1530_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1530_MN7 (XI0_I1530_an3 I0_cm62_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1530_MN8 (VSS I0_cm63_1 XI0_I1530_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1529_MN34 (XI0_I1529_bn3 XI0_I1529_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1529_MN35 (VSS I0_cm64_0 XI0_I1529_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1529_MN36 (XI0_I1529_bn3 I0_cm166_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1529_MN37 (XI0_I1529_bsn XI0_I1529_bcon XI0_I1529_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1529_MN40 (XI0_I1529_bn5 I0_cm166_2 XI0_I1529_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1529_MN39 (XI0_I1529_bn4 I0_cm64_0 XI0_I1529_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1529_MN39_1 (XI0_I1529_bn5 I0_cm64_0 XI0_I1529_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1529_MN40_1 (XI0_I1529_bsn I0_cm166_2 XI0_I1529_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1529_MN53 (VSS XI0_I1529_bsn I0_cm168_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1529_MN29 (XI0_I1529_bn1 XI0_I1529_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1529_MN30 (XI0_I1529_bcon I0_cm64_0 XI0_I1529_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1529_MN33 (XI0_I1529_bn2 I0_cm166_2 XI0_I1529_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1529_MN31 (VSS XI0_I1529_s1 XI0_I1529_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1529_MN32 (XI0_I1529_bn2 I0_cm64_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1529_MN55 (VSS XI0_I1529_bcon I0_cm168_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1529_MN38 (XI0_I1529_bn4 XI0_I1529_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1529_MN38_1 (VSS XI0_I1529_s1 XI0_I1529_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1529_MN25 (VSS XI0_I1529_asn XI0_I1529_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1529_MN10 (VSS I0_cm61_0 XI0_I1529_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1529_MN6 (XI0_I1529_an3 I0_cm61_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1529_MN9 (XI0_I1529_asn XI0_I1529_acon XI0_I1529_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1529_MN12 (XI0_I1529_an5 I0_cm63_0 XI0_I1529_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1529_MN11 (XI0_I1529_an4 I0_cm62_0 XI0_I1529_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1529_MN11_1 (XI0_I1529_an5 I0_cm62_0 XI0_I1529_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1529_MN12_1 (XI0_I1529_asn I0_cm63_0 XI0_I1529_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1529_MN10_1 (XI0_I1529_an4 I0_cm61_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1529_MN5 (XI0_I1529_acon I0_cm63_0 XI0_I1529_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1529_MN2 (XI0_I1529_an1 I0_cm62_0 XI0_I1529_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1529_MN1 (VSS I0_cm61_0 XI0_I1529_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1529_MN3 (XI0_I1529_an2 I0_cm61_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1529_MN4 (VSS I0_cm62_0 XI0_I1529_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1529_MN27 (I0_cm168_2 XI0_I1529_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1529_MN7 (XI0_I1529_an3 I0_cm62_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1529_MN8 (VSS I0_cm63_0 XI0_I1529_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1536_MN34 (XI0_I1536_bn3 XI0_I1536_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1536_MN35 (VSS I0_cm76_1 XI0_I1536_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1536_MN36 (XI0_I1536_bn3 I0_cm173_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1536_MN37 (XI0_I1536_bsn XI0_I1536_bcon XI0_I1536_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1536_MN40 (XI0_I1536_bn5 I0_cm173_2 XI0_I1536_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1536_MN39 (XI0_I1536_bn4 I0_cm76_1 XI0_I1536_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1536_MN39_1 (XI0_I1536_bn5 I0_cm76_1 XI0_I1536_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1536_MN40_1 (XI0_I1536_bsn I0_cm173_2 XI0_I1536_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1536_MN53 (VSS XI0_I1536_bsn I0_cm175_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1536_MN29 (XI0_I1536_bn1 XI0_I1536_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1536_MN30 (XI0_I1536_bcon I0_cm76_1 XI0_I1536_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1536_MN33 (XI0_I1536_bn2 I0_cm173_2 XI0_I1536_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1536_MN31 (VSS XI0_I1536_s1 XI0_I1536_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1536_MN32 (XI0_I1536_bn2 I0_cm76_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1536_MN55 (VSS XI0_I1536_bcon I0_cm175_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1536_MN38 (XI0_I1536_bn4 XI0_I1536_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1536_MN38_1 (VSS XI0_I1536_s1 XI0_I1536_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1536_MN25 (VSS XI0_I1536_asn XI0_I1536_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1536_MN10 (VSS I0_cm73_1 XI0_I1536_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1536_MN6 (XI0_I1536_an3 I0_cm73_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1536_MN9 (XI0_I1536_asn XI0_I1536_acon XI0_I1536_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1536_MN12 (XI0_I1536_an5 I0_cm75_1 XI0_I1536_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1536_MN11 (XI0_I1536_an4 I0_cm74_1 XI0_I1536_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1536_MN11_1 (XI0_I1536_an5 I0_cm74_1 XI0_I1536_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1536_MN12_1 (XI0_I1536_asn I0_cm75_1 XI0_I1536_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1536_MN10_1 (XI0_I1536_an4 I0_cm73_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1536_MN5 (XI0_I1536_acon I0_cm75_1 XI0_I1536_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1536_MN2 (XI0_I1536_an1 I0_cm74_1 XI0_I1536_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1536_MN1 (VSS I0_cm73_1 XI0_I1536_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1536_MN3 (XI0_I1536_an2 I0_cm73_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1536_MN4 (VSS I0_cm74_1 XI0_I1536_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1536_MN27 (I0_cm175_2 XI0_I1536_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1536_MN7 (XI0_I1536_an3 I0_cm74_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1536_MN8 (VSS I0_cm75_1 XI0_I1536_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1447_MN34 (XI0_I1447_bn3 XI0_I1447_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1447_MN35 (VSS I0_pp8_20 XI0_I1447_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1447_MN36 (XI0_I1447_bn3 I0_cm82_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1447_MN37 (XI0_I1447_bsn XI0_I1447_bcon XI0_I1447_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1447_MN40 (XI0_I1447_bn5 I0_cm82_2 XI0_I1447_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1447_MN39 (XI0_I1447_bn4 I0_pp8_20 XI0_I1447_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1447_MN39_1 (XI0_I1447_bn5 I0_pp8_20 XI0_I1447_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1447_MN40_1 (XI0_I1447_bsn I0_cm82_2 XI0_I1447_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1447_MN53 (VSS XI0_I1447_bsn I0_cm86_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1447_MN29 (XI0_I1447_bn1 XI0_I1447_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1447_MN30 (XI0_I1447_bcon I0_pp8_20 XI0_I1447_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1447_MN33 (XI0_I1447_bn2 I0_cm82_2 XI0_I1447_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1447_MN31 (VSS XI0_I1447_s1 XI0_I1447_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1447_MN32 (XI0_I1447_bn2 I0_pp8_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1447_MN55 (VSS XI0_I1447_bcon I0_cm86_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1447_MN38 (XI0_I1447_bn4 XI0_I1447_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1447_MN38_1 (VSS XI0_I1447_s1 XI0_I1447_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1447_MN25 (VSS XI0_I1447_asn XI0_I1447_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1447_MN10 (VSS I0_pp5_26 XI0_I1447_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1447_MN6 (XI0_I1447_an3 I0_pp5_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1447_MN9 (XI0_I1447_asn XI0_I1447_acon XI0_I1447_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1447_MN12 (XI0_I1447_an5 I0_pp7_22 XI0_I1447_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1447_MN11 (XI0_I1447_an4 I0_pp6_24 XI0_I1447_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1447_MN11_1 (XI0_I1447_an5 I0_pp6_24 XI0_I1447_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1447_MN12_1 (XI0_I1447_asn I0_pp7_22 XI0_I1447_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1447_MN10_1 (XI0_I1447_an4 I0_pp5_26 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1447_MN5 (XI0_I1447_acon I0_pp7_22 XI0_I1447_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1447_MN2 (XI0_I1447_an1 I0_pp6_24 XI0_I1447_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1447_MN1 (VSS I0_pp5_26 XI0_I1447_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1447_MN3 (XI0_I1447_an2 I0_pp5_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1447_MN4 (VSS I0_pp6_24 XI0_I1447_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1447_MN27 (I0_cm86_2 XI0_I1447_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1447_MN7 (XI0_I1447_an3 I0_pp6_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1447_MN8 (VSS I0_pp7_22 XI0_I1447_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1368_MN34 (XI0_I1368_bn3 XI0_I1368_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1368_MN35 (VSS I0_pp3_3 XI0_I1368_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1368_MN36 (XI0_I1368_bn3 I0_cm6_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1368_MN37 (XI0_I1368_bsn XI0_I1368_bcon XI0_I1368_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1368_MN40 (XI0_I1368_bn5 I0_cm6_2 XI0_I1368_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1368_MN39 (XI0_I1368_bn4 I0_pp3_3 XI0_I1368_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1368_MN39_1 (XI0_I1368_bn5 I0_pp3_3 XI0_I1368_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1368_MN40_1 (XI0_I1368_bsn I0_cm6_2 XI0_I1368_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1368_MN53 (VSS XI0_I1368_bsn I0_cm7_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1368_MN29 (XI0_I1368_bn1 XI0_I1368_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1368_MN30 (XI0_I1368_bcon I0_pp3_3 XI0_I1368_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1368_MN33 (XI0_I1368_bn2 I0_cm6_2 XI0_I1368_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1368_MN31 (VSS XI0_I1368_s1 XI0_I1368_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1368_MN32 (XI0_I1368_bn2 I0_pp3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1368_MN55 (VSS XI0_I1368_bcon I0_cm7_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1368_MN38 (XI0_I1368_bn4 XI0_I1368_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1368_MN38_1 (VSS XI0_I1368_s1 XI0_I1368_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1368_MN25 (VSS XI0_I1368_asn XI0_I1368_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1368_MN10 (VSS I0_pp0_9 XI0_I1368_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1368_MN6 (XI0_I1368_an3 I0_pp0_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1368_MN9 (XI0_I1368_asn XI0_I1368_acon XI0_I1368_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1368_MN12 (XI0_I1368_an5 I0_pp2_5 XI0_I1368_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1368_MN11 (XI0_I1368_an4 I0_pp1_7 XI0_I1368_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1368_MN11_1 (XI0_I1368_an5 I0_pp1_7 XI0_I1368_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1368_MN12_1 (XI0_I1368_asn I0_pp2_5 XI0_I1368_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1368_MN10_1 (XI0_I1368_an4 I0_pp0_9 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1368_MN5 (XI0_I1368_acon I0_pp2_5 XI0_I1368_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1368_MN2 (XI0_I1368_an1 I0_pp1_7 XI0_I1368_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1368_MN1 (VSS I0_pp0_9 XI0_I1368_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1368_MN3 (XI0_I1368_an2 I0_pp0_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1368_MN4 (VSS I0_pp1_7 XI0_I1368_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1368_MN27 (I0_cm7_2 XI0_I1368_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1368_MN7 (XI0_I1368_an3 I0_pp1_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1368_MN8 (VSS I0_pp2_5 XI0_I1368_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1371_MN34 (XI0_I1371_bn3 XI0_I1371_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1371_MN35 (VSS I0_pp3_5 XI0_I1371_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1371_MN36 (XI0_I1371_bn3 I0_cm8_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1371_MN37 (XI0_I1371_bsn XI0_I1371_bcon XI0_I1371_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1371_MN40 (XI0_I1371_bn5 I0_cm8_2 XI0_I1371_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1371_MN39 (XI0_I1371_bn4 I0_pp3_5 XI0_I1371_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1371_MN39_1 (XI0_I1371_bn5 I0_pp3_5 XI0_I1371_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1371_MN40_1 (XI0_I1371_bsn I0_cm8_2 XI0_I1371_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1371_MN53 (VSS XI0_I1371_bsn I0_cm10_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1371_MN29 (XI0_I1371_bn1 XI0_I1371_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1371_MN30 (XI0_I1371_bcon I0_pp3_5 XI0_I1371_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1371_MN33 (XI0_I1371_bn2 I0_cm8_2 XI0_I1371_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1371_MN31 (VSS XI0_I1371_s1 XI0_I1371_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1371_MN32 (XI0_I1371_bn2 I0_pp3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1371_MN55 (VSS XI0_I1371_bcon I0_cm10_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1371_MN38 (XI0_I1371_bn4 XI0_I1371_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1371_MN38_1 (VSS XI0_I1371_s1 XI0_I1371_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1371_MN25 (VSS XI0_I1371_asn XI0_I1371_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1371_MN10 (VSS I0_pp0_11 XI0_I1371_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1371_MN6 (XI0_I1371_an3 I0_pp0_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1371_MN9 (XI0_I1371_asn XI0_I1371_acon XI0_I1371_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1371_MN12 (XI0_I1371_an5 I0_pp2_7 XI0_I1371_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1371_MN11 (XI0_I1371_an4 I0_pp1_9 XI0_I1371_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1371_MN11_1 (XI0_I1371_an5 I0_pp1_9 XI0_I1371_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1371_MN12_1 (XI0_I1371_asn I0_pp2_7 XI0_I1371_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1371_MN10_1 (XI0_I1371_an4 I0_pp0_11 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1371_MN5 (XI0_I1371_acon I0_pp2_7 XI0_I1371_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1371_MN2 (XI0_I1371_an1 I0_pp1_9 XI0_I1371_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1371_MN1 (VSS I0_pp0_11 XI0_I1371_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1371_MN3 (XI0_I1371_an2 I0_pp0_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1371_MN4 (VSS I0_pp1_9 XI0_I1371_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1371_MN27 (I0_cm10_2 XI0_I1371_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1371_MN7 (XI0_I1371_an3 I0_pp1_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1371_MN8 (VSS I0_pp2_7 XI0_I1371_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1393_MN34 (XI0_I1393_bn3 XI0_I1393_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1393_MN35 (VSS I0_pp7_7 XI0_I1393_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1393_MN36 (XI0_I1393_bn3 I0_cm29_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1393_MN37 (XI0_I1393_bsn XI0_I1393_bcon XI0_I1393_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1393_MN40 (XI0_I1393_bn5 I0_cm29_2 XI0_I1393_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1393_MN39 (XI0_I1393_bn4 I0_pp7_7 XI0_I1393_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1393_MN39_1 (XI0_I1393_bn5 I0_pp7_7 XI0_I1393_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1393_MN40_1 (XI0_I1393_bsn I0_cm29_2 XI0_I1393_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1393_MN53 (VSS XI0_I1393_bsn I0_cm32_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1393_MN29 (XI0_I1393_bn1 XI0_I1393_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1393_MN30 (XI0_I1393_bcon I0_pp7_7 XI0_I1393_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1393_MN33 (XI0_I1393_bn2 I0_cm29_2 XI0_I1393_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1393_MN31 (VSS XI0_I1393_s1 XI0_I1393_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1393_MN32 (XI0_I1393_bn2 I0_pp7_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1393_MN55 (VSS XI0_I1393_bcon I0_cm32_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1393_MN38 (XI0_I1393_bn4 XI0_I1393_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1393_MN38_1 (VSS XI0_I1393_s1 XI0_I1393_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1393_MN25 (VSS XI0_I1393_asn XI0_I1393_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1393_MN10 (VSS I0_pp4_13 XI0_I1393_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1393_MN6 (XI0_I1393_an3 I0_pp4_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1393_MN9 (XI0_I1393_asn XI0_I1393_acon XI0_I1393_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1393_MN12 (XI0_I1393_an5 I0_pp6_9 XI0_I1393_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1393_MN11 (XI0_I1393_an4 I0_pp5_11 XI0_I1393_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1393_MN11_1 (XI0_I1393_an5 I0_pp5_11 XI0_I1393_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1393_MN12_1 (XI0_I1393_asn I0_pp6_9 XI0_I1393_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1393_MN10_1 (XI0_I1393_an4 I0_pp4_13 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1393_MN5 (XI0_I1393_acon I0_pp6_9 XI0_I1393_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1393_MN2 (XI0_I1393_an1 I0_pp5_11 XI0_I1393_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1393_MN1 (VSS I0_pp4_13 XI0_I1393_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1393_MN3 (XI0_I1393_an2 I0_pp4_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1393_MN4 (VSS I0_pp5_11 XI0_I1393_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1393_MN27 (I0_cm32_2 XI0_I1393_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1393_MN7 (XI0_I1393_an3 I0_pp5_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1393_MN8 (VSS I0_pp6_9 XI0_I1393_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1518_MN34 (XI0_I1518_bn3 XI0_I1518_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1518_MN35 (VSS I0_cm43_0 XI0_I1518_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1518_MN36 (XI0_I1518_bn3 I0_cm155_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1518_MN37 (XI0_I1518_bsn XI0_I1518_bcon XI0_I1518_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1518_MN40 (XI0_I1518_bn5 I0_cm155_2 XI0_I1518_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1518_MN39 (XI0_I1518_bn4 I0_cm43_0 XI0_I1518_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1518_MN39_1 (XI0_I1518_bn5 I0_cm43_0 XI0_I1518_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1518_MN40_1 (XI0_I1518_bsn I0_cm155_2 XI0_I1518_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1518_MN53 (VSS XI0_I1518_bsn I0_cm157_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1518_MN29 (XI0_I1518_bn1 XI0_I1518_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1518_MN30 (XI0_I1518_bcon I0_cm43_0 XI0_I1518_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1518_MN33 (XI0_I1518_bn2 I0_cm155_2 XI0_I1518_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1518_MN31 (VSS XI0_I1518_s1 XI0_I1518_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1518_MN32 (XI0_I1518_bn2 I0_cm43_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1518_MN55 (VSS XI0_I1518_bcon I0_cm157_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1518_MN38 (XI0_I1518_bn4 XI0_I1518_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1518_MN38_1 (VSS XI0_I1518_s1 XI0_I1518_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1518_MN25 (VSS XI0_I1518_asn XI0_I1518_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1518_MN10 (VSS I0_cm40_1 XI0_I1518_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1518_MN6 (XI0_I1518_an3 I0_cm40_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1518_MN9 (XI0_I1518_asn XI0_I1518_acon XI0_I1518_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1518_MN12 (XI0_I1518_an5 I0_cm42_1 XI0_I1518_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1518_MN11 (XI0_I1518_an4 I0_cm41_1 XI0_I1518_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1518_MN11_1 (XI0_I1518_an5 I0_cm41_1 XI0_I1518_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1518_MN12_1 (XI0_I1518_asn I0_cm42_1 XI0_I1518_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1518_MN10_1 (XI0_I1518_an4 I0_cm40_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1518_MN5 (XI0_I1518_acon I0_cm42_1 XI0_I1518_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1518_MN2 (XI0_I1518_an1 I0_cm41_1 XI0_I1518_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1518_MN1 (VSS I0_cm40_1 XI0_I1518_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1518_MN3 (XI0_I1518_an2 I0_cm40_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1518_MN4 (VSS I0_cm41_1 XI0_I1518_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1518_MN27 (I0_cm157_2 XI0_I1518_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1518_MN7 (XI0_I1518_an3 I0_cm41_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1518_MN8 (VSS I0_cm42_1 XI0_I1518_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1399_MN34 (XI0_I1399_bn3 XI0_I1399_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1399_MN35 (VSS I0_pp7_9 XI0_I1399_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1399_MN36 (XI0_I1399_bn3 I0_cm35_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1399_MN37 (XI0_I1399_bsn XI0_I1399_bcon XI0_I1399_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1399_MN40 (XI0_I1399_bn5 I0_cm35_2 XI0_I1399_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1399_MN39 (XI0_I1399_bn4 I0_pp7_9 XI0_I1399_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1399_MN39_1 (XI0_I1399_bn5 I0_pp7_9 XI0_I1399_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1399_MN40_1 (XI0_I1399_bsn I0_cm35_2 XI0_I1399_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1399_MN53 (VSS XI0_I1399_bsn I0_cm38_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1399_MN29 (XI0_I1399_bn1 XI0_I1399_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1399_MN30 (XI0_I1399_bcon I0_pp7_9 XI0_I1399_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1399_MN33 (XI0_I1399_bn2 I0_cm35_2 XI0_I1399_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1399_MN31 (VSS XI0_I1399_s1 XI0_I1399_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1399_MN32 (XI0_I1399_bn2 I0_pp7_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1399_MN55 (VSS XI0_I1399_bcon I0_cm38_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1399_MN38 (XI0_I1399_bn4 XI0_I1399_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1399_MN38_1 (VSS XI0_I1399_s1 XI0_I1399_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1399_MN25 (VSS XI0_I1399_asn XI0_I1399_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1399_MN10 (VSS I0_pp4_15 XI0_I1399_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1399_MN6 (XI0_I1399_an3 I0_pp4_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1399_MN9 (XI0_I1399_asn XI0_I1399_acon XI0_I1399_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1399_MN12 (XI0_I1399_an5 I0_pp6_11 XI0_I1399_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1399_MN11 (XI0_I1399_an4 I0_pp5_13 XI0_I1399_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1399_MN11_1 (XI0_I1399_an5 I0_pp5_13 XI0_I1399_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1399_MN12_1 (XI0_I1399_asn I0_pp6_11 XI0_I1399_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1399_MN10_1 (XI0_I1399_an4 I0_pp4_15 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1399_MN5 (XI0_I1399_acon I0_pp6_11 XI0_I1399_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1399_MN2 (XI0_I1399_an1 I0_pp5_13 XI0_I1399_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1399_MN1 (VSS I0_pp4_15 XI0_I1399_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1399_MN3 (XI0_I1399_an2 I0_pp4_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1399_MN4 (VSS I0_pp5_13 XI0_I1399_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1399_MN27 (I0_cm38_2 XI0_I1399_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1399_MN7 (XI0_I1399_an3 I0_pp5_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1399_MN8 (VSS I0_pp6_11 XI0_I1399_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1522_MN34 (XI0_I1522_bn3 XI0_I1522_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1522_MN35 (VSS I0_fa49_1 XI0_I1522_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1522_MN36 (XI0_I1522_bn3 I0_cm159_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1522_MN37 (XI0_I1522_bsn XI0_I1522_bcon XI0_I1522_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1522_MN40 (XI0_I1522_bn5 I0_cm159_2 XI0_I1522_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1522_MN39 (XI0_I1522_bn4 I0_fa49_1 XI0_I1522_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1522_MN39_1 (XI0_I1522_bn5 I0_fa49_1 XI0_I1522_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1522_MN40_1 (XI0_I1522_bsn I0_cm159_2 XI0_I1522_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1522_MN53 (VSS XI0_I1522_bsn I0_cm161_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1522_MN29 (XI0_I1522_bn1 XI0_I1522_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1522_MN30 (XI0_I1522_bcon I0_fa49_1 XI0_I1522_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1522_MN33 (XI0_I1522_bn2 I0_cm159_2 XI0_I1522_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1522_MN31 (VSS XI0_I1522_s1 XI0_I1522_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1522_MN32 (XI0_I1522_bn2 I0_fa49_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1522_MN55 (VSS XI0_I1522_bcon I0_cm161_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1522_MN38 (XI0_I1522_bn4 XI0_I1522_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1522_MN38_1 (VSS XI0_I1522_s1 XI0_I1522_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1522_MN25 (VSS XI0_I1522_asn XI0_I1522_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1522_MN10 (VSS I0_cm46_1 XI0_I1522_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1522_MN6 (XI0_I1522_an3 I0_cm46_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1522_MN9 (XI0_I1522_asn XI0_I1522_acon XI0_I1522_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1522_MN12 (XI0_I1522_an5 I0_cm48_1 XI0_I1522_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1522_MN11 (XI0_I1522_an4 I0_cm47_1 XI0_I1522_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1522_MN11_1 (XI0_I1522_an5 I0_cm47_1 XI0_I1522_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1522_MN12_1 (XI0_I1522_asn I0_cm48_1 XI0_I1522_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1522_MN10_1 (XI0_I1522_an4 I0_cm46_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1522_MN5 (XI0_I1522_acon I0_cm48_1 XI0_I1522_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1522_MN2 (XI0_I1522_an1 I0_cm47_1 XI0_I1522_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1522_MN1 (VSS I0_cm46_1 XI0_I1522_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1522_MN3 (XI0_I1522_an2 I0_cm46_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1522_MN4 (VSS I0_cm47_1 XI0_I1522_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1522_MN27 (I0_cm161_2 XI0_I1522_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1522_MN7 (XI0_I1522_an3 I0_cm47_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1522_MN8 (VSS I0_cm48_1 XI0_I1522_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1585_MN34 (XI0_I1585_bn3 XI0_I1585_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1585_MN35 (VSS I0_cm168_0 XI0_I1585_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1585_MN36 (XI0_I1585_bn3 I0_cm223_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1585_MN37 (XI0_I1585_bsn XI0_I1585_bcon XI0_I1585_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1585_MN40 (XI0_I1585_bn5 I0_cm223_2 XI0_I1585_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1585_MN39 (XI0_I1585_bn4 I0_cm168_0 XI0_I1585_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1585_MN39_1 (XI0_I1585_bn5 I0_cm168_0 XI0_I1585_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1585_MN40_1 (XI0_I1585_bsn I0_cm223_2 XI0_I1585_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1585_MN53 (VSS XI0_I1585_bsn I0_cm224_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1585_MN29 (XI0_I1585_bn1 XI0_I1585_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1585_MN30 (XI0_I1585_bcon I0_cm168_0 XI0_I1585_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1585_MN33 (XI0_I1585_bn2 I0_cm223_2 XI0_I1585_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1585_MN31 (VSS XI0_I1585_s1 XI0_I1585_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1585_MN32 (XI0_I1585_bn2 I0_cm168_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1585_MN55 (VSS XI0_I1585_bcon I0_cm224_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1585_MN38 (XI0_I1585_bn4 XI0_I1585_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67999u
    I_MXI0_I1585_MN38_1 (VSS XI0_I1585_s1 XI0_I1585_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67999u ps=1.21999u
    I_MXI0_I1585_MN25 (VSS XI0_I1585_asn XI0_I1585_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1585_MN10 (VSS I0_cm165_1 XI0_I1585_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1585_MN6 (XI0_I1585_an3 I0_cm165_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1585_MN9 (XI0_I1585_asn XI0_I1585_acon XI0_I1585_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1585_MN12 (XI0_I1585_an5 I0_cm167_0 XI0_I1585_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1585_MN11 (XI0_I1585_an4 I0_cm166_1 XI0_I1585_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75999u ps=0.67999u
    I_MXI0_I1585_MN11_1 (XI0_I1585_an5 I0_cm166_1 XI0_I1585_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67999u ps=1.75999u
    I_MXI0_I1585_MN12_1 (XI0_I1585_asn I0_cm167_0 XI0_I1585_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1585_MN10_1 (XI0_I1585_an4 I0_cm165_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1585_MN5 (XI0_I1585_acon I0_cm167_0 XI0_I1585_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1585_MN2 (XI0_I1585_an1 I0_cm166_1 XI0_I1585_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1585_MN1 (VSS I0_cm165_1 XI0_I1585_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1585_MN3 (XI0_I1585_an2 I0_cm165_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1585_MN4 (VSS I0_cm166_1 XI0_I1585_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1585_MN27 (I0_cm224_2 XI0_I1585_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1585_MN7 (XI0_I1585_an3 I0_cm166_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1585_MN8 (VSS I0_cm167_0 XI0_I1585_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1586_MN34 (XI0_I1586_bn3 XI0_I1586_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1586_MN35 (VSS I0_cm170_0 XI0_I1586_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1586_MN36 (XI0_I1586_bn3 I0_cm224_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1586_MN37 (XI0_I1586_bsn XI0_I1586_bcon XI0_I1586_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1586_MN40 (XI0_I1586_bn5 I0_cm224_2 XI0_I1586_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1586_MN39 (XI0_I1586_bn4 I0_cm170_0 XI0_I1586_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1586_MN39_1 (XI0_I1586_bn5 I0_cm170_0 XI0_I1586_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1586_MN40_1 (XI0_I1586_bsn I0_cm224_2 XI0_I1586_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1586_MN53 (VSS XI0_I1586_bsn I0_cm225_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1586_MN29 (XI0_I1586_bn1 XI0_I1586_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1586_MN30 (XI0_I1586_bcon I0_cm170_0 XI0_I1586_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1586_MN33 (XI0_I1586_bn2 I0_cm224_2 XI0_I1586_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1586_MN31 (VSS XI0_I1586_s1 XI0_I1586_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1586_MN32 (XI0_I1586_bn2 I0_cm170_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1586_MN55 (VSS XI0_I1586_bcon I0_cm225_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1586_MN38 (XI0_I1586_bn4 XI0_I1586_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21999u ps=0.67998u
    I_MXI0_I1586_MN38_1 (VSS XI0_I1586_s1 XI0_I1586_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21999u
    I_MXI0_I1586_MN25 (VSS XI0_I1586_asn XI0_I1586_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1586_MN10 (VSS I0_cm167_1 XI0_I1586_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1586_MN6 (XI0_I1586_an3 I0_cm167_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1586_MN9 (XI0_I1586_asn XI0_I1586_acon XI0_I1586_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1586_MN12 (XI0_I1586_an5 I0_cm169_0 XI0_I1586_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1586_MN11 (XI0_I1586_an4 I0_cm168_1 XI0_I1586_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1586_MN11_1 (XI0_I1586_an5 I0_cm168_1 XI0_I1586_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1586_MN12_1 (XI0_I1586_asn I0_cm169_0 XI0_I1586_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1586_MN10_1 (XI0_I1586_an4 I0_cm167_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1586_MN5 (XI0_I1586_acon I0_cm169_0 XI0_I1586_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1586_MN2 (XI0_I1586_an1 I0_cm168_1 XI0_I1586_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1586_MN1 (VSS I0_cm167_1 XI0_I1586_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1586_MN3 (XI0_I1586_an2 I0_cm167_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1586_MN4 (VSS I0_cm168_1 XI0_I1586_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1586_MN27 (I0_cm225_2 XI0_I1586_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1586_MN7 (XI0_I1586_an3 I0_cm168_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1586_MN8 (VSS I0_cm169_0 XI0_I1586_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1587_MN34 (XI0_I1587_bn3 XI0_I1587_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1587_MN35 (VSS I0_cm172_0 XI0_I1587_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1587_MN36 (XI0_I1587_bn3 I0_cm225_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1587_MN37 (XI0_I1587_bsn XI0_I1587_bcon XI0_I1587_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1587_MN40 (XI0_I1587_bn5 I0_cm225_2 XI0_I1587_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1587_MN39 (XI0_I1587_bn4 I0_cm172_0 XI0_I1587_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1587_MN39_1 (XI0_I1587_bn5 I0_cm172_0 XI0_I1587_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1587_MN40_1 (XI0_I1587_bsn I0_cm225_2 XI0_I1587_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1587_MN53 (VSS XI0_I1587_bsn I0_cm226_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1587_MN29 (XI0_I1587_bn1 XI0_I1587_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1587_MN30 (XI0_I1587_bcon I0_cm172_0 XI0_I1587_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1587_MN33 (XI0_I1587_bn2 I0_cm225_2 XI0_I1587_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1587_MN31 (VSS XI0_I1587_s1 XI0_I1587_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1587_MN32 (XI0_I1587_bn2 I0_cm172_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1587_MN55 (VSS XI0_I1587_bcon I0_cm226_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1587_MN38 (XI0_I1587_bn4 XI0_I1587_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1587_MN38_1 (VSS XI0_I1587_s1 XI0_I1587_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1587_MN25 (VSS XI0_I1587_asn XI0_I1587_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1587_MN10 (VSS I0_cm169_1 XI0_I1587_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1587_MN6 (XI0_I1587_an3 I0_cm169_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1587_MN9 (XI0_I1587_asn XI0_I1587_acon XI0_I1587_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1587_MN12 (XI0_I1587_an5 I0_cm171_0 XI0_I1587_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1587_MN11 (XI0_I1587_an4 I0_cm170_1 XI0_I1587_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1587_MN11_1 (XI0_I1587_an5 I0_cm170_1 XI0_I1587_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1587_MN12_1 (XI0_I1587_asn I0_cm171_0 XI0_I1587_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1587_MN10_1 (XI0_I1587_an4 I0_cm169_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1587_MN5 (XI0_I1587_acon I0_cm171_0 XI0_I1587_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1587_MN2 (XI0_I1587_an1 I0_cm170_1 XI0_I1587_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1587_MN1 (VSS I0_cm169_1 XI0_I1587_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1587_MN3 (XI0_I1587_an2 I0_cm169_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1587_MN4 (VSS I0_cm170_1 XI0_I1587_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1587_MN27 (I0_cm226_2 XI0_I1587_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1587_MN7 (XI0_I1587_an3 I0_cm170_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1587_MN8 (VSS I0_cm171_0 XI0_I1587_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1588_MN34 (XI0_I1588_bn3 XI0_I1588_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1588_MN35 (VSS I0_cm174_0 XI0_I1588_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1588_MN36 (XI0_I1588_bn3 I0_cm226_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1588_MN37 (XI0_I1588_bsn XI0_I1588_bcon XI0_I1588_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1588_MN40 (XI0_I1588_bn5 I0_cm226_2 XI0_I1588_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1588_MN39 (XI0_I1588_bn4 I0_cm174_0 XI0_I1588_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1588_MN39_1 (XI0_I1588_bn5 I0_cm174_0 XI0_I1588_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1588_MN40_1 (XI0_I1588_bsn I0_cm226_2 XI0_I1588_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1588_MN53 (VSS XI0_I1588_bsn I0_cm227_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1588_MN29 (XI0_I1588_bn1 XI0_I1588_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1588_MN30 (XI0_I1588_bcon I0_cm174_0 XI0_I1588_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1588_MN33 (XI0_I1588_bn2 I0_cm226_2 XI0_I1588_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1588_MN31 (VSS XI0_I1588_s1 XI0_I1588_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1588_MN32 (XI0_I1588_bn2 I0_cm174_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1588_MN55 (VSS XI0_I1588_bcon I0_cm227_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1588_MN38 (XI0_I1588_bn4 XI0_I1588_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1588_MN38_1 (VSS XI0_I1588_s1 XI0_I1588_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1588_MN25 (VSS XI0_I1588_asn XI0_I1588_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1588_MN10 (VSS I0_cm171_1 XI0_I1588_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1588_MN6 (XI0_I1588_an3 I0_cm171_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1588_MN9 (XI0_I1588_asn XI0_I1588_acon XI0_I1588_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1588_MN12 (XI0_I1588_an5 I0_cm173_0 XI0_I1588_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1588_MN11 (XI0_I1588_an4 I0_cm172_1 XI0_I1588_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1588_MN11_1 (XI0_I1588_an5 I0_cm172_1 XI0_I1588_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1588_MN12_1 (XI0_I1588_asn I0_cm173_0 XI0_I1588_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1588_MN10_1 (XI0_I1588_an4 I0_cm171_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1588_MN5 (XI0_I1588_acon I0_cm173_0 XI0_I1588_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1588_MN2 (XI0_I1588_an1 I0_cm172_1 XI0_I1588_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1588_MN1 (VSS I0_cm171_1 XI0_I1588_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1588_MN3 (XI0_I1588_an2 I0_cm171_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1588_MN4 (VSS I0_cm172_1 XI0_I1588_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1588_MN27 (I0_cm227_2 XI0_I1588_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1588_MN7 (XI0_I1588_an3 I0_cm172_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1588_MN8 (VSS I0_cm173_0 XI0_I1588_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1590_MN34 (XI0_I1590_bn3 XI0_I1590_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1590_MN35 (VSS I0_cm178_0 XI0_I1590_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1590_MN36 (XI0_I1590_bn3 I0_cm228_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1590_MN37 (XI0_I1590_bsn XI0_I1590_bcon XI0_I1590_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1590_MN40 (XI0_I1590_bn5 I0_cm228_2 XI0_I1590_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1590_MN39 (XI0_I1590_bn4 I0_cm178_0 XI0_I1590_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1590_MN39_1 (XI0_I1590_bn5 I0_cm178_0 XI0_I1590_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1590_MN40_1 (XI0_I1590_bsn I0_cm228_2 XI0_I1590_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1590_MN53 (VSS XI0_I1590_bsn I0_cm229_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1590_MN29 (XI0_I1590_bn1 XI0_I1590_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1590_MN30 (XI0_I1590_bcon I0_cm178_0 XI0_I1590_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1590_MN33 (XI0_I1590_bn2 I0_cm228_2 XI0_I1590_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1590_MN31 (VSS XI0_I1590_s1 XI0_I1590_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1590_MN32 (XI0_I1590_bn2 I0_cm178_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1590_MN55 (VSS XI0_I1590_bcon I0_cm229_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1590_MN38 (XI0_I1590_bn4 XI0_I1590_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1590_MN38_1 (VSS XI0_I1590_s1 XI0_I1590_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1590_MN25 (VSS XI0_I1590_asn XI0_I1590_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1590_MN10 (VSS I0_cm175_1 XI0_I1590_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1590_MN6 (XI0_I1590_an3 I0_cm175_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1590_MN9 (XI0_I1590_asn XI0_I1590_acon XI0_I1590_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1590_MN12 (XI0_I1590_an5 I0_cm177_0 XI0_I1590_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1590_MN11 (XI0_I1590_an4 I0_cm176_1 XI0_I1590_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1590_MN11_1 (XI0_I1590_an5 I0_cm176_1 XI0_I1590_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1590_MN12_1 (XI0_I1590_asn I0_cm177_0 XI0_I1590_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1590_MN10_1 (XI0_I1590_an4 I0_cm175_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1590_MN5 (XI0_I1590_acon I0_cm177_0 XI0_I1590_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1590_MN2 (XI0_I1590_an1 I0_cm176_1 XI0_I1590_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1590_MN1 (VSS I0_cm175_1 XI0_I1590_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1590_MN3 (XI0_I1590_an2 I0_cm175_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1590_MN4 (VSS I0_cm176_1 XI0_I1590_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1590_MN27 (I0_cm229_2 XI0_I1590_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1590_MN7 (XI0_I1590_an3 I0_cm176_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1590_MN8 (VSS I0_cm177_0 XI0_I1590_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1539_MN34 (XI0_I1539_bn3 XI0_I1539_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1539_MN35 (VSS I0_cm84_0 XI0_I1539_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1539_MN36 (XI0_I1539_bn3 I0_cm176_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1539_MN37 (XI0_I1539_bsn XI0_I1539_bcon XI0_I1539_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1539_MN40 (XI0_I1539_bn5 I0_cm176_2 XI0_I1539_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1539_MN39 (XI0_I1539_bn4 I0_cm84_0 XI0_I1539_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1539_MN39_1 (XI0_I1539_bn5 I0_cm84_0 XI0_I1539_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1539_MN40_1 (XI0_I1539_bsn I0_cm176_2 XI0_I1539_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1539_MN53 (VSS XI0_I1539_bsn I0_cm178_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1539_MN29 (XI0_I1539_bn1 XI0_I1539_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1539_MN30 (XI0_I1539_bcon I0_cm84_0 XI0_I1539_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1539_MN33 (XI0_I1539_bn2 I0_cm176_2 XI0_I1539_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1539_MN31 (VSS XI0_I1539_s1 XI0_I1539_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1539_MN32 (XI0_I1539_bn2 I0_cm84_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1539_MN55 (VSS XI0_I1539_bcon I0_cm178_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1539_MN38 (XI0_I1539_bn4 XI0_I1539_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1539_MN38_1 (VSS XI0_I1539_s1 XI0_I1539_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1539_MN25 (VSS XI0_I1539_asn XI0_I1539_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1539_MN10 (VSS I0_cm81_0 XI0_I1539_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1539_MN6 (XI0_I1539_an3 I0_cm81_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1539_MN9 (XI0_I1539_asn XI0_I1539_acon XI0_I1539_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1539_MN12 (XI0_I1539_an5 I0_cm83_0 XI0_I1539_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1539_MN11 (XI0_I1539_an4 I0_cm82_0 XI0_I1539_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1539_MN11_1 (XI0_I1539_an5 I0_cm82_0 XI0_I1539_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1539_MN12_1 (XI0_I1539_asn I0_cm83_0 XI0_I1539_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1539_MN10_1 (XI0_I1539_an4 I0_cm81_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1539_MN5 (XI0_I1539_acon I0_cm83_0 XI0_I1539_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1539_MN2 (XI0_I1539_an1 I0_cm82_0 XI0_I1539_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1539_MN1 (VSS I0_cm81_0 XI0_I1539_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1539_MN3 (XI0_I1539_an2 I0_cm81_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1539_MN4 (VSS I0_cm82_0 XI0_I1539_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1539_MN27 (I0_cm178_2 XI0_I1539_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1539_MN7 (XI0_I1539_an3 I0_cm82_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1539_MN8 (VSS I0_cm83_0 XI0_I1539_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1537_MN34 (XI0_I1537_bn3 XI0_I1537_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1537_MN35 (VSS I0_cm80_0 XI0_I1537_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1537_MN36 (XI0_I1537_bn3 I0_cm174_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1537_MN37 (XI0_I1537_bsn XI0_I1537_bcon XI0_I1537_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1537_MN40 (XI0_I1537_bn5 I0_cm174_2 XI0_I1537_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1537_MN39 (XI0_I1537_bn4 I0_cm80_0 XI0_I1537_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1537_MN39_1 (XI0_I1537_bn5 I0_cm80_0 XI0_I1537_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1537_MN40_1 (XI0_I1537_bsn I0_cm174_2 XI0_I1537_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1537_MN53 (VSS XI0_I1537_bsn I0_cm176_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1537_MN29 (XI0_I1537_bn1 XI0_I1537_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1537_MN30 (XI0_I1537_bcon I0_cm80_0 XI0_I1537_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1537_MN33 (XI0_I1537_bn2 I0_cm174_2 XI0_I1537_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1537_MN31 (VSS XI0_I1537_s1 XI0_I1537_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1537_MN32 (XI0_I1537_bn2 I0_cm80_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1537_MN55 (VSS XI0_I1537_bcon I0_cm176_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1537_MN38 (XI0_I1537_bn4 XI0_I1537_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1537_MN38_1 (VSS XI0_I1537_s1 XI0_I1537_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1537_MN25 (VSS XI0_I1537_asn XI0_I1537_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1537_MN10 (VSS I0_cm77_0 XI0_I1537_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1537_MN6 (XI0_I1537_an3 I0_cm77_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1537_MN9 (XI0_I1537_asn XI0_I1537_acon XI0_I1537_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1537_MN12 (XI0_I1537_an5 I0_cm79_0 XI0_I1537_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1537_MN11 (XI0_I1537_an4 I0_cm78_0 XI0_I1537_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1537_MN11_1 (XI0_I1537_an5 I0_cm78_0 XI0_I1537_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1537_MN12_1 (XI0_I1537_asn I0_cm79_0 XI0_I1537_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1537_MN10_1 (XI0_I1537_an4 I0_cm77_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1537_MN5 (XI0_I1537_acon I0_cm79_0 XI0_I1537_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1537_MN2 (XI0_I1537_an1 I0_cm78_0 XI0_I1537_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1537_MN1 (VSS I0_cm77_0 XI0_I1537_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1537_MN3 (XI0_I1537_an2 I0_cm77_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1537_MN4 (VSS I0_cm78_0 XI0_I1537_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1537_MN27 (I0_cm176_2 XI0_I1537_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1537_MN7 (XI0_I1537_an3 I0_cm78_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1537_MN8 (VSS I0_cm79_0 XI0_I1537_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1541_MN34 (XI0_I1541_bn3 XI0_I1541_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1541_MN35 (VSS I0_fa88_0 XI0_I1541_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1541_MN36 (XI0_I1541_bn3 I0_cm178_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1541_MN37 (XI0_I1541_bsn XI0_I1541_bcon XI0_I1541_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1541_MN40 (XI0_I1541_bn5 I0_cm178_2 XI0_I1541_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1541_MN39 (XI0_I1541_bn4 I0_fa88_0 XI0_I1541_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1541_MN39_1 (XI0_I1541_bn5 I0_fa88_0 XI0_I1541_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1541_MN40_1 (XI0_I1541_bsn I0_cm178_2 XI0_I1541_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1541_MN53 (VSS XI0_I1541_bsn I0_cm180_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1541_MN29 (XI0_I1541_bn1 XI0_I1541_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1541_MN30 (XI0_I1541_bcon I0_fa88_0 XI0_I1541_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1541_MN33 (XI0_I1541_bn2 I0_cm178_2 XI0_I1541_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1541_MN31 (VSS XI0_I1541_s1 XI0_I1541_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1541_MN32 (XI0_I1541_bn2 I0_fa88_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1541_MN55 (VSS XI0_I1541_bcon I0_cm180_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1541_MN38 (XI0_I1541_bn4 XI0_I1541_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1541_MN38_1 (VSS XI0_I1541_s1 XI0_I1541_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1541_MN25 (VSS XI0_I1541_asn XI0_I1541_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1541_MN10 (VSS I0_cm85_0 XI0_I1541_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1541_MN6 (XI0_I1541_an3 I0_cm85_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1541_MN9 (XI0_I1541_asn XI0_I1541_acon XI0_I1541_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1541_MN12 (XI0_I1541_an5 I0_cm87_0 XI0_I1541_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1541_MN11 (XI0_I1541_an4 I0_cm86_0 XI0_I1541_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1541_MN11_1 (XI0_I1541_an5 I0_cm86_0 XI0_I1541_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1541_MN12_1 (XI0_I1541_asn I0_cm87_0 XI0_I1541_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1541_MN10_1 (XI0_I1541_an4 I0_cm85_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1541_MN5 (XI0_I1541_acon I0_cm87_0 XI0_I1541_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1541_MN2 (XI0_I1541_an1 I0_cm86_0 XI0_I1541_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1541_MN1 (VSS I0_cm85_0 XI0_I1541_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1541_MN3 (XI0_I1541_an2 I0_cm85_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1541_MN4 (VSS I0_cm86_0 XI0_I1541_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1541_MN27 (I0_cm180_2 XI0_I1541_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1541_MN7 (XI0_I1541_an3 I0_cm86_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1541_MN8 (VSS I0_cm87_0 XI0_I1541_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1367_MN34 (XI0_I1367_bn3 XI0_I1367_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1367_MN35 (VSS I0_pp3_2 XI0_I1367_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1367_MN36 (XI0_I1367_bn3 I0_cm5_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1367_MN37 (XI0_I1367_bsn XI0_I1367_bcon XI0_I1367_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1367_MN40 (XI0_I1367_bn5 I0_cm5_2 XI0_I1367_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1367_MN39 (XI0_I1367_bn4 I0_pp3_2 XI0_I1367_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1367_MN39_1 (XI0_I1367_bn5 I0_pp3_2 XI0_I1367_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1367_MN40_1 (XI0_I1367_bsn I0_cm5_2 XI0_I1367_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1367_MN53 (VSS XI0_I1367_bsn I0_cm6_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1367_MN29 (XI0_I1367_bn1 XI0_I1367_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1367_MN30 (XI0_I1367_bcon I0_pp3_2 XI0_I1367_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1367_MN33 (XI0_I1367_bn2 I0_cm5_2 XI0_I1367_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1367_MN31 (VSS XI0_I1367_s1 XI0_I1367_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1367_MN32 (XI0_I1367_bn2 I0_pp3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1367_MN55 (VSS XI0_I1367_bcon I0_cm6_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1367_MN38 (XI0_I1367_bn4 XI0_I1367_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1367_MN38_1 (VSS XI0_I1367_s1 XI0_I1367_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1367_MN25 (VSS XI0_I1367_asn XI0_I1367_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1367_MN10 (VSS I0_pp0_8 XI0_I1367_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1367_MN6 (XI0_I1367_an3 I0_pp0_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1367_MN9 (XI0_I1367_asn XI0_I1367_acon XI0_I1367_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1367_MN12 (XI0_I1367_an5 I0_pp2_4 XI0_I1367_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1367_MN11 (XI0_I1367_an4 I0_pp1_6 XI0_I1367_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1367_MN11_1 (XI0_I1367_an5 I0_pp1_6 XI0_I1367_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1367_MN12_1 (XI0_I1367_asn I0_pp2_4 XI0_I1367_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1367_MN10_1 (XI0_I1367_an4 I0_pp0_8 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1367_MN5 (XI0_I1367_acon I0_pp2_4 XI0_I1367_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1367_MN2 (XI0_I1367_an1 I0_pp1_6 XI0_I1367_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1367_MN1 (VSS I0_pp0_8 XI0_I1367_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1367_MN3 (XI0_I1367_an2 I0_pp0_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1367_MN4 (VSS I0_pp1_6 XI0_I1367_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1367_MN27 (I0_cm6_2 XI0_I1367_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1367_MN7 (XI0_I1367_an3 I0_pp1_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1367_MN8 (VSS I0_pp2_4 XI0_I1367_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1369_MN34 (XI0_I1369_bn3 XI0_I1369_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1369_MN35 (VSS I0_pp3_4 XI0_I1369_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1369_MN36 (XI0_I1369_bn3 I0_cm7_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1369_MN37 (XI0_I1369_bsn XI0_I1369_bcon XI0_I1369_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1369_MN40 (XI0_I1369_bn5 I0_cm7_2 XI0_I1369_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1369_MN39 (XI0_I1369_bn4 I0_pp3_4 XI0_I1369_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1369_MN39_1 (XI0_I1369_bn5 I0_pp3_4 XI0_I1369_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1369_MN40_1 (XI0_I1369_bsn I0_cm7_2 XI0_I1369_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1369_MN53 (VSS XI0_I1369_bsn I0_cm8_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1369_MN29 (XI0_I1369_bn1 XI0_I1369_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1369_MN30 (XI0_I1369_bcon I0_pp3_4 XI0_I1369_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1369_MN33 (XI0_I1369_bn2 I0_cm7_2 XI0_I1369_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1369_MN31 (VSS XI0_I1369_s1 XI0_I1369_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1369_MN32 (XI0_I1369_bn2 I0_pp3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1369_MN55 (VSS XI0_I1369_bcon I0_cm8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1369_MN38 (XI0_I1369_bn4 XI0_I1369_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1369_MN38_1 (VSS XI0_I1369_s1 XI0_I1369_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1369_MN25 (VSS XI0_I1369_asn XI0_I1369_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1369_MN10 (VSS I0_pp0_10 XI0_I1369_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1369_MN6 (XI0_I1369_an3 I0_pp0_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1369_MN9 (XI0_I1369_asn XI0_I1369_acon XI0_I1369_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1369_MN12 (XI0_I1369_an5 I0_pp2_6 XI0_I1369_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1369_MN11 (XI0_I1369_an4 I0_pp1_8 XI0_I1369_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1369_MN11_1 (XI0_I1369_an5 I0_pp1_8 XI0_I1369_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1369_MN12_1 (XI0_I1369_asn I0_pp2_6 XI0_I1369_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1369_MN10_1 (XI0_I1369_an4 I0_pp0_10 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1369_MN5 (XI0_I1369_acon I0_pp2_6 XI0_I1369_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1369_MN2 (XI0_I1369_an1 I0_pp1_8 XI0_I1369_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1369_MN1 (VSS I0_pp0_10 XI0_I1369_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1369_MN3 (XI0_I1369_an2 I0_pp0_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1369_MN4 (VSS I0_pp1_8 XI0_I1369_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1369_MN27 (I0_cm8_2 XI0_I1369_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1369_MN7 (XI0_I1369_an3 I0_pp1_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1369_MN8 (VSS I0_pp2_6 XI0_I1369_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1366_MN34 (XI0_I1366_bn3 XI0_I1366_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1366_MN35 (VSS I0_pp3_1 XI0_I1366_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1366_MN36 (XI0_I1366_bn3 I0_cm4_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1366_MN37 (XI0_I1366_bsn XI0_I1366_bcon XI0_I1366_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1366_MN40 (XI0_I1366_bn5 I0_cm4_2 XI0_I1366_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1366_MN39 (XI0_I1366_bn4 I0_pp3_1 XI0_I1366_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1366_MN39_1 (XI0_I1366_bn5 I0_pp3_1 XI0_I1366_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1366_MN40_1 (XI0_I1366_bsn I0_cm4_2 XI0_I1366_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1366_MN53 (VSS XI0_I1366_bsn I0_cm5_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1366_MN29 (XI0_I1366_bn1 XI0_I1366_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1366_MN30 (XI0_I1366_bcon I0_pp3_1 XI0_I1366_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1366_MN33 (XI0_I1366_bn2 I0_cm4_2 XI0_I1366_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1366_MN31 (VSS XI0_I1366_s1 XI0_I1366_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1366_MN32 (XI0_I1366_bn2 I0_pp3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1366_MN55 (VSS XI0_I1366_bcon I0_cm5_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1366_MN38 (XI0_I1366_bn4 XI0_I1366_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1366_MN38_1 (VSS XI0_I1366_s1 XI0_I1366_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1366_MN25 (VSS XI0_I1366_asn XI0_I1366_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1366_MN10 (VSS I0_pp0_7 XI0_I1366_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1366_MN6 (XI0_I1366_an3 I0_pp0_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1366_MN9 (XI0_I1366_asn XI0_I1366_acon XI0_I1366_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1366_MN12 (XI0_I1366_an5 I0_pp2_3 XI0_I1366_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1366_MN11 (XI0_I1366_an4 I0_pp1_5 XI0_I1366_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1366_MN11_1 (XI0_I1366_an5 I0_pp1_5 XI0_I1366_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1366_MN12_1 (XI0_I1366_asn I0_pp2_3 XI0_I1366_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1366_MN10_1 (XI0_I1366_an4 I0_pp0_7 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1366_MN5 (XI0_I1366_acon I0_pp2_3 XI0_I1366_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1366_MN2 (XI0_I1366_an1 I0_pp1_5 XI0_I1366_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1366_MN1 (VSS I0_pp0_7 XI0_I1366_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1366_MN3 (XI0_I1366_an2 I0_pp0_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1366_MN4 (VSS I0_pp1_5 XI0_I1366_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1366_MN27 (I0_cm5_2 XI0_I1366_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1366_MN7 (XI0_I1366_an3 I0_pp1_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1366_MN8 (VSS I0_pp2_3 XI0_I1366_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1512_MN34 (XI0_I1512_bn3 XI0_I1512_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1512_MN35 (VSS I0_cm29_0 XI0_I1512_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1512_MN36 (XI0_I1512_bn3 I0_cm149_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1512_MN37 (XI0_I1512_bsn XI0_I1512_bcon XI0_I1512_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1512_MN40 (XI0_I1512_bn5 I0_cm149_2 XI0_I1512_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1512_MN39 (XI0_I1512_bn4 I0_cm29_0 XI0_I1512_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1512_MN39_1 (XI0_I1512_bn5 I0_cm29_0 XI0_I1512_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1512_MN40_1 (XI0_I1512_bsn I0_cm149_2 XI0_I1512_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1512_MN53 (VSS XI0_I1512_bsn I0_cm151_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1512_MN29 (XI0_I1512_bn1 XI0_I1512_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1512_MN30 (XI0_I1512_bcon I0_cm29_0 XI0_I1512_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1512_MN33 (XI0_I1512_bn2 I0_cm149_2 XI0_I1512_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1512_MN31 (VSS XI0_I1512_s1 XI0_I1512_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1512_MN32 (XI0_I1512_bn2 I0_cm29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1512_MN55 (VSS XI0_I1512_bcon I0_cm151_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1512_MN38 (XI0_I1512_bn4 XI0_I1512_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1512_MN38_1 (VSS XI0_I1512_s1 XI0_I1512_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1512_MN25 (VSS XI0_I1512_asn XI0_I1512_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1512_MN10 (VSS I0_cm26_1 XI0_I1512_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1512_MN6 (XI0_I1512_an3 I0_cm26_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1512_MN9 (XI0_I1512_asn XI0_I1512_acon XI0_I1512_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1512_MN12 (XI0_I1512_an5 I0_cm28_0 XI0_I1512_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1512_MN11 (XI0_I1512_an4 I0_cm27_1 XI0_I1512_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1512_MN11_1 (XI0_I1512_an5 I0_cm27_1 XI0_I1512_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1512_MN12_1 (XI0_I1512_asn I0_cm28_0 XI0_I1512_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1512_MN10_1 (XI0_I1512_an4 I0_cm26_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1512_MN5 (XI0_I1512_acon I0_cm28_0 XI0_I1512_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1512_MN2 (XI0_I1512_an1 I0_cm27_1 XI0_I1512_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1512_MN1 (VSS I0_cm26_1 XI0_I1512_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1512_MN3 (XI0_I1512_an2 I0_cm26_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1512_MN4 (VSS I0_cm27_1 XI0_I1512_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1512_MN27 (I0_cm151_2 XI0_I1512_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1512_MN7 (XI0_I1512_an3 I0_cm27_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1512_MN8 (VSS I0_cm28_0 XI0_I1512_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1515_MN34 (XI0_I1515_bn3 XI0_I1515_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1515_MN35 (VSS I0_cm37_0 XI0_I1515_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1515_MN36 (XI0_I1515_bn3 I0_cm153_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1515_MN37 (XI0_I1515_bsn XI0_I1515_bcon XI0_I1515_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1515_MN40 (XI0_I1515_bn5 I0_cm153_2 XI0_I1515_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1515_MN39 (XI0_I1515_bn4 I0_cm37_0 XI0_I1515_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1515_MN39_1 (XI0_I1515_bn5 I0_cm37_0 XI0_I1515_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1515_MN40_1 (XI0_I1515_bsn I0_cm153_2 XI0_I1515_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1515_MN53 (VSS XI0_I1515_bsn I0_cm154_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1515_MN29 (XI0_I1515_bn1 XI0_I1515_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1515_MN30 (XI0_I1515_bcon I0_cm37_0 XI0_I1515_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1515_MN33 (XI0_I1515_bn2 I0_cm153_2 XI0_I1515_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1515_MN31 (VSS XI0_I1515_s1 XI0_I1515_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1515_MN32 (XI0_I1515_bn2 I0_cm37_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1515_MN55 (VSS XI0_I1515_bcon I0_cm154_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1515_MN38 (XI0_I1515_bn4 XI0_I1515_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1515_MN38_1 (VSS XI0_I1515_s1 XI0_I1515_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1515_MN25 (VSS XI0_I1515_asn XI0_I1515_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1515_MN10 (VSS I0_cm34_1 XI0_I1515_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1515_MN6 (XI0_I1515_an3 I0_cm34_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1515_MN9 (XI0_I1515_asn XI0_I1515_acon XI0_I1515_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1515_MN12 (XI0_I1515_an5 I0_cm36_1 XI0_I1515_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1515_MN11 (XI0_I1515_an4 I0_cm35_1 XI0_I1515_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1515_MN11_1 (XI0_I1515_an5 I0_cm35_1 XI0_I1515_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1515_MN12_1 (XI0_I1515_asn I0_cm36_1 XI0_I1515_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1515_MN10_1 (XI0_I1515_an4 I0_cm34_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1515_MN5 (XI0_I1515_acon I0_cm36_1 XI0_I1515_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1515_MN2 (XI0_I1515_an1 I0_cm35_1 XI0_I1515_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1515_MN1 (VSS I0_cm34_1 XI0_I1515_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1515_MN3 (XI0_I1515_an2 I0_cm34_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1515_MN4 (VSS I0_cm35_1 XI0_I1515_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1515_MN27 (I0_cm154_2 XI0_I1515_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1515_MN7 (XI0_I1515_an3 I0_cm35_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1515_MN8 (VSS I0_cm36_1 XI0_I1515_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1516_MN34 (XI0_I1516_bn3 XI0_I1516_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1516_MN35 (VSS I0_cm40_0 XI0_I1516_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1516_MN36 (XI0_I1516_bn3 I0_cm154_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1516_MN37 (XI0_I1516_bsn XI0_I1516_bcon XI0_I1516_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1516_MN40 (XI0_I1516_bn5 I0_cm154_2 XI0_I1516_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1516_MN39 (XI0_I1516_bn4 I0_cm40_0 XI0_I1516_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1516_MN39_1 (XI0_I1516_bn5 I0_cm40_0 XI0_I1516_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1516_MN40_1 (XI0_I1516_bsn I0_cm154_2 XI0_I1516_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1516_MN53 (VSS XI0_I1516_bsn I0_cm155_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1516_MN29 (XI0_I1516_bn1 XI0_I1516_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1516_MN30 (XI0_I1516_bcon I0_cm40_0 XI0_I1516_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1516_MN33 (XI0_I1516_bn2 I0_cm154_2 XI0_I1516_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1516_MN31 (VSS XI0_I1516_s1 XI0_I1516_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1516_MN32 (XI0_I1516_bn2 I0_cm40_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1516_MN55 (VSS XI0_I1516_bcon I0_cm155_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1516_MN38 (XI0_I1516_bn4 XI0_I1516_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1516_MN38_1 (VSS XI0_I1516_s1 XI0_I1516_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1516_MN25 (VSS XI0_I1516_asn XI0_I1516_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1516_MN10 (VSS I0_cm37_1 XI0_I1516_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1516_MN6 (XI0_I1516_an3 I0_cm37_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1516_MN9 (XI0_I1516_asn XI0_I1516_acon XI0_I1516_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1516_MN12 (XI0_I1516_an5 I0_cm39_1 XI0_I1516_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1516_MN11 (XI0_I1516_an4 I0_cm38_1 XI0_I1516_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1516_MN11_1 (XI0_I1516_an5 I0_cm38_1 XI0_I1516_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1516_MN12_1 (XI0_I1516_asn I0_cm39_1 XI0_I1516_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1516_MN10_1 (XI0_I1516_an4 I0_cm37_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1516_MN5 (XI0_I1516_acon I0_cm39_1 XI0_I1516_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1516_MN2 (XI0_I1516_an1 I0_cm38_1 XI0_I1516_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1516_MN1 (VSS I0_cm37_1 XI0_I1516_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1516_MN3 (XI0_I1516_an2 I0_cm37_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1516_MN4 (VSS I0_cm38_1 XI0_I1516_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1516_MN27 (I0_cm155_2 XI0_I1516_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1516_MN7 (XI0_I1516_an3 I0_cm38_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1516_MN8 (VSS I0_cm39_1 XI0_I1516_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1583_MN34 (XI0_I1583_bn3 XI0_I1583_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1583_MN35 (VSS I0_cm164_0 XI0_I1583_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1583_MN36 (XI0_I1583_bn3 I0_cm221_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1583_MN37 (XI0_I1583_bsn XI0_I1583_bcon XI0_I1583_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1583_MN40 (XI0_I1583_bn5 I0_cm221_2 XI0_I1583_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1583_MN39 (XI0_I1583_bn4 I0_cm164_0 XI0_I1583_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1583_MN39_1 (XI0_I1583_bn5 I0_cm164_0 XI0_I1583_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1583_MN40_1 (XI0_I1583_bsn I0_cm221_2 XI0_I1583_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1583_MN53 (VSS XI0_I1583_bsn I0_cm222_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1583_MN29 (XI0_I1583_bn1 XI0_I1583_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1583_MN30 (XI0_I1583_bcon I0_cm164_0 XI0_I1583_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1583_MN33 (XI0_I1583_bn2 I0_cm221_2 XI0_I1583_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1583_MN31 (VSS XI0_I1583_s1 XI0_I1583_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1583_MN32 (XI0_I1583_bn2 I0_cm164_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1583_MN55 (VSS XI0_I1583_bcon I0_cm222_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1583_MN38 (XI0_I1583_bn4 XI0_I1583_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1583_MN38_1 (VSS XI0_I1583_s1 XI0_I1583_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1583_MN25 (VSS XI0_I1583_asn XI0_I1583_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1583_MN10 (VSS I0_cm161_1 XI0_I1583_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1583_MN6 (XI0_I1583_an3 I0_cm161_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1583_MN9 (XI0_I1583_asn XI0_I1583_acon XI0_I1583_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1583_MN12 (XI0_I1583_an5 I0_cm163_0 XI0_I1583_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1583_MN11 (XI0_I1583_an4 I0_cm162_1 XI0_I1583_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1583_MN11_1 (XI0_I1583_an5 I0_cm162_1 XI0_I1583_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1583_MN12_1 (XI0_I1583_asn I0_cm163_0 XI0_I1583_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1583_MN10_1 (XI0_I1583_an4 I0_cm161_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1583_MN5 (XI0_I1583_acon I0_cm163_0 XI0_I1583_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1583_MN2 (XI0_I1583_an1 I0_cm162_1 XI0_I1583_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1583_MN1 (VSS I0_cm161_1 XI0_I1583_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1583_MN3 (XI0_I1583_an2 I0_cm161_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1583_MN4 (VSS I0_cm162_1 XI0_I1583_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1583_MN27 (I0_cm222_2 XI0_I1583_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1583_MN7 (XI0_I1583_an3 I0_cm162_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1583_MN8 (VSS I0_cm163_0 XI0_I1583_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1531_MN34 (XI0_I1531_bn3 XI0_I1531_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1531_MN35 (VSS I0_cm68_0 XI0_I1531_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1531_MN36 (XI0_I1531_bn3 I0_cm168_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1531_MN37 (XI0_I1531_bsn XI0_I1531_bcon XI0_I1531_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1531_MN40 (XI0_I1531_bn5 I0_cm168_2 XI0_I1531_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1531_MN39 (XI0_I1531_bn4 I0_cm68_0 XI0_I1531_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1531_MN39_1 (XI0_I1531_bn5 I0_cm68_0 XI0_I1531_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1531_MN40_1 (XI0_I1531_bsn I0_cm168_2 XI0_I1531_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1531_MN53 (VSS XI0_I1531_bsn I0_cm170_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1531_MN29 (XI0_I1531_bn1 XI0_I1531_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1531_MN30 (XI0_I1531_bcon I0_cm68_0 XI0_I1531_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1531_MN33 (XI0_I1531_bn2 I0_cm168_2 XI0_I1531_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1531_MN31 (VSS XI0_I1531_s1 XI0_I1531_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1531_MN32 (XI0_I1531_bn2 I0_cm68_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1531_MN55 (VSS XI0_I1531_bcon I0_cm170_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1531_MN38 (XI0_I1531_bn4 XI0_I1531_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1531_MN38_1 (VSS XI0_I1531_s1 XI0_I1531_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1531_MN25 (VSS XI0_I1531_asn XI0_I1531_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1531_MN10 (VSS I0_cm65_0 XI0_I1531_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1531_MN6 (XI0_I1531_an3 I0_cm65_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1531_MN9 (XI0_I1531_asn XI0_I1531_acon XI0_I1531_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1531_MN12 (XI0_I1531_an5 I0_cm67_0 XI0_I1531_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1531_MN11 (XI0_I1531_an4 I0_cm66_0 XI0_I1531_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1531_MN11_1 (XI0_I1531_an5 I0_cm66_0 XI0_I1531_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1531_MN12_1 (XI0_I1531_asn I0_cm67_0 XI0_I1531_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1531_MN10_1 (XI0_I1531_an4 I0_cm65_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1531_MN5 (XI0_I1531_acon I0_cm67_0 XI0_I1531_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1531_MN2 (XI0_I1531_an1 I0_cm66_0 XI0_I1531_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1531_MN1 (VSS I0_cm65_0 XI0_I1531_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1531_MN3 (XI0_I1531_an2 I0_cm65_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1531_MN4 (VSS I0_cm66_0 XI0_I1531_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1531_MN27 (I0_cm170_2 XI0_I1531_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1531_MN7 (XI0_I1531_an3 I0_cm66_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1531_MN8 (VSS I0_cm67_0 XI0_I1531_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1523_MN34 (XI0_I1523_bn3 XI0_I1523_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1523_MN35 (VSS I0_pp12_3 XI0_I1523_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1523_MN36 (XI0_I1523_bn3 I0_pp13_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1523_MN37 (XI0_I1523_bsn XI0_I1523_bcon XI0_I1523_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1523_MN40 (XI0_I1523_bn5 I0_pp13_1 XI0_I1523_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1523_MN39 (XI0_I1523_bn4 I0_pp12_3 XI0_I1523_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1523_MN39_1 (XI0_I1523_bn5 I0_pp12_3 XI0_I1523_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1523_MN40_1 (XI0_I1523_bsn I0_pp13_1 XI0_I1523_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1523_MN53 (VSS XI0_I1523_bsn I0_cm162_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1523_MN29 (XI0_I1523_bn1 XI0_I1523_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1523_MN30 (XI0_I1523_bcon I0_pp12_3 XI0_I1523_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1523_MN33 (XI0_I1523_bn2 I0_pp13_1 XI0_I1523_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1523_MN31 (VSS XI0_I1523_s1 XI0_I1523_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1523_MN32 (XI0_I1523_bn2 I0_pp12_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1523_MN55 (VSS XI0_I1523_bcon I0_cm162_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1523_MN38 (XI0_I1523_bn4 XI0_I1523_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1523_MN38_1 (VSS XI0_I1523_s1 XI0_I1523_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1523_MN25 (VSS XI0_I1523_asn XI0_I1523_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1523_MN10 (VSS I0_cm50_0 XI0_I1523_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1523_MN6 (XI0_I1523_an3 I0_cm50_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1523_MN9 (XI0_I1523_asn XI0_I1523_acon XI0_I1523_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1523_MN12 (XI0_I1523_an5 I0_cm52_0 XI0_I1523_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1523_MN11 (XI0_I1523_an4 I0_cm51_0 XI0_I1523_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1523_MN11_1 (XI0_I1523_an5 I0_cm51_0 XI0_I1523_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1523_MN12_1 (XI0_I1523_asn I0_cm52_0 XI0_I1523_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1523_MN10_1 (XI0_I1523_an4 I0_cm50_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1523_MN5 (XI0_I1523_acon I0_cm52_0 XI0_I1523_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1523_MN2 (XI0_I1523_an1 I0_cm51_0 XI0_I1523_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1523_MN1 (VSS I0_cm50_0 XI0_I1523_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1523_MN3 (XI0_I1523_an2 I0_cm50_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1523_MN4 (VSS I0_cm51_0 XI0_I1523_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1523_MN27 (I0_cm162_2 XI0_I1523_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1523_MN7 (XI0_I1523_an3 I0_cm51_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1523_MN8 (VSS I0_cm52_0 XI0_I1523_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1533_MN34 (XI0_I1533_bn3 XI0_I1533_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1533_MN35 (VSS I0_cm72_0 XI0_I1533_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1533_MN36 (XI0_I1533_bn3 I0_cm170_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1533_MN37 (XI0_I1533_bsn XI0_I1533_bcon XI0_I1533_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1533_MN40 (XI0_I1533_bn5 I0_cm170_2 XI0_I1533_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1533_MN39 (XI0_I1533_bn4 I0_cm72_0 XI0_I1533_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1533_MN39_1 (XI0_I1533_bn5 I0_cm72_0 XI0_I1533_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1533_MN40_1 (XI0_I1533_bsn I0_cm170_2 XI0_I1533_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1533_MN53 (VSS XI0_I1533_bsn I0_cm172_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1533_MN29 (XI0_I1533_bn1 XI0_I1533_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1533_MN30 (XI0_I1533_bcon I0_cm72_0 XI0_I1533_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1533_MN33 (XI0_I1533_bn2 I0_cm170_2 XI0_I1533_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1533_MN31 (VSS XI0_I1533_s1 XI0_I1533_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1533_MN32 (XI0_I1533_bn2 I0_cm72_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1533_MN55 (VSS XI0_I1533_bcon I0_cm172_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1533_MN38 (XI0_I1533_bn4 XI0_I1533_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1533_MN38_1 (VSS XI0_I1533_s1 XI0_I1533_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1533_MN25 (VSS XI0_I1533_asn XI0_I1533_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1533_MN10 (VSS I0_cm69_0 XI0_I1533_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1533_MN6 (XI0_I1533_an3 I0_cm69_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1533_MN9 (XI0_I1533_asn XI0_I1533_acon XI0_I1533_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1533_MN12 (XI0_I1533_an5 I0_cm71_0 XI0_I1533_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1533_MN11 (XI0_I1533_an4 I0_cm70_0 XI0_I1533_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1533_MN11_1 (XI0_I1533_an5 I0_cm70_0 XI0_I1533_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1533_MN12_1 (XI0_I1533_asn I0_cm71_0 XI0_I1533_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1533_MN10_1 (XI0_I1533_an4 I0_cm69_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1533_MN5 (XI0_I1533_acon I0_cm71_0 XI0_I1533_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1533_MN2 (XI0_I1533_an1 I0_cm70_0 XI0_I1533_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1533_MN1 (VSS I0_cm69_0 XI0_I1533_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1533_MN3 (XI0_I1533_an2 I0_cm69_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1533_MN4 (VSS I0_cm70_0 XI0_I1533_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1533_MN27 (I0_cm172_2 XI0_I1533_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1533_MN7 (XI0_I1533_an3 I0_cm70_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1533_MN8 (VSS I0_cm71_0 XI0_I1533_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1589_MN34 (XI0_I1589_bn3 XI0_I1589_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1589_MN35 (VSS I0_cm176_0 XI0_I1589_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1589_MN36 (XI0_I1589_bn3 I0_cm227_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1589_MN37 (XI0_I1589_bsn XI0_I1589_bcon XI0_I1589_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1589_MN40 (XI0_I1589_bn5 I0_cm227_2 XI0_I1589_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1589_MN39 (XI0_I1589_bn4 I0_cm176_0 XI0_I1589_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1589_MN39_1 (XI0_I1589_bn5 I0_cm176_0 XI0_I1589_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1589_MN40_1 (XI0_I1589_bsn I0_cm227_2 XI0_I1589_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1589_MN53 (VSS XI0_I1589_bsn I0_cm228_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1589_MN29 (XI0_I1589_bn1 XI0_I1589_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1589_MN30 (XI0_I1589_bcon I0_cm176_0 XI0_I1589_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1589_MN33 (XI0_I1589_bn2 I0_cm227_2 XI0_I1589_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1589_MN31 (VSS XI0_I1589_s1 XI0_I1589_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1589_MN32 (XI0_I1589_bn2 I0_cm176_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1589_MN55 (VSS XI0_I1589_bcon I0_cm228_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1589_MN38 (XI0_I1589_bn4 XI0_I1589_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1589_MN38_1 (VSS XI0_I1589_s1 XI0_I1589_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1589_MN25 (VSS XI0_I1589_asn XI0_I1589_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1589_MN10 (VSS I0_cm173_1 XI0_I1589_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1589_MN6 (XI0_I1589_an3 I0_cm173_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1589_MN9 (XI0_I1589_asn XI0_I1589_acon XI0_I1589_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1589_MN12 (XI0_I1589_an5 I0_cm175_0 XI0_I1589_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1589_MN11 (XI0_I1589_an4 I0_cm174_1 XI0_I1589_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1589_MN11_1 (XI0_I1589_an5 I0_cm174_1 XI0_I1589_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1589_MN12_1 (XI0_I1589_asn I0_cm175_0 XI0_I1589_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1589_MN10_1 (XI0_I1589_an4 I0_cm173_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1589_MN5 (XI0_I1589_acon I0_cm175_0 XI0_I1589_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1589_MN2 (XI0_I1589_an1 I0_cm174_1 XI0_I1589_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1589_MN1 (VSS I0_cm173_1 XI0_I1589_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1589_MN3 (XI0_I1589_an2 I0_cm173_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1589_MN4 (VSS I0_cm174_1 XI0_I1589_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1589_MN27 (I0_cm228_2 XI0_I1589_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1589_MN7 (XI0_I1589_an3 I0_cm174_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1589_MN8 (VSS I0_cm175_0 XI0_I1589_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1535_MN34 (XI0_I1535_bn3 XI0_I1535_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1535_MN35 (VSS I0_cm76_0 XI0_I1535_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1535_MN36 (XI0_I1535_bn3 I0_cm172_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1535_MN37 (XI0_I1535_bsn XI0_I1535_bcon XI0_I1535_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1535_MN40 (XI0_I1535_bn5 I0_cm172_2 XI0_I1535_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1535_MN39 (XI0_I1535_bn4 I0_cm76_0 XI0_I1535_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1535_MN39_1 (XI0_I1535_bn5 I0_cm76_0 XI0_I1535_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1535_MN40_1 (XI0_I1535_bsn I0_cm172_2 XI0_I1535_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1535_MN53 (VSS XI0_I1535_bsn I0_cm174_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1535_MN29 (XI0_I1535_bn1 XI0_I1535_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1535_MN30 (XI0_I1535_bcon I0_cm76_0 XI0_I1535_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
