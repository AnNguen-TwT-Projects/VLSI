    I_MXI0_I671_MN1 (XI0_I671_n1 I0_one3_b3_0 XI0_I671_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I671_MN9 (VSS XI0_I671_xn XI0_I671_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I672_MN11 (VSS I0_B_7_b3_0 XI0_I672_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I672_MN14 (VSS XI0_I672_xbn XI0_I672_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I672_MN16 (XI0_I672_xn2 I0_B_7_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I672_MN15 (I0_pp3_4 XI0_I672_xan XI0_I672_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I672_MN13 (XI0_I672_xn1 XI0_I672_xn I0_pp3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I672_MN2 (VSS I0_A_4_b3_1 XI0_I672_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I672_MN4 (XI0_I672_n2 I0_A_3_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I672_MN3 (XI0_I672_xn I0_two3_b3_0 XI0_I672_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I672_MN1 (XI0_I672_n1 I0_one3_b3_0 XI0_I672_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I672_MN9 (VSS XI0_I672_xn XI0_I672_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I729_MN11 (VSS I0_B_9_b3_1 XI0_I729_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I729_MN14 (VSS XI0_I729_xbn XI0_I729_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I729_MN16 (XI0_I729_xn2 I0_B_9_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I729_MN15 (I0_pp4_6 XI0_I729_xan XI0_I729_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I729_MN13 (XI0_I729_xn1 XI0_I729_xn I0_pp4_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I729_MN2 (VSS I0_A_6_b3_1 XI0_I729_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I729_MN4 (XI0_I729_n2 I0_A_5_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I729_MN3 (XI0_I729_xn I0_two4_b3_1 XI0_I729_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I729_MN1 (XI0_I729_n1 I0_one4_b3_1 XI0_I729_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I729_MN9 (VSS XI0_I729_xn XI0_I729_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I731_MN11 (VSS I0_B_9_b3_1 XI0_I731_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I731_MN14 (VSS XI0_I731_xbn XI0_I731_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I731_MN16 (XI0_I731_xn2 I0_B_9_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I731_MN15 (I0_pp4_8 XI0_I731_xan XI0_I731_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I731_MN13 (XI0_I731_xn1 XI0_I731_xn I0_pp4_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I731_MN2 (VSS I0_A_8_b3_1 XI0_I731_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I731_MN4 (XI0_I731_n2 I0_A_7_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I731_MN3 (XI0_I731_xn I0_two4_b3_1 XI0_I731_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I731_MN1 (XI0_I731_n1 I0_one4_b3_1 XI0_I731_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I731_MN9 (VSS XI0_I731_xn XI0_I731_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I732_MN11 (VSS I0_B_9_b3_1 XI0_I732_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I732_MN14 (VSS XI0_I732_xbn XI0_I732_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I732_MN16 (XI0_I732_xn2 I0_B_9_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I732_MN15 (I0_pp4_9 XI0_I732_xan XI0_I732_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I732_MN13 (XI0_I732_xn1 XI0_I732_xn I0_pp4_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I732_MN2 (VSS I0_A_9_b3_1 XI0_I732_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I732_MN4 (XI0_I732_n2 I0_A_8_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I732_MN3 (XI0_I732_xn I0_two4_b3_1 XI0_I732_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I732_MN1 (XI0_I732_n1 I0_one4_b3_1 XI0_I732_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I732_MN9 (VSS XI0_I732_xn XI0_I732_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I786_MN11 (VSS I0_B_11_b3_1 XI0_I786_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I786_MN14 (VSS XI0_I786_xbn XI0_I786_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I786_MN16 (XI0_I786_xn2 I0_B_11_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I786_MN15 (I0_pp5_8 XI0_I786_xan XI0_I786_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I786_MN13 (XI0_I786_xn1 XI0_I786_xn I0_pp5_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I786_MN2 (VSS I0_A_8_b3_1 XI0_I786_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I786_MN4 (XI0_I786_n2 I0_A_7_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I786_MN3 (XI0_I786_xn I0_two5_b3_1 XI0_I786_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I786_MN1 (XI0_I786_n1 I0_one5_b3_1 XI0_I786_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I786_MN9 (VSS XI0_I786_xn XI0_I786_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I787_MN11 (VSS I0_B_11_b3_1 XI0_I787_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I787_MN14 (VSS XI0_I787_xbn XI0_I787_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I787_MN16 (XI0_I787_xn2 I0_B_11_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I787_MN15 (I0_pp5_9 XI0_I787_xan XI0_I787_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I787_MN13 (XI0_I787_xn1 XI0_I787_xn I0_pp5_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I787_MN2 (VSS I0_A_9_b3_1 XI0_I787_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I787_MN4 (XI0_I787_n2 I0_A_8_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I787_MN3 (XI0_I787_xn I0_two5_b3_1 XI0_I787_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I787_MN1 (XI0_I787_n1 I0_one5_b3_1 XI0_I787_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I787_MN9 (VSS XI0_I787_xn XI0_I787_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I897_MN11 (VSS I0_B_15_b3_1 XI0_I897_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I897_MN14 (VSS XI0_I897_xbn XI0_I897_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I897_MN16 (XI0_I897_xn2 I0_B_15_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I897_MN15 (I0_pp7_9 XI0_I897_xan XI0_I897_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I897_MN13 (XI0_I897_xn1 XI0_I897_xn I0_pp7_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I897_MN2 (VSS I0_A_9_b3_2 XI0_I897_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I897_MN4 (XI0_I897_n2 I0_A_8_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I897_MN3 (XI0_I897_xn I0_two7_b3_1 XI0_I897_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I897_MN1 (XI0_I897_n1 I0_one7_b3_1 XI0_I897_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I897_MN9 (VSS XI0_I897_xn XI0_I897_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I841_MN11 (VSS I0_B_13_b3_1 XI0_I841_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I841_MN14 (VSS XI0_I841_xbn XI0_I841_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I841_MN16 (XI0_I841_xn2 I0_B_13_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I841_MN15 (I0_pp6_8 XI0_I841_xan XI0_I841_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I841_MN13 (XI0_I841_xn1 XI0_I841_xn I0_pp6_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I841_MN2 (VSS I0_A_8_b3_2 XI0_I841_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I841_MN4 (XI0_I841_n2 I0_A_7_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I841_MN3 (XI0_I841_xn I0_two6_b3_1 XI0_I841_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I841_MN1 (XI0_I841_n1 I0_one6_b3_1 XI0_I841_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I841_MN9 (VSS XI0_I841_xn XI0_I841_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I918_MN11 (VSS I0_B_15_b3_5 XI0_I918_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I918_MN14 (VSS XI0_I918_xbn XI0_I918_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I918_MN16 (XI0_I918_xn2 I0_B_15_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I918_MN15 (I0_pp7_30 XI0_I918_xan XI0_I918_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I918_MN13 (XI0_I918_xn1 XI0_I918_xn I0_pp7_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I918_MN2 (VSS I0_A_30_b3_2 XI0_I918_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I918_MN4 (XI0_I918_n2 I0_A_29_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I918_MN3 (XI0_I918_xn I0_two7_b3_5 XI0_I918_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I918_MN1 (XI0_I918_n1 I0_one7_b3_5 XI0_I918_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I918_MN9 (VSS XI0_I918_xn XI0_I918_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I920_MN11 (VSS I0_B_15_b3_5 XI0_I920_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I920_MN14 (VSS XI0_I920_xbn XI0_I920_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I920_MN16 (XI0_I920_xn2 I0_B_15_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I920_MN15 (I0_pp7_32 XI0_I920_xan XI0_I920_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I920_MN13 (XI0_I920_xn1 XI0_I920_xn I0_pp7_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I920_MN2 (VSS I0_A_31_b3_3 XI0_I920_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I920_MN4 (XI0_I920_n2 I0_A_31_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I920_MN3 (XI0_I920_xn I0_two7_b3_5 XI0_I920_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I920_MN1 (XI0_I920_n1 I0_one7_b3_5 XI0_I920_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I920_MN9 (VSS XI0_I920_xn XI0_I920_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I670_MN11 (VSS I0_B_7_b3_0 XI0_I670_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I670_MN14 (VSS XI0_I670_xbn XI0_I670_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I670_MN16 (XI0_I670_xn2 I0_B_7_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I670_MN15 (I0_pp3_2 XI0_I670_xan XI0_I670_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I670_MN13 (XI0_I670_xn1 XI0_I670_xn I0_pp3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I670_MN2 (VSS I0_A_2_b3_1 XI0_I670_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I670_MN4 (XI0_I670_n2 I0_A_1_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I670_MN3 (XI0_I670_xn I0_two3_b3_0 XI0_I670_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I670_MN1 (XI0_I670_n1 I0_one3_b3_0 XI0_I670_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I670_MN9 (VSS XI0_I670_xn XI0_I670_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I727_MN11 (VSS I0_B_9_b3_0 XI0_I727_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I727_MN14 (VSS XI0_I727_xbn XI0_I727_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I727_MN16 (XI0_I727_xn2 I0_B_9_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I727_MN15 (I0_pp4_4 XI0_I727_xan XI0_I727_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I727_MN13 (XI0_I727_xn1 XI0_I727_xn I0_pp4_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I727_MN2 (VSS I0_A_4_b3_1 XI0_I727_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I727_MN4 (XI0_I727_n2 I0_A_3_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I727_MN3 (XI0_I727_xn I0_two4_b3_0 XI0_I727_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I727_MN1 (XI0_I727_n1 I0_one4_b3_0 XI0_I727_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I727_MN9 (VSS XI0_I727_xn XI0_I727_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I725_MN11 (VSS I0_B_9_b3_0 XI0_I725_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I725_MN14 (VSS XI0_I725_xbn XI0_I725_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I725_MN16 (XI0_I725_xn2 I0_B_9_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I725_MN15 (I0_pp4_2 XI0_I725_xan XI0_I725_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I725_MN13 (XI0_I725_xn1 XI0_I725_xn I0_pp4_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I725_MN2 (VSS I0_A_2_b3_1 XI0_I725_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I725_MN4 (XI0_I725_n2 I0_A_1_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I725_MN3 (XI0_I725_xn I0_two4_b3_0 XI0_I725_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I725_MN1 (XI0_I725_n1 I0_one4_b3_0 XI0_I725_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I725_MN9 (VSS XI0_I725_xn XI0_I725_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I728_MN11 (VSS I0_B_9_b3_1 XI0_I728_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I728_MN14 (VSS XI0_I728_xbn XI0_I728_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I728_MN16 (XI0_I728_xn2 I0_B_9_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I728_MN15 (I0_pp4_5 XI0_I728_xan XI0_I728_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I728_MN13 (XI0_I728_xn1 XI0_I728_xn I0_pp4_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I728_MN2 (VSS I0_A_5_b3_1 XI0_I728_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I728_MN4 (XI0_I728_n2 I0_A_4_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I728_MN3 (XI0_I728_xn I0_two4_b3_0 XI0_I728_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I728_MN1 (XI0_I728_n1 I0_one4_b3_0 XI0_I728_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I728_MN9 (VSS XI0_I728_xn XI0_I728_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I730_MN11 (VSS I0_B_9_b3_1 XI0_I730_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I730_MN14 (VSS XI0_I730_xbn XI0_I730_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I730_MN16 (XI0_I730_xn2 I0_B_9_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I730_MN15 (I0_pp4_7 XI0_I730_xan XI0_I730_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I730_MN13 (XI0_I730_xn1 XI0_I730_xn I0_pp4_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I730_MN2 (VSS I0_A_7_b3_1 XI0_I730_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I730_MN4 (XI0_I730_n2 I0_A_6_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I730_MN3 (XI0_I730_xn I0_two4_b3_1 XI0_I730_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I730_MN1 (XI0_I730_n1 I0_one4_b3_1 XI0_I730_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I730_MN9 (VSS XI0_I730_xn XI0_I730_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I784_MN11 (VSS I0_B_11_b3_1 XI0_I784_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I784_MN14 (VSS XI0_I784_xbn XI0_I784_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I784_MN16 (XI0_I784_xn2 I0_B_11_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I784_MN15 (I0_pp5_6 XI0_I784_xan XI0_I784_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I784_MN13 (XI0_I784_xn1 XI0_I784_xn I0_pp5_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I784_MN2 (VSS I0_A_6_b3_1 XI0_I784_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I784_MN4 (XI0_I784_n2 I0_A_5_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I784_MN3 (XI0_I784_xn I0_two5_b3_1 XI0_I784_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I784_MN1 (XI0_I784_n1 I0_one5_b3_1 XI0_I784_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I784_MN9 (VSS XI0_I784_xn XI0_I784_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I839_MN11 (VSS I0_B_13_b3_1 XI0_I839_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I839_MN14 (VSS XI0_I839_xbn XI0_I839_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I839_MN16 (XI0_I839_xn2 I0_B_13_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I839_MN15 (I0_pp6_6 XI0_I839_xan XI0_I839_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I839_MN13 (XI0_I839_xn1 XI0_I839_xn I0_pp6_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I839_MN2 (VSS I0_A_6_b3_2 XI0_I839_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I839_MN4 (XI0_I839_n2 I0_A_5_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I839_MN3 (XI0_I839_xn I0_two6_b3_1 XI0_I839_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I839_MN1 (XI0_I839_n1 I0_one6_b3_1 XI0_I839_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I839_MN9 (VSS XI0_I839_xn XI0_I839_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I785_MN11 (VSS I0_B_11_b3_1 XI0_I785_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I785_MN14 (VSS XI0_I785_xbn XI0_I785_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I785_MN16 (XI0_I785_xn2 I0_B_11_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I785_MN15 (I0_pp5_7 XI0_I785_xan XI0_I785_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I785_MN13 (XI0_I785_xn1 XI0_I785_xn I0_pp5_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I785_MN2 (VSS I0_A_7_b3_1 XI0_I785_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I785_MN4 (XI0_I785_n2 I0_A_6_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I785_MN3 (XI0_I785_xn I0_two5_b3_1 XI0_I785_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I785_MN1 (XI0_I785_n1 I0_one5_b3_1 XI0_I785_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I785_MN9 (VSS XI0_I785_xn XI0_I785_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I838_MN11 (VSS I0_B_13_b3_1 XI0_I838_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I838_MN14 (VSS XI0_I838_xbn XI0_I838_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I838_MN16 (XI0_I838_xn2 I0_B_13_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I838_MN15 (I0_pp6_5 XI0_I838_xan XI0_I838_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I838_MN13 (XI0_I838_xn1 XI0_I838_xn I0_pp6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I838_MN2 (VSS I0_A_5_b3_2 XI0_I838_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I838_MN4 (XI0_I838_n2 I0_A_4_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I838_MN3 (XI0_I838_xn I0_two6_b3_0 XI0_I838_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I838_MN1 (XI0_I838_n1 I0_one6_b3_0 XI0_I838_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I838_MN9 (VSS XI0_I838_xn XI0_I838_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I840_MN11 (VSS I0_B_13_b3_1 XI0_I840_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I840_MN14 (VSS XI0_I840_xbn XI0_I840_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I840_MN16 (XI0_I840_xn2 I0_B_13_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I840_MN15 (I0_pp6_7 XI0_I840_xan XI0_I840_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I840_MN13 (XI0_I840_xn1 XI0_I840_xn I0_pp6_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I840_MN2 (VSS I0_A_7_b3_2 XI0_I840_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I840_MN4 (XI0_I840_n2 I0_A_6_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I840_MN3 (XI0_I840_xn I0_two6_b3_1 XI0_I840_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I840_MN1 (XI0_I840_n1 I0_one6_b3_1 XI0_I840_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I840_MN9 (VSS XI0_I840_xn XI0_I840_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I895_MN11 (VSS I0_B_15_b3_1 XI0_I895_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I895_MN14 (VSS XI0_I895_xbn XI0_I895_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I895_MN16 (XI0_I895_xn2 I0_B_15_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I895_MN15 (I0_pp7_7 XI0_I895_xan XI0_I895_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I895_MN13 (XI0_I895_xn1 XI0_I895_xn I0_pp7_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I895_MN2 (VSS I0_A_7_b3_2 XI0_I895_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I895_MN4 (XI0_I895_n2 I0_A_6_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I895_MN3 (XI0_I895_xn I0_two7_b3_1 XI0_I895_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I895_MN1 (XI0_I895_n1 I0_one7_b3_1 XI0_I895_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I895_MN9 (VSS XI0_I895_xn XI0_I895_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I894_MN11 (VSS I0_B_15_b3_1 XI0_I894_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I894_MN14 (VSS XI0_I894_xbn XI0_I894_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I894_MN16 (XI0_I894_xn2 I0_B_15_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I894_MN15 (I0_pp7_6 XI0_I894_xan XI0_I894_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I894_MN13 (XI0_I894_xn1 XI0_I894_xn I0_pp7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I894_MN2 (VSS I0_A_6_b3_2 XI0_I894_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I894_MN4 (XI0_I894_n2 I0_A_5_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I894_MN3 (XI0_I894_xn I0_two7_b3_1 XI0_I894_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I894_MN1 (XI0_I894_n1 I0_one7_b3_1 XI0_I894_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I894_MN9 (VSS XI0_I894_xn XI0_I894_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I617_MN11 (VSS I0_B_5_b3_0 XI0_I617_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I617_MN14 (VSS XI0_I617_xbn XI0_I617_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I617_MN16 (XI0_I617_xn2 I0_B_5_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I617_MN15 (I0_pp2_4 XI0_I617_xan XI0_I617_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I617_MN13 (XI0_I617_xn1 XI0_I617_xn I0_pp2_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I617_MN2 (VSS I0_A_4_b3_0 XI0_I617_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I617_MN4 (XI0_I617_n2 I0_A_3_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I617_MN3 (XI0_I617_xn I0_two2_b3_0 XI0_I617_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I617_MN1 (XI0_I617_n1 I0_one2_b3_0 XI0_I617_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I617_MN9 (VSS XI0_I617_xn XI0_I617_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I668_MN11 (VSS I0_B_7_b3_0 XI0_I668_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I668_MN14 (VSS XI0_I668_xbn XI0_I668_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I668_MN16 (XI0_I668_xn2 I0_B_7_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I668_MN15 (I0_pp3_0 XI0_I668_xan XI0_I668_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I668_MN13 (XI0_I668_xn1 XI0_I668_xn I0_pp3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I668_MN2 (VSS I0_A_0_b3_1 XI0_I668_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I668_MN4 (XI0_I668_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I668_MN3 (XI0_I668_xn I0_two3_b3_0 XI0_I668_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I668_MN1 (XI0_I668_n1 I0_one3_b3_0 XI0_I668_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I668_MN9 (VSS XI0_I668_xn XI0_I668_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I562_MN11 (VSS I0_B_3_b3_0 XI0_I562_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I562_MN14 (VSS XI0_I562_xbn XI0_I562_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I562_MN16 (XI0_I562_xn2 I0_B_3_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I562_MN15 (I0_pp1_4 XI0_I562_xan XI0_I562_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I562_MN13 (XI0_I562_xn1 XI0_I562_xn I0_pp1_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I562_MN2 (VSS I0_A_4_b3_0 XI0_I562_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I562_MN4 (XI0_I562_n2 I0_A_3_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I562_MN3 (XI0_I562_xn I0_two1_b3_0 XI0_I562_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I562_MN1 (XI0_I562_n1 I0_one1_b3_0 XI0_I562_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I562_MN9 (VSS XI0_I562_xn XI0_I562_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I669_MN11 (VSS I0_B_7_b3_0 XI0_I669_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I669_MN14 (VSS XI0_I669_xbn XI0_I669_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I669_MN16 (XI0_I669_xn2 I0_B_7_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I669_MN15 (I0_pp3_1 XI0_I669_xan XI0_I669_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I669_MN13 (XI0_I669_xn1 XI0_I669_xn I0_pp3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I669_MN2 (VSS I0_A_1_b3_1 XI0_I669_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I669_MN4 (XI0_I669_n2 I0_A_0_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I669_MN3 (XI0_I669_xn I0_two3_b3_0 XI0_I669_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I669_MN1 (XI0_I669_n1 I0_one3_b3_0 XI0_I669_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I669_MN9 (VSS XI0_I669_xn XI0_I669_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I780_MN11 (VSS I0_B_11_b3_0 XI0_I780_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I780_MN14 (VSS XI0_I780_xbn XI0_I780_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I780_MN16 (XI0_I780_xn2 I0_B_11_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I780_MN15 (I0_pp5_2 XI0_I780_xan XI0_I780_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I780_MN13 (XI0_I780_xn1 XI0_I780_xn I0_pp5_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I780_MN2 (VSS I0_A_2_b3_1 XI0_I780_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I780_MN4 (XI0_I780_n2 I0_A_1_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I780_MN3 (XI0_I780_xn I0_two5_b3_0 XI0_I780_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I780_MN1 (XI0_I780_n1 I0_one5_b3_0 XI0_I780_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I780_MN9 (VSS XI0_I780_xn XI0_I780_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I778_MN11 (VSS I0_B_11_b3_0 XI0_I778_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I778_MN14 (VSS XI0_I778_xbn XI0_I778_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I778_MN16 (XI0_I778_xn2 I0_B_11_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I778_MN15 (I0_pp5_0 XI0_I778_xan XI0_I778_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I778_MN13 (XI0_I778_xn1 XI0_I778_xn I0_pp5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I778_MN2 (VSS I0_A_0_b3_1 XI0_I778_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I778_MN4 (XI0_I778_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I778_MN3 (XI0_I778_xn I0_two5_b3_0 XI0_I778_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I778_MN1 (XI0_I778_n1 I0_one5_b3_0 XI0_I778_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I778_MN9 (VSS XI0_I778_xn XI0_I778_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I888_MN11 (VSS I0_B_15_b3_0 XI0_I888_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I888_MN14 (VSS XI0_I888_xbn XI0_I888_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I888_MN16 (XI0_I888_xn2 I0_B_15_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I888_MN15 (I0_pp7_0 XI0_I888_xan XI0_I888_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I888_MN13 (XI0_I888_xn1 XI0_I888_xn I0_pp7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I888_MN2 (VSS I0_A_0_b3_2 XI0_I888_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I888_MN4 (XI0_I888_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I888_MN3 (XI0_I888_xn I0_two7_b3_0 XI0_I888_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I888_MN1 (XI0_I888_n1 I0_one7_b3_0 XI0_I888_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I888_MN9 (VSS XI0_I888_xn XI0_I888_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I782_MN11 (VSS I0_B_11_b3_0 XI0_I782_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I782_MN14 (VSS XI0_I782_xbn XI0_I782_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I782_MN16 (XI0_I782_xn2 I0_B_11_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I782_MN15 (I0_pp5_4 XI0_I782_xan XI0_I782_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I782_MN13 (XI0_I782_xn1 XI0_I782_xn I0_pp5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I782_MN2 (VSS I0_A_4_b3_1 XI0_I782_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I782_MN4 (XI0_I782_n2 I0_A_3_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I782_MN3 (XI0_I782_xn I0_two5_b3_0 XI0_I782_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I782_MN1 (XI0_I782_n1 I0_one5_b3_0 XI0_I782_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I782_MN9 (VSS XI0_I782_xn XI0_I782_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I837_MN11 (VSS I0_B_13_b3_0 XI0_I837_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I837_MN14 (VSS XI0_I837_xbn XI0_I837_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I837_MN16 (XI0_I837_xn2 I0_B_13_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I837_MN15 (I0_pp6_4 XI0_I837_xan XI0_I837_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I837_MN13 (XI0_I837_xn1 XI0_I837_xn I0_pp6_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I837_MN2 (VSS I0_A_4_b3_2 XI0_I837_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I837_MN4 (XI0_I837_n2 I0_A_3_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I837_MN3 (XI0_I837_xn I0_two6_b3_0 XI0_I837_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I837_MN1 (XI0_I837_n1 I0_one6_b3_0 XI0_I837_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I837_MN9 (VSS XI0_I837_xn XI0_I837_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I890_MN11 (VSS I0_B_15_b3_0 XI0_I890_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I890_MN14 (VSS XI0_I890_xbn XI0_I890_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I890_MN16 (XI0_I890_xn2 I0_B_15_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I890_MN15 (I0_pp7_2 XI0_I890_xan XI0_I890_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I890_MN13 (XI0_I890_xn1 XI0_I890_xn I0_pp7_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I890_MN2 (VSS I0_A_2_b3_2 XI0_I890_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I890_MN4 (XI0_I890_n2 I0_A_1_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I890_MN3 (XI0_I890_xn I0_two7_b3_0 XI0_I890_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I890_MN1 (XI0_I890_n1 I0_one7_b3_0 XI0_I890_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I890_MN9 (VSS XI0_I890_xn XI0_I890_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I783_MN11 (VSS I0_B_11_b3_1 XI0_I783_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I783_MN14 (VSS XI0_I783_xbn XI0_I783_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I783_MN16 (XI0_I783_xn2 I0_B_11_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I783_MN15 (I0_pp5_5 XI0_I783_xan XI0_I783_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I783_MN13 (XI0_I783_xn1 XI0_I783_xn I0_pp5_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I783_MN2 (VSS I0_A_5_b3_1 XI0_I783_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I783_MN4 (XI0_I783_n2 I0_A_4_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I783_MN3 (XI0_I783_xn I0_two5_b3_0 XI0_I783_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I783_MN1 (XI0_I783_n1 I0_one5_b3_0 XI0_I783_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I783_MN9 (VSS XI0_I783_xn XI0_I783_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I893_MN11 (VSS I0_B_15_b3_1 XI0_I893_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I893_MN14 (VSS XI0_I893_xbn XI0_I893_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I893_MN16 (XI0_I893_xn2 I0_B_15_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I893_MN15 (I0_pp7_5 XI0_I893_xan XI0_I893_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I893_MN13 (XI0_I893_xn1 XI0_I893_xn I0_pp7_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I893_MN2 (VSS I0_A_5_b3_2 XI0_I893_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I893_MN4 (XI0_I893_n2 I0_A_4_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I893_MN3 (XI0_I893_xn I0_two7_b3_0 XI0_I893_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I893_MN1 (XI0_I893_n1 I0_one7_b3_0 XI0_I893_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I893_MN9 (VSS XI0_I893_xn XI0_I893_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I507_MN11 (VSS I0_B_1_b3_0 XI0_I507_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I507_MN14 (VSS XI0_I507_xbn XI0_I507_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I507_MN16 (XI0_I507_xn2 I0_B_1_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I507_MN15 (I0_pp0_4 XI0_I507_xan XI0_I507_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I507_MN13 (XI0_I507_xn1 XI0_I507_xn I0_pp0_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I507_MN2 (VSS I0_A_4_b3_0 XI0_I507_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I507_MN4 (XI0_I507_n2 I0_A_3_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I507_MN3 (XI0_I507_xn I0_two0_b3_0 XI0_I507_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I507_MN1 (XI0_I507_n1 I0_one0_b3_0 XI0_I507_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I507_MN9 (VSS XI0_I507_xn XI0_I507_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I615_MN11 (VSS I0_B_5_b3_0 XI0_I615_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I615_MN14 (VSS XI0_I615_xbn XI0_I615_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I615_MN16 (XI0_I615_xn2 I0_B_5_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I615_MN15 (I0_pp2_2 XI0_I615_xan XI0_I615_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I615_MN13 (XI0_I615_xn1 XI0_I615_xn I0_pp2_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I615_MN2 (VSS I0_A_2_b3_0 XI0_I615_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I615_MN4 (XI0_I615_n2 I0_A_1_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I615_MN3 (XI0_I615_xn I0_two2_b3_0 XI0_I615_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I615_MN1 (XI0_I615_n1 I0_one2_b3_0 XI0_I615_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I615_MN9 (VSS XI0_I615_xn XI0_I615_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I613_MN11 (VSS I0_B_5_b3_0 XI0_I613_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I613_MN14 (VSS XI0_I613_xbn XI0_I613_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I613_MN16 (XI0_I613_xn2 I0_B_5_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I613_MN15 (I0_pp2_0 XI0_I613_xan XI0_I613_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I613_MN13 (XI0_I613_xn1 XI0_I613_xn I0_pp2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I613_MN2 (VSS I0_A_0_b3_0 XI0_I613_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I613_MN4 (XI0_I613_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I613_MN3 (XI0_I613_xn I0_two2_b3_0 XI0_I613_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I613_MN1 (XI0_I613_n1 I0_one2_b3_0 XI0_I613_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I613_MN9 (VSS XI0_I613_xn XI0_I613_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I614_MN11 (VSS I0_B_5_b3_0 XI0_I614_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I614_MN14 (VSS XI0_I614_xbn XI0_I614_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I614_MN16 (XI0_I614_xn2 I0_B_5_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I614_MN15 (I0_pp2_1 XI0_I614_xan XI0_I614_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I614_MN13 (XI0_I614_xn1 XI0_I614_xn I0_pp2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I614_MN2 (VSS I0_A_1_b3_0 XI0_I614_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I614_MN4 (XI0_I614_n2 I0_A_0_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I614_MN3 (XI0_I614_xn I0_two2_b3_0 XI0_I614_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I614_MN1 (XI0_I614_n1 I0_one2_b3_0 XI0_I614_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I614_MN9 (VSS XI0_I614_xn XI0_I614_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I616_MN11 (VSS I0_B_5_b3_0 XI0_I616_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I616_MN14 (VSS XI0_I616_xbn XI0_I616_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I616_MN16 (XI0_I616_xn2 I0_B_5_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I616_MN15 (I0_pp2_3 XI0_I616_xan XI0_I616_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I616_MN13 (XI0_I616_xn1 XI0_I616_xn I0_pp2_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I616_MN2 (VSS I0_A_3_b3_0 XI0_I616_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I616_MN4 (XI0_I616_n2 I0_A_2_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I616_MN3 (XI0_I616_xn I0_two2_b3_0 XI0_I616_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I616_MN1 (XI0_I616_n1 I0_one2_b3_0 XI0_I616_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I616_MN9 (VSS XI0_I616_xn XI0_I616_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I723_MN11 (VSS I0_B_9_b3_0 XI0_I723_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I723_MN14 (VSS XI0_I723_xbn XI0_I723_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I723_MN16 (XI0_I723_xn2 I0_B_9_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I723_MN15 (I0_pp4_0 XI0_I723_xan XI0_I723_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I723_MN13 (XI0_I723_xn1 XI0_I723_xn I0_pp4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I723_MN2 (VSS I0_A_0_b3_1 XI0_I723_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I723_MN4 (XI0_I723_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I723_MN3 (XI0_I723_xn I0_two4_b3_0 XI0_I723_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I723_MN1 (XI0_I723_n1 I0_one4_b3_0 XI0_I723_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I723_MN9 (VSS XI0_I723_xn XI0_I723_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I724_MN11 (VSS I0_B_9_b3_0 XI0_I724_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I724_MN14 (VSS XI0_I724_xbn XI0_I724_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I724_MN16 (XI0_I724_xn2 I0_B_9_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I724_MN15 (I0_pp4_1 XI0_I724_xan XI0_I724_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I724_MN13 (XI0_I724_xn1 XI0_I724_xn I0_pp4_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I724_MN2 (VSS I0_A_1_b3_1 XI0_I724_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I724_MN4 (XI0_I724_n2 I0_A_0_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I724_MN3 (XI0_I724_xn I0_two4_b3_0 XI0_I724_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I724_MN1 (XI0_I724_n1 I0_one4_b3_0 XI0_I724_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I724_MN9 (VSS XI0_I724_xn XI0_I724_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I726_MN11 (VSS I0_B_9_b3_0 XI0_I726_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I726_MN14 (VSS XI0_I726_xbn XI0_I726_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I726_MN16 (XI0_I726_xn2 I0_B_9_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I726_MN15 (I0_pp4_3 XI0_I726_xan XI0_I726_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I726_MN13 (XI0_I726_xn1 XI0_I726_xn I0_pp4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I726_MN2 (VSS I0_A_3_b3_1 XI0_I726_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I726_MN4 (XI0_I726_n2 I0_A_2_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I726_MN3 (XI0_I726_xn I0_two4_b3_0 XI0_I726_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I726_MN1 (XI0_I726_n1 I0_one4_b3_0 XI0_I726_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I726_MN9 (VSS XI0_I726_xn XI0_I726_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I779_MN11 (VSS I0_B_11_b3_0 XI0_I779_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I779_MN14 (VSS XI0_I779_xbn XI0_I779_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I779_MN16 (XI0_I779_xn2 I0_B_11_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I779_MN15 (I0_pp5_1 XI0_I779_xan XI0_I779_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I779_MN13 (XI0_I779_xn1 XI0_I779_xn I0_pp5_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I779_MN2 (VSS I0_A_1_b3_1 XI0_I779_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I779_MN4 (XI0_I779_n2 I0_A_0_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I779_MN3 (XI0_I779_xn I0_two5_b3_0 XI0_I779_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I779_MN1 (XI0_I779_n1 I0_one5_b3_0 XI0_I779_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I779_MN9 (VSS XI0_I779_xn XI0_I779_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I781_MN11 (VSS I0_B_11_b3_0 XI0_I781_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I781_MN14 (VSS XI0_I781_xbn XI0_I781_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I781_MN16 (XI0_I781_xn2 I0_B_11_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I781_MN15 (I0_pp5_3 XI0_I781_xan XI0_I781_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I781_MN13 (XI0_I781_xn1 XI0_I781_xn I0_pp5_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I781_MN2 (VSS I0_A_3_b3_1 XI0_I781_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I781_MN4 (XI0_I781_n2 I0_A_2_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I781_MN3 (XI0_I781_xn I0_two5_b3_0 XI0_I781_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I781_MN1 (XI0_I781_n1 I0_one5_b3_0 XI0_I781_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I781_MN9 (VSS XI0_I781_xn XI0_I781_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I889_MN11 (VSS I0_B_15_b3_0 XI0_I889_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I889_MN14 (VSS XI0_I889_xbn XI0_I889_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I889_MN16 (XI0_I889_xn2 I0_B_15_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I889_MN15 (I0_pp7_1 XI0_I889_xan XI0_I889_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I889_MN13 (XI0_I889_xn1 XI0_I889_xn I0_pp7_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I889_MN2 (VSS I0_A_1_b3_2 XI0_I889_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I889_MN4 (XI0_I889_n2 I0_A_0_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I889_MN3 (XI0_I889_xn I0_two7_b3_0 XI0_I889_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I889_MN1 (XI0_I889_n1 I0_one7_b3_0 XI0_I889_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I889_MN9 (VSS XI0_I889_xn XI0_I889_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I833_MN11 (VSS I0_B_13_b3_0 XI0_I833_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I833_MN14 (VSS XI0_I833_xbn XI0_I833_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I833_MN16 (XI0_I833_xn2 I0_B_13_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I833_MN15 (I0_pp6_0 XI0_I833_xan XI0_I833_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I833_MN13 (XI0_I833_xn1 XI0_I833_xn I0_pp6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I833_MN2 (VSS I0_A_0_b3_2 XI0_I833_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I833_MN4 (XI0_I833_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I833_MN3 (XI0_I833_xn I0_two6_b3_0 XI0_I833_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I833_MN1 (XI0_I833_n1 I0_one6_b3_0 XI0_I833_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I833_MN9 (VSS XI0_I833_xn XI0_I833_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I835_MN11 (VSS I0_B_13_b3_0 XI0_I835_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I835_MN14 (VSS XI0_I835_xbn XI0_I835_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I835_MN16 (XI0_I835_xn2 I0_B_13_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I835_MN15 (I0_pp6_2 XI0_I835_xan XI0_I835_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I835_MN13 (XI0_I835_xn1 XI0_I835_xn I0_pp6_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I835_MN2 (VSS I0_A_2_b3_2 XI0_I835_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I835_MN4 (XI0_I835_n2 I0_A_1_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I835_MN3 (XI0_I835_xn I0_two6_b3_0 XI0_I835_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I835_MN1 (XI0_I835_n1 I0_one6_b3_0 XI0_I835_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I835_MN9 (VSS XI0_I835_xn XI0_I835_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I891_MN11 (VSS I0_B_15_b3_0 XI0_I891_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I891_MN14 (VSS XI0_I891_xbn XI0_I891_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I891_MN16 (XI0_I891_xn2 I0_B_15_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I891_MN15 (I0_pp7_3 XI0_I891_xan XI0_I891_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I891_MN13 (XI0_I891_xn1 XI0_I891_xn I0_pp7_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I891_MN2 (VSS I0_A_3_b3_2 XI0_I891_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I891_MN4 (XI0_I891_n2 I0_A_2_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I891_MN3 (XI0_I891_xn I0_two7_b3_0 XI0_I891_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I891_MN1 (XI0_I891_n1 I0_one7_b3_0 XI0_I891_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I891_MN9 (VSS XI0_I891_xn XI0_I891_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I836_MN11 (VSS I0_B_13_b3_0 XI0_I836_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I836_MN14 (VSS XI0_I836_xbn XI0_I836_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I836_MN16 (XI0_I836_xn2 I0_B_13_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I836_MN15 (I0_pp6_3 XI0_I836_xan XI0_I836_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I836_MN13 (XI0_I836_xn1 XI0_I836_xn I0_pp6_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I836_MN2 (VSS I0_A_3_b3_2 XI0_I836_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I836_MN4 (XI0_I836_n2 I0_A_2_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I836_MN3 (XI0_I836_xn I0_two6_b3_0 XI0_I836_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I836_MN1 (XI0_I836_n1 I0_one6_b3_0 XI0_I836_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I836_MN9 (VSS XI0_I836_xn XI0_I836_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I892_MN11 (VSS I0_B_15_b3_0 XI0_I892_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I892_MN14 (VSS XI0_I892_xbn XI0_I892_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I892_MN16 (XI0_I892_xn2 I0_B_15_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I892_MN15 (I0_pp7_4 XI0_I892_xan XI0_I892_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I892_MN13 (XI0_I892_xn1 XI0_I892_xn I0_pp7_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I892_MN2 (VSS I0_A_4_b3_2 XI0_I892_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I892_MN4 (XI0_I892_n2 I0_A_3_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I892_MN3 (XI0_I892_xn I0_two7_b3_0 XI0_I892_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I892_MN1 (XI0_I892_n1 I0_one7_b3_0 XI0_I892_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I892_MN9 (VSS XI0_I892_xn XI0_I892_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I955_MN11 (VSS I0_B_17_b3_2 XI0_I955_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I955_MN14 (VSS XI0_I955_xbn XI0_I955_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I955_MN16 (XI0_I955_xn2 I0_B_17_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I955_MN15 (I0_pp8_12 XI0_I955_xan XI0_I955_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I955_MN13 (XI0_I955_xn1 XI0_I955_xn I0_pp8_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I955_MN2 (VSS I0_A_12_b3_3 XI0_I955_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I955_MN4 (XI0_I955_n2 I0_A_11_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I955_MN3 (XI0_I955_xn I0_two8_b3_2 XI0_I955_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I955_MN1 (XI0_I955_n1 I0_one8_b3_2 XI0_I955_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I955_MN9 (VSS XI0_I955_xn XI0_I955_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I957_MN11 (VSS I0_B_17_b3_2 XI0_I957_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I957_MN14 (VSS XI0_I957_xbn XI0_I957_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I957_MN16 (XI0_I957_xn2 I0_B_17_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I957_MN15 (I0_pp8_14 XI0_I957_xan XI0_I957_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I957_MN13 (XI0_I957_xn1 XI0_I957_xn I0_pp8_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I957_MN2 (VSS I0_A_14_b3_3 XI0_I957_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I957_MN4 (XI0_I957_n2 I0_A_13_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I957_MN3 (XI0_I957_xn I0_two8_b3_2 XI0_I957_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I957_MN1 (XI0_I957_n1 I0_one8_b3_2 XI0_I957_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I957_MN9 (VSS XI0_I957_xn XI0_I957_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I958_MN11 (VSS I0_B_17_b3_2 XI0_I958_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I958_MN14 (VSS XI0_I958_xbn XI0_I958_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I958_MN16 (XI0_I958_xn2 I0_B_17_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I958_MN15 (I0_pp8_15 XI0_I958_xan XI0_I958_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I958_MN13 (XI0_I958_xn1 XI0_I958_xn I0_pp8_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I958_MN2 (VSS I0_A_15_b3_3 XI0_I958_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I958_MN4 (XI0_I958_n2 I0_A_14_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I958_MN3 (XI0_I958_xn I0_two8_b3_2 XI0_I958_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I958_MN1 (XI0_I958_n1 I0_one8_b3_2 XI0_I958_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I958_MN9 (VSS XI0_I958_xn XI0_I958_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1013_MN11 (VSS I0_B_19_b3_2 XI0_I1013_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1013_MN14 (VSS XI0_I1013_xbn XI0_I1013_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1013_MN16 (XI0_I1013_xn2 I0_B_19_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1013_MN15 (I0_pp9_15 XI0_I1013_xan XI0_I1013_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1013_MN13 (XI0_I1013_xn1 XI0_I1013_xn I0_pp9_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1013_MN2 (VSS I0_A_15_b3_3 XI0_I1013_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1013_MN4 (XI0_I1013_n2 I0_A_14_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1013_MN3 (XI0_I1013_xn I0_two9_b3_2 XI0_I1013_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1013_MN1 (XI0_I1013_n1 I0_one9_b3_2 XI0_I1013_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1013_MN9 (VSS XI0_I1013_xn XI0_I1013_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I961_MN11 (VSS I0_B_17_b3_3 XI0_I961_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I961_MN14 (VSS XI0_I961_xbn XI0_I961_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I961_MN16 (XI0_I961_xn2 I0_B_17_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I961_MN15 (I0_pp8_18 XI0_I961_xan XI0_I961_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I961_MN13 (XI0_I961_xn1 XI0_I961_xn I0_pp8_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I961_MN2 (VSS I0_A_18_b3_3 XI0_I961_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I961_MN4 (XI0_I961_n2 I0_A_17_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I961_MN3 (XI0_I961_xn I0_two8_b3_3 XI0_I961_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I961_MN1 (XI0_I961_n1 I0_one8_b3_3 XI0_I961_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I961_MN9 (VSS XI0_I961_xn XI0_I961_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I504_MN11 (VSS I0_B_1_b3_0 XI0_I504_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I504_MN14 (VSS XI0_I504_xbn XI0_I504_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I504_MN16 (XI0_I504_xn2 I0_B_1_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I504_MN15 (I0_pp0_1 XI0_I504_xan XI0_I504_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I504_MN13 (XI0_I504_xn1 XI0_I504_xn I0_pp0_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I504_MN2 (VSS I0_A_1_b3_0 XI0_I504_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I504_MN4 (XI0_I504_n2 I0_A_0_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I504_MN3 (XI0_I504_xn I0_two0_b3_0 XI0_I504_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I504_MN1 (XI0_I504_n1 I0_one0_b3_0 XI0_I504_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I504_MN9 (VSS XI0_I504_xn XI0_I504_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I503_MN11 (VSS I0_B_1_b3_0 XI0_I503_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I503_MN14 (VSS XI0_I503_xbn XI0_I503_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I503_MN16 (XI0_I503_xn2 I0_B_1_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I503_MN15 (I0_pp0_0 XI0_I503_xan XI0_I503_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I503_MN13 (XI0_I503_xn1 XI0_I503_xn I0_pp0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I503_MN2 (VSS I0_A_0_b3_0 XI0_I503_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I503_MN4 (XI0_I503_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I503_MN3 (XI0_I503_xn I0_two0_b3_0 XI0_I503_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I503_MN1 (XI0_I503_n1 I0_one0_b3_0 XI0_I503_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I503_MN9 (VSS XI0_I503_xn XI0_I503_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I506_MN11 (VSS I0_B_1_b3_0 XI0_I506_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I506_MN14 (VSS XI0_I506_xbn XI0_I506_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I506_MN16 (XI0_I506_xn2 I0_B_1_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I506_MN15 (I0_pp0_3 XI0_I506_xan XI0_I506_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I506_MN13 (XI0_I506_xn1 XI0_I506_xn I0_pp0_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I506_MN2 (VSS I0_A_3_b3_0 XI0_I506_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I506_MN4 (XI0_I506_n2 I0_A_2_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I506_MN3 (XI0_I506_xn I0_two0_b3_0 XI0_I506_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I506_MN1 (XI0_I506_n1 I0_one0_b3_0 XI0_I506_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I506_MN9 (VSS XI0_I506_xn XI0_I506_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I561_MN11 (VSS I0_B_3_b3_0 XI0_I561_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I561_MN14 (VSS XI0_I561_xbn XI0_I561_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I561_MN16 (XI0_I561_xn2 I0_B_3_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I561_MN15 (I0_pp1_3 XI0_I561_xan XI0_I561_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I561_MN13 (XI0_I561_xn1 XI0_I561_xn I0_pp1_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I561_MN2 (VSS I0_A_3_b3_0 XI0_I561_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I561_MN4 (XI0_I561_n2 I0_A_2_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I561_MN3 (XI0_I561_xn I0_two1_b3_0 XI0_I561_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I561_MN1 (XI0_I561_n1 I0_one1_b3_0 XI0_I561_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I561_MN9 (VSS XI0_I561_xn XI0_I561_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I560_MN11 (VSS I0_B_3_b3_0 XI0_I560_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I560_MN14 (VSS XI0_I560_xbn XI0_I560_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I560_MN16 (XI0_I560_xn2 I0_B_3_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I560_MN15 (I0_pp1_2 XI0_I560_xan XI0_I560_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I560_MN13 (XI0_I560_xn1 XI0_I560_xn I0_pp1_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I560_MN2 (VSS I0_A_2_b3_0 XI0_I560_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I560_MN4 (XI0_I560_n2 I0_A_1_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I560_MN3 (XI0_I560_xn I0_two1_b3_0 XI0_I560_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I560_MN1 (XI0_I560_n1 I0_one1_b3_0 XI0_I560_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I560_MN9 (VSS XI0_I560_xn XI0_I560_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I834_MN11 (VSS I0_B_13_b3_0 XI0_I834_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I834_MN14 (VSS XI0_I834_xbn XI0_I834_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I834_MN16 (XI0_I834_xn2 I0_B_13_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I834_MN15 (I0_pp6_1 XI0_I834_xan XI0_I834_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I834_MN13 (XI0_I834_xn1 XI0_I834_xn I0_pp6_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I834_MN2 (VSS I0_A_1_b3_2 XI0_I834_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I834_MN4 (XI0_I834_n2 I0_A_0_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I834_MN3 (XI0_I834_xn I0_two6_b3_0 XI0_I834_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I834_MN1 (XI0_I834_n1 I0_one6_b3_0 XI0_I834_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I834_MN9 (VSS XI0_I834_xn XI0_I834_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1063_MN11 (VSS I0_B_21_b3_1 XI0_I1063_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1063_MN14 (VSS XI0_I1063_xbn XI0_I1063_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1063_MN16 (XI0_I1063_xn2 I0_B_21_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1063_MN15 (I0_pp10_10 XI0_I1063_xan XI0_I1063_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1063_MN13 (XI0_I1063_xn1 XI0_I1063_xn I0_pp10_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1063_MN2 (VSS I0_A_10_b3_3 XI0_I1063_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1063_MN4 (XI0_I1063_n2 I0_A_9_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1063_MN3 (XI0_I1063_xn I0_two10_b3_1 XI0_I1063_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1063_MN1 (XI0_I1063_n1 I0_one10_b3_1 XI0_I1063_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1063_MN9 (VSS XI0_I1063_xn XI0_I1063_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1009_MN11 (VSS I0_B_19_b3_2 XI0_I1009_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1009_MN14 (VSS XI0_I1009_xbn XI0_I1009_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1009_MN16 (XI0_I1009_xn2 I0_B_19_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1009_MN15 (I0_pp9_11 XI0_I1009_xan XI0_I1009_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1009_MN13 (XI0_I1009_xn1 XI0_I1009_xn I0_pp9_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1009_MN2 (VSS I0_A_11_b3_3 XI0_I1009_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1009_MN4 (XI0_I1009_n2 I0_A_10_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1009_MN3 (XI0_I1009_xn I0_two9_b3_2 XI0_I1009_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1009_MN1 (XI0_I1009_n1 I0_one9_b3_2 XI0_I1009_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1009_MN9 (VSS XI0_I1009_xn XI0_I1009_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1010_MN11 (VSS I0_B_19_b3_2 XI0_I1010_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1010_MN14 (VSS XI0_I1010_xbn XI0_I1010_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1010_MN16 (XI0_I1010_xn2 I0_B_19_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1010_MN15 (I0_pp9_12 XI0_I1010_xan XI0_I1010_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1010_MN13 (XI0_I1010_xn1 XI0_I1010_xn I0_pp9_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1010_MN2 (VSS I0_A_12_b3_3 XI0_I1010_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1010_MN4 (XI0_I1010_n2 I0_A_11_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1010_MN3 (XI0_I1010_xn I0_two9_b3_2 XI0_I1010_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1010_MN1 (XI0_I1010_n1 I0_one9_b3_2 XI0_I1010_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1010_MN9 (VSS XI0_I1010_xn XI0_I1010_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I954_MN11 (VSS I0_B_17_b3_2 XI0_I954_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I954_MN14 (VSS XI0_I954_xbn XI0_I954_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I954_MN16 (XI0_I954_xn2 I0_B_17_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I954_MN15 (I0_pp8_11 XI0_I954_xan XI0_I954_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I954_MN13 (XI0_I954_xn1 XI0_I954_xn I0_pp8_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I954_MN2 (VSS I0_A_11_b3_3 XI0_I954_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I954_MN4 (XI0_I954_n2 I0_A_10_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I954_MN3 (XI0_I954_xn I0_two8_b3_2 XI0_I954_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I954_MN1 (XI0_I954_n1 I0_one8_b3_2 XI0_I954_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I954_MN9 (VSS XI0_I954_xn XI0_I954_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I956_MN11 (VSS I0_B_17_b3_2 XI0_I956_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I956_MN14 (VSS XI0_I956_xbn XI0_I956_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I956_MN16 (XI0_I956_xn2 I0_B_17_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I956_MN15 (I0_pp8_13 XI0_I956_xan XI0_I956_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I956_MN13 (XI0_I956_xn1 XI0_I956_xn I0_pp8_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I956_MN2 (VSS I0_A_13_b3_3 XI0_I956_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I956_MN4 (XI0_I956_n2 I0_A_12_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I956_MN3 (XI0_I956_xn I0_two8_b3_2 XI0_I956_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I956_MN1 (XI0_I956_n1 I0_one8_b3_2 XI0_I956_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I956_MN9 (VSS XI0_I956_xn XI0_I956_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1011_MN11 (VSS I0_B_19_b3_2 XI0_I1011_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1011_MN14 (VSS XI0_I1011_xbn XI0_I1011_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1011_MN16 (XI0_I1011_xn2 I0_B_19_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1011_MN15 (I0_pp9_13 XI0_I1011_xan XI0_I1011_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1011_MN13 (XI0_I1011_xn1 XI0_I1011_xn I0_pp9_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1011_MN2 (VSS I0_A_13_b3_3 XI0_I1011_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1011_MN4 (XI0_I1011_n2 I0_A_12_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1011_MN3 (XI0_I1011_xn I0_two9_b3_2 XI0_I1011_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1011_MN1 (XI0_I1011_n1 I0_one9_b3_2 XI0_I1011_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1011_MN9 (VSS XI0_I1011_xn XI0_I1011_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I959_MN11 (VSS I0_B_17_b3_2 XI0_I959_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I959_MN14 (VSS XI0_I959_xbn XI0_I959_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I959_MN16 (XI0_I959_xn2 I0_B_17_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I959_MN15 (I0_pp8_16 XI0_I959_xan XI0_I959_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I959_MN13 (XI0_I959_xn1 XI0_I959_xn I0_pp8_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I959_MN2 (VSS I0_A_16_b3_3 XI0_I959_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I959_MN4 (XI0_I959_n2 I0_A_15_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I959_MN3 (XI0_I959_xn I0_two8_b3_2 XI0_I959_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I959_MN1 (XI0_I959_n1 I0_one8_b3_2 XI0_I959_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I959_MN9 (VSS XI0_I959_xn XI0_I959_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1012_MN11 (VSS I0_B_19_b3_2 XI0_I1012_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1012_MN14 (VSS XI0_I1012_xbn XI0_I1012_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1012_MN16 (XI0_I1012_xn2 I0_B_19_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1012_MN15 (I0_pp9_14 XI0_I1012_xan XI0_I1012_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1012_MN13 (XI0_I1012_xn1 XI0_I1012_xn I0_pp9_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1012_MN2 (VSS I0_A_14_b3_3 XI0_I1012_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1012_MN4 (XI0_I1012_n2 I0_A_13_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1012_MN3 (XI0_I1012_xn I0_two9_b3_2 XI0_I1012_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1012_MN1 (XI0_I1012_n1 I0_one9_b3_2 XI0_I1012_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1012_MN9 (VSS XI0_I1012_xn XI0_I1012_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1014_MN11 (VSS I0_B_19_b3_2 XI0_I1014_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1014_MN14 (VSS XI0_I1014_xbn XI0_I1014_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1014_MN16 (XI0_I1014_xn2 I0_B_19_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1014_MN15 (I0_pp9_16 XI0_I1014_xan XI0_I1014_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1014_MN13 (XI0_I1014_xn1 XI0_I1014_xn I0_pp9_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1014_MN2 (VSS I0_A_16_b3_3 XI0_I1014_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1014_MN4 (XI0_I1014_n2 I0_A_15_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1014_MN3 (XI0_I1014_xn I0_two9_b3_2 XI0_I1014_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1014_MN1 (XI0_I1014_n1 I0_one9_b3_2 XI0_I1014_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1014_MN9 (VSS XI0_I1014_xn XI0_I1014_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1066_MN11 (VSS I0_B_21_b3_2 XI0_I1066_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1066_MN14 (VSS XI0_I1066_xbn XI0_I1066_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1066_MN16 (XI0_I1066_xn2 I0_B_21_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1066_MN15 (I0_pp10_13 XI0_I1066_xan XI0_I1066_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1066_MN13 (XI0_I1066_xn1 XI0_I1066_xn I0_pp10_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1066_MN2 (VSS I0_A_13_b3_3 XI0_I1066_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1066_MN4 (XI0_I1066_n2 I0_A_12_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1066_MN3 (XI0_I1066_xn I0_two10_b3_2 XI0_I1066_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1066_MN1 (XI0_I1066_n1 I0_one10_b3_2 XI0_I1066_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1066_MN9 (VSS XI0_I1066_xn XI0_I1066_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1067_MN11 (VSS I0_B_21_b3_2 XI0_I1067_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1067_MN14 (VSS XI0_I1067_xbn XI0_I1067_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1067_MN16 (XI0_I1067_xn2 I0_B_21_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1067_MN15 (I0_pp10_14 XI0_I1067_xan XI0_I1067_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1067_MN13 (XI0_I1067_xn1 XI0_I1067_xn I0_pp10_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1067_MN2 (VSS I0_A_14_b3_3 XI0_I1067_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1067_MN4 (XI0_I1067_n2 I0_A_13_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1067_MN3 (XI0_I1067_xn I0_two10_b3_2 XI0_I1067_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1067_MN1 (XI0_I1067_n1 I0_one10_b3_2 XI0_I1067_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1067_MN9 (VSS XI0_I1067_xn XI0_I1067_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1069_MN11 (VSS I0_B_21_b3_2 XI0_I1069_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1069_MN14 (VSS XI0_I1069_xbn XI0_I1069_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1069_MN16 (XI0_I1069_xn2 I0_B_21_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1069_MN15 (I0_pp10_16 XI0_I1069_xan XI0_I1069_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1069_MN13 (XI0_I1069_xn1 XI0_I1069_xn I0_pp10_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1069_MN2 (VSS I0_A_16_b3_3 XI0_I1069_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1069_MN4 (XI0_I1069_n2 I0_A_15_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1069_MN3 (XI0_I1069_xn I0_two10_b3_2 XI0_I1069_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1069_MN1 (XI0_I1069_n1 I0_one10_b3_2 XI0_I1069_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1069_MN9 (VSS XI0_I1069_xn XI0_I1069_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1068_MN11 (VSS I0_B_21_b3_2 XI0_I1068_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1068_MN14 (VSS XI0_I1068_xbn XI0_I1068_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1068_MN16 (XI0_I1068_xn2 I0_B_21_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1068_MN15 (I0_pp10_15 XI0_I1068_xan XI0_I1068_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1068_MN13 (XI0_I1068_xn1 XI0_I1068_xn I0_pp10_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1068_MN2 (VSS I0_A_15_b3_3 XI0_I1068_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1068_MN4 (XI0_I1068_n2 I0_A_14_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1068_MN3 (XI0_I1068_xn I0_two10_b3_2 XI0_I1068_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1068_MN1 (XI0_I1068_n1 I0_one10_b3_2 XI0_I1068_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1068_MN9 (VSS XI0_I1068_xn XI0_I1068_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I962_MN11 (VSS I0_B_17_b3_3 XI0_I962_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I962_MN14 (VSS XI0_I962_xbn XI0_I962_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I962_MN16 (XI0_I962_xn2 I0_B_17_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I962_MN15 (I0_pp8_19 XI0_I962_xan XI0_I962_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I962_MN13 (XI0_I962_xn1 XI0_I962_xn I0_pp8_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I962_MN2 (VSS I0_A_19_b3_3 XI0_I962_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I962_MN4 (XI0_I962_n2 I0_A_18_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I962_MN3 (XI0_I962_xn I0_two8_b3_3 XI0_I962_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I962_MN1 (XI0_I962_n1 I0_one8_b3_3 XI0_I962_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I962_MN9 (VSS XI0_I962_xn XI0_I962_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I960_MN11 (VSS I0_B_17_b3_3 XI0_I960_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I960_MN14 (VSS XI0_I960_xbn XI0_I960_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I960_MN16 (XI0_I960_xn2 I0_B_17_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I960_MN15 (I0_pp8_17 XI0_I960_xan XI0_I960_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I960_MN13 (XI0_I960_xn1 XI0_I960_xn I0_pp8_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I960_MN2 (VSS I0_A_17_b3_3 XI0_I960_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I960_MN4 (XI0_I960_n2 I0_A_16_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I960_MN3 (XI0_I960_xn I0_two8_b3_3 XI0_I960_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I960_MN1 (XI0_I960_n1 I0_one8_b3_3 XI0_I960_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I960_MN9 (VSS XI0_I960_xn XI0_I960_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1015_MN11 (VSS I0_B_19_b3_3 XI0_I1015_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1015_MN14 (VSS XI0_I1015_xbn XI0_I1015_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1015_MN16 (XI0_I1015_xn2 I0_B_19_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1015_MN15 (I0_pp9_17 XI0_I1015_xan XI0_I1015_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1015_MN13 (XI0_I1015_xn1 XI0_I1015_xn I0_pp9_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1015_MN2 (VSS I0_A_17_b3_3 XI0_I1015_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1015_MN4 (XI0_I1015_n2 I0_A_16_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1015_MN3 (XI0_I1015_xn I0_two9_b3_3 XI0_I1015_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1015_MN1 (XI0_I1015_n1 I0_one9_b3_3 XI0_I1015_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1015_MN9 (VSS XI0_I1015_xn XI0_I1015_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1017_MN11 (VSS I0_B_19_b3_3 XI0_I1017_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1017_MN14 (VSS XI0_I1017_xbn XI0_I1017_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1017_MN16 (XI0_I1017_xn2 I0_B_19_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1017_MN15 (I0_pp9_19 XI0_I1017_xan XI0_I1017_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1017_MN13 (XI0_I1017_xn1 XI0_I1017_xn I0_pp9_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1017_MN2 (VSS I0_A_19_b3_3 XI0_I1017_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1017_MN4 (XI0_I1017_n2 I0_A_18_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1017_MN3 (XI0_I1017_xn I0_two9_b3_3 XI0_I1017_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1017_MN1 (XI0_I1017_n1 I0_one9_b3_3 XI0_I1017_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1017_MN9 (VSS XI0_I1017_xn XI0_I1017_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I505_MN11 (VSS I0_B_1_b3_0 XI0_I505_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I505_MN14 (VSS XI0_I505_xbn XI0_I505_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I505_MN16 (XI0_I505_xn2 I0_B_1_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I505_MN15 (I0_pp0_2 XI0_I505_xan XI0_I505_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I505_MN13 (XI0_I505_xn1 XI0_I505_xn I0_pp0_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I505_MN2 (VSS I0_A_2_b3_0 XI0_I505_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I505_MN4 (XI0_I505_n2 I0_A_1_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I505_MN3 (XI0_I505_xn I0_two0_b3_0 XI0_I505_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I505_MN1 (XI0_I505_n1 I0_one0_b3_0 XI0_I505_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I505_MN9 (VSS XI0_I505_xn XI0_I505_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I559_MN11 (VSS I0_B_3_b3_0 XI0_I559_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I559_MN14 (VSS XI0_I559_xbn XI0_I559_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I559_MN16 (XI0_I559_xn2 I0_B_3_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I559_MN15 (I0_pp1_1 XI0_I559_xan XI0_I559_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I559_MN13 (XI0_I559_xn1 XI0_I559_xn I0_pp1_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I559_MN2 (VSS I0_A_1_b3_0 XI0_I559_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I559_MN4 (XI0_I559_n2 I0_A_0_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I559_MN3 (XI0_I559_xn I0_two1_b3_0 XI0_I559_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I559_MN1 (XI0_I559_n1 I0_one1_b3_0 XI0_I559_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I559_MN9 (VSS XI0_I559_xn XI0_I559_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I558_MN11 (VSS I0_B_3_b3_0 XI0_I558_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I558_MN14 (VSS XI0_I558_xbn XI0_I558_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I558_MN16 (XI0_I558_xn2 I0_B_3_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I558_MN15 (I0_pp1_0 XI0_I558_xan XI0_I558_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I558_MN13 (XI0_I558_xn1 XI0_I558_xn I0_pp1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I558_MN2 (VSS I0_A_0_b3_0 XI0_I558_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I558_MN4 (XI0_I558_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I558_MN3 (XI0_I558_xn I0_two1_b3_0 XI0_I558_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I558_MN1 (XI0_I558_n1 I0_one1_b3_0 XI0_I558_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I558_MN9 (VSS XI0_I558_xn XI0_I558_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1008_MN11 (VSS I0_B_19_b3_1 XI0_I1008_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1008_MN14 (VSS XI0_I1008_xbn XI0_I1008_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1008_MN16 (XI0_I1008_xn2 I0_B_19_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1008_MN15 (I0_pp9_10 XI0_I1008_xan XI0_I1008_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1008_MN13 (XI0_I1008_xn1 XI0_I1008_xn I0_pp9_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1008_MN2 (VSS I0_A_10_b3_3 XI0_I1008_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1008_MN4 (XI0_I1008_n2 I0_A_9_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1008_MN3 (XI0_I1008_xn I0_two9_b3_1 XI0_I1008_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1008_MN1 (XI0_I1008_n1 I0_one9_b3_1 XI0_I1008_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1008_MN9 (VSS XI0_I1008_xn XI0_I1008_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I953_MN11 (VSS I0_B_17_b3_1 XI0_I953_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I953_MN14 (VSS XI0_I953_xbn XI0_I953_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I953_MN16 (XI0_I953_xn2 I0_B_17_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I953_MN15 (I0_pp8_10 XI0_I953_xan XI0_I953_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I953_MN13 (XI0_I953_xn1 XI0_I953_xn I0_pp8_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I953_MN2 (VSS I0_A_10_b3_3 XI0_I953_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I953_MN4 (XI0_I953_n2 I0_A_9_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I953_MN3 (XI0_I953_xn I0_two8_b3_1 XI0_I953_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I953_MN1 (XI0_I953_n1 I0_one8_b3_1 XI0_I953_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I953_MN9 (VSS XI0_I953_xn XI0_I953_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I952_MN11 (VSS I0_B_17_b3_1 XI0_I952_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I952_MN14 (VSS XI0_I952_xbn XI0_I952_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I952_MN16 (XI0_I952_xn2 I0_B_17_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I952_MN15 (I0_pp8_9 XI0_I952_xan XI0_I952_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I952_MN13 (XI0_I952_xn1 XI0_I952_xn I0_pp8_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I952_MN2 (VSS I0_A_9_b3_3 XI0_I952_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I952_MN4 (XI0_I952_n2 I0_A_8_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I952_MN3 (XI0_I952_xn I0_two8_b3_1 XI0_I952_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I952_MN1 (XI0_I952_n1 I0_one8_b3_1 XI0_I952_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I952_MN9 (VSS XI0_I952_xn XI0_I952_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1006_MN11 (VSS I0_B_19_b3_1 XI0_I1006_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1006_MN14 (VSS XI0_I1006_xbn XI0_I1006_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1006_MN16 (XI0_I1006_xn2 I0_B_19_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1006_MN15 (I0_pp9_8 XI0_I1006_xan XI0_I1006_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1006_MN13 (XI0_I1006_xn1 XI0_I1006_xn I0_pp9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1006_MN2 (VSS I0_A_8_b3_3 XI0_I1006_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1006_MN4 (XI0_I1006_n2 I0_A_7_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1006_MN3 (XI0_I1006_xn I0_two9_b3_1 XI0_I1006_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1006_MN1 (XI0_I1006_n1 I0_one9_b3_1 XI0_I1006_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1006_MN9 (VSS XI0_I1006_xn XI0_I1006_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1061_MN11 (VSS I0_B_21_b3_1 XI0_I1061_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1061_MN14 (VSS XI0_I1061_xbn XI0_I1061_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1061_MN16 (XI0_I1061_xn2 I0_B_21_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1061_MN15 (I0_pp10_8 XI0_I1061_xan XI0_I1061_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1061_MN13 (XI0_I1061_xn1 XI0_I1061_xn I0_pp10_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1061_MN2 (VSS I0_A_8_b3_3 XI0_I1061_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1061_MN4 (XI0_I1061_n2 I0_A_7_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1061_MN3 (XI0_I1061_xn I0_two10_b3_1 XI0_I1061_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1061_MN1 (XI0_I1061_n1 I0_one10_b3_1 XI0_I1061_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1061_MN9 (VSS XI0_I1061_xn XI0_I1061_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1062_MN11 (VSS I0_B_21_b3_1 XI0_I1062_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1062_MN14 (VSS XI0_I1062_xbn XI0_I1062_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1062_MN16 (XI0_I1062_xn2 I0_B_21_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1062_MN15 (I0_pp10_9 XI0_I1062_xan XI0_I1062_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1062_MN13 (XI0_I1062_xn1 XI0_I1062_xn I0_pp10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1062_MN2 (VSS I0_A_9_b3_3 XI0_I1062_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1062_MN4 (XI0_I1062_n2 I0_A_8_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1062_MN3 (XI0_I1062_xn I0_two10_b3_1 XI0_I1062_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1062_MN1 (XI0_I1062_n1 I0_one10_b3_1 XI0_I1062_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1062_MN9 (VSS XI0_I1062_xn XI0_I1062_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1064_MN11 (VSS I0_B_21_b3_2 XI0_I1064_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1064_MN14 (VSS XI0_I1064_xbn XI0_I1064_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1064_MN16 (XI0_I1064_xn2 I0_B_21_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1064_MN15 (I0_pp10_11 XI0_I1064_xan XI0_I1064_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1064_MN13 (XI0_I1064_xn1 XI0_I1064_xn I0_pp10_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1064_MN2 (VSS I0_A_11_b3_3 XI0_I1064_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1064_MN4 (XI0_I1064_n2 I0_A_10_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1064_MN3 (XI0_I1064_xn I0_two10_b3_2 XI0_I1064_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1064_MN1 (XI0_I1064_n1 I0_one10_b3_2 XI0_I1064_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1064_MN9 (VSS XI0_I1064_xn XI0_I1064_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1065_MN11 (VSS I0_B_21_b3_2 XI0_I1065_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1065_MN14 (VSS XI0_I1065_xbn XI0_I1065_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1065_MN16 (XI0_I1065_xn2 I0_B_21_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1065_MN15 (I0_pp10_12 XI0_I1065_xan XI0_I1065_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1065_MN13 (XI0_I1065_xn1 XI0_I1065_xn I0_pp10_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1065_MN2 (VSS I0_A_12_b3_3 XI0_I1065_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1065_MN4 (XI0_I1065_n2 I0_A_11_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1065_MN3 (XI0_I1065_xn I0_two10_b3_2 XI0_I1065_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1065_MN1 (XI0_I1065_n1 I0_one10_b3_2 XI0_I1065_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1065_MN9 (VSS XI0_I1065_xn XI0_I1065_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I963_MN11 (VSS I0_B_17_b3_3 XI0_I963_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I963_MN14 (VSS XI0_I963_xbn XI0_I963_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I963_MN16 (XI0_I963_xn2 I0_B_17_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I963_MN15 (I0_pp8_20 XI0_I963_xan XI0_I963_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I963_MN13 (XI0_I963_xn1 XI0_I963_xn I0_pp8_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I963_MN2 (VSS I0_A_20_b3_3 XI0_I963_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I963_MN4 (XI0_I963_n2 I0_A_19_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I963_MN3 (XI0_I963_xn I0_two8_b3_3 XI0_I963_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I963_MN1 (XI0_I963_n1 I0_one8_b3_3 XI0_I963_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I963_MN9 (VSS XI0_I963_xn XI0_I963_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I964_MN11 (VSS I0_B_17_b3_3 XI0_I964_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I964_MN14 (VSS XI0_I964_xbn XI0_I964_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I964_MN16 (XI0_I964_xn2 I0_B_17_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I964_MN15 (I0_pp8_21 XI0_I964_xan XI0_I964_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I964_MN13 (XI0_I964_xn1 XI0_I964_xn I0_pp8_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I964_MN2 (VSS I0_A_21_b3_3 XI0_I964_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I964_MN4 (XI0_I964_n2 I0_A_20_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I964_MN3 (XI0_I964_xn I0_two8_b3_3 XI0_I964_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I964_MN1 (XI0_I964_n1 I0_one8_b3_3 XI0_I964_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I964_MN9 (VSS XI0_I964_xn XI0_I964_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1018_MN11 (VSS I0_B_19_b3_3 XI0_I1018_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1018_MN14 (VSS XI0_I1018_xbn XI0_I1018_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1018_MN16 (XI0_I1018_xn2 I0_B_19_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1018_MN15 (I0_pp9_20 XI0_I1018_xan XI0_I1018_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1018_MN13 (XI0_I1018_xn1 XI0_I1018_xn I0_pp9_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1018_MN2 (VSS I0_A_20_b3_3 XI0_I1018_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1018_MN4 (XI0_I1018_n2 I0_A_19_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1018_MN3 (XI0_I1018_xn I0_two9_b3_3 XI0_I1018_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1018_MN1 (XI0_I1018_n1 I0_one9_b3_3 XI0_I1018_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1018_MN9 (VSS XI0_I1018_xn XI0_I1018_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1016_MN11 (VSS I0_B_19_b3_3 XI0_I1016_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1016_MN14 (VSS XI0_I1016_xbn XI0_I1016_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1016_MN16 (XI0_I1016_xn2 I0_B_19_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1016_MN15 (I0_pp9_18 XI0_I1016_xan XI0_I1016_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1016_MN13 (XI0_I1016_xn1 XI0_I1016_xn I0_pp9_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1016_MN2 (VSS I0_A_18_b3_3 XI0_I1016_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1016_MN4 (XI0_I1016_n2 I0_A_17_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1016_MN3 (XI0_I1016_xn I0_two9_b3_3 XI0_I1016_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1016_MN1 (XI0_I1016_n1 I0_one9_b3_3 XI0_I1016_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1016_MN9 (VSS XI0_I1016_xn XI0_I1016_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I946_MN11 (VSS I0_B_17_b3_0 XI0_I946_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I946_MN14 (VSS XI0_I946_xbn XI0_I946_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I946_MN16 (XI0_I946_xn2 I0_B_17_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I946_MN15 (I0_pp8_3 XI0_I946_xan XI0_I946_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I946_MN13 (XI0_I946_xn1 XI0_I946_xn I0_pp8_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I946_MN2 (VSS I0_A_3_b3_3 XI0_I946_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I946_MN4 (XI0_I946_n2 I0_A_2_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I946_MN3 (XI0_I946_xn I0_two8_b3_0 XI0_I946_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I946_MN1 (XI0_I946_n1 I0_one8_b3_0 XI0_I946_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I946_MN9 (VSS XI0_I946_xn XI0_I946_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I947_MN11 (VSS I0_B_17_b3_0 XI0_I947_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I947_MN14 (VSS XI0_I947_xbn XI0_I947_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I947_MN16 (XI0_I947_xn2 I0_B_17_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I947_MN15 (I0_pp8_4 XI0_I947_xan XI0_I947_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I947_MN13 (XI0_I947_xn1 XI0_I947_xn I0_pp8_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I947_MN2 (VSS I0_A_4_b3_3 XI0_I947_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I947_MN4 (XI0_I947_n2 I0_A_3_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I947_MN3 (XI0_I947_xn I0_two8_b3_0 XI0_I947_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I947_MN1 (XI0_I947_n1 I0_one8_b3_0 XI0_I947_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I947_MN9 (VSS XI0_I947_xn XI0_I947_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I948_MN11 (VSS I0_B_17_b3_1 XI0_I948_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I948_MN14 (VSS XI0_I948_xbn XI0_I948_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I948_MN16 (XI0_I948_xn2 I0_B_17_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I948_MN15 (I0_pp8_5 XI0_I948_xan XI0_I948_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I948_MN13 (XI0_I948_xn1 XI0_I948_xn I0_pp8_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I948_MN2 (VSS I0_A_5_b3_3 XI0_I948_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I948_MN4 (XI0_I948_n2 I0_A_4_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I948_MN3 (XI0_I948_xn I0_two8_b3_0 XI0_I948_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I948_MN1 (XI0_I948_n1 I0_one8_b3_0 XI0_I948_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I948_MN9 (VSS XI0_I948_xn XI0_I948_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1007_MN11 (VSS I0_B_19_b3_1 XI0_I1007_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1007_MN14 (VSS XI0_I1007_xbn XI0_I1007_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1007_MN16 (XI0_I1007_xn2 I0_B_19_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1007_MN15 (I0_pp9_9 XI0_I1007_xan XI0_I1007_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1007_MN13 (XI0_I1007_xn1 XI0_I1007_xn I0_pp9_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1007_MN2 (VSS I0_A_9_b3_3 XI0_I1007_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1007_MN4 (XI0_I1007_n2 I0_A_8_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1007_MN3 (XI0_I1007_xn I0_two9_b3_1 XI0_I1007_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1007_MN1 (XI0_I1007_n1 I0_one9_b3_1 XI0_I1007_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1007_MN9 (VSS XI0_I1007_xn XI0_I1007_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I951_MN11 (VSS I0_B_17_b3_1 XI0_I951_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I951_MN14 (VSS XI0_I951_xbn XI0_I951_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I951_MN16 (XI0_I951_xn2 I0_B_17_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I951_MN15 (I0_pp8_8 XI0_I951_xan XI0_I951_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I951_MN13 (XI0_I951_xn1 XI0_I951_xn I0_pp8_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I951_MN2 (VSS I0_A_8_b3_3 XI0_I951_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I951_MN4 (XI0_I951_n2 I0_A_7_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I951_MN3 (XI0_I951_xn I0_two8_b3_1 XI0_I951_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I951_MN1 (XI0_I951_n1 I0_one8_b3_1 XI0_I951_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I951_MN9 (VSS XI0_I951_xn XI0_I951_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1058_MN11 (VSS I0_B_21_b3_1 XI0_I1058_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1058_MN14 (VSS XI0_I1058_xbn XI0_I1058_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1058_MN16 (XI0_I1058_xn2 I0_B_21_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1058_MN15 (I0_pp10_5 XI0_I1058_xan XI0_I1058_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1058_MN13 (XI0_I1058_xn1 XI0_I1058_xn I0_pp10_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1058_MN2 (VSS I0_A_5_b3_3 XI0_I1058_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1058_MN4 (XI0_I1058_n2 I0_A_4_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1058_MN3 (XI0_I1058_xn I0_two10_b3_0 XI0_I1058_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1058_MN1 (XI0_I1058_n1 I0_one10_b3_0 XI0_I1058_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1058_MN9 (VSS XI0_I1058_xn XI0_I1058_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1059_MN11 (VSS I0_B_21_b3_1 XI0_I1059_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1059_MN14 (VSS XI0_I1059_xbn XI0_I1059_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1059_MN16 (XI0_I1059_xn2 I0_B_21_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1059_MN15 (I0_pp10_6 XI0_I1059_xan XI0_I1059_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1059_MN13 (XI0_I1059_xn1 XI0_I1059_xn I0_pp10_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1059_MN2 (VSS I0_A_6_b3_3 XI0_I1059_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1059_MN4 (XI0_I1059_n2 I0_A_5_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1059_MN3 (XI0_I1059_xn I0_two10_b3_1 XI0_I1059_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1059_MN1 (XI0_I1059_n1 I0_one10_b3_1 XI0_I1059_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1059_MN9 (VSS XI0_I1059_xn XI0_I1059_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1060_MN11 (VSS I0_B_21_b3_1 XI0_I1060_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1060_MN14 (VSS XI0_I1060_xbn XI0_I1060_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1060_MN16 (XI0_I1060_xn2 I0_B_21_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1060_MN15 (I0_pp10_7 XI0_I1060_xan XI0_I1060_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1060_MN13 (XI0_I1060_xn1 XI0_I1060_xn I0_pp10_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1060_MN2 (VSS I0_A_7_b3_3 XI0_I1060_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1060_MN4 (XI0_I1060_n2 I0_A_6_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1060_MN3 (XI0_I1060_xn I0_two10_b3_1 XI0_I1060_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1060_MN1 (XI0_I1060_n1 I0_one10_b3_1 XI0_I1060_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1060_MN9 (VSS XI0_I1060_xn XI0_I1060_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1117_MN11 (VSS I0_B_23_b3_1 XI0_I1117_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1117_MN14 (VSS XI0_I1117_xbn XI0_I1117_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1117_MN16 (XI0_I1117_xn2 I0_B_23_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1117_MN15 (I0_pp11_9 XI0_I1117_xan XI0_I1117_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1117_MN13 (XI0_I1117_xn1 XI0_I1117_xn I0_pp11_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1117_MN2 (VSS I0_A_9_b3_4 XI0_I1117_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1117_MN4 (XI0_I1117_n2 I0_A_8_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1117_MN3 (XI0_I1117_xn I0_two11_b3_1 XI0_I1117_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1117_MN1 (XI0_I1117_n1 I0_one11_b3_1 XI0_I1117_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1117_MN9 (VSS XI0_I1117_xn XI0_I1117_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1118_MN11 (VSS I0_B_23_b3_1 XI0_I1118_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1118_MN14 (VSS XI0_I1118_xbn XI0_I1118_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1118_MN16 (XI0_I1118_xn2 I0_B_23_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1118_MN15 (I0_pp11_10 XI0_I1118_xan XI0_I1118_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1118_MN13 (XI0_I1118_xn1 XI0_I1118_xn I0_pp11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1118_MN2 (VSS I0_A_10_b3_4 XI0_I1118_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1118_MN4 (XI0_I1118_n2 I0_A_9_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1118_MN3 (XI0_I1118_xn I0_two11_b3_1 XI0_I1118_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1118_MN1 (XI0_I1118_n1 I0_one11_b3_1 XI0_I1118_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1118_MN9 (VSS XI0_I1118_xn XI0_I1118_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1116_MN11 (VSS I0_B_23_b3_1 XI0_I1116_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1116_MN14 (VSS XI0_I1116_xbn XI0_I1116_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1116_MN16 (XI0_I1116_xn2 I0_B_23_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1116_MN15 (I0_pp11_8 XI0_I1116_xan XI0_I1116_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1116_MN13 (XI0_I1116_xn1 XI0_I1116_xn I0_pp11_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1116_MN2 (VSS I0_A_8_b3_4 XI0_I1116_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1116_MN4 (XI0_I1116_n2 I0_A_7_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1116_MN3 (XI0_I1116_xn I0_two11_b3_1 XI0_I1116_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1116_MN1 (XI0_I1116_n1 I0_one11_b3_1 XI0_I1116_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1116_MN9 (VSS XI0_I1116_xn XI0_I1116_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1119_MN11 (VSS I0_B_23_b3_2 XI0_I1119_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1119_MN14 (VSS XI0_I1119_xbn XI0_I1119_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1119_MN16 (XI0_I1119_xn2 I0_B_23_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1119_MN15 (I0_pp11_11 XI0_I1119_xan XI0_I1119_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1119_MN13 (XI0_I1119_xn1 XI0_I1119_xn I0_pp11_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1119_MN2 (VSS I0_A_11_b3_4 XI0_I1119_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1119_MN4 (XI0_I1119_n2 I0_A_10_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1119_MN3 (XI0_I1119_xn I0_two11_b3_2 XI0_I1119_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1119_MN1 (XI0_I1119_n1 I0_one11_b3_2 XI0_I1119_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1119_MN9 (VSS XI0_I1119_xn XI0_I1119_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1120_MN11 (VSS I0_B_23_b3_2 XI0_I1120_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1120_MN14 (VSS XI0_I1120_xbn XI0_I1120_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1120_MN16 (XI0_I1120_xn2 I0_B_23_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1120_MN15 (I0_pp11_12 XI0_I1120_xan XI0_I1120_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1120_MN13 (XI0_I1120_xn1 XI0_I1120_xn I0_pp11_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1120_MN2 (VSS I0_A_12_b3_4 XI0_I1120_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1120_MN4 (XI0_I1120_n2 I0_A_11_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1120_MN3 (XI0_I1120_xn I0_two11_b3_2 XI0_I1120_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1120_MN1 (XI0_I1120_n1 I0_one11_b3_2 XI0_I1120_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1120_MN9 (VSS XI0_I1120_xn XI0_I1120_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1121_MN11 (VSS I0_B_23_b3_2 XI0_I1121_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1121_MN14 (VSS XI0_I1121_xbn XI0_I1121_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1121_MN16 (XI0_I1121_xn2 I0_B_23_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1121_MN15 (I0_pp11_13 XI0_I1121_xan XI0_I1121_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1121_MN13 (XI0_I1121_xn1 XI0_I1121_xn I0_pp11_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1121_MN2 (VSS I0_A_13_b3_4 XI0_I1121_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1121_MN4 (XI0_I1121_n2 I0_A_12_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1121_MN3 (XI0_I1121_xn I0_two11_b3_2 XI0_I1121_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1121_MN1 (XI0_I1121_n1 I0_one11_b3_2 XI0_I1121_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1121_MN9 (VSS XI0_I1121_xn XI0_I1121_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1122_MN11 (VSS I0_B_23_b3_2 XI0_I1122_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1122_MN14 (VSS XI0_I1122_xbn XI0_I1122_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1122_MN16 (XI0_I1122_xn2 I0_B_23_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1122_MN15 (I0_pp11_14 XI0_I1122_xan XI0_I1122_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1122_MN13 (XI0_I1122_xn1 XI0_I1122_xn I0_pp11_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1122_MN2 (VSS I0_A_14_b3_4 XI0_I1122_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1122_MN4 (XI0_I1122_n2 I0_A_13_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1122_MN3 (XI0_I1122_xn I0_two11_b3_2 XI0_I1122_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1122_MN1 (XI0_I1122_n1 I0_one11_b3_2 XI0_I1122_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1122_MN9 (VSS XI0_I1122_xn XI0_I1122_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1070_MN11 (VSS I0_B_21_b3_3 XI0_I1070_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1070_MN14 (VSS XI0_I1070_xbn XI0_I1070_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1070_MN16 (XI0_I1070_xn2 I0_B_21_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1070_MN15 (I0_pp10_17 XI0_I1070_xan XI0_I1070_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1070_MN13 (XI0_I1070_xn1 XI0_I1070_xn I0_pp10_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1070_MN2 (VSS I0_A_17_b3_3 XI0_I1070_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1070_MN4 (XI0_I1070_n2 I0_A_16_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1070_MN3 (XI0_I1070_xn I0_two10_b3_3 XI0_I1070_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1070_MN1 (XI0_I1070_n1 I0_one10_b3_3 XI0_I1070_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1070_MN9 (VSS XI0_I1070_xn XI0_I1070_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1071_MN11 (VSS I0_B_21_b3_3 XI0_I1071_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1071_MN14 (VSS XI0_I1071_xbn XI0_I1071_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1071_MN16 (XI0_I1071_xn2 I0_B_21_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1071_MN15 (I0_pp10_18 XI0_I1071_xan XI0_I1071_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1071_MN13 (XI0_I1071_xn1 XI0_I1071_xn I0_pp10_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1071_MN2 (VSS I0_A_18_b3_3 XI0_I1071_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1071_MN4 (XI0_I1071_n2 I0_A_17_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1071_MN3 (XI0_I1071_xn I0_two10_b3_3 XI0_I1071_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1071_MN1 (XI0_I1071_n1 I0_one10_b3_3 XI0_I1071_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1071_MN9 (VSS XI0_I1071_xn XI0_I1071_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1019_MN11 (VSS I0_B_19_b3_3 XI0_I1019_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1019_MN14 (VSS XI0_I1019_xbn XI0_I1019_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1019_MN16 (XI0_I1019_xn2 I0_B_19_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1019_MN15 (I0_pp9_21 XI0_I1019_xan XI0_I1019_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1019_MN13 (XI0_I1019_xn1 XI0_I1019_xn I0_pp9_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1019_MN2 (VSS I0_A_21_b3_3 XI0_I1019_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1019_MN4 (XI0_I1019_n2 I0_A_20_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1019_MN3 (XI0_I1019_xn I0_two9_b3_3 XI0_I1019_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1019_MN1 (XI0_I1019_n1 I0_one9_b3_3 XI0_I1019_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1019_MN9 (VSS XI0_I1019_xn XI0_I1019_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I945_MN11 (VSS I0_B_17_b3_0 XI0_I945_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I945_MN14 (VSS XI0_I945_xbn XI0_I945_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I945_MN16 (XI0_I945_xn2 I0_B_17_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I945_MN15 (I0_pp8_2 XI0_I945_xan XI0_I945_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I945_MN13 (XI0_I945_xn1 XI0_I945_xn I0_pp8_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I945_MN2 (VSS I0_A_2_b3_3 XI0_I945_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I945_MN4 (XI0_I945_n2 I0_A_1_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I945_MN3 (XI0_I945_xn I0_two8_b3_0 XI0_I945_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I945_MN1 (XI0_I945_n1 I0_one8_b3_0 XI0_I945_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I945_MN9 (VSS XI0_I945_xn XI0_I945_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I943_MN11 (VSS I0_B_17_b3_0 XI0_I943_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I943_MN14 (VSS XI0_I943_xbn XI0_I943_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I943_MN16 (XI0_I943_xn2 I0_B_17_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I943_MN15 (I0_pp8_0 XI0_I943_xan XI0_I943_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I943_MN13 (XI0_I943_xn1 XI0_I943_xn I0_pp8_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I943_MN2 (VSS I0_A_0_b3_3 XI0_I943_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I943_MN4 (XI0_I943_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I943_MN3 (XI0_I943_xn I0_two8_b3_0 XI0_I943_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I943_MN1 (XI0_I943_n1 I0_one8_b3_0 XI0_I943_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I943_MN9 (VSS XI0_I943_xn XI0_I943_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I944_MN11 (VSS I0_B_17_b3_0 XI0_I944_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I944_MN14 (VSS XI0_I944_xbn XI0_I944_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I944_MN16 (XI0_I944_xn2 I0_B_17_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I944_MN15 (I0_pp8_1 XI0_I944_xan XI0_I944_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I944_MN13 (XI0_I944_xn1 XI0_I944_xn I0_pp8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I944_MN2 (VSS I0_A_1_b3_3 XI0_I944_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I944_MN4 (XI0_I944_n2 I0_A_0_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I944_MN3 (XI0_I944_xn I0_two8_b3_0 XI0_I944_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I944_MN1 (XI0_I944_n1 I0_one8_b3_0 XI0_I944_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I944_MN9 (VSS XI0_I944_xn XI0_I944_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1053_MN11 (VSS I0_B_21_b3_0 XI0_I1053_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1053_MN14 (VSS XI0_I1053_xbn XI0_I1053_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1053_MN16 (XI0_I1053_xn2 I0_B_21_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1053_MN15 (I0_pp10_0 XI0_I1053_xan XI0_I1053_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1053_MN13 (XI0_I1053_xn1 XI0_I1053_xn I0_pp10_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1053_MN2 (VSS I0_A_0_b3_3 XI0_I1053_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1053_MN4 (XI0_I1053_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1053_MN3 (XI0_I1053_xn I0_two10_b3_0 XI0_I1053_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1053_MN1 (XI0_I1053_n1 I0_one10_b3_0 XI0_I1053_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1053_MN9 (VSS XI0_I1053_xn XI0_I1053_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1054_MN11 (VSS I0_B_21_b3_0 XI0_I1054_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1054_MN14 (VSS XI0_I1054_xbn XI0_I1054_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1054_MN16 (XI0_I1054_xn2 I0_B_21_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1054_MN15 (I0_pp10_1 XI0_I1054_xan XI0_I1054_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1054_MN13 (XI0_I1054_xn1 XI0_I1054_xn I0_pp10_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1054_MN2 (VSS I0_A_1_b3_3 XI0_I1054_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1054_MN4 (XI0_I1054_n2 I0_A_0_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1054_MN3 (XI0_I1054_xn I0_two10_b3_0 XI0_I1054_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1054_MN1 (XI0_I1054_n1 I0_one10_b3_0 XI0_I1054_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1054_MN9 (VSS XI0_I1054_xn XI0_I1054_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1055_MN11 (VSS I0_B_21_b3_0 XI0_I1055_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1055_MN14 (VSS XI0_I1055_xbn XI0_I1055_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1055_MN16 (XI0_I1055_xn2 I0_B_21_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1055_MN15 (I0_pp10_2 XI0_I1055_xan XI0_I1055_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1055_MN13 (XI0_I1055_xn1 XI0_I1055_xn I0_pp10_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1055_MN2 (VSS I0_A_2_b3_3 XI0_I1055_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1055_MN4 (XI0_I1055_n2 I0_A_1_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1055_MN3 (XI0_I1055_xn I0_two10_b3_0 XI0_I1055_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1055_MN1 (XI0_I1055_n1 I0_one10_b3_0 XI0_I1055_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1055_MN9 (VSS XI0_I1055_xn XI0_I1055_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I950_MN11 (VSS I0_B_17_b3_1 XI0_I950_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I950_MN14 (VSS XI0_I950_xbn XI0_I950_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I950_MN16 (XI0_I950_xn2 I0_B_17_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I950_MN15 (I0_pp8_7 XI0_I950_xan XI0_I950_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I950_MN13 (XI0_I950_xn1 XI0_I950_xn I0_pp8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I950_MN2 (VSS I0_A_7_b3_3 XI0_I950_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I950_MN4 (XI0_I950_n2 I0_A_6_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I950_MN3 (XI0_I950_xn I0_two8_b3_1 XI0_I950_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I950_MN1 (XI0_I950_n1 I0_one8_b3_1 XI0_I950_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I950_MN9 (VSS XI0_I950_xn XI0_I950_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1057_MN11 (VSS I0_B_21_b3_0 XI0_I1057_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1057_MN14 (VSS XI0_I1057_xbn XI0_I1057_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1057_MN16 (XI0_I1057_xn2 I0_B_21_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1057_MN15 (I0_pp10_4 XI0_I1057_xan XI0_I1057_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1057_MN13 (XI0_I1057_xn1 XI0_I1057_xn I0_pp10_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1057_MN2 (VSS I0_A_4_b3_3 XI0_I1057_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1057_MN4 (XI0_I1057_n2 I0_A_3_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1057_MN3 (XI0_I1057_xn I0_two10_b3_0 XI0_I1057_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1057_MN1 (XI0_I1057_n1 I0_one10_b3_0 XI0_I1057_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1057_MN9 (VSS XI0_I1057_xn XI0_I1057_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1002_MN11 (VSS I0_B_19_b3_0 XI0_I1002_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1002_MN14 (VSS XI0_I1002_xbn XI0_I1002_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1002_MN16 (XI0_I1002_xn2 I0_B_19_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1002_MN15 (I0_pp9_4 XI0_I1002_xan XI0_I1002_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1002_MN13 (XI0_I1002_xn1 XI0_I1002_xn I0_pp9_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1002_MN2 (VSS I0_A_4_b3_3 XI0_I1002_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1002_MN4 (XI0_I1002_n2 I0_A_3_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1002_MN3 (XI0_I1002_xn I0_two9_b3_0 XI0_I1002_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1002_MN1 (XI0_I1002_n1 I0_one9_b3_0 XI0_I1002_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1002_MN9 (VSS XI0_I1002_xn XI0_I1002_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1003_MN11 (VSS I0_B_19_b3_1 XI0_I1003_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1003_MN14 (VSS XI0_I1003_xbn XI0_I1003_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1003_MN16 (XI0_I1003_xn2 I0_B_19_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1003_MN15 (I0_pp9_5 XI0_I1003_xan XI0_I1003_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1003_MN13 (XI0_I1003_xn1 XI0_I1003_xn I0_pp9_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1003_MN2 (VSS I0_A_5_b3_3 XI0_I1003_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1003_MN4 (XI0_I1003_n2 I0_A_4_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1003_MN3 (XI0_I1003_xn I0_two9_b3_0 XI0_I1003_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1003_MN1 (XI0_I1003_n1 I0_one9_b3_0 XI0_I1003_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1003_MN9 (VSS XI0_I1003_xn XI0_I1003_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1004_MN11 (VSS I0_B_19_b3_1 XI0_I1004_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1004_MN14 (VSS XI0_I1004_xbn XI0_I1004_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1004_MN16 (XI0_I1004_xn2 I0_B_19_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1004_MN15 (I0_pp9_6 XI0_I1004_xan XI0_I1004_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1004_MN13 (XI0_I1004_xn1 XI0_I1004_xn I0_pp9_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1004_MN2 (VSS I0_A_6_b3_3 XI0_I1004_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1004_MN4 (XI0_I1004_n2 I0_A_5_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1004_MN3 (XI0_I1004_xn I0_two9_b3_1 XI0_I1004_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1004_MN1 (XI0_I1004_n1 I0_one9_b3_1 XI0_I1004_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1004_MN9 (VSS XI0_I1004_xn XI0_I1004_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1005_MN11 (VSS I0_B_19_b3_1 XI0_I1005_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1005_MN14 (VSS XI0_I1005_xbn XI0_I1005_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1005_MN16 (XI0_I1005_xn2 I0_B_19_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1005_MN15 (I0_pp9_7 XI0_I1005_xan XI0_I1005_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1005_MN13 (XI0_I1005_xn1 XI0_I1005_xn I0_pp9_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1005_MN2 (VSS I0_A_7_b3_3 XI0_I1005_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1005_MN4 (XI0_I1005_n2 I0_A_6_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1005_MN3 (XI0_I1005_xn I0_two9_b3_1 XI0_I1005_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1005_MN1 (XI0_I1005_n1 I0_one9_b3_1 XI0_I1005_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1005_MN9 (VSS XI0_I1005_xn XI0_I1005_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1115_MN11 (VSS I0_B_23_b3_1 XI0_I1115_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1115_MN14 (VSS XI0_I1115_xbn XI0_I1115_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1115_MN16 (XI0_I1115_xn2 I0_B_23_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1115_MN15 (I0_pp11_7 XI0_I1115_xan XI0_I1115_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1115_MN13 (XI0_I1115_xn1 XI0_I1115_xn I0_pp11_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1115_MN2 (VSS I0_A_7_b3_4 XI0_I1115_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1115_MN4 (XI0_I1115_n2 I0_A_6_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1115_MN3 (XI0_I1115_xn I0_two11_b3_1 XI0_I1115_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1115_MN1 (XI0_I1115_n1 I0_one11_b3_1 XI0_I1115_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1115_MN9 (VSS XI0_I1115_xn XI0_I1115_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1172_MN11 (VSS I0_B_25_b3_1 XI0_I1172_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1172_MN14 (VSS XI0_I1172_xbn XI0_I1172_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1172_MN16 (XI0_I1172_xn2 I0_B_25_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1172_MN15 (I0_pp12_9 XI0_I1172_xan XI0_I1172_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1172_MN13 (XI0_I1172_xn1 XI0_I1172_xn I0_pp12_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1172_MN2 (VSS I0_A_9_b3_4 XI0_I1172_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1172_MN4 (XI0_I1172_n2 I0_A_8_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1172_MN3 (XI0_I1172_xn I0_two12_b3_1 XI0_I1172_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1172_MN1 (XI0_I1172_n1 I0_one12_b3_1 XI0_I1172_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1172_MN9 (VSS XI0_I1172_xn XI0_I1172_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1173_MN11 (VSS I0_B_25_b3_1 XI0_I1173_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1173_MN14 (VSS XI0_I1173_xbn XI0_I1173_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1173_MN16 (XI0_I1173_xn2 I0_B_25_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1173_MN15 (I0_pp12_10 XI0_I1173_xan XI0_I1173_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1173_MN13 (XI0_I1173_xn1 XI0_I1173_xn I0_pp12_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1173_MN2 (VSS I0_A_10_b3_4 XI0_I1173_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1173_MN4 (XI0_I1173_n2 I0_A_9_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1173_MN3 (XI0_I1173_xn I0_two12_b3_1 XI0_I1173_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1173_MN1 (XI0_I1173_n1 I0_one12_b3_1 XI0_I1173_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1173_MN9 (VSS XI0_I1173_xn XI0_I1173_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1227_MN11 (VSS I0_B_27_b3_1 XI0_I1227_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1227_MN14 (VSS XI0_I1227_xbn XI0_I1227_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1227_MN16 (XI0_I1227_xn2 I0_B_27_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1227_MN15 (I0_pp13_9 XI0_I1227_xan XI0_I1227_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1227_MN13 (XI0_I1227_xn1 XI0_I1227_xn I0_pp13_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1227_MN2 (VSS I0_A_9_b3_4 XI0_I1227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1227_MN4 (XI0_I1227_n2 I0_A_8_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1227_MN3 (XI0_I1227_xn I0_two13_b3_1 XI0_I1227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1227_MN1 (XI0_I1227_n1 I0_one13_b3_1 XI0_I1227_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1227_MN9 (VSS XI0_I1227_xn XI0_I1227_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1280_MN11 (VSS I0_B_29_b3_1 XI0_I1280_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1280_MN14 (VSS XI0_I1280_xbn XI0_I1280_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1280_MN16 (XI0_I1280_xn2 I0_B_29_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1280_MN15 (I0_pp14_7 XI0_I1280_xan XI0_I1280_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1280_MN13 (XI0_I1280_xn1 XI0_I1280_xn I0_pp14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1280_MN2 (VSS I0_A_7_b3_5 XI0_I1280_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1280_MN4 (XI0_I1280_n2 I0_A_6_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1280_MN3 (XI0_I1280_xn I0_two14_b3_1 XI0_I1280_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1280_MN1 (XI0_I1280_n1 I0_one14_b3_1 XI0_I1280_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1280_MN9 (VSS XI0_I1280_xn XI0_I1280_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1174_MN11 (VSS I0_B_25_b3_2 XI0_I1174_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1174_MN14 (VSS XI0_I1174_xbn XI0_I1174_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1174_MN16 (XI0_I1174_xn2 I0_B_25_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1174_MN15 (I0_pp12_11 XI0_I1174_xan XI0_I1174_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1174_MN13 (XI0_I1174_xn1 XI0_I1174_xn I0_pp12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1174_MN2 (VSS I0_A_11_b3_4 XI0_I1174_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1174_MN4 (XI0_I1174_n2 I0_A_10_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1174_MN3 (XI0_I1174_xn I0_two12_b3_2 XI0_I1174_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1174_MN1 (XI0_I1174_n1 I0_one12_b3_2 XI0_I1174_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1174_MN9 (VSS XI0_I1174_xn XI0_I1174_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1283_MN11 (VSS I0_B_29_b3_1 XI0_I1283_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1283_MN14 (VSS XI0_I1283_xbn XI0_I1283_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1283_MN16 (XI0_I1283_xn2 I0_B_29_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1283_MN15 (I0_pp14_10 XI0_I1283_xan XI0_I1283_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1283_MN13 (XI0_I1283_xn1 XI0_I1283_xn I0_pp14_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1283_MN2 (VSS I0_A_10_b3_5 XI0_I1283_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1283_MN4 (XI0_I1283_n2 I0_A_9_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1283_MN3 (XI0_I1283_xn I0_two14_b3_1 XI0_I1283_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1283_MN1 (XI0_I1283_n1 I0_one14_b3_1 XI0_I1283_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1283_MN9 (VSS XI0_I1283_xn XI0_I1283_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1175_MN11 (VSS I0_B_25_b3_2 XI0_I1175_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1175_MN14 (VSS XI0_I1175_xbn XI0_I1175_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1175_MN16 (XI0_I1175_xn2 I0_B_25_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1175_MN15 (I0_pp12_12 XI0_I1175_xan XI0_I1175_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1175_MN13 (XI0_I1175_xn1 XI0_I1175_xn I0_pp12_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1175_MN2 (VSS I0_A_12_b3_4 XI0_I1175_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1175_MN4 (XI0_I1175_n2 I0_A_11_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1175_MN3 (XI0_I1175_xn I0_two12_b3_2 XI0_I1175_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1175_MN1 (XI0_I1175_n1 I0_one12_b3_2 XI0_I1175_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1175_MN9 (VSS XI0_I1175_xn XI0_I1175_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1229_MN11 (VSS I0_B_27_b3_2 XI0_I1229_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1229_MN14 (VSS XI0_I1229_xbn XI0_I1229_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1229_MN16 (XI0_I1229_xn2 I0_B_27_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1229_MN15 (I0_pp13_11 XI0_I1229_xan XI0_I1229_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1229_MN13 (XI0_I1229_xn1 XI0_I1229_xn I0_pp13_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1229_MN2 (VSS I0_A_11_b3_4 XI0_I1229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1229_MN4 (XI0_I1229_n2 I0_A_10_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1229_MN3 (XI0_I1229_xn I0_two13_b3_2 XI0_I1229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1229_MN1 (XI0_I1229_n1 I0_one13_b3_2 XI0_I1229_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1229_MN9 (VSS XI0_I1229_xn XI0_I1229_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1123_MN11 (VSS I0_B_23_b3_2 XI0_I1123_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1123_MN14 (VSS XI0_I1123_xbn XI0_I1123_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1123_MN16 (XI0_I1123_xn2 I0_B_23_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1123_MN15 (I0_pp11_15 XI0_I1123_xan XI0_I1123_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1123_MN13 (XI0_I1123_xn1 XI0_I1123_xn I0_pp11_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1123_MN2 (VSS I0_A_15_b3_4 XI0_I1123_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1123_MN4 (XI0_I1123_n2 I0_A_14_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1123_MN3 (XI0_I1123_xn I0_two11_b3_2 XI0_I1123_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1123_MN1 (XI0_I1123_n1 I0_one11_b3_2 XI0_I1123_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1123_MN9 (VSS XI0_I1123_xn XI0_I1123_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1176_MN11 (VSS I0_B_25_b3_2 XI0_I1176_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1176_MN14 (VSS XI0_I1176_xbn XI0_I1176_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1176_MN16 (XI0_I1176_xn2 I0_B_25_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1176_MN15 (I0_pp12_13 XI0_I1176_xan XI0_I1176_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1176_MN13 (XI0_I1176_xn1 XI0_I1176_xn I0_pp12_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1176_MN2 (VSS I0_A_13_b3_4 XI0_I1176_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1176_MN4 (XI0_I1176_n2 I0_A_12_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1176_MN3 (XI0_I1176_xn I0_two12_b3_2 XI0_I1176_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1176_MN1 (XI0_I1176_n1 I0_one12_b3_2 XI0_I1176_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1176_MN9 (VSS XI0_I1176_xn XI0_I1176_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1124_MN11 (VSS I0_B_23_b3_2 XI0_I1124_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1124_MN14 (VSS XI0_I1124_xbn XI0_I1124_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1124_MN16 (XI0_I1124_xn2 I0_B_23_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1124_MN15 (I0_pp11_16 XI0_I1124_xan XI0_I1124_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1124_MN13 (XI0_I1124_xn1 XI0_I1124_xn I0_pp11_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1124_MN2 (VSS I0_A_16_b3_4 XI0_I1124_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1124_MN4 (XI0_I1124_n2 I0_A_15_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1124_MN3 (XI0_I1124_xn I0_two11_b3_2 XI0_I1124_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1124_MN1 (XI0_I1124_n1 I0_one11_b3_2 XI0_I1124_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1124_MN9 (VSS XI0_I1124_xn XI0_I1124_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1072_MN11 (VSS I0_B_21_b3_3 XI0_I1072_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1072_MN14 (VSS XI0_I1072_xbn XI0_I1072_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1072_MN16 (XI0_I1072_xn2 I0_B_21_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1072_MN15 (I0_pp10_19 XI0_I1072_xan XI0_I1072_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1072_MN13 (XI0_I1072_xn1 XI0_I1072_xn I0_pp10_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1072_MN2 (VSS I0_A_19_b3_3 XI0_I1072_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1072_MN4 (XI0_I1072_n2 I0_A_18_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1072_MN3 (XI0_I1072_xn I0_two10_b3_3 XI0_I1072_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1072_MN1 (XI0_I1072_n1 I0_one10_b3_3 XI0_I1072_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1072_MN9 (VSS XI0_I1072_xn XI0_I1072_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1073_MN11 (VSS I0_B_21_b3_3 XI0_I1073_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1073_MN14 (VSS XI0_I1073_xbn XI0_I1073_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1073_MN16 (XI0_I1073_xn2 I0_B_21_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1073_MN15 (I0_pp10_20 XI0_I1073_xan XI0_I1073_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1073_MN13 (XI0_I1073_xn1 XI0_I1073_xn I0_pp10_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1073_MN2 (VSS I0_A_20_b3_3 XI0_I1073_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1073_MN4 (XI0_I1073_n2 I0_A_19_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1073_MN3 (XI0_I1073_xn I0_two10_b3_3 XI0_I1073_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1073_MN1 (XI0_I1073_n1 I0_one10_b3_3 XI0_I1073_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1073_MN9 (VSS XI0_I1073_xn XI0_I1073_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1074_MN11 (VSS I0_B_21_b3_3 XI0_I1074_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1074_MN14 (VSS XI0_I1074_xbn XI0_I1074_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1074_MN16 (XI0_I1074_xn2 I0_B_21_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1074_MN15 (I0_pp10_21 XI0_I1074_xan XI0_I1074_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1074_MN13 (XI0_I1074_xn1 XI0_I1074_xn I0_pp10_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1074_MN2 (VSS I0_A_21_b3_3 XI0_I1074_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1074_MN4 (XI0_I1074_n2 I0_A_20_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1074_MN3 (XI0_I1074_xn I0_two10_b3_3 XI0_I1074_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1074_MN1 (XI0_I1074_n1 I0_one10_b3_3 XI0_I1074_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1074_MN9 (VSS XI0_I1074_xn XI0_I1074_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I998_MN11 (VSS I0_B_19_b3_0 XI0_I998_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I998_MN14 (VSS XI0_I998_xbn XI0_I998_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I998_MN16 (XI0_I998_xn2 I0_B_19_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I998_MN15 (I0_pp9_0 XI0_I998_xan XI0_I998_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I998_MN13 (XI0_I998_xn1 XI0_I998_xn I0_pp9_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I998_MN2 (VSS I0_A_0_b3_3 XI0_I998_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I998_MN4 (XI0_I998_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I998_MN3 (XI0_I998_xn I0_two9_b3_0 XI0_I998_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I998_MN1 (XI0_I998_n1 I0_one9_b3_0 XI0_I998_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I998_MN9 (VSS XI0_I998_xn XI0_I998_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1000_MN11 (VSS I0_B_19_b3_0 XI0_I1000_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1000_MN14 (VSS XI0_I1000_xbn XI0_I1000_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1000_MN16 (XI0_I1000_xn2 I0_B_19_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1000_MN15 (I0_pp9_2 XI0_I1000_xan XI0_I1000_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1000_MN13 (XI0_I1000_xn1 XI0_I1000_xn I0_pp9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1000_MN2 (VSS I0_A_2_b3_3 XI0_I1000_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1000_MN4 (XI0_I1000_n2 I0_A_1_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1000_MN3 (XI0_I1000_xn I0_two9_b3_0 XI0_I1000_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1000_MN1 (XI0_I1000_n1 I0_one9_b3_0 XI0_I1000_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1000_MN9 (VSS XI0_I1000_xn XI0_I1000_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I999_MN11 (VSS I0_B_19_b3_0 XI0_I999_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I999_MN14 (VSS XI0_I999_xbn XI0_I999_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I999_MN16 (XI0_I999_xn2 I0_B_19_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I999_MN15 (I0_pp9_1 XI0_I999_xan XI0_I999_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I999_MN13 (XI0_I999_xn1 XI0_I999_xn I0_pp9_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I999_MN2 (VSS I0_A_1_b3_3 XI0_I999_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I999_MN4 (XI0_I999_n2 I0_A_0_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I999_MN3 (XI0_I999_xn I0_two9_b3_0 XI0_I999_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I999_MN1 (XI0_I999_n1 I0_one9_b3_0 XI0_I999_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I999_MN9 (VSS XI0_I999_xn XI0_I999_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1001_MN11 (VSS I0_B_19_b3_0 XI0_I1001_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1001_MN14 (VSS XI0_I1001_xbn XI0_I1001_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1001_MN16 (XI0_I1001_xn2 I0_B_19_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1001_MN15 (I0_pp9_3 XI0_I1001_xan XI0_I1001_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1001_MN13 (XI0_I1001_xn1 XI0_I1001_xn I0_pp9_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1001_MN2 (VSS I0_A_3_b3_3 XI0_I1001_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1001_MN4 (XI0_I1001_n2 I0_A_2_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1001_MN3 (XI0_I1001_xn I0_two9_b3_0 XI0_I1001_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1001_MN1 (XI0_I1001_n1 I0_one9_b3_0 XI0_I1001_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1001_MN9 (VSS XI0_I1001_xn XI0_I1001_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1056_MN11 (VSS I0_B_21_b3_0 XI0_I1056_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1056_MN14 (VSS XI0_I1056_xbn XI0_I1056_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1056_MN16 (XI0_I1056_xn2 I0_B_21_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1056_MN15 (I0_pp10_3 XI0_I1056_xan XI0_I1056_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1056_MN13 (XI0_I1056_xn1 XI0_I1056_xn I0_pp10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1056_MN2 (VSS I0_A_3_b3_3 XI0_I1056_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1056_MN4 (XI0_I1056_n2 I0_A_2_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1056_MN3 (XI0_I1056_xn I0_two10_b3_0 XI0_I1056_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1056_MN1 (XI0_I1056_n1 I0_one10_b3_0 XI0_I1056_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1056_MN9 (VSS XI0_I1056_xn XI0_I1056_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I949_MN11 (VSS I0_B_17_b3_1 XI0_I949_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I949_MN14 (VSS XI0_I949_xbn XI0_I949_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I949_MN16 (XI0_I949_xn2 I0_B_17_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I949_MN15 (I0_pp8_6 XI0_I949_xan XI0_I949_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I949_MN13 (XI0_I949_xn1 XI0_I949_xn I0_pp8_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I949_MN2 (VSS I0_A_6_b3_3 XI0_I949_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I949_MN4 (XI0_I949_n2 I0_A_5_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I949_MN3 (XI0_I949_xn I0_two8_b3_1 XI0_I949_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I949_MN1 (XI0_I949_n1 I0_one8_b3_1 XI0_I949_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I949_MN9 (VSS XI0_I949_xn XI0_I949_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1110_MN11 (VSS I0_B_23_b3_0 XI0_I1110_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1110_MN14 (VSS XI0_I1110_xbn XI0_I1110_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1110_MN16 (XI0_I1110_xn2 I0_B_23_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1110_MN15 (I0_pp11_2 XI0_I1110_xan XI0_I1110_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1110_MN13 (XI0_I1110_xn1 XI0_I1110_xn I0_pp11_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1110_MN2 (VSS I0_A_2_b3_4 XI0_I1110_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1110_MN4 (XI0_I1110_n2 I0_A_1_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1110_MN3 (XI0_I1110_xn I0_two11_b3_0 XI0_I1110_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1110_MN1 (XI0_I1110_n1 I0_one11_b3_0 XI0_I1110_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1110_MN9 (VSS XI0_I1110_xn XI0_I1110_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1112_MN11 (VSS I0_B_23_b3_0 XI0_I1112_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1112_MN14 (VSS XI0_I1112_xbn XI0_I1112_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1112_MN16 (XI0_I1112_xn2 I0_B_23_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1112_MN15 (I0_pp11_4 XI0_I1112_xan XI0_I1112_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1112_MN13 (XI0_I1112_xn1 XI0_I1112_xn I0_pp11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1112_MN2 (VSS I0_A_4_b3_4 XI0_I1112_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1112_MN4 (XI0_I1112_n2 I0_A_3_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1112_MN3 (XI0_I1112_xn I0_two11_b3_0 XI0_I1112_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1112_MN1 (XI0_I1112_n1 I0_one11_b3_0 XI0_I1112_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1112_MN9 (VSS XI0_I1112_xn XI0_I1112_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1114_MN11 (VSS I0_B_23_b3_1 XI0_I1114_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1114_MN14 (VSS XI0_I1114_xbn XI0_I1114_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1114_MN16 (XI0_I1114_xn2 I0_B_23_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1114_MN15 (I0_pp11_6 XI0_I1114_xan XI0_I1114_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1114_MN13 (XI0_I1114_xn1 XI0_I1114_xn I0_pp11_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1114_MN2 (VSS I0_A_6_b3_4 XI0_I1114_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1114_MN4 (XI0_I1114_n2 I0_A_5_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1114_MN3 (XI0_I1114_xn I0_two11_b3_1 XI0_I1114_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1114_MN1 (XI0_I1114_n1 I0_one11_b3_1 XI0_I1114_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1114_MN9 (VSS XI0_I1114_xn XI0_I1114_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1113_MN11 (VSS I0_B_23_b3_1 XI0_I1113_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1113_MN14 (VSS XI0_I1113_xbn XI0_I1113_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1113_MN16 (XI0_I1113_xn2 I0_B_23_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1113_MN15 (I0_pp11_5 XI0_I1113_xan XI0_I1113_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1113_MN13 (XI0_I1113_xn1 XI0_I1113_xn I0_pp11_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1113_MN2 (VSS I0_A_5_b3_4 XI0_I1113_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1113_MN4 (XI0_I1113_n2 I0_A_4_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1113_MN3 (XI0_I1113_xn I0_two11_b3_0 XI0_I1113_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1113_MN1 (XI0_I1113_n1 I0_one11_b3_0 XI0_I1113_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1113_MN9 (VSS XI0_I1113_xn XI0_I1113_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1170_MN11 (VSS I0_B_25_b3_1 XI0_I1170_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1170_MN14 (VSS XI0_I1170_xbn XI0_I1170_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1170_MN16 (XI0_I1170_xn2 I0_B_25_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1170_MN15 (I0_pp12_7 XI0_I1170_xan XI0_I1170_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1170_MN13 (XI0_I1170_xn1 XI0_I1170_xn I0_pp12_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1170_MN2 (VSS I0_A_7_b3_4 XI0_I1170_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1170_MN4 (XI0_I1170_n2 I0_A_6_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1170_MN3 (XI0_I1170_xn I0_two12_b3_1 XI0_I1170_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1170_MN1 (XI0_I1170_n1 I0_one12_b3_1 XI0_I1170_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1170_MN9 (VSS XI0_I1170_xn XI0_I1170_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1225_MN11 (VSS I0_B_27_b3_1 XI0_I1225_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1225_MN14 (VSS XI0_I1225_xbn XI0_I1225_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1225_MN16 (XI0_I1225_xn2 I0_B_27_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1225_MN15 (I0_pp13_7 XI0_I1225_xan XI0_I1225_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1225_MN13 (XI0_I1225_xn1 XI0_I1225_xn I0_pp13_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1225_MN2 (VSS I0_A_7_b3_4 XI0_I1225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1225_MN4 (XI0_I1225_n2 I0_A_6_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1225_MN3 (XI0_I1225_xn I0_two13_b3_1 XI0_I1225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1225_MN1 (XI0_I1225_n1 I0_one13_b3_1 XI0_I1225_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1225_MN9 (VSS XI0_I1225_xn XI0_I1225_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1171_MN11 (VSS I0_B_25_b3_1 XI0_I1171_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1171_MN14 (VSS XI0_I1171_xbn XI0_I1171_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1171_MN16 (XI0_I1171_xn2 I0_B_25_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1171_MN15 (I0_pp12_8 XI0_I1171_xan XI0_I1171_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1171_MN13 (XI0_I1171_xn1 XI0_I1171_xn I0_pp12_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1171_MN2 (VSS I0_A_8_b3_4 XI0_I1171_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1171_MN4 (XI0_I1171_n2 I0_A_7_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1171_MN3 (XI0_I1171_xn I0_two12_b3_1 XI0_I1171_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1171_MN1 (XI0_I1171_n1 I0_one12_b3_1 XI0_I1171_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1171_MN9 (VSS XI0_I1171_xn XI0_I1171_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1226_MN11 (VSS I0_B_27_b3_1 XI0_I1226_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1226_MN14 (VSS XI0_I1226_xbn XI0_I1226_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1226_MN16 (XI0_I1226_xn2 I0_B_27_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1226_MN15 (I0_pp13_8 XI0_I1226_xan XI0_I1226_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1226_MN13 (XI0_I1226_xn1 XI0_I1226_xn I0_pp13_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1226_MN2 (VSS I0_A_8_b3_4 XI0_I1226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1226_MN4 (XI0_I1226_n2 I0_A_7_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1226_MN3 (XI0_I1226_xn I0_two13_b3_1 XI0_I1226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1226_MN1 (XI0_I1226_n1 I0_one13_b3_1 XI0_I1226_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1226_MN9 (VSS XI0_I1226_xn XI0_I1226_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1228_MN11 (VSS I0_B_27_b3_1 XI0_I1228_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1228_MN14 (VSS XI0_I1228_xbn XI0_I1228_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1228_MN16 (XI0_I1228_xn2 I0_B_27_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1228_MN15 (I0_pp13_10 XI0_I1228_xan XI0_I1228_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1228_MN13 (XI0_I1228_xn1 XI0_I1228_xn I0_pp13_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1228_MN2 (VSS I0_A_10_b3_4 XI0_I1228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1228_MN4 (XI0_I1228_n2 I0_A_9_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1228_MN3 (XI0_I1228_xn I0_two13_b3_1 XI0_I1228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1228_MN1 (XI0_I1228_n1 I0_one13_b3_1 XI0_I1228_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1228_MN9 (VSS XI0_I1228_xn XI0_I1228_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1281_MN11 (VSS I0_B_29_b3_1 XI0_I1281_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1281_MN14 (VSS XI0_I1281_xbn XI0_I1281_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1281_MN16 (XI0_I1281_xn2 I0_B_29_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1281_MN15 (I0_pp14_8 XI0_I1281_xan XI0_I1281_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1281_MN13 (XI0_I1281_xn1 XI0_I1281_xn I0_pp14_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1281_MN2 (VSS I0_A_8_b3_5 XI0_I1281_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1281_MN4 (XI0_I1281_n2 I0_A_7_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1281_MN3 (XI0_I1281_xn I0_two14_b3_1 XI0_I1281_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1281_MN1 (XI0_I1281_n1 I0_one14_b3_1 XI0_I1281_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1281_MN9 (VSS XI0_I1281_xn XI0_I1281_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1282_MN11 (VSS I0_B_29_b3_1 XI0_I1282_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1282_MN14 (VSS XI0_I1282_xbn XI0_I1282_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1282_MN16 (XI0_I1282_xn2 I0_B_29_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1282_MN15 (I0_pp14_9 XI0_I1282_xan XI0_I1282_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1282_MN13 (XI0_I1282_xn1 XI0_I1282_xn I0_pp14_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1282_MN2 (VSS I0_A_9_b3_5 XI0_I1282_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1282_MN4 (XI0_I1282_n2 I0_A_8_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1282_MN3 (XI0_I1282_xn I0_two14_b3_1 XI0_I1282_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1282_MN1 (XI0_I1282_n1 I0_one14_b3_1 XI0_I1282_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1282_MN9 (VSS XI0_I1282_xn XI0_I1282_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1230_MN11 (VSS I0_B_27_b3_2 XI0_I1230_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1230_MN14 (VSS XI0_I1230_xbn XI0_I1230_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1230_MN16 (XI0_I1230_xn2 I0_B_27_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1230_MN15 (I0_pp13_12 XI0_I1230_xan XI0_I1230_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1230_MN13 (XI0_I1230_xn1 XI0_I1230_xn I0_pp13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1230_MN2 (VSS I0_A_12_b3_4 XI0_I1230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1230_MN4 (XI0_I1230_n2 I0_A_11_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1230_MN3 (XI0_I1230_xn I0_two13_b3_2 XI0_I1230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1230_MN1 (XI0_I1230_n1 I0_one13_b3_2 XI0_I1230_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1230_MN9 (VSS XI0_I1230_xn XI0_I1230_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1178_MN11 (VSS I0_B_25_b3_2 XI0_I1178_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1178_MN14 (VSS XI0_I1178_xbn XI0_I1178_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1178_MN16 (XI0_I1178_xn2 I0_B_25_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1178_MN15 (I0_pp12_15 XI0_I1178_xan XI0_I1178_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1178_MN13 (XI0_I1178_xn1 XI0_I1178_xn I0_pp12_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1178_MN2 (VSS I0_A_15_b3_4 XI0_I1178_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1178_MN4 (XI0_I1178_n2 I0_A_14_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1178_MN3 (XI0_I1178_xn I0_two12_b3_2 XI0_I1178_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1178_MN1 (XI0_I1178_n1 I0_one12_b3_2 XI0_I1178_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1178_MN9 (VSS XI0_I1178_xn XI0_I1178_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1177_MN11 (VSS I0_B_25_b3_2 XI0_I1177_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1177_MN14 (VSS XI0_I1177_xbn XI0_I1177_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1177_MN16 (XI0_I1177_xn2 I0_B_25_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1177_MN15 (I0_pp12_14 XI0_I1177_xan XI0_I1177_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1177_MN13 (XI0_I1177_xn1 XI0_I1177_xn I0_pp12_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1177_MN2 (VSS I0_A_14_b3_4 XI0_I1177_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1177_MN4 (XI0_I1177_n2 I0_A_13_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1177_MN3 (XI0_I1177_xn I0_two12_b3_2 XI0_I1177_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1177_MN1 (XI0_I1177_n1 I0_one12_b3_2 XI0_I1177_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1177_MN9 (VSS XI0_I1177_xn XI0_I1177_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1109_MN11 (VSS I0_B_23_b3_0 XI0_I1109_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1109_MN14 (VSS XI0_I1109_xbn XI0_I1109_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1109_MN16 (XI0_I1109_xn2 I0_B_23_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1109_MN15 (I0_pp11_1 XI0_I1109_xan XI0_I1109_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1109_MN13 (XI0_I1109_xn1 XI0_I1109_xn I0_pp11_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1109_MN2 (VSS I0_A_1_b3_4 XI0_I1109_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1109_MN4 (XI0_I1109_n2 I0_A_0_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1109_MN3 (XI0_I1109_xn I0_two11_b3_0 XI0_I1109_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1109_MN1 (XI0_I1109_n1 I0_one11_b3_0 XI0_I1109_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1109_MN9 (VSS XI0_I1109_xn XI0_I1109_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1108_MN11 (VSS I0_B_23_b3_0 XI0_I1108_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1108_MN14 (VSS XI0_I1108_xbn XI0_I1108_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1108_MN16 (XI0_I1108_xn2 I0_B_23_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1108_MN15 (I0_pp11_0 XI0_I1108_xan XI0_I1108_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1108_MN13 (XI0_I1108_xn1 XI0_I1108_xn I0_pp11_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1108_MN2 (VSS I0_A_0_b3_4 XI0_I1108_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1108_MN4 (XI0_I1108_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1108_MN3 (XI0_I1108_xn I0_two11_b3_0 XI0_I1108_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1108_MN1 (XI0_I1108_n1 I0_one11_b3_0 XI0_I1108_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1108_MN9 (VSS XI0_I1108_xn XI0_I1108_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1111_MN11 (VSS I0_B_23_b3_0 XI0_I1111_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1111_MN14 (VSS XI0_I1111_xbn XI0_I1111_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1111_MN16 (XI0_I1111_xn2 I0_B_23_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1111_MN15 (I0_pp11_3 XI0_I1111_xan XI0_I1111_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1111_MN13 (XI0_I1111_xn1 XI0_I1111_xn I0_pp11_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1111_MN2 (VSS I0_A_3_b3_4 XI0_I1111_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1111_MN4 (XI0_I1111_n2 I0_A_2_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1111_MN3 (XI0_I1111_xn I0_two11_b3_0 XI0_I1111_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1111_MN1 (XI0_I1111_n1 I0_one11_b3_0 XI0_I1111_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1111_MN9 (VSS XI0_I1111_xn XI0_I1111_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1169_MN11 (VSS I0_B_25_b3_1 XI0_I1169_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1169_MN14 (VSS XI0_I1169_xbn XI0_I1169_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1169_MN16 (XI0_I1169_xn2 I0_B_25_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1169_MN15 (I0_pp12_6 XI0_I1169_xan XI0_I1169_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1169_MN13 (XI0_I1169_xn1 XI0_I1169_xn I0_pp12_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1169_MN2 (VSS I0_A_6_b3_4 XI0_I1169_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1169_MN4 (XI0_I1169_n2 I0_A_5_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1169_MN3 (XI0_I1169_xn I0_two12_b3_1 XI0_I1169_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1169_MN1 (XI0_I1169_n1 I0_one12_b3_1 XI0_I1169_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1169_MN9 (VSS XI0_I1169_xn XI0_I1169_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1168_MN11 (VSS I0_B_25_b3_1 XI0_I1168_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1168_MN14 (VSS XI0_I1168_xbn XI0_I1168_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1168_MN16 (XI0_I1168_xn2 I0_B_25_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1168_MN15 (I0_pp12_5 XI0_I1168_xan XI0_I1168_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1168_MN13 (XI0_I1168_xn1 XI0_I1168_xn I0_pp12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1168_MN2 (VSS I0_A_5_b3_4 XI0_I1168_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1168_MN4 (XI0_I1168_n2 I0_A_4_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1168_MN3 (XI0_I1168_xn I0_two12_b3_0 XI0_I1168_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1168_MN1 (XI0_I1168_n1 I0_one12_b3_0 XI0_I1168_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1168_MN9 (VSS XI0_I1168_xn XI0_I1168_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1224_MN11 (VSS I0_B_27_b3_1 XI0_I1224_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1224_MN14 (VSS XI0_I1224_xbn XI0_I1224_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1224_MN16 (XI0_I1224_xn2 I0_B_27_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1224_MN15 (I0_pp13_6 XI0_I1224_xan XI0_I1224_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1224_MN13 (XI0_I1224_xn1 XI0_I1224_xn I0_pp13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1224_MN2 (VSS I0_A_6_b3_4 XI0_I1224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1224_MN4 (XI0_I1224_n2 I0_A_5_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1224_MN3 (XI0_I1224_xn I0_two13_b3_1 XI0_I1224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1224_MN1 (XI0_I1224_n1 I0_one13_b3_1 XI0_I1224_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1224_MN9 (VSS XI0_I1224_xn XI0_I1224_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1279_MN11 (VSS I0_B_29_b3_1 XI0_I1279_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1279_MN14 (VSS XI0_I1279_xbn XI0_I1279_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1279_MN16 (XI0_I1279_xn2 I0_B_29_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1279_MN15 (I0_pp14_6 XI0_I1279_xan XI0_I1279_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1279_MN13 (XI0_I1279_xn1 XI0_I1279_xn I0_pp14_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1279_MN2 (VSS I0_A_6_b3_5 XI0_I1279_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1279_MN4 (XI0_I1279_n2 I0_A_5_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1279_MN3 (XI0_I1279_xn I0_two14_b3_1 XI0_I1279_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1279_MN1 (XI0_I1279_n1 I0_one14_b3_1 XI0_I1279_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1279_MN9 (VSS XI0_I1279_xn XI0_I1279_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1336_MN11 (VSS I0_B_31_b3_1 XI0_I1336_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1336_MN14 (VSS XI0_I1336_xbn XI0_I1336_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1336_MN16 (XI0_I1336_xn2 I0_B_31_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1336_MN15 (I0_pp15_8 XI0_I1336_xan XI0_I1336_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1336_MN13 (XI0_I1336_xn1 XI0_I1336_xn I0_pp15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1336_MN2 (VSS I0_A_8_b3_5 XI0_I1336_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1336_MN4 (XI0_I1336_n2 I0_A_7_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1336_MN3 (XI0_I1336_xn I0_two15_b3_1 XI0_I1336_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1336_MN1 (XI0_I1336_n1 I0_one15_b3_1 XI0_I1336_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1336_MN9 (VSS XI0_I1336_xn XI0_I1336_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1337_MN11 (VSS I0_B_31_b3_1 XI0_I1337_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1337_MN14 (VSS XI0_I1337_xbn XI0_I1337_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1337_MN16 (XI0_I1337_xn2 I0_B_31_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1337_MN15 (I0_pp15_9 XI0_I1337_xan XI0_I1337_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1337_MN13 (XI0_I1337_xn1 XI0_I1337_xn I0_pp15_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1337_MN2 (VSS I0_A_9_b3_5 XI0_I1337_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1337_MN4 (XI0_I1337_n2 I0_A_8_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1337_MN3 (XI0_I1337_xn I0_two15_b3_1 XI0_I1337_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1337_MN1 (XI0_I1337_n1 I0_one15_b3_1 XI0_I1337_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1337_MN9 (VSS XI0_I1337_xn XI0_I1337_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1231_MN11 (VSS I0_B_27_b3_2 XI0_I1231_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1231_MN14 (VSS XI0_I1231_xbn XI0_I1231_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1231_MN16 (XI0_I1231_xn2 I0_B_27_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1231_MN15 (I0_pp13_13 XI0_I1231_xan XI0_I1231_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1231_MN13 (XI0_I1231_xn1 XI0_I1231_xn I0_pp13_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1231_MN2 (VSS I0_A_13_b3_4 XI0_I1231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1231_MN4 (XI0_I1231_n2 I0_A_12_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1231_MN3 (XI0_I1231_xn I0_two13_b3_2 XI0_I1231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1231_MN1 (XI0_I1231_n1 I0_one13_b3_2 XI0_I1231_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1231_MN9 (VSS XI0_I1231_xn XI0_I1231_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1179_MN11 (VSS I0_B_25_b3_2 XI0_I1179_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1179_MN14 (VSS XI0_I1179_xbn XI0_I1179_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1179_MN16 (XI0_I1179_xn2 I0_B_25_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1179_MN15 (I0_pp12_16 XI0_I1179_xan XI0_I1179_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1179_MN13 (XI0_I1179_xn1 XI0_I1179_xn I0_pp12_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1179_MN2 (VSS I0_A_16_b3_4 XI0_I1179_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1179_MN4 (XI0_I1179_n2 I0_A_15_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1179_MN3 (XI0_I1179_xn I0_two12_b3_2 XI0_I1179_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1179_MN1 (XI0_I1179_n1 I0_one12_b3_2 XI0_I1179_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1179_MN9 (VSS XI0_I1179_xn XI0_I1179_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1163_MN11 (VSS I0_B_25_b3_0 XI0_I1163_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1163_MN14 (VSS XI0_I1163_xbn XI0_I1163_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1163_MN16 (XI0_I1163_xn2 I0_B_25_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1163_MN15 (I0_pp12_0 XI0_I1163_xan XI0_I1163_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1163_MN13 (XI0_I1163_xn1 XI0_I1163_xn I0_pp12_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1163_MN2 (VSS I0_A_0_b3_4 XI0_I1163_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1163_MN4 (XI0_I1163_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1163_MN3 (XI0_I1163_xn I0_two12_b3_0 XI0_I1163_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1163_MN1 (XI0_I1163_n1 I0_one12_b3_0 XI0_I1163_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1163_MN9 (VSS XI0_I1163_xn XI0_I1163_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1166_MN11 (VSS I0_B_25_b3_0 XI0_I1166_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1166_MN14 (VSS XI0_I1166_xbn XI0_I1166_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1166_MN16 (XI0_I1166_xn2 I0_B_25_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1166_MN15 (I0_pp12_3 XI0_I1166_xan XI0_I1166_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1166_MN13 (XI0_I1166_xn1 XI0_I1166_xn I0_pp12_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1166_MN2 (VSS I0_A_3_b3_4 XI0_I1166_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1166_MN4 (XI0_I1166_n2 I0_A_2_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1166_MN3 (XI0_I1166_xn I0_two12_b3_0 XI0_I1166_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1166_MN1 (XI0_I1166_n1 I0_one12_b3_0 XI0_I1166_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1166_MN9 (VSS XI0_I1166_xn XI0_I1166_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1164_MN11 (VSS I0_B_25_b3_0 XI0_I1164_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1164_MN14 (VSS XI0_I1164_xbn XI0_I1164_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1164_MN16 (XI0_I1164_xn2 I0_B_25_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1164_MN15 (I0_pp12_1 XI0_I1164_xan XI0_I1164_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1164_MN13 (XI0_I1164_xn1 XI0_I1164_xn I0_pp12_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1164_MN2 (VSS I0_A_1_b3_4 XI0_I1164_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1164_MN4 (XI0_I1164_n2 I0_A_0_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1164_MN3 (XI0_I1164_xn I0_two12_b3_0 XI0_I1164_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1164_MN1 (XI0_I1164_n1 I0_one12_b3_0 XI0_I1164_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1164_MN9 (VSS XI0_I1164_xn XI0_I1164_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1165_MN11 (VSS I0_B_25_b3_0 XI0_I1165_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1165_MN14 (VSS XI0_I1165_xbn XI0_I1165_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1165_MN16 (XI0_I1165_xn2 I0_B_25_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1165_MN15 (I0_pp12_2 XI0_I1165_xan XI0_I1165_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1165_MN13 (XI0_I1165_xn1 XI0_I1165_xn I0_pp12_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1165_MN2 (VSS I0_A_2_b3_4 XI0_I1165_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1165_MN4 (XI0_I1165_n2 I0_A_1_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1165_MN3 (XI0_I1165_xn I0_two12_b3_0 XI0_I1165_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1165_MN1 (XI0_I1165_n1 I0_one12_b3_0 XI0_I1165_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1165_MN9 (VSS XI0_I1165_xn XI0_I1165_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1221_MN11 (VSS I0_B_27_b3_0 XI0_I1221_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1221_MN14 (VSS XI0_I1221_xbn XI0_I1221_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1221_MN16 (XI0_I1221_xn2 I0_B_27_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1221_MN15 (I0_pp13_3 XI0_I1221_xan XI0_I1221_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1221_MN13 (XI0_I1221_xn1 XI0_I1221_xn I0_pp13_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1221_MN2 (VSS I0_A_3_b3_4 XI0_I1221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1221_MN4 (XI0_I1221_n2 I0_A_2_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1221_MN3 (XI0_I1221_xn I0_two13_b3_0 XI0_I1221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1221_MN1 (XI0_I1221_n1 I0_one13_b3_0 XI0_I1221_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1221_MN9 (VSS XI0_I1221_xn XI0_I1221_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1167_MN11 (VSS I0_B_25_b3_0 XI0_I1167_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1167_MN14 (VSS XI0_I1167_xbn XI0_I1167_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1167_MN16 (XI0_I1167_xn2 I0_B_25_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1167_MN15 (I0_pp12_4 XI0_I1167_xan XI0_I1167_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1167_MN13 (XI0_I1167_xn1 XI0_I1167_xn I0_pp12_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1167_MN2 (VSS I0_A_4_b3_4 XI0_I1167_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1167_MN4 (XI0_I1167_n2 I0_A_3_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1167_MN3 (XI0_I1167_xn I0_two12_b3_0 XI0_I1167_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1167_MN1 (XI0_I1167_n1 I0_one12_b3_0 XI0_I1167_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1167_MN9 (VSS XI0_I1167_xn XI0_I1167_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1334_MN11 (VSS I0_B_31_b3_1 XI0_I1334_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1334_MN14 (VSS XI0_I1334_xbn XI0_I1334_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1334_MN16 (XI0_I1334_xn2 I0_B_31_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1334_MN15 (I0_pp15_6 XI0_I1334_xan XI0_I1334_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1334_MN13 (XI0_I1334_xn1 XI0_I1334_xn I0_pp15_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1334_MN2 (VSS I0_A_6_b3_5 XI0_I1334_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1334_MN4 (XI0_I1334_n2 I0_A_5_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1334_MN3 (XI0_I1334_xn I0_two15_b3_1 XI0_I1334_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1334_MN1 (XI0_I1334_n1 I0_one15_b3_1 XI0_I1334_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1334_MN9 (VSS XI0_I1334_xn XI0_I1334_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1335_MN11 (VSS I0_B_31_b3_1 XI0_I1335_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1335_MN14 (VSS XI0_I1335_xbn XI0_I1335_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1335_MN16 (XI0_I1335_xn2 I0_B_31_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1335_MN15 (I0_pp15_7 XI0_I1335_xan XI0_I1335_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1335_MN13 (XI0_I1335_xn1 XI0_I1335_xn I0_pp15_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1335_MN2 (VSS I0_A_7_b3_5 XI0_I1335_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1335_MN4 (XI0_I1335_n2 I0_A_6_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1335_MN3 (XI0_I1335_xn I0_two15_b3_1 XI0_I1335_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1335_MN1 (XI0_I1335_n1 I0_one15_b3_1 XI0_I1335_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1335_MN9 (VSS XI0_I1335_xn XI0_I1335_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1338_MN11 (VSS I0_B_31_b3_1 XI0_I1338_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1338_MN14 (VSS XI0_I1338_xbn XI0_I1338_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1338_MN16 (XI0_I1338_xn2 I0_B_31_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1338_MN15 (I0_pp15_10 XI0_I1338_xan XI0_I1338_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1338_MN13 (XI0_I1338_xn1 XI0_I1338_xn I0_pp15_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1338_MN2 (VSS I0_A_10_b3_5 XI0_I1338_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1338_MN4 (XI0_I1338_n2 I0_A_9_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1338_MN3 (XI0_I1338_xn I0_two15_b3_1 XI0_I1338_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1338_MN1 (XI0_I1338_n1 I0_one15_b3_1 XI0_I1338_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1338_MN9 (VSS XI0_I1338_xn XI0_I1338_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1233_MN11 (VSS I0_B_27_b3_2 XI0_I1233_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1233_MN14 (VSS XI0_I1233_xbn XI0_I1233_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1233_MN16 (XI0_I1233_xn2 I0_B_27_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1233_MN15 (I0_pp13_15 XI0_I1233_xan XI0_I1233_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1233_MN13 (XI0_I1233_xn1 XI0_I1233_xn I0_pp13_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1233_MN2 (VSS I0_A_15_b3_4 XI0_I1233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1233_MN4 (XI0_I1233_n2 I0_A_14_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1233_MN3 (XI0_I1233_xn I0_two13_b3_2 XI0_I1233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1233_MN1 (XI0_I1233_n1 I0_one13_b3_2 XI0_I1233_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1233_MN9 (VSS XI0_I1233_xn XI0_I1233_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1232_MN11 (VSS I0_B_27_b3_2 XI0_I1232_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1232_MN14 (VSS XI0_I1232_xbn XI0_I1232_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1232_MN16 (XI0_I1232_xn2 I0_B_27_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1232_MN15 (I0_pp13_14 XI0_I1232_xan XI0_I1232_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1232_MN13 (XI0_I1232_xn1 XI0_I1232_xn I0_pp13_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1232_MN2 (VSS I0_A_14_b3_4 XI0_I1232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1232_MN4 (XI0_I1232_n2 I0_A_13_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1232_MN3 (XI0_I1232_xn I0_two13_b3_2 XI0_I1232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1232_MN1 (XI0_I1232_n1 I0_one13_b3_2 XI0_I1232_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1232_MN9 (VSS XI0_I1232_xn XI0_I1232_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I965_MN11 (VSS I0_B_17_b3_3 XI0_I965_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I965_MN14 (VSS XI0_I965_xbn XI0_I965_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I965_MN16 (XI0_I965_xn2 I0_B_17_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I965_MN15 (I0_pp8_22 XI0_I965_xan XI0_I965_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I965_MN13 (XI0_I965_xn1 XI0_I965_xn I0_pp8_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I965_MN2 (VSS I0_A_22_b3_3 XI0_I965_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I965_MN4 (XI0_I965_n2 I0_A_21_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I965_MN3 (XI0_I965_xn I0_two8_b3_4 XI0_I965_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I965_MN1 (XI0_I965_n1 I0_one8_b3_4 XI0_I965_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I965_MN9 (VSS XI0_I965_xn XI0_I965_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1020_MN11 (VSS I0_B_19_b3_3 XI0_I1020_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1020_MN14 (VSS XI0_I1020_xbn XI0_I1020_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1020_MN16 (XI0_I1020_xn2 I0_B_19_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1020_MN15 (I0_pp9_22 XI0_I1020_xan XI0_I1020_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1020_MN13 (XI0_I1020_xn1 XI0_I1020_xn I0_pp9_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1020_MN2 (VSS I0_A_22_b3_3 XI0_I1020_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1020_MN4 (XI0_I1020_n2 I0_A_21_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1020_MN3 (XI0_I1020_xn I0_two9_b3_4 XI0_I1020_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1020_MN1 (XI0_I1020_n1 I0_one9_b3_4 XI0_I1020_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1020_MN9 (VSS XI0_I1020_xn XI0_I1020_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1218_MN11 (VSS I0_B_27_b3_0 XI0_I1218_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1218_MN14 (VSS XI0_I1218_xbn XI0_I1218_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1218_MN16 (XI0_I1218_xn2 I0_B_27_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1218_MN15 (I0_pp13_0 XI0_I1218_xan XI0_I1218_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1218_MN13 (XI0_I1218_xn1 XI0_I1218_xn I0_pp13_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1218_MN2 (VSS I0_A_0_b3_4 XI0_I1218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1218_MN4 (XI0_I1218_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1218_MN3 (XI0_I1218_xn I0_two13_b3_0 XI0_I1218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1218_MN1 (XI0_I1218_n1 I0_one13_b3_0 XI0_I1218_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1218_MN9 (VSS XI0_I1218_xn XI0_I1218_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1219_MN11 (VSS I0_B_27_b3_0 XI0_I1219_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1219_MN14 (VSS XI0_I1219_xbn XI0_I1219_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1219_MN16 (XI0_I1219_xn2 I0_B_27_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1219_MN15 (I0_pp13_1 XI0_I1219_xan XI0_I1219_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1219_MN13 (XI0_I1219_xn1 XI0_I1219_xn I0_pp13_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1219_MN2 (VSS I0_A_1_b3_4 XI0_I1219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1219_MN4 (XI0_I1219_n2 I0_A_0_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1219_MN3 (XI0_I1219_xn I0_two13_b3_0 XI0_I1219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1219_MN1 (XI0_I1219_n1 I0_one13_b3_0 XI0_I1219_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1219_MN9 (VSS XI0_I1219_xn XI0_I1219_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1222_MN11 (VSS I0_B_27_b3_0 XI0_I1222_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1222_MN14 (VSS XI0_I1222_xbn XI0_I1222_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1222_MN16 (XI0_I1222_xn2 I0_B_27_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1222_MN15 (I0_pp13_4 XI0_I1222_xan XI0_I1222_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1222_MN13 (XI0_I1222_xn1 XI0_I1222_xn I0_pp13_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1222_MN2 (VSS I0_A_4_b3_4 XI0_I1222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1222_MN4 (XI0_I1222_n2 I0_A_3_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1222_MN3 (XI0_I1222_xn I0_two13_b3_0 XI0_I1222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1222_MN1 (XI0_I1222_n1 I0_one13_b3_0 XI0_I1222_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1222_MN9 (VSS XI0_I1222_xn XI0_I1222_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1220_MN11 (VSS I0_B_27_b3_0 XI0_I1220_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1220_MN14 (VSS XI0_I1220_xbn XI0_I1220_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1220_MN16 (XI0_I1220_xn2 I0_B_27_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1220_MN15 (I0_pp13_2 XI0_I1220_xan XI0_I1220_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1220_MN13 (XI0_I1220_xn1 XI0_I1220_xn I0_pp13_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1220_MN2 (VSS I0_A_2_b3_4 XI0_I1220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1220_MN4 (XI0_I1220_n2 I0_A_1_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1220_MN3 (XI0_I1220_xn I0_two13_b3_0 XI0_I1220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1220_MN1 (XI0_I1220_n1 I0_one13_b3_0 XI0_I1220_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1220_MN9 (VSS XI0_I1220_xn XI0_I1220_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1274_MN11 (VSS I0_B_29_b3_0 XI0_I1274_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1274_MN14 (VSS XI0_I1274_xbn XI0_I1274_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1274_MN16 (XI0_I1274_xn2 I0_B_29_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1274_MN15 (I0_pp14_1 XI0_I1274_xan XI0_I1274_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1274_MN13 (XI0_I1274_xn1 XI0_I1274_xn I0_pp14_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1274_MN2 (VSS I0_A_1_b3_5 XI0_I1274_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1274_MN4 (XI0_I1274_n2 I0_A_0_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1274_MN3 (XI0_I1274_xn I0_two14_b3_0 XI0_I1274_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1274_MN1 (XI0_I1274_n1 I0_one14_b3_0 XI0_I1274_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1274_MN9 (VSS XI0_I1274_xn XI0_I1274_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1223_MN11 (VSS I0_B_27_b3_1 XI0_I1223_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1223_MN14 (VSS XI0_I1223_xbn XI0_I1223_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1223_MN16 (XI0_I1223_xn2 I0_B_27_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1223_MN15 (I0_pp13_5 XI0_I1223_xan XI0_I1223_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1223_MN13 (XI0_I1223_xn1 XI0_I1223_xn I0_pp13_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1223_MN2 (VSS I0_A_5_b3_4 XI0_I1223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1223_MN4 (XI0_I1223_n2 I0_A_4_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1223_MN3 (XI0_I1223_xn I0_two13_b3_0 XI0_I1223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1223_MN1 (XI0_I1223_n1 I0_one13_b3_0 XI0_I1223_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1223_MN9 (VSS XI0_I1223_xn XI0_I1223_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1330_MN11 (VSS I0_B_31_b3_0 XI0_I1330_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1330_MN14 (VSS XI0_I1330_xbn XI0_I1330_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1330_MN16 (XI0_I1330_xn2 I0_B_31_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1330_MN15 (I0_pp15_2 XI0_I1330_xan XI0_I1330_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1330_MN13 (XI0_I1330_xn1 XI0_I1330_xn I0_pp15_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1330_MN2 (VSS I0_A_2_b3_5 XI0_I1330_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1330_MN4 (XI0_I1330_n2 I0_A_1_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1330_MN3 (XI0_I1330_xn I0_two15_b3_0 XI0_I1330_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1330_MN1 (XI0_I1330_n1 I0_one15_b3_0 XI0_I1330_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1330_MN9 (VSS XI0_I1330_xn XI0_I1330_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1278_MN11 (VSS I0_B_29_b3_1 XI0_I1278_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1278_MN14 (VSS XI0_I1278_xbn XI0_I1278_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1278_MN16 (XI0_I1278_xn2 I0_B_29_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1278_MN15 (I0_pp14_5 XI0_I1278_xan XI0_I1278_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1278_MN13 (XI0_I1278_xn1 XI0_I1278_xn I0_pp14_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1278_MN2 (VSS I0_A_5_b3_5 XI0_I1278_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1278_MN4 (XI0_I1278_n2 I0_A_4_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1278_MN3 (XI0_I1278_xn I0_two14_b3_0 XI0_I1278_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1278_MN1 (XI0_I1278_n1 I0_one14_b3_0 XI0_I1278_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1278_MN9 (VSS XI0_I1278_xn XI0_I1278_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1277_MN11 (VSS I0_B_29_b3_0 XI0_I1277_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1277_MN14 (VSS XI0_I1277_xbn XI0_I1277_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1277_MN16 (XI0_I1277_xn2 I0_B_29_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1277_MN15 (I0_pp14_4 XI0_I1277_xan XI0_I1277_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1277_MN13 (XI0_I1277_xn1 XI0_I1277_xn I0_pp14_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1277_MN2 (VSS I0_A_4_b3_5 XI0_I1277_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1277_MN4 (XI0_I1277_n2 I0_A_3_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1277_MN3 (XI0_I1277_xn I0_two14_b3_0 XI0_I1277_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1277_MN1 (XI0_I1277_n1 I0_one14_b3_0 XI0_I1277_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1277_MN9 (VSS XI0_I1277_xn XI0_I1277_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1333_MN11 (VSS I0_B_31_b3_1 XI0_I1333_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1333_MN14 (VSS XI0_I1333_xbn XI0_I1333_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1333_MN16 (XI0_I1333_xn2 I0_B_31_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1333_MN15 (I0_pp15_5 XI0_I1333_xan XI0_I1333_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1333_MN13 (XI0_I1333_xn1 XI0_I1333_xn I0_pp15_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1333_MN2 (VSS I0_A_5_b3_5 XI0_I1333_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1333_MN4 (XI0_I1333_n2 I0_A_4_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1333_MN3 (XI0_I1333_xn I0_two15_b3_0 XI0_I1333_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1333_MN1 (XI0_I1333_n1 I0_one15_b3_0 XI0_I1333_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1333_MN9 (VSS XI0_I1333_xn XI0_I1333_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1332_MN11 (VSS I0_B_31_b3_0 XI0_I1332_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1332_MN14 (VSS XI0_I1332_xbn XI0_I1332_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1332_MN16 (XI0_I1332_xn2 I0_B_31_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1332_MN15 (I0_pp15_4 XI0_I1332_xan XI0_I1332_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1332_MN13 (XI0_I1332_xn1 XI0_I1332_xn I0_pp15_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1332_MN2 (VSS I0_A_4_b3_5 XI0_I1332_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1332_MN4 (XI0_I1332_n2 I0_A_3_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1332_MN3 (XI0_I1332_xn I0_two15_b3_0 XI0_I1332_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1332_MN1 (XI0_I1332_n1 I0_one15_b3_0 XI0_I1332_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1332_MN9 (VSS XI0_I1332_xn XI0_I1332_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1284_MN11 (VSS I0_B_29_b3_2 XI0_I1284_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1284_MN14 (VSS XI0_I1284_xbn XI0_I1284_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1284_MN16 (XI0_I1284_xn2 I0_B_29_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1284_MN15 (I0_pp14_11 XI0_I1284_xan XI0_I1284_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1284_MN13 (XI0_I1284_xn1 XI0_I1284_xn I0_pp14_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1284_MN2 (VSS I0_A_11_b3_5 XI0_I1284_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1284_MN4 (XI0_I1284_n2 I0_A_10_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1284_MN3 (XI0_I1284_xn I0_two14_b3_2 XI0_I1284_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1284_MN1 (XI0_I1284_n1 I0_one14_b3_2 XI0_I1284_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1284_MN9 (VSS XI0_I1284_xn XI0_I1284_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1285_MN11 (VSS I0_B_29_b3_2 XI0_I1285_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1285_MN14 (VSS XI0_I1285_xbn XI0_I1285_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1285_MN16 (XI0_I1285_xn2 I0_B_29_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1285_MN15 (I0_pp14_12 XI0_I1285_xan XI0_I1285_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1285_MN13 (XI0_I1285_xn1 XI0_I1285_xn I0_pp14_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1285_MN2 (VSS I0_A_12_b3_5 XI0_I1285_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1285_MN4 (XI0_I1285_n2 I0_A_11_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1285_MN3 (XI0_I1285_xn I0_two14_b3_2 XI0_I1285_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1285_MN1 (XI0_I1285_n1 I0_one14_b3_2 XI0_I1285_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1285_MN9 (VSS XI0_I1285_xn XI0_I1285_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1234_MN11 (VSS I0_B_27_b3_2 XI0_I1234_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1234_MN14 (VSS XI0_I1234_xbn XI0_I1234_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1234_MN16 (XI0_I1234_xn2 I0_B_27_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1234_MN15 (I0_pp13_16 XI0_I1234_xan XI0_I1234_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1234_MN13 (XI0_I1234_xn1 XI0_I1234_xn I0_pp13_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1234_MN2 (VSS I0_A_16_b3_4 XI0_I1234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1234_MN4 (XI0_I1234_n2 I0_A_15_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1234_MN3 (XI0_I1234_xn I0_two13_b3_2 XI0_I1234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1234_MN1 (XI0_I1234_n1 I0_one13_b3_2 XI0_I1234_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1234_MN9 (VSS XI0_I1234_xn XI0_I1234_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I966_MN11 (VSS I0_B_17_b3_4 XI0_I966_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I966_MN14 (VSS XI0_I966_xbn XI0_I966_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I966_MN16 (XI0_I966_xn2 I0_B_17_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I966_MN15 (I0_pp8_23 XI0_I966_xan XI0_I966_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I966_MN13 (XI0_I966_xn1 XI0_I966_xn I0_pp8_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I966_MN2 (VSS I0_A_23_b3_3 XI0_I966_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I966_MN4 (XI0_I966_n2 I0_A_22_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I966_MN3 (XI0_I966_xn I0_two8_b3_4 XI0_I966_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I966_MN1 (XI0_I966_n1 I0_one8_b3_4 XI0_I966_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I966_MN9 (VSS XI0_I966_xn XI0_I966_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1021_MN11 (VSS I0_B_19_b3_4 XI0_I1021_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1021_MN14 (VSS XI0_I1021_xbn XI0_I1021_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1021_MN16 (XI0_I1021_xn2 I0_B_19_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1021_MN15 (I0_pp9_23 XI0_I1021_xan XI0_I1021_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1021_MN13 (XI0_I1021_xn1 XI0_I1021_xn I0_pp9_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1021_MN2 (VSS I0_A_23_b3_3 XI0_I1021_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1021_MN4 (XI0_I1021_n2 I0_A_22_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1021_MN3 (XI0_I1021_xn I0_two9_b3_4 XI0_I1021_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1021_MN1 (XI0_I1021_n1 I0_one9_b3_4 XI0_I1021_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1021_MN9 (VSS XI0_I1021_xn XI0_I1021_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1329_MN11 (VSS I0_B_31_b3_0 XI0_I1329_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1329_MN14 (VSS XI0_I1329_xbn XI0_I1329_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1329_MN16 (XI0_I1329_xn2 I0_B_31_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1329_MN15 (I0_pp15_1 XI0_I1329_xan XI0_I1329_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1329_MN13 (XI0_I1329_xn1 XI0_I1329_xn I0_pp15_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1329_MN2 (VSS I0_A_1_b3_5 XI0_I1329_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1329_MN4 (XI0_I1329_n2 I0_A_0_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1329_MN3 (XI0_I1329_xn I0_two15_b3_0 XI0_I1329_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1329_MN1 (XI0_I1329_n1 I0_one15_b3_0 XI0_I1329_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1329_MN9 (VSS XI0_I1329_xn XI0_I1329_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1273_MN11 (VSS I0_B_29_b3_0 XI0_I1273_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1273_MN14 (VSS XI0_I1273_xbn XI0_I1273_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1273_MN16 (XI0_I1273_xn2 I0_B_29_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1273_MN15 (I0_pp14_0 XI0_I1273_xan XI0_I1273_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1273_MN13 (XI0_I1273_xn1 XI0_I1273_xn I0_pp14_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1273_MN2 (VSS I0_A_0_b3_5 XI0_I1273_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1273_MN4 (XI0_I1273_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1273_MN3 (XI0_I1273_xn I0_two14_b3_0 XI0_I1273_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1273_MN1 (XI0_I1273_n1 I0_one14_b3_0 XI0_I1273_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1273_MN9 (VSS XI0_I1273_xn XI0_I1273_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1275_MN11 (VSS I0_B_29_b3_0 XI0_I1275_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1275_MN14 (VSS XI0_I1275_xbn XI0_I1275_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1275_MN16 (XI0_I1275_xn2 I0_B_29_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1275_MN15 (I0_pp14_2 XI0_I1275_xan XI0_I1275_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1275_MN13 (XI0_I1275_xn1 XI0_I1275_xn I0_pp14_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1275_MN2 (VSS I0_A_2_b3_5 XI0_I1275_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1275_MN4 (XI0_I1275_n2 I0_A_1_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1275_MN3 (XI0_I1275_xn I0_two14_b3_0 XI0_I1275_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1275_MN1 (XI0_I1275_n1 I0_one14_b3_0 XI0_I1275_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1275_MN9 (VSS XI0_I1275_xn XI0_I1275_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1328_MN11 (VSS I0_B_31_b3_0 XI0_I1328_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1328_MN14 (VSS XI0_I1328_xbn XI0_I1328_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1328_MN16 (XI0_I1328_xn2 I0_B_31_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1328_MN15 (I0_pp15_0 XI0_I1328_xan XI0_I1328_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1328_MN13 (XI0_I1328_xn1 XI0_I1328_xn I0_pp15_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1328_MN2 (VSS I0_A_0_b3_5 XI0_I1328_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1328_MN4 (XI0_I1328_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1328_MN3 (XI0_I1328_xn I0_two15_b3_0 XI0_I1328_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1328_MN1 (XI0_I1328_n1 I0_one15_b3_0 XI0_I1328_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1328_MN9 (VSS XI0_I1328_xn XI0_I1328_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1276_MN11 (VSS I0_B_29_b3_0 XI0_I1276_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1276_MN14 (VSS XI0_I1276_xbn XI0_I1276_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1276_MN16 (XI0_I1276_xn2 I0_B_29_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1276_MN15 (I0_pp14_3 XI0_I1276_xan XI0_I1276_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1276_MN13 (XI0_I1276_xn1 XI0_I1276_xn I0_pp14_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1276_MN2 (VSS I0_A_3_b3_5 XI0_I1276_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1276_MN4 (XI0_I1276_n2 I0_A_2_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1276_MN3 (XI0_I1276_xn I0_two14_b3_0 XI0_I1276_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1276_MN1 (XI0_I1276_n1 I0_one14_b3_0 XI0_I1276_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1276_MN9 (VSS XI0_I1276_xn XI0_I1276_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1331_MN11 (VSS I0_B_31_b3_0 XI0_I1331_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1331_MN14 (VSS XI0_I1331_xbn XI0_I1331_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1331_MN16 (XI0_I1331_xn2 I0_B_31_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1331_MN15 (I0_pp15_3 XI0_I1331_xan XI0_I1331_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1331_MN13 (XI0_I1331_xn1 XI0_I1331_xn I0_pp15_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1331_MN2 (VSS I0_A_3_b3_5 XI0_I1331_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1331_MN4 (XI0_I1331_n2 I0_A_2_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1331_MN3 (XI0_I1331_xn I0_two15_b3_0 XI0_I1331_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1331_MN1 (XI0_I1331_n1 I0_one15_b3_0 XI0_I1331_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1331_MN9 (VSS XI0_I1331_xn XI0_I1331_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1340_MN11 (VSS I0_B_31_b3_2 XI0_I1340_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1340_MN14 (VSS XI0_I1340_xbn XI0_I1340_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1340_MN16 (XI0_I1340_xn2 I0_B_31_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1340_MN15 (I0_pp15_12 XI0_I1340_xan XI0_I1340_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1340_MN13 (XI0_I1340_xn1 XI0_I1340_xn I0_pp15_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1340_MN2 (VSS I0_A_12_b3_5 XI0_I1340_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1340_MN4 (XI0_I1340_n2 I0_A_11_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1340_MN3 (XI0_I1340_xn I0_two15_b3_2 XI0_I1340_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1340_MN1 (XI0_I1340_n1 I0_one15_b3_2 XI0_I1340_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1340_MN9 (VSS XI0_I1340_xn XI0_I1340_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1339_MN11 (VSS I0_B_31_b3_2 XI0_I1339_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1339_MN14 (VSS XI0_I1339_xbn XI0_I1339_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1339_MN16 (XI0_I1339_xn2 I0_B_31_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1339_MN15 (I0_pp15_11 XI0_I1339_xan XI0_I1339_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1339_MN13 (XI0_I1339_xn1 XI0_I1339_xn I0_pp15_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1339_MN2 (VSS I0_A_11_b3_5 XI0_I1339_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1339_MN4 (XI0_I1339_n2 I0_A_10_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1339_MN3 (XI0_I1339_xn I0_two15_b3_2 XI0_I1339_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1339_MN1 (XI0_I1339_n1 I0_one15_b3_2 XI0_I1339_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1339_MN9 (VSS XI0_I1339_xn XI0_I1339_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1286_MN11 (VSS I0_B_29_b3_2 XI0_I1286_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1286_MN14 (VSS XI0_I1286_xbn XI0_I1286_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1286_MN16 (XI0_I1286_xn2 I0_B_29_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1286_MN15 (I0_pp14_13 XI0_I1286_xan XI0_I1286_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1286_MN13 (XI0_I1286_xn1 XI0_I1286_xn I0_pp14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1286_MN2 (VSS I0_A_13_b3_5 XI0_I1286_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1286_MN4 (XI0_I1286_n2 I0_A_12_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1286_MN3 (XI0_I1286_xn I0_two14_b3_2 XI0_I1286_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1286_MN1 (XI0_I1286_n1 I0_one14_b3_2 XI0_I1286_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1286_MN9 (VSS XI0_I1286_xn XI0_I1286_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I967_MN11 (VSS I0_B_17_b3_4 XI0_I967_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I967_MN14 (VSS XI0_I967_xbn XI0_I967_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I967_MN16 (XI0_I967_xn2 I0_B_17_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I967_MN15 (I0_pp8_24 XI0_I967_xan XI0_I967_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I967_MN13 (XI0_I967_xn1 XI0_I967_xn I0_pp8_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I967_MN2 (VSS I0_A_24_b3_3 XI0_I967_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I967_MN4 (XI0_I967_n2 I0_A_23_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I967_MN3 (XI0_I967_xn I0_two8_b3_4 XI0_I967_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I967_MN1 (XI0_I967_n1 I0_one8_b3_4 XI0_I967_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I967_MN9 (VSS XI0_I967_xn XI0_I967_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1289_MN11 (VSS I0_B_29_b3_2 XI0_I1289_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1289_MN14 (VSS XI0_I1289_xbn XI0_I1289_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1289_MN16 (XI0_I1289_xn2 I0_B_29_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1289_MN15 (I0_pp14_16 XI0_I1289_xan XI0_I1289_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1289_MN13 (XI0_I1289_xn1 XI0_I1289_xn I0_pp14_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1289_MN2 (VSS I0_A_16_b3_5 XI0_I1289_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1289_MN4 (XI0_I1289_n2 I0_A_15_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1289_MN3 (XI0_I1289_xn I0_two14_b3_2 XI0_I1289_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1289_MN1 (XI0_I1289_n1 I0_one14_b3_2 XI0_I1289_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1289_MN9 (VSS XI0_I1289_xn XI0_I1289_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1288_MN11 (VSS I0_B_29_b3_2 XI0_I1288_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1288_MN14 (VSS XI0_I1288_xbn XI0_I1288_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1288_MN16 (XI0_I1288_xn2 I0_B_29_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1288_MN15 (I0_pp14_15 XI0_I1288_xan XI0_I1288_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1288_MN13 (XI0_I1288_xn1 XI0_I1288_xn I0_pp14_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1288_MN2 (VSS I0_A_15_b3_5 XI0_I1288_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1288_MN4 (XI0_I1288_n2 I0_A_14_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1288_MN3 (XI0_I1288_xn I0_two14_b3_2 XI0_I1288_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1288_MN1 (XI0_I1288_n1 I0_one14_b3_2 XI0_I1288_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1288_MN9 (VSS XI0_I1288_xn XI0_I1288_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1341_MN11 (VSS I0_B_31_b3_2 XI0_I1341_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1341_MN14 (VSS XI0_I1341_xbn XI0_I1341_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1341_MN16 (XI0_I1341_xn2 I0_B_31_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1341_MN15 (I0_pp15_13 XI0_I1341_xan XI0_I1341_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1341_MN13 (XI0_I1341_xn1 XI0_I1341_xn I0_pp15_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1341_MN2 (VSS I0_A_13_b3_5 XI0_I1341_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1341_MN4 (XI0_I1341_n2 I0_A_12_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1341_MN3 (XI0_I1341_xn I0_two15_b3_2 XI0_I1341_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1341_MN1 (XI0_I1341_n1 I0_one15_b3_2 XI0_I1341_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1341_MN9 (VSS XI0_I1341_xn XI0_I1341_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1287_MN11 (VSS I0_B_29_b3_2 XI0_I1287_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1287_MN14 (VSS XI0_I1287_xbn XI0_I1287_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1287_MN16 (XI0_I1287_xn2 I0_B_29_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1287_MN15 (I0_pp14_14 XI0_I1287_xan XI0_I1287_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1287_MN13 (XI0_I1287_xn1 XI0_I1287_xn I0_pp14_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1287_MN2 (VSS I0_A_14_b3_5 XI0_I1287_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1287_MN4 (XI0_I1287_n2 I0_A_13_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1287_MN3 (XI0_I1287_xn I0_two14_b3_2 XI0_I1287_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1287_MN1 (XI0_I1287_n1 I0_one14_b3_2 XI0_I1287_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1287_MN9 (VSS XI0_I1287_xn XI0_I1287_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1075_MN11 (VSS I0_B_21_b3_3 XI0_I1075_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1075_MN14 (VSS XI0_I1075_xbn XI0_I1075_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1075_MN16 (XI0_I1075_xn2 I0_B_21_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1075_MN15 (I0_pp10_22 XI0_I1075_xan XI0_I1075_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1075_MN13 (XI0_I1075_xn1 XI0_I1075_xn I0_pp10_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1075_MN2 (VSS I0_A_22_b3_3 XI0_I1075_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1075_MN4 (XI0_I1075_n2 I0_A_21_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1075_MN3 (XI0_I1075_xn I0_two10_b3_4 XI0_I1075_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1075_MN1 (XI0_I1075_n1 I0_one10_b3_4 XI0_I1075_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1075_MN9 (VSS XI0_I1075_xn XI0_I1075_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I968_MN11 (VSS I0_B_17_b3_4 XI0_I968_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I968_MN14 (VSS XI0_I968_xbn XI0_I968_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I968_MN16 (XI0_I968_xn2 I0_B_17_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I968_MN15 (I0_pp8_25 XI0_I968_xan XI0_I968_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I968_MN13 (XI0_I968_xn1 XI0_I968_xn I0_pp8_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I968_MN2 (VSS I0_A_25_b3_3 XI0_I968_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I968_MN4 (XI0_I968_n2 I0_A_24_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I968_MN3 (XI0_I968_xn I0_two8_b3_4 XI0_I968_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I968_MN1 (XI0_I968_n1 I0_one8_b3_4 XI0_I968_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I968_MN9 (VSS XI0_I968_xn XI0_I968_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1022_MN11 (VSS I0_B_19_b3_4 XI0_I1022_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1022_MN14 (VSS XI0_I1022_xbn XI0_I1022_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1022_MN16 (XI0_I1022_xn2 I0_B_19_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1022_MN15 (I0_pp9_24 XI0_I1022_xan XI0_I1022_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1022_MN13 (XI0_I1022_xn1 XI0_I1022_xn I0_pp9_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1022_MN2 (VSS I0_A_24_b3_3 XI0_I1022_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1022_MN4 (XI0_I1022_n2 I0_A_23_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1022_MN3 (XI0_I1022_xn I0_two9_b3_4 XI0_I1022_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1022_MN1 (XI0_I1022_n1 I0_one9_b3_4 XI0_I1022_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1022_MN9 (VSS XI0_I1022_xn XI0_I1022_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1344_MN11 (VSS I0_B_31_b3_2 XI0_I1344_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1344_MN14 (VSS XI0_I1344_xbn XI0_I1344_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1344_MN16 (XI0_I1344_xn2 I0_B_31_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1344_MN15 (I0_pp15_16 XI0_I1344_xan XI0_I1344_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1344_MN13 (XI0_I1344_xn1 XI0_I1344_xn I0_pp15_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1344_MN2 (VSS I0_A_16_b3_5 XI0_I1344_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1344_MN4 (XI0_I1344_n2 I0_A_15_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1344_MN3 (XI0_I1344_xn I0_two15_b3_2 XI0_I1344_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1344_MN1 (XI0_I1344_n1 I0_one15_b3_2 XI0_I1344_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1344_MN9 (VSS XI0_I1344_xn XI0_I1344_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1343_MN11 (VSS I0_B_31_b3_2 XI0_I1343_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1343_MN14 (VSS XI0_I1343_xbn XI0_I1343_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1343_MN16 (XI0_I1343_xn2 I0_B_31_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1343_MN15 (I0_pp15_15 XI0_I1343_xan XI0_I1343_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1343_MN13 (XI0_I1343_xn1 XI0_I1343_xn I0_pp15_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1343_MN2 (VSS I0_A_15_b3_5 XI0_I1343_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1343_MN4 (XI0_I1343_n2 I0_A_14_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1343_MN3 (XI0_I1343_xn I0_two15_b3_2 XI0_I1343_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1343_MN1 (XI0_I1343_n1 I0_one15_b3_2 XI0_I1343_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1343_MN9 (VSS XI0_I1343_xn XI0_I1343_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1342_MN11 (VSS I0_B_31_b3_2 XI0_I1342_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1342_MN14 (VSS XI0_I1342_xbn XI0_I1342_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1342_MN16 (XI0_I1342_xn2 I0_B_31_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1342_MN15 (I0_pp15_14 XI0_I1342_xan XI0_I1342_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1342_MN13 (XI0_I1342_xn1 XI0_I1342_xn I0_pp15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1342_MN2 (VSS I0_A_14_b3_5 XI0_I1342_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1342_MN4 (XI0_I1342_n2 I0_A_13_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1342_MN3 (XI0_I1342_xn I0_two15_b3_2 XI0_I1342_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1342_MN1 (XI0_I1342_n1 I0_one15_b3_2 XI0_I1342_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1342_MN9 (VSS XI0_I1342_xn XI0_I1342_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1077_MN11 (VSS I0_B_21_b3_4 XI0_I1077_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1077_MN14 (VSS XI0_I1077_xbn XI0_I1077_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1077_MN16 (XI0_I1077_xn2 I0_B_21_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1077_MN15 (I0_pp10_24 XI0_I1077_xan XI0_I1077_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1077_MN13 (XI0_I1077_xn1 XI0_I1077_xn I0_pp10_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1077_MN2 (VSS I0_A_24_b3_3 XI0_I1077_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1077_MN4 (XI0_I1077_n2 I0_A_23_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1077_MN3 (XI0_I1077_xn I0_two10_b3_4 XI0_I1077_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1077_MN1 (XI0_I1077_n1 I0_one10_b3_4 XI0_I1077_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1077_MN9 (VSS XI0_I1077_xn XI0_I1077_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I970_MN11 (VSS I0_B_17_b3_4 XI0_I970_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I970_MN14 (VSS XI0_I970_xbn XI0_I970_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I970_MN16 (XI0_I970_xn2 I0_B_17_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I970_MN15 (I0_pp8_27 XI0_I970_xan XI0_I970_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I970_MN13 (XI0_I970_xn1 XI0_I970_xn I0_pp8_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I970_MN2 (VSS I0_A_27_b3_3 XI0_I970_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I970_MN4 (XI0_I970_n2 I0_A_26_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I970_MN3 (XI0_I970_xn I0_two8_b3_4 XI0_I970_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I970_MN1 (XI0_I970_n1 I0_one8_b3_4 XI0_I970_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I970_MN9 (VSS XI0_I970_xn XI0_I970_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I969_MN11 (VSS I0_B_17_b3_4 XI0_I969_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I969_MN14 (VSS XI0_I969_xbn XI0_I969_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I969_MN16 (XI0_I969_xn2 I0_B_17_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I969_MN15 (I0_pp8_26 XI0_I969_xan XI0_I969_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I969_MN13 (XI0_I969_xn1 XI0_I969_xn I0_pp8_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I969_MN2 (VSS I0_A_26_b3_3 XI0_I969_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I969_MN4 (XI0_I969_n2 I0_A_25_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I969_MN3 (XI0_I969_xn I0_two8_b3_4 XI0_I969_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I969_MN1 (XI0_I969_n1 I0_one8_b3_4 XI0_I969_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I969_MN9 (VSS XI0_I969_xn XI0_I969_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1181_MN11 (VSS I0_B_25_b3_3 XI0_I1181_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1181_MN14 (VSS XI0_I1181_xbn XI0_I1181_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1181_MN16 (XI0_I1181_xn2 I0_B_25_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1181_MN15 (I0_pp12_18 XI0_I1181_xan XI0_I1181_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1181_MN13 (XI0_I1181_xn1 XI0_I1181_xn I0_pp12_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1181_MN2 (VSS I0_A_18_b3_4 XI0_I1181_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1181_MN4 (XI0_I1181_n2 I0_A_17_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1181_MN3 (XI0_I1181_xn I0_two12_b3_3 XI0_I1181_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1181_MN1 (XI0_I1181_n1 I0_one12_b3_3 XI0_I1181_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1181_MN9 (VSS XI0_I1181_xn XI0_I1181_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1126_MN11 (VSS I0_B_23_b3_3 XI0_I1126_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1126_MN14 (VSS XI0_I1126_xbn XI0_I1126_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1126_MN16 (XI0_I1126_xn2 I0_B_23_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1126_MN15 (I0_pp11_18 XI0_I1126_xan XI0_I1126_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1126_MN13 (XI0_I1126_xn1 XI0_I1126_xn I0_pp11_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1126_MN2 (VSS I0_A_18_b3_4 XI0_I1126_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1126_MN4 (XI0_I1126_n2 I0_A_17_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1126_MN3 (XI0_I1126_xn I0_two11_b3_3 XI0_I1126_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1126_MN1 (XI0_I1126_n1 I0_one11_b3_3 XI0_I1126_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1126_MN9 (VSS XI0_I1126_xn XI0_I1126_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1180_MN11 (VSS I0_B_25_b3_3 XI0_I1180_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1180_MN14 (VSS XI0_I1180_xbn XI0_I1180_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1180_MN16 (XI0_I1180_xn2 I0_B_25_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1180_MN15 (I0_pp12_17 XI0_I1180_xan XI0_I1180_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1180_MN13 (XI0_I1180_xn1 XI0_I1180_xn I0_pp12_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1180_MN2 (VSS I0_A_17_b3_4 XI0_I1180_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1180_MN4 (XI0_I1180_n2 I0_A_16_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1180_MN3 (XI0_I1180_xn I0_two12_b3_3 XI0_I1180_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1180_MN1 (XI0_I1180_n1 I0_one12_b3_3 XI0_I1180_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1180_MN9 (VSS XI0_I1180_xn XI0_I1180_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1125_MN11 (VSS I0_B_23_b3_3 XI0_I1125_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1125_MN14 (VSS XI0_I1125_xbn XI0_I1125_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1125_MN16 (XI0_I1125_xn2 I0_B_23_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1125_MN15 (I0_pp11_17 XI0_I1125_xan XI0_I1125_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1125_MN13 (XI0_I1125_xn1 XI0_I1125_xn I0_pp11_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1125_MN2 (VSS I0_A_17_b3_4 XI0_I1125_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1125_MN4 (XI0_I1125_n2 I0_A_16_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1125_MN3 (XI0_I1125_xn I0_two11_b3_3 XI0_I1125_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1125_MN1 (XI0_I1125_n1 I0_one11_b3_3 XI0_I1125_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1125_MN9 (VSS XI0_I1125_xn XI0_I1125_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1079_MN11 (VSS I0_B_21_b3_4 XI0_I1079_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1079_MN14 (VSS XI0_I1079_xbn XI0_I1079_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1079_MN16 (XI0_I1079_xn2 I0_B_21_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1079_MN15 (I0_pp10_26 XI0_I1079_xan XI0_I1079_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1079_MN13 (XI0_I1079_xn1 XI0_I1079_xn I0_pp10_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1079_MN2 (VSS I0_A_26_b3_3 XI0_I1079_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1079_MN4 (XI0_I1079_n2 I0_A_25_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1079_MN3 (XI0_I1079_xn I0_two10_b3_4 XI0_I1079_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1079_MN1 (XI0_I1079_n1 I0_one10_b3_4 XI0_I1079_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1079_MN9 (VSS XI0_I1079_xn XI0_I1079_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1078_MN11 (VSS I0_B_21_b3_4 XI0_I1078_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1078_MN14 (VSS XI0_I1078_xbn XI0_I1078_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1078_MN16 (XI0_I1078_xn2 I0_B_21_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1078_MN15 (I0_pp10_25 XI0_I1078_xan XI0_I1078_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1078_MN13 (XI0_I1078_xn1 XI0_I1078_xn I0_pp10_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1078_MN2 (VSS I0_A_25_b3_3 XI0_I1078_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1078_MN4 (XI0_I1078_n2 I0_A_24_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1078_MN3 (XI0_I1078_xn I0_two10_b3_4 XI0_I1078_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1078_MN1 (XI0_I1078_n1 I0_one10_b3_4 XI0_I1078_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1078_MN9 (VSS XI0_I1078_xn XI0_I1078_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1024_MN11 (VSS I0_B_19_b3_4 XI0_I1024_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1024_MN14 (VSS XI0_I1024_xbn XI0_I1024_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1024_MN16 (XI0_I1024_xn2 I0_B_19_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1024_MN15 (I0_pp9_26 XI0_I1024_xan XI0_I1024_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1024_MN13 (XI0_I1024_xn1 XI0_I1024_xn I0_pp9_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1024_MN2 (VSS I0_A_26_b3_3 XI0_I1024_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1024_MN4 (XI0_I1024_n2 I0_A_25_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1024_MN3 (XI0_I1024_xn I0_two9_b3_4 XI0_I1024_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1024_MN1 (XI0_I1024_n1 I0_one9_b3_4 XI0_I1024_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1024_MN9 (VSS XI0_I1024_xn XI0_I1024_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1076_MN11 (VSS I0_B_21_b3_4 XI0_I1076_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1076_MN14 (VSS XI0_I1076_xbn XI0_I1076_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1076_MN16 (XI0_I1076_xn2 I0_B_21_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1076_MN15 (I0_pp10_23 XI0_I1076_xan XI0_I1076_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1076_MN13 (XI0_I1076_xn1 XI0_I1076_xn I0_pp10_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1076_MN2 (VSS I0_A_23_b3_3 XI0_I1076_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1076_MN4 (XI0_I1076_n2 I0_A_22_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1076_MN3 (XI0_I1076_xn I0_two10_b3_4 XI0_I1076_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1076_MN1 (XI0_I1076_n1 I0_one10_b3_4 XI0_I1076_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1076_MN9 (VSS XI0_I1076_xn XI0_I1076_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1080_MN11 (VSS I0_B_21_b3_4 XI0_I1080_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1080_MN14 (VSS XI0_I1080_xbn XI0_I1080_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1080_MN16 (XI0_I1080_xn2 I0_B_21_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1080_MN15 (I0_pp10_27 XI0_I1080_xan XI0_I1080_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1080_MN13 (XI0_I1080_xn1 XI0_I1080_xn I0_pp10_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1080_MN2 (VSS I0_A_27_b3_3 XI0_I1080_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1080_MN4 (XI0_I1080_n2 I0_A_26_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1080_MN3 (XI0_I1080_xn I0_two10_b3_4 XI0_I1080_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1080_MN1 (XI0_I1080_n1 I0_one10_b3_4 XI0_I1080_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1080_MN9 (VSS XI0_I1080_xn XI0_I1080_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1025_MN11 (VSS I0_B_19_b3_4 XI0_I1025_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1025_MN14 (VSS XI0_I1025_xbn XI0_I1025_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1025_MN16 (XI0_I1025_xn2 I0_B_19_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1025_MN15 (I0_pp9_27 XI0_I1025_xan XI0_I1025_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1025_MN13 (XI0_I1025_xn1 XI0_I1025_xn I0_pp9_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1025_MN2 (VSS I0_A_27_b3_3 XI0_I1025_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1025_MN4 (XI0_I1025_n2 I0_A_26_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1025_MN3 (XI0_I1025_xn I0_two9_b3_4 XI0_I1025_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1025_MN1 (XI0_I1025_n1 I0_one9_b3_4 XI0_I1025_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1025_MN9 (VSS XI0_I1025_xn XI0_I1025_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1023_MN11 (VSS I0_B_19_b3_4 XI0_I1023_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1023_MN14 (VSS XI0_I1023_xbn XI0_I1023_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1023_MN16 (XI0_I1023_xn2 I0_B_19_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1023_MN15 (I0_pp9_25 XI0_I1023_xan XI0_I1023_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1023_MN13 (XI0_I1023_xn1 XI0_I1023_xn I0_pp9_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1023_MN2 (VSS I0_A_25_b3_3 XI0_I1023_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1023_MN4 (XI0_I1023_n2 I0_A_24_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1023_MN3 (XI0_I1023_xn I0_two9_b3_4 XI0_I1023_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1023_MN1 (XI0_I1023_n1 I0_one9_b3_4 XI0_I1023_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1023_MN9 (VSS XI0_I1023_xn XI0_I1023_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1236_MN11 (VSS I0_B_27_b3_3 XI0_I1236_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1236_MN14 (VSS XI0_I1236_xbn XI0_I1236_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1236_MN16 (XI0_I1236_xn2 I0_B_27_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1236_MN15 (I0_pp13_18 XI0_I1236_xan XI0_I1236_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1236_MN13 (XI0_I1236_xn1 XI0_I1236_xn I0_pp13_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1236_MN2 (VSS I0_A_18_b3_4 XI0_I1236_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1236_MN4 (XI0_I1236_n2 I0_A_17_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1236_MN3 (XI0_I1236_xn I0_two13_b3_3 XI0_I1236_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1236_MN1 (XI0_I1236_n1 I0_one13_b3_3 XI0_I1236_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1236_MN9 (VSS XI0_I1236_xn XI0_I1236_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1235_MN11 (VSS I0_B_27_b3_3 XI0_I1235_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1235_MN14 (VSS XI0_I1235_xbn XI0_I1235_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1235_MN16 (XI0_I1235_xn2 I0_B_27_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1235_MN15 (I0_pp13_17 XI0_I1235_xan XI0_I1235_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1235_MN13 (XI0_I1235_xn1 XI0_I1235_xn I0_pp13_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1235_MN2 (VSS I0_A_17_b3_4 XI0_I1235_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1235_MN4 (XI0_I1235_n2 I0_A_16_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1235_MN3 (XI0_I1235_xn I0_two13_b3_3 XI0_I1235_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1235_MN1 (XI0_I1235_n1 I0_one13_b3_3 XI0_I1235_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1235_MN9 (VSS XI0_I1235_xn XI0_I1235_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1183_MN11 (VSS I0_B_25_b3_3 XI0_I1183_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1183_MN14 (VSS XI0_I1183_xbn XI0_I1183_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1183_MN16 (XI0_I1183_xn2 I0_B_25_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1183_MN15 (I0_pp12_20 XI0_I1183_xan XI0_I1183_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1183_MN13 (XI0_I1183_xn1 XI0_I1183_xn I0_pp12_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1183_MN2 (VSS I0_A_20_b3_4 XI0_I1183_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1183_MN4 (XI0_I1183_n2 I0_A_19_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1183_MN3 (XI0_I1183_xn I0_two12_b3_3 XI0_I1183_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1183_MN1 (XI0_I1183_n1 I0_one12_b3_3 XI0_I1183_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1183_MN9 (VSS XI0_I1183_xn XI0_I1183_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1182_MN11 (VSS I0_B_25_b3_3 XI0_I1182_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1182_MN14 (VSS XI0_I1182_xbn XI0_I1182_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1182_MN16 (XI0_I1182_xn2 I0_B_25_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1182_MN15 (I0_pp12_19 XI0_I1182_xan XI0_I1182_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1182_MN13 (XI0_I1182_xn1 XI0_I1182_xn I0_pp12_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1182_MN2 (VSS I0_A_19_b3_4 XI0_I1182_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1182_MN4 (XI0_I1182_n2 I0_A_18_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1182_MN3 (XI0_I1182_xn I0_two12_b3_3 XI0_I1182_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1182_MN1 (XI0_I1182_n1 I0_one12_b3_3 XI0_I1182_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1182_MN9 (VSS XI0_I1182_xn XI0_I1182_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1128_MN11 (VSS I0_B_23_b3_3 XI0_I1128_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1128_MN14 (VSS XI0_I1128_xbn XI0_I1128_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1128_MN16 (XI0_I1128_xn2 I0_B_23_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1128_MN15 (I0_pp11_20 XI0_I1128_xan XI0_I1128_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1128_MN13 (XI0_I1128_xn1 XI0_I1128_xn I0_pp11_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1128_MN2 (VSS I0_A_20_b3_4 XI0_I1128_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1128_MN4 (XI0_I1128_n2 I0_A_19_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1128_MN3 (XI0_I1128_xn I0_two11_b3_3 XI0_I1128_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1128_MN1 (XI0_I1128_n1 I0_one11_b3_3 XI0_I1128_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1128_MN9 (VSS XI0_I1128_xn XI0_I1128_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1127_MN11 (VSS I0_B_23_b3_3 XI0_I1127_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1127_MN14 (VSS XI0_I1127_xbn XI0_I1127_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1127_MN16 (XI0_I1127_xn2 I0_B_23_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1127_MN15 (I0_pp11_19 XI0_I1127_xan XI0_I1127_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1127_MN13 (XI0_I1127_xn1 XI0_I1127_xn I0_pp11_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1127_MN2 (VSS I0_A_19_b3_4 XI0_I1127_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1127_MN4 (XI0_I1127_n2 I0_A_18_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1127_MN3 (XI0_I1127_xn I0_two11_b3_3 XI0_I1127_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1127_MN1 (XI0_I1127_n1 I0_one11_b3_3 XI0_I1127_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1127_MN9 (VSS XI0_I1127_xn XI0_I1127_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1193_MN11 (VSS I0_B_25_b3_5 XI0_I1193_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1193_MN14 (VSS XI0_I1193_xbn XI0_I1193_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1193_MN16 (XI0_I1193_xn2 I0_B_25_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1193_MN15 (I0_pp12_30 XI0_I1193_xan XI0_I1193_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1193_MN13 (XI0_I1193_xn1 XI0_I1193_xn I0_pp12_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1193_MN2 (VSS I0_A_30_b3_4 XI0_I1193_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1193_MN4 (XI0_I1193_n2 I0_A_29_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1193_MN3 (XI0_I1193_xn I0_two12_b3_5 XI0_I1193_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1193_MN1 (XI0_I1193_n1 I0_one12_b3_5 XI0_I1193_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1193_MN9 (VSS XI0_I1193_xn XI0_I1193_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1237_MN11 (VSS I0_B_27_b3_3 XI0_I1237_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1237_MN14 (VSS XI0_I1237_xbn XI0_I1237_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1237_MN16 (XI0_I1237_xn2 I0_B_27_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1237_MN15 (I0_pp13_19 XI0_I1237_xan XI0_I1237_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1237_MN13 (XI0_I1237_xn1 XI0_I1237_xn I0_pp13_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1237_MN2 (VSS I0_A_19_b3_4 XI0_I1237_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1237_MN4 (XI0_I1237_n2 I0_A_18_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1237_MN3 (XI0_I1237_xn I0_two13_b3_3 XI0_I1237_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1237_MN1 (XI0_I1237_n1 I0_one13_b3_3 XI0_I1237_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1237_MN9 (VSS XI0_I1237_xn XI0_I1237_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1184_MN11 (VSS I0_B_25_b3_3 XI0_I1184_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1184_MN14 (VSS XI0_I1184_xbn XI0_I1184_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1184_MN16 (XI0_I1184_xn2 I0_B_25_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1184_MN15 (I0_pp12_21 XI0_I1184_xan XI0_I1184_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1184_MN13 (XI0_I1184_xn1 XI0_I1184_xn I0_pp12_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1184_MN2 (VSS I0_A_21_b3_4 XI0_I1184_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1184_MN4 (XI0_I1184_n2 I0_A_20_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1184_MN3 (XI0_I1184_xn I0_two12_b3_3 XI0_I1184_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1184_MN1 (XI0_I1184_n1 I0_one12_b3_3 XI0_I1184_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1184_MN9 (VSS XI0_I1184_xn XI0_I1184_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1129_MN11 (VSS I0_B_23_b3_3 XI0_I1129_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1129_MN14 (VSS XI0_I1129_xbn XI0_I1129_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1129_MN16 (XI0_I1129_xn2 I0_B_23_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1129_MN15 (I0_pp11_21 XI0_I1129_xan XI0_I1129_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1129_MN13 (XI0_I1129_xn1 XI0_I1129_xn I0_pp11_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1129_MN2 (VSS I0_A_21_b3_4 XI0_I1129_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1129_MN4 (XI0_I1129_n2 I0_A_20_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1129_MN3 (XI0_I1129_xn I0_two11_b3_3 XI0_I1129_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1129_MN1 (XI0_I1129_n1 I0_one11_b3_3 XI0_I1129_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1129_MN9 (VSS XI0_I1129_xn XI0_I1129_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1195_MN11 (VSS I0_B_25_b3_5 XI0_I1195_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1195_MN14 (VSS XI0_I1195_xbn XI0_I1195_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1195_MN16 (XI0_I1195_xn2 I0_B_25_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1195_MN15 (I0_pp12_32 XI0_I1195_xan XI0_I1195_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1195_MN13 (XI0_I1195_xn1 XI0_I1195_xn I0_pp12_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1195_MN2 (VSS I0_A_31_b3_6 XI0_I1195_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1195_MN4 (XI0_I1195_n2 I0_A_31_b3_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1195_MN3 (XI0_I1195_xn I0_two12_b3_5 XI0_I1195_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1195_MN1 (XI0_I1195_n1 I0_one12_b3_5 XI0_I1195_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1195_MN9 (VSS XI0_I1195_xn XI0_I1195_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1250_MN11 (VSS I0_B_27_b3_5 XI0_I1250_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1250_MN14 (VSS XI0_I1250_xbn XI0_I1250_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1250_MN16 (XI0_I1250_xn2 I0_B_27_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1250_MN15 (I0_pp13_32 XI0_I1250_xan XI0_I1250_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1250_MN13 (XI0_I1250_xn1 XI0_I1250_xn I0_pp13_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1250_MN2 (VSS I0_A_31_b3_6 XI0_I1250_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1250_MN4 (XI0_I1250_n2 I0_A_31_b3_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1250_MN3 (XI0_I1250_xn I0_two13_b3_5 XI0_I1250_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1250_MN1 (XI0_I1250_n1 I0_one13_b3_5 XI0_I1250_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1250_MN9 (VSS XI0_I1250_xn XI0_I1250_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1194_MN11 (VSS I0_B_25_b3_5 XI0_I1194_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1194_MN14 (VSS XI0_I1194_xbn XI0_I1194_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1194_MN16 (XI0_I1194_xn2 I0_B_25_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1194_MN15 (I0_pp12_31 XI0_I1194_xan XI0_I1194_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1194_MN13 (XI0_I1194_xn1 XI0_I1194_xn I0_pp12_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1194_MN2 (VSS I0_A_31_b3_6 XI0_I1194_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1194_MN4 (XI0_I1194_n2 I0_A_30_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1194_MN3 (XI0_I1194_xn I0_two12_b3_5 XI0_I1194_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1194_MN1 (XI0_I1194_n1 I0_one12_b3_5 XI0_I1194_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1194_MN9 (VSS XI0_I1194_xn XI0_I1194_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1247_MN11 (VSS I0_B_27_b3_5 XI0_I1247_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1247_MN14 (VSS XI0_I1247_xbn XI0_I1247_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1247_MN16 (XI0_I1247_xn2 I0_B_27_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1247_MN15 (I0_pp13_29 XI0_I1247_xan XI0_I1247_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1247_MN13 (XI0_I1247_xn1 XI0_I1247_xn I0_pp13_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1247_MN2 (VSS I0_A_29_b3_4 XI0_I1247_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1247_MN4 (XI0_I1247_n2 I0_A_28_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1247_MN3 (XI0_I1247_xn I0_two13_b3_5 XI0_I1247_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1247_MN1 (XI0_I1247_n1 I0_one13_b3_5 XI0_I1247_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1247_MN9 (VSS XI0_I1247_xn XI0_I1247_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1192_MN11 (VSS I0_B_25_b3_5 XI0_I1192_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1192_MN14 (VSS XI0_I1192_xbn XI0_I1192_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1192_MN16 (XI0_I1192_xn2 I0_B_25_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1192_MN15 (I0_pp12_29 XI0_I1192_xan XI0_I1192_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1192_MN13 (XI0_I1192_xn1 XI0_I1192_xn I0_pp12_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1192_MN2 (VSS I0_A_29_b3_4 XI0_I1192_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1192_MN4 (XI0_I1192_n2 I0_A_28_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1192_MN3 (XI0_I1192_xn I0_two12_b3_5 XI0_I1192_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1192_MN1 (XI0_I1192_n1 I0_one12_b3_5 XI0_I1192_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1192_MN9 (VSS XI0_I1192_xn XI0_I1192_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1137_MN11 (VSS I0_B_23_b3_5 XI0_I1137_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1137_MN14 (VSS XI0_I1137_xbn XI0_I1137_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1137_MN16 (XI0_I1137_xn2 I0_B_23_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1137_MN15 (I0_pp11_29 XI0_I1137_xan XI0_I1137_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1137_MN13 (XI0_I1137_xn1 XI0_I1137_xn I0_pp11_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1137_MN2 (VSS I0_A_29_b3_4 XI0_I1137_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1137_MN4 (XI0_I1137_n2 I0_A_28_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1137_MN3 (XI0_I1137_xn I0_two11_b3_5 XI0_I1137_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1137_MN1 (XI0_I1137_n1 I0_one11_b3_5 XI0_I1137_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1137_MN9 (VSS XI0_I1137_xn XI0_I1137_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1191_MN11 (VSS I0_B_25_b3_4 XI0_I1191_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1191_MN14 (VSS XI0_I1191_xbn XI0_I1191_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1191_MN16 (XI0_I1191_xn2 I0_B_25_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1191_MN15 (I0_pp12_28 XI0_I1191_xan XI0_I1191_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1191_MN13 (XI0_I1191_xn1 XI0_I1191_xn I0_pp12_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1191_MN2 (VSS I0_A_28_b3_4 XI0_I1191_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1191_MN4 (XI0_I1191_n2 I0_A_27_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1191_MN3 (XI0_I1191_xn I0_two12_b3_5 XI0_I1191_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1191_MN1 (XI0_I1191_n1 I0_one12_b3_5 XI0_I1191_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1191_MN9 (VSS XI0_I1191_xn XI0_I1191_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1136_MN11 (VSS I0_B_23_b3_4 XI0_I1136_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1136_MN14 (VSS XI0_I1136_xbn XI0_I1136_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1136_MN16 (XI0_I1136_xn2 I0_B_23_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1136_MN15 (I0_pp11_28 XI0_I1136_xan XI0_I1136_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1136_MN13 (XI0_I1136_xn1 XI0_I1136_xn I0_pp11_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1136_MN2 (VSS I0_A_28_b3_4 XI0_I1136_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1136_MN4 (XI0_I1136_n2 I0_A_27_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1136_MN3 (XI0_I1136_xn I0_two11_b3_5 XI0_I1136_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1136_MN1 (XI0_I1136_n1 I0_one11_b3_5 XI0_I1136_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1136_MN9 (VSS XI0_I1136_xn XI0_I1136_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1239_MN11 (VSS I0_B_27_b3_3 XI0_I1239_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1239_MN14 (VSS XI0_I1239_xbn XI0_I1239_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1239_MN16 (XI0_I1239_xn2 I0_B_27_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1239_MN15 (I0_pp13_21 XI0_I1239_xan XI0_I1239_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1239_MN13 (XI0_I1239_xn1 XI0_I1239_xn I0_pp13_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1239_MN2 (VSS I0_A_21_b3_4 XI0_I1239_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1239_MN4 (XI0_I1239_n2 I0_A_20_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1239_MN3 (XI0_I1239_xn I0_two13_b3_3 XI0_I1239_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1239_MN1 (XI0_I1239_n1 I0_one13_b3_3 XI0_I1239_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1239_MN9 (VSS XI0_I1239_xn XI0_I1239_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1238_MN11 (VSS I0_B_27_b3_3 XI0_I1238_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1238_MN14 (VSS XI0_I1238_xbn XI0_I1238_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1238_MN16 (XI0_I1238_xn2 I0_B_27_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1238_MN15 (I0_pp13_20 XI0_I1238_xan XI0_I1238_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1238_MN13 (XI0_I1238_xn1 XI0_I1238_xn I0_pp13_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1238_MN2 (VSS I0_A_20_b3_4 XI0_I1238_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1238_MN4 (XI0_I1238_n2 I0_A_19_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1238_MN3 (XI0_I1238_xn I0_two13_b3_3 XI0_I1238_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1238_MN1 (XI0_I1238_n1 I0_one13_b3_3 XI0_I1238_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1238_MN9 (VSS XI0_I1238_xn XI0_I1238_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I971_MN11 (VSS I0_B_17_b3_4 XI0_I971_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I971_MN14 (VSS XI0_I971_xbn XI0_I971_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I971_MN16 (XI0_I971_xn2 I0_B_17_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I971_MN15 (I0_pp8_28 XI0_I971_xan XI0_I971_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I971_MN13 (XI0_I971_xn1 XI0_I971_xn I0_pp8_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I971_MN2 (VSS I0_A_28_b3_3 XI0_I971_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I971_MN4 (XI0_I971_n2 I0_A_27_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I971_MN3 (XI0_I971_xn I0_two8_b3_5 XI0_I971_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I971_MN1 (XI0_I971_n1 I0_one8_b3_5 XI0_I971_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I971_MN9 (VSS XI0_I971_xn XI0_I971_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1248_MN11 (VSS I0_B_27_b3_5 XI0_I1248_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1248_MN14 (VSS XI0_I1248_xbn XI0_I1248_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1248_MN16 (XI0_I1248_xn2 I0_B_27_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1248_MN15 (I0_pp13_30 XI0_I1248_xan XI0_I1248_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1248_MN13 (XI0_I1248_xn1 XI0_I1248_xn I0_pp13_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1248_MN2 (VSS I0_A_30_b3_4 XI0_I1248_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1248_MN4 (XI0_I1248_n2 I0_A_29_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1248_MN3 (XI0_I1248_xn I0_two13_b3_5 XI0_I1248_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1248_MN1 (XI0_I1248_n1 I0_one13_b3_5 XI0_I1248_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1248_MN9 (VSS XI0_I1248_xn XI0_I1248_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1249_MN11 (VSS I0_B_27_b3_5 XI0_I1249_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1249_MN14 (VSS XI0_I1249_xbn XI0_I1249_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1249_MN16 (XI0_I1249_xn2 I0_B_27_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1249_MN15 (I0_pp13_31 XI0_I1249_xan XI0_I1249_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1249_MN13 (XI0_I1249_xn1 XI0_I1249_xn I0_pp13_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1249_MN2 (VSS I0_A_31_b3_6 XI0_I1249_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1249_MN4 (XI0_I1249_n2 I0_A_30_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1249_MN3 (XI0_I1249_xn I0_two13_b3_5 XI0_I1249_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1249_MN1 (XI0_I1249_n1 I0_one13_b3_5 XI0_I1249_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1249_MN9 (VSS XI0_I1249_xn XI0_I1249_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1138_MN11 (VSS I0_B_23_b3_5 XI0_I1138_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1138_MN14 (VSS XI0_I1138_xbn XI0_I1138_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1138_MN16 (XI0_I1138_xn2 I0_B_23_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1138_MN15 (I0_pp11_30 XI0_I1138_xan XI0_I1138_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1138_MN13 (XI0_I1138_xn1 XI0_I1138_xn I0_pp11_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1138_MN2 (VSS I0_A_30_b3_4 XI0_I1138_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1138_MN4 (XI0_I1138_n2 I0_A_29_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1138_MN3 (XI0_I1138_xn I0_two11_b3_5 XI0_I1138_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1138_MN1 (XI0_I1138_n1 I0_one11_b3_5 XI0_I1138_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1138_MN9 (VSS XI0_I1138_xn XI0_I1138_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1246_MN11 (VSS I0_B_27_b3_4 XI0_I1246_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1246_MN14 (VSS XI0_I1246_xbn XI0_I1246_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1246_MN16 (XI0_I1246_xn2 I0_B_27_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1246_MN15 (I0_pp13_28 XI0_I1246_xan XI0_I1246_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1246_MN13 (XI0_I1246_xn1 XI0_I1246_xn I0_pp13_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1246_MN2 (VSS I0_A_28_b3_4 XI0_I1246_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1246_MN4 (XI0_I1246_n2 I0_A_27_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1246_MN3 (XI0_I1246_xn I0_two13_b3_5 XI0_I1246_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1246_MN1 (XI0_I1246_n1 I0_one13_b3_5 XI0_I1246_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1246_MN9 (VSS XI0_I1246_xn XI0_I1246_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1139_MN11 (VSS I0_B_23_b3_5 XI0_I1139_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1139_MN14 (VSS XI0_I1139_xbn XI0_I1139_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1139_MN16 (XI0_I1139_xn2 I0_B_23_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1139_MN15 (I0_pp11_31 XI0_I1139_xan XI0_I1139_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1139_MN13 (XI0_I1139_xn1 XI0_I1139_xn I0_pp11_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1139_MN2 (VSS I0_A_31_b3_5 XI0_I1139_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1139_MN4 (XI0_I1139_n2 I0_A_30_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1139_MN3 (XI0_I1139_xn I0_two11_b3_5 XI0_I1139_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1139_MN1 (XI0_I1139_n1 I0_one11_b3_5 XI0_I1139_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1139_MN9 (VSS XI0_I1139_xn XI0_I1139_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1185_MN11 (VSS I0_B_25_b3_3 XI0_I1185_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1185_MN14 (VSS XI0_I1185_xbn XI0_I1185_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1185_MN16 (XI0_I1185_xn2 I0_B_25_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1185_MN15 (I0_pp12_22 XI0_I1185_xan XI0_I1185_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1185_MN13 (XI0_I1185_xn1 XI0_I1185_xn I0_pp12_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1185_MN2 (VSS I0_A_22_b3_4 XI0_I1185_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1185_MN4 (XI0_I1185_n2 I0_A_21_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1185_MN3 (XI0_I1185_xn I0_two12_b3_4 XI0_I1185_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1185_MN1 (XI0_I1185_n1 I0_one12_b3_4 XI0_I1185_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1185_MN9 (VSS XI0_I1185_xn XI0_I1185_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1240_MN11 (VSS I0_B_27_b3_3 XI0_I1240_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1240_MN14 (VSS XI0_I1240_xbn XI0_I1240_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1240_MN16 (XI0_I1240_xn2 I0_B_27_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1240_MN15 (I0_pp13_22 XI0_I1240_xan XI0_I1240_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1240_MN13 (XI0_I1240_xn1 XI0_I1240_xn I0_pp13_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1240_MN2 (VSS I0_A_22_b3_4 XI0_I1240_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1240_MN4 (XI0_I1240_n2 I0_A_21_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1240_MN3 (XI0_I1240_xn I0_two13_b3_4 XI0_I1240_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1240_MN1 (XI0_I1240_n1 I0_one13_b3_4 XI0_I1240_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1240_MN9 (VSS XI0_I1240_xn XI0_I1240_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1130_MN11 (VSS I0_B_23_b3_3 XI0_I1130_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1130_MN14 (VSS XI0_I1130_xbn XI0_I1130_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1130_MN16 (XI0_I1130_xn2 I0_B_23_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1130_MN15 (I0_pp11_22 XI0_I1130_xan XI0_I1130_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1130_MN13 (XI0_I1130_xn1 XI0_I1130_xn I0_pp11_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1130_MN2 (VSS I0_A_22_b3_4 XI0_I1130_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1130_MN4 (XI0_I1130_n2 I0_A_21_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1130_MN3 (XI0_I1130_xn I0_two11_b3_4 XI0_I1130_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1130_MN1 (XI0_I1130_n1 I0_one11_b3_4 XI0_I1130_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1130_MN9 (VSS XI0_I1130_xn XI0_I1130_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1081_MN11 (VSS I0_B_21_b3_4 XI0_I1081_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1081_MN14 (VSS XI0_I1081_xbn XI0_I1081_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1081_MN16 (XI0_I1081_xn2 I0_B_21_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1081_MN15 (I0_pp10_28 XI0_I1081_xan XI0_I1081_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1081_MN13 (XI0_I1081_xn1 XI0_I1081_xn I0_pp10_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1081_MN2 (VSS I0_A_28_b3_3 XI0_I1081_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1081_MN4 (XI0_I1081_n2 I0_A_27_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1081_MN3 (XI0_I1081_xn I0_two10_b3_5 XI0_I1081_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1081_MN1 (XI0_I1081_n1 I0_one10_b3_5 XI0_I1081_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1081_MN9 (VSS XI0_I1081_xn XI0_I1081_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I972_MN11 (VSS I0_B_17_b3_5 XI0_I972_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I972_MN14 (VSS XI0_I972_xbn XI0_I972_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I972_MN16 (XI0_I972_xn2 I0_B_17_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I972_MN15 (I0_pp8_29 XI0_I972_xan XI0_I972_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I972_MN13 (XI0_I972_xn1 XI0_I972_xn I0_pp8_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I972_MN2 (VSS I0_A_29_b3_3 XI0_I972_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I972_MN4 (XI0_I972_n2 I0_A_28_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I972_MN3 (XI0_I972_xn I0_two8_b3_5 XI0_I972_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I972_MN1 (XI0_I972_n1 I0_one8_b3_5 XI0_I972_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I972_MN9 (VSS XI0_I972_xn XI0_I972_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1026_MN11 (VSS I0_B_19_b3_4 XI0_I1026_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1026_MN14 (VSS XI0_I1026_xbn XI0_I1026_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1026_MN16 (XI0_I1026_xn2 I0_B_19_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1026_MN15 (I0_pp9_28 XI0_I1026_xan XI0_I1026_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1026_MN13 (XI0_I1026_xn1 XI0_I1026_xn I0_pp9_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1026_MN2 (VSS I0_A_28_b3_3 XI0_I1026_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1026_MN4 (XI0_I1026_n2 I0_A_27_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1026_MN3 (XI0_I1026_xn I0_two9_b3_5 XI0_I1026_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1026_MN1 (XI0_I1026_n1 I0_one9_b3_5 XI0_I1026_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1026_MN9 (VSS XI0_I1026_xn XI0_I1026_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1140_MN11 (VSS I0_B_23_b3_5 XI0_I1140_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1140_MN14 (VSS XI0_I1140_xbn XI0_I1140_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1140_MN16 (XI0_I1140_xn2 I0_B_23_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1140_MN15 (I0_pp11_32 XI0_I1140_xan XI0_I1140_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1140_MN13 (XI0_I1140_xn1 XI0_I1140_xn I0_pp11_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1140_MN2 (VSS I0_A_31_b3_5 XI0_I1140_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1140_MN4 (XI0_I1140_n2 I0_A_31_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1140_MN3 (XI0_I1140_xn I0_two11_b3_5 XI0_I1140_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1140_MN1 (XI0_I1140_n1 I0_one11_b3_5 XI0_I1140_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1140_MN9 (VSS XI0_I1140_xn XI0_I1140_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1290_MN11 (VSS I0_B_29_b3_3 XI0_I1290_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1290_MN14 (VSS XI0_I1290_xbn XI0_I1290_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1290_MN16 (XI0_I1290_xn2 I0_B_29_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1290_MN15 (I0_pp14_17 XI0_I1290_xan XI0_I1290_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1290_MN13 (XI0_I1290_xn1 XI0_I1290_xn I0_pp14_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1290_MN2 (VSS I0_A_17_b3_5 XI0_I1290_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1290_MN4 (XI0_I1290_n2 I0_A_16_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1290_MN3 (XI0_I1290_xn I0_two14_b3_3 XI0_I1290_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1290_MN1 (XI0_I1290_n1 I0_one14_b3_3 XI0_I1290_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1290_MN9 (VSS XI0_I1290_xn XI0_I1290_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1291_MN11 (VSS I0_B_29_b3_3 XI0_I1291_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1291_MN14 (VSS XI0_I1291_xbn XI0_I1291_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1291_MN16 (XI0_I1291_xn2 I0_B_29_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1291_MN15 (I0_pp14_18 XI0_I1291_xan XI0_I1291_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1291_MN13 (XI0_I1291_xn1 XI0_I1291_xn I0_pp14_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1291_MN2 (VSS I0_A_18_b3_5 XI0_I1291_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1291_MN4 (XI0_I1291_n2 I0_A_17_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1291_MN3 (XI0_I1291_xn I0_two14_b3_3 XI0_I1291_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1291_MN1 (XI0_I1291_n1 I0_one14_b3_3 XI0_I1291_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1291_MN9 (VSS XI0_I1291_xn XI0_I1291_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1186_MN11 (VSS I0_B_25_b3_4 XI0_I1186_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1186_MN14 (VSS XI0_I1186_xbn XI0_I1186_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1186_MN16 (XI0_I1186_xn2 I0_B_25_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1186_MN15 (I0_pp12_23 XI0_I1186_xan XI0_I1186_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1186_MN13 (XI0_I1186_xn1 XI0_I1186_xn I0_pp12_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1186_MN2 (VSS I0_A_23_b3_4 XI0_I1186_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1186_MN4 (XI0_I1186_n2 I0_A_22_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1186_MN3 (XI0_I1186_xn I0_two12_b3_4 XI0_I1186_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1186_MN1 (XI0_I1186_n1 I0_one12_b3_4 XI0_I1186_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1186_MN9 (VSS XI0_I1186_xn XI0_I1186_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1293_MN11 (VSS I0_B_29_b3_3 XI0_I1293_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1293_MN14 (VSS XI0_I1293_xbn XI0_I1293_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1293_MN16 (XI0_I1293_xn2 I0_B_29_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1293_MN15 (I0_pp14_20 XI0_I1293_xan XI0_I1293_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1293_MN13 (XI0_I1293_xn1 XI0_I1293_xn I0_pp14_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1293_MN2 (VSS I0_A_20_b3_5 XI0_I1293_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1293_MN4 (XI0_I1293_n2 I0_A_19_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1293_MN3 (XI0_I1293_xn I0_two14_b3_3 XI0_I1293_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1293_MN1 (XI0_I1293_n1 I0_one14_b3_3 XI0_I1293_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1293_MN9 (VSS XI0_I1293_xn XI0_I1293_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1292_MN11 (VSS I0_B_29_b3_3 XI0_I1292_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1292_MN14 (VSS XI0_I1292_xbn XI0_I1292_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1292_MN16 (XI0_I1292_xn2 I0_B_29_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1292_MN15 (I0_pp14_19 XI0_I1292_xan XI0_I1292_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1292_MN13 (XI0_I1292_xn1 XI0_I1292_xn I0_pp14_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1292_MN2 (VSS I0_A_19_b3_5 XI0_I1292_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1292_MN4 (XI0_I1292_n2 I0_A_18_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1292_MN3 (XI0_I1292_xn I0_two14_b3_3 XI0_I1292_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1292_MN1 (XI0_I1292_n1 I0_one14_b3_3 XI0_I1292_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1292_MN9 (VSS XI0_I1292_xn XI0_I1292_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1132_MN11 (VSS I0_B_23_b3_4 XI0_I1132_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1132_MN14 (VSS XI0_I1132_xbn XI0_I1132_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1132_MN16 (XI0_I1132_xn2 I0_B_23_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1132_MN15 (I0_pp11_24 XI0_I1132_xan XI0_I1132_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1132_MN13 (XI0_I1132_xn1 XI0_I1132_xn I0_pp11_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1132_MN2 (VSS I0_A_24_b3_4 XI0_I1132_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1132_MN4 (XI0_I1132_n2 I0_A_23_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1132_MN3 (XI0_I1132_xn I0_two11_b3_4 XI0_I1132_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1132_MN1 (XI0_I1132_n1 I0_one11_b3_4 XI0_I1132_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1132_MN9 (VSS XI0_I1132_xn XI0_I1132_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1085_MN11 (VSS I0_B_21_b3_5 XI0_I1085_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1085_MN14 (VSS XI0_I1085_xbn XI0_I1085_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1085_MN16 (XI0_I1085_xn2 I0_B_21_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1085_MN15 (I0_pp10_32 XI0_I1085_xan XI0_I1085_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1085_MN13 (XI0_I1085_xn1 XI0_I1085_xn I0_pp10_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1085_MN2 (VSS I0_A_31_b3_5 XI0_I1085_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1085_MN4 (XI0_I1085_n2 I0_A_31_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1085_MN3 (XI0_I1085_xn I0_two10_b3_5 XI0_I1085_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1085_MN1 (XI0_I1085_n1 I0_one10_b3_5 XI0_I1085_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1085_MN9 (VSS XI0_I1085_xn XI0_I1085_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1131_MN11 (VSS I0_B_23_b3_4 XI0_I1131_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1131_MN14 (VSS XI0_I1131_xbn XI0_I1131_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1131_MN16 (XI0_I1131_xn2 I0_B_23_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1131_MN15 (I0_pp11_23 XI0_I1131_xan XI0_I1131_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1131_MN13 (XI0_I1131_xn1 XI0_I1131_xn I0_pp11_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1131_MN2 (VSS I0_A_23_b3_4 XI0_I1131_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1131_MN4 (XI0_I1131_n2 I0_A_22_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1131_MN3 (XI0_I1131_xn I0_two11_b3_4 XI0_I1131_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1131_MN1 (XI0_I1131_n1 I0_one11_b3_4 XI0_I1131_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1131_MN9 (VSS XI0_I1131_xn XI0_I1131_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1084_MN11 (VSS I0_B_21_b3_5 XI0_I1084_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1084_MN14 (VSS XI0_I1084_xbn XI0_I1084_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1084_MN16 (XI0_I1084_xn2 I0_B_21_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1084_MN15 (I0_pp10_31 XI0_I1084_xan XI0_I1084_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1084_MN13 (XI0_I1084_xn1 XI0_I1084_xn I0_pp10_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1084_MN2 (VSS I0_A_31_b3_5 XI0_I1084_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1084_MN4 (XI0_I1084_n2 I0_A_30_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1084_MN3 (XI0_I1084_xn I0_two10_b3_5 XI0_I1084_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1084_MN1 (XI0_I1084_n1 I0_one10_b3_5 XI0_I1084_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1084_MN9 (VSS XI0_I1084_xn XI0_I1084_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1083_MN11 (VSS I0_B_21_b3_5 XI0_I1083_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1083_MN14 (VSS XI0_I1083_xbn XI0_I1083_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1083_MN16 (XI0_I1083_xn2 I0_B_21_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1083_MN15 (I0_pp10_30 XI0_I1083_xan XI0_I1083_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1083_MN13 (XI0_I1083_xn1 XI0_I1083_xn I0_pp10_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1083_MN2 (VSS I0_A_30_b3_3 XI0_I1083_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1083_MN4 (XI0_I1083_n2 I0_A_29_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1083_MN3 (XI0_I1083_xn I0_two10_b3_5 XI0_I1083_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1083_MN1 (XI0_I1083_n1 I0_one10_b3_5 XI0_I1083_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1083_MN9 (VSS XI0_I1083_xn XI0_I1083_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I973_MN11 (VSS I0_B_17_b3_5 XI0_I973_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I973_MN14 (VSS XI0_I973_xbn XI0_I973_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I973_MN16 (XI0_I973_xn2 I0_B_17_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I973_MN15 (I0_pp8_30 XI0_I973_xan XI0_I973_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I973_MN13 (XI0_I973_xn1 XI0_I973_xn I0_pp8_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I973_MN2 (VSS I0_A_30_b3_3 XI0_I973_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I973_MN4 (XI0_I973_n2 I0_A_29_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I973_MN3 (XI0_I973_xn I0_two8_b3_5 XI0_I973_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I973_MN1 (XI0_I973_n1 I0_one8_b3_5 XI0_I973_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I973_MN9 (VSS XI0_I973_xn XI0_I973_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1302_MN11 (VSS I0_B_29_b3_5 XI0_I1302_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1302_MN14 (VSS XI0_I1302_xbn XI0_I1302_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1302_MN16 (XI0_I1302_xn2 I0_B_29_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1302_MN15 (I0_pp14_29 XI0_I1302_xan XI0_I1302_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1302_MN13 (XI0_I1302_xn1 XI0_I1302_xn I0_pp14_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1302_MN2 (VSS I0_A_29_b3_5 XI0_I1302_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1302_MN4 (XI0_I1302_n2 I0_A_28_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1302_MN3 (XI0_I1302_xn I0_two14_b3_5 XI0_I1302_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1302_MN1 (XI0_I1302_n1 I0_one14_b3_5 XI0_I1302_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1302_MN9 (VSS XI0_I1302_xn XI0_I1302_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1301_MN11 (VSS I0_B_29_b3_4 XI0_I1301_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1301_MN14 (VSS XI0_I1301_xbn XI0_I1301_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1301_MN16 (XI0_I1301_xn2 I0_B_29_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1301_MN15 (I0_pp14_28 XI0_I1301_xan XI0_I1301_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1301_MN13 (XI0_I1301_xn1 XI0_I1301_xn I0_pp14_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1301_MN2 (VSS I0_A_28_b3_5 XI0_I1301_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1301_MN4 (XI0_I1301_n2 I0_A_27_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1301_MN3 (XI0_I1301_xn I0_two14_b3_5 XI0_I1301_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1301_MN1 (XI0_I1301_n1 I0_one14_b3_5 XI0_I1301_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1301_MN9 (VSS XI0_I1301_xn XI0_I1301_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1300_MN11 (VSS I0_B_29_b3_4 XI0_I1300_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1300_MN14 (VSS XI0_I1300_xbn XI0_I1300_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1300_MN16 (XI0_I1300_xn2 I0_B_29_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1300_MN15 (I0_pp14_27 XI0_I1300_xan XI0_I1300_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1300_MN13 (XI0_I1300_xn1 XI0_I1300_xn I0_pp14_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1300_MN2 (VSS I0_A_27_b3_5 XI0_I1300_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1300_MN4 (XI0_I1300_n2 I0_A_26_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1300_MN3 (XI0_I1300_xn I0_two14_b3_4 XI0_I1300_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1300_MN1 (XI0_I1300_n1 I0_one14_b3_4 XI0_I1300_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1300_MN9 (VSS XI0_I1300_xn XI0_I1300_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1245_MN11 (VSS I0_B_27_b3_4 XI0_I1245_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1245_MN14 (VSS XI0_I1245_xbn XI0_I1245_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1245_MN16 (XI0_I1245_xn2 I0_B_27_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1245_MN15 (I0_pp13_27 XI0_I1245_xan XI0_I1245_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1245_MN13 (XI0_I1245_xn1 XI0_I1245_xn I0_pp13_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1245_MN2 (VSS I0_A_27_b3_4 XI0_I1245_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1245_MN4 (XI0_I1245_n2 I0_A_26_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1245_MN3 (XI0_I1245_xn I0_two13_b3_4 XI0_I1245_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1245_MN1 (XI0_I1245_n1 I0_one13_b3_4 XI0_I1245_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1245_MN9 (VSS XI0_I1245_xn XI0_I1245_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1345_MN11 (VSS I0_B_31_b3_3 XI0_I1345_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1345_MN14 (VSS XI0_I1345_xbn XI0_I1345_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1345_MN16 (XI0_I1345_xn2 I0_B_31_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1345_MN15 (I0_pp15_17 XI0_I1345_xan XI0_I1345_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1345_MN13 (XI0_I1345_xn1 XI0_I1345_xn I0_pp15_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1345_MN2 (VSS I0_A_17_b3_5 XI0_I1345_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1345_MN4 (XI0_I1345_n2 I0_A_16_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1345_MN3 (XI0_I1345_xn I0_two15_b3_3 XI0_I1345_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1345_MN1 (XI0_I1345_n1 I0_one15_b3_3 XI0_I1345_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1345_MN9 (VSS XI0_I1345_xn XI0_I1345_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1294_MN11 (VSS I0_B_29_b3_3 XI0_I1294_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1294_MN14 (VSS XI0_I1294_xbn XI0_I1294_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1294_MN16 (XI0_I1294_xn2 I0_B_29_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1294_MN15 (I0_pp14_21 XI0_I1294_xan XI0_I1294_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1294_MN13 (XI0_I1294_xn1 XI0_I1294_xn I0_pp14_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1294_MN2 (VSS I0_A_21_b3_5 XI0_I1294_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1294_MN4 (XI0_I1294_n2 I0_A_20_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1294_MN3 (XI0_I1294_xn I0_two14_b3_3 XI0_I1294_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1294_MN1 (XI0_I1294_n1 I0_one14_b3_3 XI0_I1294_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1294_MN9 (VSS XI0_I1294_xn XI0_I1294_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1346_MN11 (VSS I0_B_31_b3_3 XI0_I1346_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1346_MN14 (VSS XI0_I1346_xbn XI0_I1346_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1346_MN16 (XI0_I1346_xn2 I0_B_31_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1346_MN15 (I0_pp15_18 XI0_I1346_xan XI0_I1346_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1346_MN13 (XI0_I1346_xn1 XI0_I1346_xn I0_pp15_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1346_MN2 (VSS I0_A_18_b3_5 XI0_I1346_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1346_MN4 (XI0_I1346_n2 I0_A_17_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1346_MN3 (XI0_I1346_xn I0_two15_b3_3 XI0_I1346_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1346_MN1 (XI0_I1346_n1 I0_one15_b3_3 XI0_I1346_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1346_MN9 (VSS XI0_I1346_xn XI0_I1346_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1133_MN11 (VSS I0_B_23_b3_4 XI0_I1133_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1133_MN14 (VSS XI0_I1133_xbn XI0_I1133_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1133_MN16 (XI0_I1133_xn2 I0_B_23_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1133_MN15 (I0_pp11_25 XI0_I1133_xan XI0_I1133_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1133_MN13 (XI0_I1133_xn1 XI0_I1133_xn I0_pp11_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1133_MN2 (VSS I0_A_25_b3_4 XI0_I1133_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1133_MN4 (XI0_I1133_n2 I0_A_24_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1133_MN3 (XI0_I1133_xn I0_two11_b3_4 XI0_I1133_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1133_MN1 (XI0_I1133_n1 I0_one11_b3_4 XI0_I1133_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1133_MN9 (VSS XI0_I1133_xn XI0_I1133_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1082_MN11 (VSS I0_B_21_b3_5 XI0_I1082_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1082_MN14 (VSS XI0_I1082_xbn XI0_I1082_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1082_MN16 (XI0_I1082_xn2 I0_B_21_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1082_MN15 (I0_pp10_29 XI0_I1082_xan XI0_I1082_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1082_MN13 (XI0_I1082_xn1 XI0_I1082_xn I0_pp10_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1082_MN2 (VSS I0_A_29_b3_3 XI0_I1082_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1082_MN4 (XI0_I1082_n2 I0_A_28_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1082_MN3 (XI0_I1082_xn I0_two10_b3_5 XI0_I1082_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1082_MN1 (XI0_I1082_n1 I0_one10_b3_5 XI0_I1082_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1082_MN9 (VSS XI0_I1082_xn XI0_I1082_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1027_MN11 (VSS I0_B_19_b3_5 XI0_I1027_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1027_MN14 (VSS XI0_I1027_xbn XI0_I1027_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1027_MN16 (XI0_I1027_xn2 I0_B_19_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1027_MN15 (I0_pp9_29 XI0_I1027_xan XI0_I1027_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1027_MN13 (XI0_I1027_xn1 XI0_I1027_xn I0_pp9_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1027_MN2 (VSS I0_A_29_b3_3 XI0_I1027_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1027_MN4 (XI0_I1027_n2 I0_A_28_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1027_MN3 (XI0_I1027_xn I0_two9_b3_5 XI0_I1027_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1027_MN1 (XI0_I1027_n1 I0_one9_b3_5 XI0_I1027_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1027_MN9 (VSS XI0_I1027_xn XI0_I1027_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1303_MN11 (VSS I0_B_29_b3_5 XI0_I1303_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1303_MN14 (VSS XI0_I1303_xbn XI0_I1303_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1303_MN16 (XI0_I1303_xn2 I0_B_29_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1303_MN15 (I0_pp14_30 XI0_I1303_xan XI0_I1303_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1303_MN13 (XI0_I1303_xn1 XI0_I1303_xn I0_pp14_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1303_MN2 (VSS I0_A_30_b3_5 XI0_I1303_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1303_MN4 (XI0_I1303_n2 I0_A_29_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1303_MN3 (XI0_I1303_xn I0_two14_b3_5 XI0_I1303_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1303_MN1 (XI0_I1303_n1 I0_one14_b3_5 XI0_I1303_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1303_MN9 (VSS XI0_I1303_xn XI0_I1303_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1355_MN11 (VSS I0_B_31_b3_4 XI0_I1355_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1355_MN14 (VSS XI0_I1355_xbn XI0_I1355_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1355_MN16 (XI0_I1355_xn2 I0_B_31_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1355_MN15 (I0_pp15_27 XI0_I1355_xan XI0_I1355_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1355_MN13 (XI0_I1355_xn1 XI0_I1355_xn I0_pp15_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1355_MN2 (VSS I0_A_27_b3_5 XI0_I1355_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1355_MN4 (XI0_I1355_n2 I0_A_26_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1355_MN3 (XI0_I1355_xn I0_two15_b3_4 XI0_I1355_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1355_MN1 (XI0_I1355_n1 I0_one15_b3_4 XI0_I1355_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1355_MN9 (VSS XI0_I1355_xn XI0_I1355_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1356_MN11 (VSS I0_B_31_b3_4 XI0_I1356_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1356_MN14 (VSS XI0_I1356_xbn XI0_I1356_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1356_MN16 (XI0_I1356_xn2 I0_B_31_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1356_MN15 (I0_pp15_28 XI0_I1356_xan XI0_I1356_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1356_MN13 (XI0_I1356_xn1 XI0_I1356_xn I0_pp15_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1356_MN2 (VSS I0_A_28_b3_5 XI0_I1356_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1356_MN4 (XI0_I1356_n2 I0_A_27_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
