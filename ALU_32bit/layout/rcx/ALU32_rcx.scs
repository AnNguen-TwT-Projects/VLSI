    I_MXI1_I976_I233_MP2 (VDD I1_I976_pn30 XI1_I976_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I233_MP3 (XI1_I976_I233_p1 XI1_I976_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I233_MP0 (VDD I1_I976_pn30 XI1_I976_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I232_MP1 (VDD I1_I976_G28_0 XI1_I976_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I232_MP5 (I1_p9_29 I1_I976_G28_0 XI1_I976_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I232_MP4 (XI1_I976_I232_p1 XI1_I976_I232_An I1_p9_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I232_MP2 (VDD I1_I976_pn29 XI1_I976_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I232_MP3 (XI1_I976_I232_p1 XI1_I976_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I232_MP0 (VDD I1_I976_pn29 XI1_I976_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I229_MP1 (VDD I1_I976_G25_0 XI1_I976_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I229_MP5 (I1_p9_26 I1_I976_G25_0 XI1_I976_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I229_MP4 (XI1_I976_I229_p1 XI1_I976_I229_An I1_p9_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I229_MP2 (VDD I1_I976_pn26 XI1_I976_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I229_MP3 (XI1_I976_I229_p1 XI1_I976_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I229_MP0 (VDD I1_I976_pn26 XI1_I976_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I228_MP1 (VDD I1_I976_G24_0 XI1_I976_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I228_MP5 (I1_p9_25 I1_I976_G24_0 XI1_I976_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I228_MP4 (XI1_I976_I228_p1 XI1_I976_I228_An I1_p9_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I228_MP2 (VDD I1_I976_pn25 XI1_I976_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I228_MP3 (XI1_I976_I228_p1 XI1_I976_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I228_MP0 (VDD I1_I976_pn25 XI1_I976_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I40_MP1 (VDD I1_b9_8 XI1_I976_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I40_MP5 (I1_I976_pn8 I1_b9_8 XI1_I976_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I40_MP4 (XI1_I976_I40_p1 XI1_I976_I40_An I1_I976_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I40_MP2 (VDD I1_p8_7 XI1_I976_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I40_MP3 (XI1_I976_I40_p1 XI1_I976_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I40_MP0 (VDD I1_p8_7 XI1_I976_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I38_MP1 (VDD I1_b9_6 XI1_I976_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I38_MP5 (I1_I976_pn6 I1_b9_6 XI1_I976_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I38_MP4 (XI1_I976_I38_p1 XI1_I976_I38_An I1_I976_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I38_MP2 (VDD I1_p8_5 XI1_I976_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I38_MP3 (XI1_I976_I38_p1 XI1_I976_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I38_MP0 (VDD I1_p8_5 XI1_I976_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I33_MP1 (VDD I1_b8_1 XI1_I930_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I33_MP5 (I1_I930_pn1 I1_b8_1 XI1_I930_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I33_MP4 (XI1_I930_I33_p1 XI1_I930_I33_An I1_I930_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I33_MP2 (VDD I1_p7_0 XI1_I930_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I33_MP3 (XI1_I930_I33_p1 XI1_I930_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I33_MP0 (VDD I1_p7_0 XI1_I930_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I36_MP1 (VDD I1_b2_4 XI1_I654_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I36_MP5 (I1_I654_pn4 I1_b2_4 XI1_I654_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I36_MP4 (XI1_I654_I36_p1 XI1_I654_I36_An I1_I654_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I36_MP2 (VDD I1_p1_3 XI1_I654_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I36_MP3 (XI1_I654_I36_p1 XI1_I654_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I36_MP0 (VDD I1_p1_3 XI1_I654_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I37_MP1 (VDD I1_b2_5 XI1_I654_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I37_MP5 (I1_I654_pn5 I1_b2_5 XI1_I654_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I37_MP4 (XI1_I654_I37_p1 XI1_I654_I37_An I1_I654_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I37_MP2 (VDD I1_p1_4 XI1_I654_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I37_MP3 (XI1_I654_I37_p1 XI1_I654_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I37_MP0 (VDD I1_p1_4 XI1_I654_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I39_MP1 (VDD I1_b2_7 XI1_I654_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I39_MP5 (I1_I654_pn7 I1_b2_7 XI1_I654_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I39_MP4 (XI1_I654_I39_p1 XI1_I654_I39_An I1_I654_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I39_MP2 (VDD I1_p1_6 XI1_I654_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I39_MP3 (XI1_I654_I39_p1 XI1_I654_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I39_MP0 (VDD I1_p1_6 XI1_I654_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I41_MP1 (VDD I1_b2_9 XI1_I654_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I41_MP5 (I1_I654_pn9 I1_b2_9 XI1_I654_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I41_MP4 (XI1_I654_I41_p1 XI1_I654_I41_An I1_I654_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I41_MP2 (VDD I1_p1_8 XI1_I654_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I41_MP3 (XI1_I654_I41_p1 XI1_I654_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I41_MP0 (VDD I1_p1_8 XI1_I654_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I45_MP1 (VDD I1_b2_13 XI1_I654_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I45_MP5 (I1_I654_pn13 I1_b2_13 XI1_I654_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I45_MP4 (XI1_I654_I45_p1 XI1_I654_I45_An I1_I654_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I45_MP2 (VDD I1_p1_12 XI1_I654_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I45_MP3 (XI1_I654_I45_p1 XI1_I654_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I45_MP0 (VDD I1_p1_12 XI1_I654_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I51_MP1 (VDD I1_b2_19 XI1_I654_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I51_MP5 (I1_I654_pn19 I1_b2_19 XI1_I654_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I51_MP4 (XI1_I654_I51_p1 XI1_I654_I51_An I1_I654_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I51_MP2 (VDD I1_p1_18 XI1_I654_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I51_MP3 (XI1_I654_I51_p1 XI1_I654_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I51_MP0 (VDD I1_p1_18 XI1_I654_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I52_MP1 (VDD I1_b2_20 XI1_I654_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I52_MP5 (I1_I654_pn20 I1_b2_20 XI1_I654_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I52_MP4 (XI1_I654_I52_p1 XI1_I654_I52_An I1_I654_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I52_MP2 (VDD I1_p1_19 XI1_I654_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I52_MP3 (XI1_I654_I52_p1 XI1_I654_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I52_MP0 (VDD I1_p1_19 XI1_I654_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I54_MP1 (VDD I1_b2_22 XI1_I654_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I54_MP5 (I1_I654_pn22 I1_b2_22 XI1_I654_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I54_MP4 (XI1_I654_I54_p1 XI1_I654_I54_An I1_I654_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I54_MP2 (VDD I1_p1_21 XI1_I654_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I54_MP3 (XI1_I654_I54_p1 XI1_I654_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I54_MP0 (VDD I1_p1_21 XI1_I654_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I56_MP1 (VDD I1_b2_24 XI1_I654_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I56_MP5 (I1_I654_pn24 I1_b2_24 XI1_I654_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I56_MP4 (XI1_I654_I56_p1 XI1_I654_I56_An I1_I654_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I56_MP2 (VDD I1_p1_23 XI1_I654_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I56_MP3 (XI1_I654_I56_p1 XI1_I654_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I56_MP0 (VDD I1_p1_23 XI1_I654_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I57_MP1 (VDD I1_b2_25 XI1_I654_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I57_MP5 (I1_I654_pn25 I1_b2_25 XI1_I654_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I57_MP4 (XI1_I654_I57_p1 XI1_I654_I57_An I1_I654_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I57_MP2 (VDD I1_p1_24 XI1_I654_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I57_MP3 (XI1_I654_I57_p1 XI1_I654_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I57_MP0 (VDD I1_p1_24 XI1_I654_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I59_MP1 (VDD I1_b2_27 XI1_I654_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I59_MP5 (I1_I654_pn27 I1_b2_27 XI1_I654_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I59_MP4 (XI1_I654_I59_p1 XI1_I654_I59_An I1_I654_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I59_MP2 (VDD I1_p1_26 XI1_I654_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I59_MP3 (XI1_I654_I59_p1 XI1_I654_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I59_MP0 (VDD I1_p1_26 XI1_I654_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I209_MP1 (VDD I1_I1436_G5_0 XI1_I1436_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I209_MP5 (I1_p19_6 I1_I1436_G5_0 XI1_I1436_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I209_MP4 (XI1_I1436_I209_p1 XI1_I1436_I209_An I1_p19_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I209_MP2 (VDD I1_I1436_pn6 XI1_I1436_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I209_MP3 (XI1_I1436_I209_p1 XI1_I1436_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I209_MP0 (VDD I1_I1436_pn6 XI1_I1436_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I221_MP1 (VDD I1_I1114_G17_0 XI1_I1114_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I221_MP5 (I1_p12_18 I1_I1114_G17_0 XI1_I1114_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I221_MP4 (XI1_I1114_I221_p1 XI1_I1114_I221_An I1_p12_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I221_MP2 (VDD I1_I1114_pn18 XI1_I1114_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I221_MP3 (XI1_I1114_I221_p1 XI1_I1114_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I221_MP0 (VDD I1_I1114_pn18 XI1_I1114_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I220_MP1 (VDD I1_I1114_G16_0 XI1_I1114_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I220_MP5 (I1_p12_17 I1_I1114_G16_0 XI1_I1114_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I220_MP4 (XI1_I1114_I220_p1 XI1_I1114_I220_An I1_p12_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I220_MP2 (VDD I1_I1114_pn17 XI1_I1114_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I220_MP3 (XI1_I1114_I220_p1 XI1_I1114_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I220_MP0 (VDD I1_I1114_pn17 XI1_I1114_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I50_MP1 (VDD I1_b12_18 XI1_I1114_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I50_MP5 (I1_I1114_pn18 I1_b12_18 XI1_I1114_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I50_MP4 (XI1_I1114_I50_p1 XI1_I1114_I50_An I1_I1114_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I50_MP2 (VDD I1_p11_17 XI1_I1114_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I50_MP3 (XI1_I1114_I50_p1 XI1_I1114_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I50_MP0 (VDD I1_p11_17 XI1_I1114_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I224_MP1 (VDD I1_I1068_G20_0 XI1_I1068_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I224_MP5 (I1_p11_21 I1_I1068_G20_0 XI1_I1068_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I224_MP4 (XI1_I1068_I224_p1 XI1_I1068_I224_An I1_p11_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I224_MP2 (VDD I1_I1068_pn21 XI1_I1068_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I224_MP3 (XI1_I1068_I224_p1 XI1_I1068_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I224_MP0 (VDD I1_I1068_pn21 XI1_I1068_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I54_MP1 (VDD I1_b11_22 XI1_I1068_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I54_MP5 (I1_I1068_pn22 I1_b11_22 XI1_I1068_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I54_MP4 (XI1_I1068_I54_p1 XI1_I1068_I54_An I1_I1068_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I54_MP2 (VDD I1_p10_21 XI1_I1068_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I54_MP3 (XI1_I1068_I54_p1 XI1_I1068_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I54_MP0 (VDD I1_p10_21 XI1_I1068_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I58_MP1 (VDD I1_b10_26 XI1_I1022_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I58_MP5 (I1_I1022_pn26 I1_b10_26 XI1_I1022_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I58_MP4 (XI1_I1022_I58_p1 XI1_I1022_I58_An I1_I1022_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I58_MP2 (VDD I1_p9_25 XI1_I1022_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I58_MP3 (XI1_I1022_I58_p1 XI1_I1022_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I58_MP0 (VDD I1_p9_25 XI1_I1022_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I57_MP1 (VDD I1_b10_25 XI1_I1022_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I57_MP5 (I1_I1022_pn25 I1_b10_25 XI1_I1022_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I57_MP4 (XI1_I1022_I57_p1 XI1_I1022_I57_An I1_I1022_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I57_MP2 (VDD I1_p9_24 XI1_I1022_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I57_MP3 (XI1_I1022_I57_p1 XI1_I1022_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I57_MP0 (VDD I1_p9_24 XI1_I1022_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I227_MP1 (VDD I1_I976_G23_0 XI1_I976_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I227_MP5 (I1_p9_24 I1_I976_G23_0 XI1_I976_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I227_MP4 (XI1_I976_I227_p1 XI1_I976_I227_An I1_p9_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I227_MP2 (VDD I1_I976_pn24 XI1_I976_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I227_MP3 (XI1_I976_I227_p1 XI1_I976_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I227_MP0 (VDD I1_I976_pn24 XI1_I976_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I226_MP1 (VDD I1_I976_G22_0 XI1_I976_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I226_MP5 (I1_p9_23 I1_I976_G22_0 XI1_I976_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I226_MP4 (XI1_I976_I226_p1 XI1_I976_I226_An I1_p9_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I226_MP2 (VDD I1_I976_pn23 XI1_I976_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I226_MP3 (XI1_I976_I226_p1 XI1_I976_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I226_MP0 (VDD I1_I976_pn23 XI1_I976_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I225_MP1 (VDD I1_I976_G21_0 XI1_I976_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I225_MP5 (I1_p9_22 I1_I976_G21_0 XI1_I976_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I225_MP4 (XI1_I976_I225_p1 XI1_I976_I225_An I1_p9_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I225_MP2 (VDD I1_I976_pn22 XI1_I976_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I225_MP3 (XI1_I976_I225_p1 XI1_I976_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I225_MP0 (VDD I1_I976_pn22 XI1_I976_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I223_MP1 (VDD I1_I976_G19_0 XI1_I976_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I223_MP5 (I1_p9_20 I1_I976_G19_0 XI1_I976_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I223_MP4 (XI1_I976_I223_p1 XI1_I976_I223_An I1_p9_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I223_MP2 (VDD I1_I976_pn20 XI1_I976_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I223_MP3 (XI1_I976_I223_p1 XI1_I976_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I223_MP0 (VDD I1_I976_pn20 XI1_I976_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I204_MP1 (VDD I1_I930_G0_0 XI1_I930_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I204_MP5 (I1_p8_1 I1_I930_G0_0 XI1_I930_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I204_MP4 (XI1_I930_I204_p1 XI1_I930_I204_An I1_p8_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I204_MP2 (VDD I1_I930_pn1 XI1_I930_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I204_MP3 (XI1_I930_I204_p1 XI1_I930_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I204_MP0 (VDD I1_I930_pn1 XI1_I930_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I32_MP1 (VDD I1_b2_0 XI1_I654_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I32_MP5 (I1_I654_pn0 I1_b2_0 XI1_I654_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I32_MP4 (XI1_I654_I32_p1 XI1_I654_I32_An I1_I654_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I32_MP2 (VDD I1_aa29 XI1_I654_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I32_MP3 (XI1_I654_I32_p1 XI1_I654_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I32_MP0 (VDD I1_aa29 XI1_I654_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I203_MP1 (VDD I1_qu30_b3_5 XI1_I654_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I203_MP5 (I1_p2_0 I1_qu30_b3_5 XI1_I654_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I203_MP4 (XI1_I654_I203_p1 XI1_I654_I203_An I1_p2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I203_MP2 (VDD I1_I654_pn0 XI1_I654_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I203_MP3 (XI1_I654_I203_p1 XI1_I654_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I203_MP0 (VDD I1_I654_pn0 XI1_I654_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I38_MP1 (VDD I1_b2_6 XI1_I654_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I38_MP5 (I1_I654_pn6 I1_b2_6 XI1_I654_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I38_MP4 (XI1_I654_I38_p1 XI1_I654_I38_An I1_I654_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I38_MP2 (VDD I1_p1_5 XI1_I654_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I38_MP3 (XI1_I654_I38_p1 XI1_I654_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I38_MP0 (VDD I1_p1_5 XI1_I654_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I40_MP1 (VDD I1_b2_8 XI1_I654_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I40_MP5 (I1_I654_pn8 I1_b2_8 XI1_I654_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I40_MP4 (XI1_I654_I40_p1 XI1_I654_I40_An I1_I654_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I40_MP2 (VDD I1_p1_7 XI1_I654_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I40_MP3 (XI1_I654_I40_p1 XI1_I654_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I40_MP0 (VDD I1_p1_7 XI1_I654_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I43_MP1 (VDD I1_b2_11 XI1_I654_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I43_MP5 (I1_I654_pn11 I1_b2_11 XI1_I654_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I43_MP4 (XI1_I654_I43_p1 XI1_I654_I43_An I1_I654_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I43_MP2 (VDD I1_p1_10 XI1_I654_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I43_MP3 (XI1_I654_I43_p1 XI1_I654_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I43_MP0 (VDD I1_p1_10 XI1_I654_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I42_MP1 (VDD I1_b2_10 XI1_I654_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I42_MP5 (I1_I654_pn10 I1_b2_10 XI1_I654_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I42_MP4 (XI1_I654_I42_p1 XI1_I654_I42_An I1_I654_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I42_MP2 (VDD I1_p1_9 XI1_I654_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I42_MP3 (XI1_I654_I42_p1 XI1_I654_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I42_MP0 (VDD I1_p1_9 XI1_I654_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I44_MP1 (VDD I1_b2_12 XI1_I654_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I44_MP5 (I1_I654_pn12 I1_b2_12 XI1_I654_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I44_MP4 (XI1_I654_I44_p1 XI1_I654_I44_An I1_I654_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I44_MP2 (VDD I1_p1_11 XI1_I654_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I44_MP3 (XI1_I654_I44_p1 XI1_I654_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I44_MP0 (VDD I1_p1_11 XI1_I654_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I46_MP1 (VDD I1_b2_14 XI1_I654_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I46_MP5 (I1_I654_pn14 I1_b2_14 XI1_I654_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I46_MP4 (XI1_I654_I46_p1 XI1_I654_I46_An I1_I654_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I46_MP2 (VDD I1_p1_13 XI1_I654_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I46_MP3 (XI1_I654_I46_p1 XI1_I654_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I46_MP0 (VDD I1_p1_13 XI1_I654_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I47_MP1 (VDD I1_b2_15 XI1_I654_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I47_MP5 (I1_I654_pn15 I1_b2_15 XI1_I654_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I47_MP4 (XI1_I654_I47_p1 XI1_I654_I47_An I1_I654_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I47_MP2 (VDD I1_p1_14 XI1_I654_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I47_MP3 (XI1_I654_I47_p1 XI1_I654_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I47_MP0 (VDD I1_p1_14 XI1_I654_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I48_MP1 (VDD I1_b2_16 XI1_I654_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I48_MP5 (I1_I654_pn16 I1_b2_16 XI1_I654_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I48_MP4 (XI1_I654_I48_p1 XI1_I654_I48_An I1_I654_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I48_MP2 (VDD I1_p1_15 XI1_I654_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I48_MP3 (XI1_I654_I48_p1 XI1_I654_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I48_MP0 (VDD I1_p1_15 XI1_I654_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I49_MP1 (VDD I1_b2_17 XI1_I654_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I49_MP5 (I1_I654_pn17 I1_b2_17 XI1_I654_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I49_MP4 (XI1_I654_I49_p1 XI1_I654_I49_An I1_I654_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I49_MP2 (VDD I1_p1_16 XI1_I654_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I49_MP3 (XI1_I654_I49_p1 XI1_I654_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I49_MP0 (VDD I1_p1_16 XI1_I654_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I50_MP1 (VDD I1_b2_18 XI1_I654_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I50_MP5 (I1_I654_pn18 I1_b2_18 XI1_I654_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I50_MP4 (XI1_I654_I50_p1 XI1_I654_I50_An I1_I654_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I50_MP2 (VDD I1_p1_17 XI1_I654_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I50_MP3 (XI1_I654_I50_p1 XI1_I654_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I50_MP0 (VDD I1_p1_17 XI1_I654_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I53_MP1 (VDD I1_b2_21 XI1_I654_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I53_MP5 (I1_I654_pn21 I1_b2_21 XI1_I654_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I53_MP4 (XI1_I654_I53_p1 XI1_I654_I53_An I1_I654_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I53_MP2 (VDD I1_p1_20 XI1_I654_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I53_MP3 (XI1_I654_I53_p1 XI1_I654_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I53_MP0 (VDD I1_p1_20 XI1_I654_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I55_MP1 (VDD I1_b2_23 XI1_I654_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I55_MP5 (I1_I654_pn23 I1_b2_23 XI1_I654_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I55_MP4 (XI1_I654_I55_p1 XI1_I654_I55_An I1_I654_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I55_MP2 (VDD I1_p1_22 XI1_I654_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I55_MP3 (XI1_I654_I55_p1 XI1_I654_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I55_MP0 (VDD I1_p1_22 XI1_I654_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I62_MP1 (VDD I1_b2_30 XI1_I654_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I62_MP5 (I1_I654_pn30 I1_b2_30 XI1_I654_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I62_MP4 (XI1_I654_I62_p1 XI1_I654_I62_An I1_I654_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I62_MP2 (VDD I1_p1_29 XI1_I654_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I62_MP3 (XI1_I654_I62_p1 XI1_I654_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I62_MP0 (VDD I1_p1_29 XI1_I654_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I63_MP1 (VDD I1_b19_31 XI1_I1436_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I63_MP5 (I1_I1436_pn31 I1_b19_31 XI1_I1436_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I63_MP4 (XI1_I1436_I63_p1 XI1_I1436_I63_An I1_I1436_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I63_MP2 (VDD I1_p18_30 XI1_I1436_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I63_MP3 (XI1_I1436_I63_p1 XI1_I1436_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I63_MP0 (VDD I1_p18_30 XI1_I1436_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I233_MP1 (VDD I1_I1436_G29_0 XI1_I1436_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I233_MP5 (I1_p19_30 I1_I1436_G29_0 XI1_I1436_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I233_MP4 (XI1_I1436_I233_p1 XI1_I1436_I233_An I1_p19_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I233_MP2 (VDD I1_I1436_pn30 XI1_I1436_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I233_MP3 (XI1_I1436_I233_p1 XI1_I1436_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I233_MP0 (VDD I1_I1436_pn30 XI1_I1436_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I229_MP1 (VDD I1_I1436_G25_0 XI1_I1436_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I229_MP5 (I1_p19_26 I1_I1436_G25_0 XI1_I1436_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I229_MP4 (XI1_I1436_I229_p1 XI1_I1436_I229_An I1_p19_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I229_MP2 (VDD I1_I1436_pn26 XI1_I1436_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I229_MP3 (XI1_I1436_I229_p1 XI1_I1436_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I229_MP0 (VDD I1_I1436_pn26 XI1_I1436_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I223_MP1 (VDD I1_I1436_G19_0 XI1_I1436_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I223_MP5 (I1_p19_20 I1_I1436_G19_0 XI1_I1436_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I223_MP4 (XI1_I1436_I223_p1 XI1_I1436_I223_An I1_p19_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I223_MP2 (VDD I1_I1436_pn20 XI1_I1436_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I223_MP3 (XI1_I1436_I223_p1 XI1_I1436_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I223_MP0 (VDD I1_I1436_pn20 XI1_I1436_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I221_MP1 (VDD I1_I1436_G17_0 XI1_I1436_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I221_MP5 (I1_p19_18 I1_I1436_G17_0 XI1_I1436_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I221_MP4 (XI1_I1436_I221_p1 XI1_I1436_I221_An I1_p19_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I221_MP2 (VDD I1_I1436_pn18 XI1_I1436_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I221_MP3 (XI1_I1436_I221_p1 XI1_I1436_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I221_MP0 (VDD I1_I1436_pn18 XI1_I1436_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I211_MP1 (VDD I1_I1436_G7_0 XI1_I1436_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I211_MP5 (I1_p19_8 I1_I1436_G7_0 XI1_I1436_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I211_MP4 (XI1_I1436_I211_p1 XI1_I1436_I211_An I1_p19_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I211_MP2 (VDD I1_I1436_pn8 XI1_I1436_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I211_MP3 (XI1_I1436_I211_p1 XI1_I1436_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I211_MP0 (VDD I1_I1436_pn8 XI1_I1436_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I38_MP1 (VDD I1_b20_6 XI1_I1482_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I38_MP5 (I1_I1482_pn6 I1_b20_6 XI1_I1482_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I38_MP4 (XI1_I1482_I38_p1 XI1_I1482_I38_An I1_I1482_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I38_MP2 (VDD I1_p19_5 XI1_I1482_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I38_MP3 (XI1_I1482_I38_p1 XI1_I1482_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I38_MP0 (VDD I1_p19_5 XI1_I1482_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I205_MP1 (VDD I1_I1436_G1_0 XI1_I1436_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I205_MP5 (I1_p19_2 I1_I1436_G1_0 XI1_I1436_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I205_MP4 (XI1_I1436_I205_p1 XI1_I1436_I205_An I1_p19_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I205_MP2 (VDD I1_I1436_pn2 XI1_I1436_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I205_MP3 (XI1_I1436_I205_p1 XI1_I1436_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I205_MP0 (VDD I1_I1436_pn2 XI1_I1436_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I36_MP1 (VDD I1_b20_4 XI1_I1482_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I36_MP5 (I1_I1482_pn4 I1_b20_4 XI1_I1482_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I36_MP4 (XI1_I1482_I36_p1 XI1_I1482_I36_An I1_I1482_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I36_MP2 (VDD I1_p19_3 XI1_I1482_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I36_MP3 (XI1_I1482_I36_p1 XI1_I1482_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I36_MP0 (VDD I1_p19_3 XI1_I1482_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I32_MP1 (VDD I1_b19_0 XI1_I1436_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I32_MP5 (I1_I1436_pn0 I1_b19_0 XI1_I1436_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I32_MP4 (XI1_I1436_I32_p1 XI1_I1436_I32_An I1_I1436_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I32_MP2 (VDD I1_aa12 XI1_I1436_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I32_MP3 (XI1_I1436_I32_p1 XI1_I1436_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I32_MP0 (VDD I1_aa12 XI1_I1436_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I48_MP1 (VDD I1_b12_16 XI1_I1114_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I48_MP5 (I1_I1114_pn16 I1_b12_16 XI1_I1114_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I48_MP4 (XI1_I1114_I48_p1 XI1_I1114_I48_An I1_I1114_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I48_MP2 (VDD I1_p11_15 XI1_I1114_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I48_MP3 (XI1_I1114_I48_p1 XI1_I1114_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I48_MP0 (VDD I1_p11_15 XI1_I1114_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I49_MP1 (VDD I1_b12_17 XI1_I1114_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I49_MP5 (I1_I1114_pn17 I1_b12_17 XI1_I1114_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I49_MP4 (XI1_I1114_I49_p1 XI1_I1114_I49_An I1_I1114_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I49_MP2 (VDD I1_p11_16 XI1_I1114_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I49_MP3 (XI1_I1114_I49_p1 XI1_I1114_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I49_MP0 (VDD I1_p11_16 XI1_I1114_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I222_MP1 (VDD I1_I1068_G18_0 XI1_I1068_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I222_MP5 (I1_p11_19 I1_I1068_G18_0 XI1_I1068_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I222_MP4 (XI1_I1068_I222_p1 XI1_I1068_I222_An I1_p11_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I222_MP2 (VDD I1_I1068_pn19 XI1_I1068_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I222_MP3 (XI1_I1068_I222_p1 XI1_I1068_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I222_MP0 (VDD I1_I1068_pn19 XI1_I1068_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I223_MP1 (VDD I1_I1068_G19_0 XI1_I1068_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I223_MP5 (I1_p11_20 I1_I1068_G19_0 XI1_I1068_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I223_MP4 (XI1_I1068_I223_p1 XI1_I1068_I223_An I1_p11_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I223_MP2 (VDD I1_I1068_pn20 XI1_I1068_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I223_MP3 (XI1_I1068_I223_p1 XI1_I1068_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I223_MP0 (VDD I1_I1068_pn20 XI1_I1068_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I52_MP1 (VDD I1_b11_20 XI1_I1068_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I52_MP5 (I1_I1068_pn20 I1_b11_20 XI1_I1068_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I52_MP4 (XI1_I1068_I52_p1 XI1_I1068_I52_An I1_I1068_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I52_MP2 (VDD I1_p10_19 XI1_I1068_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I52_MP3 (XI1_I1068_I52_p1 XI1_I1068_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I52_MP0 (VDD I1_p10_19 XI1_I1068_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I53_MP1 (VDD I1_b11_21 XI1_I1068_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I53_MP5 (I1_I1068_pn21 I1_b11_21 XI1_I1068_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I53_MP4 (XI1_I1068_I53_p1 XI1_I1068_I53_An I1_I1068_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I53_MP2 (VDD I1_p10_20 XI1_I1068_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I53_MP3 (XI1_I1068_I53_p1 XI1_I1068_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I53_MP0 (VDD I1_p10_20 XI1_I1068_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I226_MP1 (VDD I1_I1022_G22_0 XI1_I1022_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I226_MP5 (I1_p10_23 I1_I1022_G22_0 XI1_I1022_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I226_MP4 (XI1_I1022_I226_p1 XI1_I1022_I226_An I1_p10_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I226_MP2 (VDD I1_I1022_pn23 XI1_I1022_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I226_MP3 (XI1_I1022_I226_p1 XI1_I1022_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I226_MP0 (VDD I1_I1022_pn23 XI1_I1022_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I229_MP1 (VDD I1_I1022_G25_0 XI1_I1022_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I229_MP5 (I1_p10_26 I1_I1022_G25_0 XI1_I1022_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I229_MP4 (XI1_I1022_I229_p1 XI1_I1022_I229_An I1_p10_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I229_MP2 (VDD I1_I1022_pn26 XI1_I1022_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I229_MP3 (XI1_I1022_I229_p1 XI1_I1022_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I229_MP0 (VDD I1_I1022_pn26 XI1_I1022_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I227_MP1 (VDD I1_I1022_G23_0 XI1_I1022_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I227_MP5 (I1_p10_24 I1_I1022_G23_0 XI1_I1022_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I227_MP4 (XI1_I1022_I227_p1 XI1_I1022_I227_An I1_p10_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I227_MP2 (VDD I1_I1022_pn24 XI1_I1022_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I227_MP3 (XI1_I1022_I227_p1 XI1_I1022_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I227_MP0 (VDD I1_I1022_pn24 XI1_I1022_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I56_MP1 (VDD I1_b10_24 XI1_I1022_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I56_MP5 (I1_I1022_pn24 I1_b10_24 XI1_I1022_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I56_MP4 (XI1_I1022_I56_p1 XI1_I1022_I56_An I1_I1022_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I56_MP2 (VDD I1_p9_23 XI1_I1022_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I56_MP3 (XI1_I1022_I56_p1 XI1_I1022_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I56_MP0 (VDD I1_p9_23 XI1_I1022_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I55_MP1 (VDD I1_b10_23 XI1_I1022_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I55_MP5 (I1_I1022_pn23 I1_b10_23 XI1_I1022_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I55_MP4 (XI1_I1022_I55_p1 XI1_I1022_I55_An I1_I1022_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I55_MP2 (VDD I1_p9_22 XI1_I1022_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I55_MP3 (XI1_I1022_I55_p1 XI1_I1022_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I55_MP0 (VDD I1_p9_22 XI1_I1022_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I224_MP1 (VDD I1_I976_G20_0 XI1_I976_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I224_MP5 (I1_p9_21 I1_I976_G20_0 XI1_I976_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I224_MP4 (XI1_I976_I224_p1 XI1_I976_I224_An I1_p9_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I224_MP2 (VDD I1_I976_pn21 XI1_I976_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I224_MP3 (XI1_I976_I224_p1 XI1_I976_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I224_MP0 (VDD I1_I976_pn21 XI1_I976_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I221_MP1 (VDD I1_I976_G17_0 XI1_I976_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I221_MP5 (I1_p9_18 I1_I976_G17_0 XI1_I976_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I221_MP4 (XI1_I976_I221_p1 XI1_I976_I221_An I1_p9_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I221_MP2 (VDD I1_I976_pn18 XI1_I976_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I221_MP3 (XI1_I976_I221_p1 XI1_I976_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I221_MP0 (VDD I1_I976_pn18 XI1_I976_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I211_MP1 (VDD I1_I976_G7_0 XI1_I976_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I211_MP5 (I1_p9_8 I1_I976_G7_0 XI1_I976_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I211_MP4 (XI1_I976_I211_p1 XI1_I976_I211_An I1_p9_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I211_MP2 (VDD I1_I976_pn8 XI1_I976_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I211_MP3 (XI1_I976_I211_p1 XI1_I976_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I211_MP0 (VDD I1_I976_pn8 XI1_I976_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I37_MP1 (VDD I1_b9_5 XI1_I976_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I37_MP5 (I1_I976_pn5 I1_b9_5 XI1_I976_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I37_MP4 (XI1_I976_I37_p1 XI1_I976_I37_An I1_I976_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I37_MP2 (VDD I1_p8_4 XI1_I976_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I37_MP3 (XI1_I976_I37_p1 XI1_I976_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I37_MP0 (VDD I1_p8_4 XI1_I976_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I204_MP1 (VDD I1_I608_G0_0 XI1_I608_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I204_MP5 (I1_p1_1 I1_I608_G0_0 XI1_I608_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I204_MP4 (XI1_I608_I204_p1 XI1_I608_I204_An I1_p1_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I204_MP2 (VDD I1_I608_pn1 XI1_I608_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I204_MP3 (XI1_I608_I204_p1 XI1_I608_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I204_MP0 (VDD I1_I608_pn1 XI1_I608_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I205_MP1 (VDD I1_I608_G1_0 XI1_I608_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I205_MP5 (I1_p1_2 I1_I608_G1_0 XI1_I608_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I205_MP4 (XI1_I608_I205_p1 XI1_I608_I205_An I1_p1_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I205_MP2 (VDD I1_I608_pn2 XI1_I608_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I205_MP3 (XI1_I608_I205_p1 XI1_I608_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I205_MP0 (VDD I1_I608_pn2 XI1_I608_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I208_MP1 (VDD I1_I608_G4_0 XI1_I608_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I208_MP5 (I1_p1_5 I1_I608_G4_0 XI1_I608_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I208_MP4 (XI1_I608_I208_p1 XI1_I608_I208_An I1_p1_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I208_MP2 (VDD I1_I608_pn5 XI1_I608_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I208_MP3 (XI1_I608_I208_p1 XI1_I608_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I208_MP0 (VDD I1_I608_pn5 XI1_I608_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I210_MP1 (VDD I1_I608_G6_0 XI1_I608_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I210_MP5 (I1_p1_7 I1_I608_G6_0 XI1_I608_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I210_MP4 (XI1_I608_I210_p1 XI1_I608_I210_An I1_p1_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I210_MP2 (VDD I1_I608_pn7 XI1_I608_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I210_MP3 (XI1_I608_I210_p1 XI1_I608_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I210_MP0 (VDD I1_I608_pn7 XI1_I608_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I220_MP1 (VDD I1_I608_G16_0 XI1_I608_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I220_MP5 (I1_p1_17 I1_I608_G16_0 XI1_I608_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I220_MP4 (XI1_I608_I220_p1 XI1_I608_I220_An I1_p1_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I220_MP2 (VDD I1_I608_pn17 XI1_I608_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I220_MP3 (XI1_I608_I220_p1 XI1_I608_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I220_MP0 (VDD I1_I608_pn17 XI1_I608_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I222_MP1 (VDD I1_I608_G18_0 XI1_I608_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I222_MP5 (I1_p1_19 I1_I608_G18_0 XI1_I608_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I222_MP4 (XI1_I608_I222_p1 XI1_I608_I222_An I1_p1_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I222_MP2 (VDD I1_I608_pn19 XI1_I608_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I222_MP3 (XI1_I608_I222_p1 XI1_I608_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I222_MP0 (VDD I1_I608_pn19 XI1_I608_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I224_MP1 (VDD I1_I608_G20_0 XI1_I608_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I224_MP5 (I1_p1_21 I1_I608_G20_0 XI1_I608_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I224_MP4 (XI1_I608_I224_p1 XI1_I608_I224_An I1_p1_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I224_MP2 (VDD I1_I608_pn21 XI1_I608_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I224_MP3 (XI1_I608_I224_p1 XI1_I608_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I224_MP0 (VDD I1_I608_pn21 XI1_I608_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I226_MP1 (VDD I1_I608_G22_0 XI1_I608_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I226_MP5 (I1_p1_23 I1_I608_G22_0 XI1_I608_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I226_MP4 (XI1_I608_I226_p1 XI1_I608_I226_An I1_p1_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I226_MP2 (VDD I1_I608_pn23 XI1_I608_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I226_MP3 (XI1_I608_I226_p1 XI1_I608_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I226_MP0 (VDD I1_I608_pn23 XI1_I608_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I228_MP1 (VDD I1_I608_G24_0 XI1_I608_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I228_MP5 (I1_p1_25 I1_I608_G24_0 XI1_I608_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I228_MP4 (XI1_I608_I228_p1 XI1_I608_I228_An I1_p1_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I228_MP2 (VDD I1_I608_pn25 XI1_I608_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I228_MP3 (XI1_I608_I228_p1 XI1_I608_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I228_MP0 (VDD I1_I608_pn25 XI1_I608_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I234_MP1 (VDD I1_c1_m XI1_I608_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I234_MP5 (I1_p1_31 I1_c1_m XI1_I608_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I234_MP4 (XI1_I608_I234_p1 XI1_I608_I234_An I1_p1_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I234_MP2 (VDD I1_I608_pn31 XI1_I608_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I234_MP3 (XI1_I608_I234_p1 XI1_I608_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I234_MP0 (VDD I1_I608_pn31 XI1_I608_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I58_MP1 (VDD I1_b2_26 XI1_I654_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I58_MP5 (I1_I654_pn26 I1_b2_26 XI1_I654_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I58_MP4 (XI1_I654_I58_p1 XI1_I654_I58_An I1_I654_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I58_MP2 (VDD I1_p1_25 XI1_I654_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I58_MP3 (XI1_I654_I58_p1 XI1_I654_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I58_MP0 (VDD I1_p1_25 XI1_I654_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I63_MP1 (VDD I1_b2_31 XI1_I654_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I63_MP5 (I1_I654_pn31 I1_b2_31 XI1_I654_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I63_MP4 (XI1_I654_I63_p1 XI1_I654_I63_An I1_I654_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I63_MP2 (VDD I1_p1_30 XI1_I654_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I63_MP3 (XI1_I654_I63_p1 XI1_I654_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I63_MP0 (VDD I1_p1_30 XI1_I654_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I234_MP1 (VDD I1_c19_m XI1_I1436_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I234_MP5 (I1_p19_31 I1_c19_m XI1_I1436_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I234_MP4 (XI1_I1436_I234_p1 XI1_I1436_I234_An I1_p19_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I234_MP2 (VDD I1_I1436_pn31 XI1_I1436_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I234_MP3 (XI1_I1436_I234_p1 XI1_I1436_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I234_MP0 (VDD I1_I1436_pn31 XI1_I1436_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I231_MP1 (VDD I1_I1436_G27_0 XI1_I1436_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I231_MP5 (I1_p19_28 I1_I1436_G27_0 XI1_I1436_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I231_MP4 (XI1_I1436_I231_p1 XI1_I1436_I231_An I1_p19_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I231_MP2 (VDD I1_I1436_pn28 XI1_I1436_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I231_MP3 (XI1_I1436_I231_p1 XI1_I1436_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I231_MP0 (VDD I1_I1436_pn28 XI1_I1436_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I227_MP1 (VDD I1_I1436_G23_0 XI1_I1436_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I227_MP5 (I1_p19_24 I1_I1436_G23_0 XI1_I1436_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I227_MP4 (XI1_I1436_I227_p1 XI1_I1436_I227_An I1_p19_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I227_MP2 (VDD I1_I1436_pn24 XI1_I1436_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I227_MP3 (XI1_I1436_I227_p1 XI1_I1436_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I227_MP0 (VDD I1_I1436_pn24 XI1_I1436_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I225_MP1 (VDD I1_I1436_G21_0 XI1_I1436_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I225_MP5 (I1_p19_22 I1_I1436_G21_0 XI1_I1436_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I225_MP4 (XI1_I1436_I225_p1 XI1_I1436_I225_An I1_p19_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I225_MP2 (VDD I1_I1436_pn22 XI1_I1436_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I225_MP3 (XI1_I1436_I225_p1 XI1_I1436_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I225_MP0 (VDD I1_I1436_pn22 XI1_I1436_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I50_MP1 (VDD I1_b20_18 XI1_I1482_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I50_MP5 (I1_I1482_pn18 I1_b20_18 XI1_I1482_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I50_MP4 (XI1_I1482_I50_p1 XI1_I1482_I50_An I1_I1482_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I50_MP2 (VDD I1_p19_17 XI1_I1482_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I50_MP3 (XI1_I1482_I50_p1 XI1_I1482_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I50_MP0 (VDD I1_p19_17 XI1_I1482_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I48_MP1 (VDD I1_b20_16 XI1_I1482_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I48_MP5 (I1_I1482_pn16 I1_b20_16 XI1_I1482_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I48_MP4 (XI1_I1482_I48_p1 XI1_I1482_I48_An I1_I1482_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I48_MP2 (VDD I1_p19_15 XI1_I1482_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I48_MP3 (XI1_I1482_I48_p1 XI1_I1482_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I48_MP0 (VDD I1_p19_15 XI1_I1482_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I46_MP1 (VDD I1_b20_14 XI1_I1482_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I46_MP5 (I1_I1482_pn14 I1_b20_14 XI1_I1482_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I46_MP4 (XI1_I1482_I46_p1 XI1_I1482_I46_An I1_I1482_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I46_MP2 (VDD I1_p19_13 XI1_I1482_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I46_MP3 (XI1_I1482_I46_p1 XI1_I1482_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I46_MP0 (VDD I1_p19_13 XI1_I1482_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I43_MP1 (VDD I1_b20_11 XI1_I1482_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I43_MP5 (I1_I1482_pn11 I1_b20_11 XI1_I1482_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I43_MP4 (XI1_I1482_I43_p1 XI1_I1482_I43_An I1_I1482_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I43_MP2 (VDD I1_p19_10 XI1_I1482_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I43_MP3 (XI1_I1482_I43_p1 XI1_I1482_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I43_MP0 (VDD I1_p19_10 XI1_I1482_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I40_MP1 (VDD I1_b20_8 XI1_I1482_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I40_MP5 (I1_I1482_pn8 I1_b20_8 XI1_I1482_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I40_MP4 (XI1_I1482_I40_p1 XI1_I1482_I40_An I1_I1482_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I40_MP2 (VDD I1_p19_7 XI1_I1482_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I40_MP3 (XI1_I1482_I40_p1 XI1_I1482_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I40_MP0 (VDD I1_p19_7 XI1_I1482_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I203_MP1 (VDD I1_qu13_b3_5 XI1_I1436_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I203_MP5 (I1_p19_0 I1_qu13_b3_5 XI1_I1436_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I203_MP4 (XI1_I1436_I203_p1 XI1_I1436_I203_An I1_p19_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I203_MP2 (VDD I1_I1436_pn0 XI1_I1436_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I203_MP3 (XI1_I1436_I203_p1 XI1_I1436_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I203_MP0 (VDD I1_I1436_pn0 XI1_I1436_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I47_MP1 (VDD I1_b12_15 XI1_I1114_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I47_MP5 (I1_I1114_pn15 I1_b12_15 XI1_I1114_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I47_MP4 (XI1_I1114_I47_p1 XI1_I1114_I47_An I1_I1114_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I47_MP2 (VDD I1_p11_14 XI1_I1114_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I47_MP3 (XI1_I1114_I47_p1 XI1_I1114_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I47_MP0 (VDD I1_p11_14 XI1_I1114_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I46_MP1 (VDD I1_b12_14 XI1_I1114_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I46_MP5 (I1_I1114_pn14 I1_b12_14 XI1_I1114_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I46_MP4 (XI1_I1114_I46_p1 XI1_I1114_I46_An I1_I1114_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I46_MP2 (VDD I1_p11_13 XI1_I1114_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I46_MP3 (XI1_I1114_I46_p1 XI1_I1114_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I46_MP0 (VDD I1_p11_13 XI1_I1114_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I221_MP1 (VDD I1_I1068_G17_0 XI1_I1068_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I221_MP5 (I1_p11_18 I1_I1068_G17_0 XI1_I1068_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I221_MP4 (XI1_I1068_I221_p1 XI1_I1068_I221_An I1_p11_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I221_MP2 (VDD I1_I1068_pn18 XI1_I1068_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I221_MP3 (XI1_I1068_I221_p1 XI1_I1068_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I221_MP0 (VDD I1_I1068_pn18 XI1_I1068_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I51_MP1 (VDD I1_b11_19 XI1_I1068_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I51_MP5 (I1_I1068_pn19 I1_b11_19 XI1_I1068_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I51_MP4 (XI1_I1068_I51_p1 XI1_I1068_I51_An I1_I1068_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I51_MP2 (VDD I1_p10_18 XI1_I1068_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I51_MP3 (XI1_I1068_I51_p1 XI1_I1068_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I51_MP0 (VDD I1_p10_18 XI1_I1068_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I228_MP1 (VDD I1_I1022_G24_0 XI1_I1022_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I228_MP5 (I1_p10_25 I1_I1022_G24_0 XI1_I1022_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I228_MP4 (XI1_I1022_I228_p1 XI1_I1022_I228_An I1_p10_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I228_MP2 (VDD I1_I1022_pn25 XI1_I1022_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I228_MP3 (XI1_I1022_I228_p1 XI1_I1022_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I228_MP0 (VDD I1_I1022_pn25 XI1_I1022_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I234_MP1 (VDD I1_c9_m XI1_I976_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I234_MP5 (I1_p9_31 I1_c9_m XI1_I976_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I234_MP4 (XI1_I976_I234_p1 XI1_I976_I234_An I1_p9_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I234_MP2 (VDD I1_I976_pn31 XI1_I976_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I234_MP3 (XI1_I976_I234_p1 XI1_I976_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I234_MP0 (VDD I1_I976_pn31 XI1_I976_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I225_MP1 (VDD I1_I1022_G21_0 XI1_I1022_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I225_MP5 (I1_p10_22 I1_I1022_G21_0 XI1_I1022_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I225_MP4 (XI1_I1022_I225_p1 XI1_I1022_I225_An I1_p10_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I225_MP2 (VDD I1_I1022_pn22 XI1_I1022_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I225_MP3 (XI1_I1022_I225_p1 XI1_I1022_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I225_MP0 (VDD I1_I1022_pn22 XI1_I1022_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I54_MP1 (VDD I1_b10_22 XI1_I1022_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I54_MP5 (I1_I1022_pn22 I1_b10_22 XI1_I1022_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I54_MP4 (XI1_I1022_I54_p1 XI1_I1022_I54_An I1_I1022_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I54_MP2 (VDD I1_p9_21 XI1_I1022_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I54_MP3 (XI1_I1022_I54_p1 XI1_I1022_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I54_MP0 (VDD I1_p9_21 XI1_I1022_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I53_MP1 (VDD I1_b10_21 XI1_I1022_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I53_MP5 (I1_I1022_pn21 I1_b10_21 XI1_I1022_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I53_MP4 (XI1_I1022_I53_p1 XI1_I1022_I53_An I1_I1022_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I53_MP2 (VDD I1_p9_20 XI1_I1022_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I53_MP3 (XI1_I1022_I53_p1 XI1_I1022_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I53_MP0 (VDD I1_p9_20 XI1_I1022_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I209_MP1 (VDD I1_I976_G5_0 XI1_I976_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I209_MP5 (I1_p9_6 I1_I976_G5_0 XI1_I976_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I209_MP4 (XI1_I976_I209_p1 XI1_I976_I209_An I1_p9_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I209_MP2 (VDD I1_I976_pn6 XI1_I976_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I209_MP3 (XI1_I976_I209_p1 XI1_I976_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I209_MP0 (VDD I1_I976_pn6 XI1_I976_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I36_MP1 (VDD I1_b9_4 XI1_I976_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I36_MP5 (I1_I976_pn4 I1_b9_4 XI1_I976_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I36_MP4 (XI1_I976_I36_p1 XI1_I976_I36_An I1_I976_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I36_MP2 (VDD I1_p8_3 XI1_I976_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I36_MP3 (XI1_I976_I36_p1 XI1_I976_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I36_MP0 (VDD I1_p8_3 XI1_I976_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I33_MP1 (VDD I1_b1_1 XI1_I608_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I33_MP5 (I1_I608_pn1 I1_b1_1 XI1_I608_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I33_MP4 (XI1_I608_I33_p1 XI1_I608_I33_An I1_I608_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I33_MP2 (VDD I1_p0_0 XI1_I608_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I33_MP3 (XI1_I608_I33_p1 XI1_I608_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I33_MP0 (VDD I1_p0_0 XI1_I608_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I230_MP1 (VDD I1_I608_G26_0 XI1_I608_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I230_MP5 (I1_p1_27 I1_I608_G26_0 XI1_I608_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I230_MP4 (XI1_I608_I230_p1 XI1_I608_I230_An I1_p1_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I230_MP2 (VDD I1_I608_pn27 XI1_I608_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I230_MP3 (XI1_I608_I230_p1 XI1_I608_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I230_MP0 (VDD I1_I608_pn27 XI1_I608_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I232_MP1 (VDD I1_I608_G28_0 XI1_I608_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I232_MP5 (I1_p1_29 I1_I608_G28_0 XI1_I608_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I232_MP4 (XI1_I608_I232_p1 XI1_I608_I232_An I1_p1_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I232_MP2 (VDD I1_I608_pn29 XI1_I608_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I232_MP3 (XI1_I608_I232_p1 XI1_I608_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I232_MP0 (VDD I1_I608_pn29 XI1_I608_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I233_MP1 (VDD I1_I608_G29_0 XI1_I608_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I233_MP5 (I1_p1_30 I1_I608_G29_0 XI1_I608_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I233_MP4 (XI1_I608_I233_p1 XI1_I608_I233_An I1_p1_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I233_MP2 (VDD I1_I608_pn30 XI1_I608_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I233_MP3 (XI1_I608_I233_p1 XI1_I608_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I233_MP0 (VDD I1_I608_pn30 XI1_I608_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I56_MP1 (VDD I1_b20_24 XI1_I1482_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I56_MP5 (I1_I1482_pn24 I1_b20_24 XI1_I1482_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I56_MP4 (XI1_I1482_I56_p1 XI1_I1482_I56_An I1_I1482_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I56_MP2 (VDD I1_p19_23 XI1_I1482_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I56_MP3 (XI1_I1482_I56_p1 XI1_I1482_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I56_MP0 (VDD I1_p19_23 XI1_I1482_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I55_MP1 (VDD I1_b20_23 XI1_I1482_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I55_MP5 (I1_I1482_pn23 I1_b20_23 XI1_I1482_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I55_MP4 (XI1_I1482_I55_p1 XI1_I1482_I55_An I1_I1482_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I55_MP2 (VDD I1_p19_22 XI1_I1482_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I55_MP3 (XI1_I1482_I55_p1 XI1_I1482_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I55_MP0 (VDD I1_p19_22 XI1_I1482_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I54_MP1 (VDD I1_b20_22 XI1_I1482_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I54_MP5 (I1_I1482_pn22 I1_b20_22 XI1_I1482_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I54_MP4 (XI1_I1482_I54_p1 XI1_I1482_I54_An I1_I1482_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I54_MP2 (VDD I1_p19_21 XI1_I1482_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I54_MP3 (XI1_I1482_I54_p1 XI1_I1482_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I54_MP0 (VDD I1_p19_21 XI1_I1482_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I52_MP1 (VDD I1_b20_20 XI1_I1482_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I52_MP5 (I1_I1482_pn20 I1_b20_20 XI1_I1482_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I52_MP4 (XI1_I1482_I52_p1 XI1_I1482_I52_An I1_I1482_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I52_MP2 (VDD I1_p19_19 XI1_I1482_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I52_MP3 (XI1_I1482_I52_p1 XI1_I1482_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I52_MP0 (VDD I1_p19_19 XI1_I1482_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I53_MP1 (VDD I1_b20_21 XI1_I1482_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I53_MP5 (I1_I1482_pn21 I1_b20_21 XI1_I1482_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I53_MP4 (XI1_I1482_I53_p1 XI1_I1482_I53_An I1_I1482_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I53_MP2 (VDD I1_p19_20 XI1_I1482_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I53_MP3 (XI1_I1482_I53_p1 XI1_I1482_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I53_MP0 (VDD I1_p19_20 XI1_I1482_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I51_MP1 (VDD I1_b20_19 XI1_I1482_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I51_MP5 (I1_I1482_pn19 I1_b20_19 XI1_I1482_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I51_MP4 (XI1_I1482_I51_p1 XI1_I1482_I51_An I1_I1482_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I51_MP2 (VDD I1_p19_18 XI1_I1482_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I51_MP3 (XI1_I1482_I51_p1 XI1_I1482_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I51_MP0 (VDD I1_p19_18 XI1_I1482_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I49_MP1 (VDD I1_b20_17 XI1_I1482_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I49_MP5 (I1_I1482_pn17 I1_b20_17 XI1_I1482_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I49_MP4 (XI1_I1482_I49_p1 XI1_I1482_I49_An I1_I1482_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I49_MP2 (VDD I1_p19_16 XI1_I1482_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I49_MP3 (XI1_I1482_I49_p1 XI1_I1482_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I49_MP0 (VDD I1_p19_16 XI1_I1482_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I47_MP1 (VDD I1_b20_15 XI1_I1482_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I47_MP5 (I1_I1482_pn15 I1_b20_15 XI1_I1482_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I47_MP4 (XI1_I1482_I47_p1 XI1_I1482_I47_An I1_I1482_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I47_MP2 (VDD I1_p19_14 XI1_I1482_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I47_MP3 (XI1_I1482_I47_p1 XI1_I1482_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I47_MP0 (VDD I1_p19_14 XI1_I1482_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I45_MP1 (VDD I1_b20_13 XI1_I1482_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I45_MP5 (I1_I1482_pn13 I1_b20_13 XI1_I1482_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I45_MP4 (XI1_I1482_I45_p1 XI1_I1482_I45_An I1_I1482_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I45_MP2 (VDD I1_p19_12 XI1_I1482_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I45_MP3 (XI1_I1482_I45_p1 XI1_I1482_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I45_MP0 (VDD I1_p19_12 XI1_I1482_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I44_MP1 (VDD I1_b20_12 XI1_I1482_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I44_MP5 (I1_I1482_pn12 I1_b20_12 XI1_I1482_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I44_MP4 (XI1_I1482_I44_p1 XI1_I1482_I44_An I1_I1482_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I44_MP2 (VDD I1_p19_11 XI1_I1482_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I44_MP3 (XI1_I1482_I44_p1 XI1_I1482_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I44_MP0 (VDD I1_p19_11 XI1_I1482_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I42_MP1 (VDD I1_b20_10 XI1_I1482_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I42_MP5 (I1_I1482_pn10 I1_b20_10 XI1_I1482_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I42_MP4 (XI1_I1482_I42_p1 XI1_I1482_I42_An I1_I1482_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I42_MP2 (VDD I1_p19_9 XI1_I1482_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I42_MP3 (XI1_I1482_I42_p1 XI1_I1482_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I42_MP0 (VDD I1_p19_9 XI1_I1482_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I41_MP1 (VDD I1_b20_9 XI1_I1482_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I41_MP5 (I1_I1482_pn9 I1_b20_9 XI1_I1482_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I41_MP4 (XI1_I1482_I41_p1 XI1_I1482_I41_An I1_I1482_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I41_MP2 (VDD I1_p19_8 XI1_I1482_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I41_MP3 (XI1_I1482_I41_p1 XI1_I1482_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I41_MP0 (VDD I1_p19_8 XI1_I1482_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I39_MP1 (VDD I1_b20_7 XI1_I1482_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I39_MP5 (I1_I1482_pn7 I1_b20_7 XI1_I1482_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I39_MP4 (XI1_I1482_I39_p1 XI1_I1482_I39_An I1_I1482_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I39_MP2 (VDD I1_p19_6 XI1_I1482_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I39_MP3 (XI1_I1482_I39_p1 XI1_I1482_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I39_MP0 (VDD I1_p19_6 XI1_I1482_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I37_MP1 (VDD I1_b20_5 XI1_I1482_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I37_MP5 (I1_I1482_pn5 I1_b20_5 XI1_I1482_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I37_MP4 (XI1_I1482_I37_p1 XI1_I1482_I37_An I1_I1482_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I37_MP2 (VDD I1_p19_4 XI1_I1482_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I37_MP3 (XI1_I1482_I37_p1 XI1_I1482_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I37_MP0 (VDD I1_p19_4 XI1_I1482_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I35_MP1 (VDD I1_b20_3 XI1_I1482_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I35_MP5 (I1_I1482_pn3 I1_b20_3 XI1_I1482_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I35_MP4 (XI1_I1482_I35_p1 XI1_I1482_I35_An I1_I1482_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I35_MP2 (VDD I1_p19_2 XI1_I1482_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I35_MP3 (XI1_I1482_I35_p1 XI1_I1482_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I35_MP0 (VDD I1_p19_2 XI1_I1482_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I34_MP1 (VDD I1_b20_2 XI1_I1482_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I34_MP5 (I1_I1482_pn2 I1_b20_2 XI1_I1482_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I34_MP4 (XI1_I1482_I34_p1 XI1_I1482_I34_An I1_I1482_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I34_MP2 (VDD I1_p19_1 XI1_I1482_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I34_MP3 (XI1_I1482_I34_p1 XI1_I1482_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I34_MP0 (VDD I1_p19_1 XI1_I1482_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I211_MP1 (VDD I1_I1114_G7_0 XI1_I1114_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I211_MP5 (I1_p12_8 I1_I1114_G7_0 XI1_I1114_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I211_MP4 (XI1_I1114_I211_p1 XI1_I1114_I211_An I1_p12_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I211_MP2 (VDD I1_I1114_pn8 XI1_I1114_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I211_MP3 (XI1_I1114_I211_p1 XI1_I1114_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I211_MP0 (VDD I1_I1114_pn8 XI1_I1114_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I210_MP1 (VDD I1_I1114_G6_0 XI1_I1114_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I210_MP5 (I1_p12_7 I1_I1114_G6_0 XI1_I1114_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I210_MP4 (XI1_I1114_I210_p1 XI1_I1114_I210_An I1_p12_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I210_MP2 (VDD I1_I1114_pn7 XI1_I1114_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I210_MP3 (XI1_I1114_I210_p1 XI1_I1114_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I210_MP0 (VDD I1_I1114_pn7 XI1_I1114_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I45_MP1 (VDD I1_b12_13 XI1_I1114_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I45_MP5 (I1_I1114_pn13 I1_b12_13 XI1_I1114_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I45_MP4 (XI1_I1114_I45_p1 XI1_I1114_I45_An I1_I1114_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I45_MP2 (VDD I1_p11_12 XI1_I1114_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I45_MP3 (XI1_I1114_I45_p1 XI1_I1114_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I45_MP0 (VDD I1_p11_12 XI1_I1114_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I220_MP1 (VDD I1_I1068_G16_0 XI1_I1068_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I220_MP5 (I1_p11_17 I1_I1068_G16_0 XI1_I1068_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I220_MP4 (XI1_I1068_I220_p1 XI1_I1068_I220_An I1_p11_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I220_MP2 (VDD I1_I1068_pn17 XI1_I1068_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I220_MP3 (XI1_I1068_I220_p1 XI1_I1068_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I220_MP0 (VDD I1_I1068_pn17 XI1_I1068_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I49_MP1 (VDD I1_b11_17 XI1_I1068_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I49_MP5 (I1_I1068_pn17 I1_b11_17 XI1_I1068_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I49_MP4 (XI1_I1068_I49_p1 XI1_I1068_I49_An I1_I1068_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I49_MP2 (VDD I1_p10_16 XI1_I1068_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I49_MP3 (XI1_I1068_I49_p1 XI1_I1068_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I49_MP0 (VDD I1_p10_16 XI1_I1068_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I50_MP1 (VDD I1_b11_18 XI1_I1068_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I50_MP5 (I1_I1068_pn18 I1_b11_18 XI1_I1068_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I50_MP4 (XI1_I1068_I50_p1 XI1_I1068_I50_An I1_I1068_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I50_MP2 (VDD I1_p10_17 XI1_I1068_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I50_MP3 (XI1_I1068_I50_p1 XI1_I1068_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I50_MP0 (VDD I1_p10_17 XI1_I1068_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I224_MP1 (VDD I1_I1022_G20_0 XI1_I1022_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I224_MP5 (I1_p10_21 I1_I1022_G20_0 XI1_I1022_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I224_MP4 (XI1_I1022_I224_p1 XI1_I1022_I224_An I1_p10_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I224_MP2 (VDD I1_I1022_pn21 XI1_I1022_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I224_MP3 (XI1_I1022_I224_p1 XI1_I1022_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I224_MP0 (VDD I1_I1022_pn21 XI1_I1022_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I52_MP1 (VDD I1_b10_20 XI1_I1022_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I52_MP5 (I1_I1022_pn20 I1_b10_20 XI1_I1022_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I52_MP4 (XI1_I1022_I52_p1 XI1_I1022_I52_An I1_I1022_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I52_MP2 (VDD I1_p9_19 XI1_I1022_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I52_MP3 (XI1_I1022_I52_p1 XI1_I1022_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I52_MP0 (VDD I1_p9_19 XI1_I1022_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I51_MP1 (VDD I1_b10_19 XI1_I1022_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I51_MP5 (I1_I1022_pn19 I1_b10_19 XI1_I1022_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I51_MP4 (XI1_I1022_I51_p1 XI1_I1022_I51_An I1_I1022_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I51_MP2 (VDD I1_p9_18 XI1_I1022_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I51_MP3 (XI1_I1022_I51_p1 XI1_I1022_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I51_MP0 (VDD I1_p9_18 XI1_I1022_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I222_MP1 (VDD I1_I976_G18_0 XI1_I976_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I222_MP5 (I1_p9_19 I1_I976_G18_0 XI1_I976_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I222_MP4 (XI1_I976_I222_p1 XI1_I976_I222_An I1_p9_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I222_MP2 (VDD I1_I976_pn19 XI1_I976_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I222_MP3 (XI1_I976_I222_p1 XI1_I976_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I222_MP0 (VDD I1_I976_pn19 XI1_I976_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I35_MP1 (VDD I1_b9_3 XI1_I976_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I35_MP5 (I1_I976_pn3 I1_b9_3 XI1_I976_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I35_MP4 (XI1_I976_I35_p1 XI1_I976_I35_An I1_I976_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I35_MP2 (VDD I1_p8_2 XI1_I976_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I35_MP3 (XI1_I976_I35_p1 XI1_I976_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I35_MP0 (VDD I1_p8_2 XI1_I976_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I34_MP1 (VDD I1_b1_2 XI1_I608_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I34_MP5 (I1_I608_pn2 I1_b1_2 XI1_I608_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I34_MP4 (XI1_I608_I34_p1 XI1_I608_I34_An I1_I608_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I34_MP2 (VDD I1_p0_1 XI1_I608_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I34_MP3 (XI1_I608_I34_p1 XI1_I608_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I34_MP0 (VDD I1_p0_1 XI1_I608_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I209_MP1 (VDD I1_I608_G5_0 XI1_I608_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I209_MP5 (I1_p1_6 I1_I608_G5_0 XI1_I608_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I209_MP4 (XI1_I608_I209_p1 XI1_I608_I209_An I1_p1_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I209_MP2 (VDD I1_I608_pn6 XI1_I608_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I209_MP3 (XI1_I608_I209_p1 XI1_I608_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I209_MP0 (VDD I1_I608_pn6 XI1_I608_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I211_MP1 (VDD I1_I608_G7_0 XI1_I608_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I211_MP5 (I1_p1_8 I1_I608_G7_0 XI1_I608_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I211_MP4 (XI1_I608_I211_p1 XI1_I608_I211_An I1_p1_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I211_MP2 (VDD I1_I608_pn8 XI1_I608_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I211_MP3 (XI1_I608_I211_p1 XI1_I608_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I211_MP0 (VDD I1_I608_pn8 XI1_I608_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I221_MP1 (VDD I1_I608_G17_0 XI1_I608_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I221_MP5 (I1_p1_18 I1_I608_G17_0 XI1_I608_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I221_MP4 (XI1_I608_I221_p1 XI1_I608_I221_An I1_p1_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I221_MP2 (VDD I1_I608_pn18 XI1_I608_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I221_MP3 (XI1_I608_I221_p1 XI1_I608_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I221_MP0 (VDD I1_I608_pn18 XI1_I608_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I223_MP1 (VDD I1_I608_G19_0 XI1_I608_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I223_MP5 (I1_p1_20 I1_I608_G19_0 XI1_I608_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I223_MP4 (XI1_I608_I223_p1 XI1_I608_I223_An I1_p1_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I223_MP2 (VDD I1_I608_pn20 XI1_I608_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I223_MP3 (XI1_I608_I223_p1 XI1_I608_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I223_MP0 (VDD I1_I608_pn20 XI1_I608_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I227_MP1 (VDD I1_I608_G23_0 XI1_I608_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I227_MP5 (I1_p1_24 I1_I608_G23_0 XI1_I608_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I227_MP4 (XI1_I608_I227_p1 XI1_I608_I227_An I1_p1_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I227_MP2 (VDD I1_I608_pn24 XI1_I608_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I227_MP3 (XI1_I608_I227_p1 XI1_I608_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I227_MP0 (VDD I1_I608_pn24 XI1_I608_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I229_MP1 (VDD I1_I608_G25_0 XI1_I608_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I229_MP5 (I1_p1_26 I1_I608_G25_0 XI1_I608_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I229_MP4 (XI1_I608_I229_p1 XI1_I608_I229_An I1_p1_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I229_MP2 (VDD I1_I608_pn26 XI1_I608_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I229_MP3 (XI1_I608_I229_p1 XI1_I608_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I229_MP0 (VDD I1_I608_pn26 XI1_I608_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I231_MP1 (VDD I1_I608_G27_0 XI1_I608_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I231_MP5 (I1_p1_28 I1_I608_G27_0 XI1_I608_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I231_MP4 (XI1_I608_I231_p1 XI1_I608_I231_An I1_p1_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I231_MP2 (VDD I1_I608_pn28 XI1_I608_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I231_MP3 (XI1_I608_I231_p1 XI1_I608_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I231_MP0 (VDD I1_I608_pn28 XI1_I608_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I62_MP1 (VDD I1_b1_30 XI1_I608_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I62_MP5 (I1_I608_pn30 I1_b1_30 XI1_I608_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I62_MP4 (XI1_I608_I62_p1 XI1_I608_I62_An I1_I608_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I62_MP2 (VDD I1_p0_29 XI1_I608_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I62_MP3 (XI1_I608_I62_p1 XI1_I608_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I62_MP0 (VDD I1_p0_29 XI1_I608_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I57_MP1 (VDD I1_b20_25 XI1_I1482_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I57_MP5 (I1_I1482_pn25 I1_b20_25 XI1_I1482_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I57_MP4 (XI1_I1482_I57_p1 XI1_I1482_I57_An I1_I1482_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I57_MP2 (VDD I1_p19_24 XI1_I1482_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I57_MP3 (XI1_I1482_I57_p1 XI1_I1482_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I57_MP0 (VDD I1_p19_24 XI1_I1482_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I33_MP1 (VDD I1_b20_1 XI1_I1482_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I33_MP5 (I1_I1482_pn1 I1_b20_1 XI1_I1482_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I33_MP4 (XI1_I1482_I33_p1 XI1_I1482_I33_An I1_I1482_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I33_MP2 (VDD I1_p19_0 XI1_I1482_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I33_MP3 (XI1_I1482_I33_p1 XI1_I1482_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I33_MP0 (VDD I1_p19_0 XI1_I1482_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I209_MP1 (VDD I1_I1114_G5_0 XI1_I1114_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I209_MP5 (I1_p12_6 I1_I1114_G5_0 XI1_I1114_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I209_MP4 (XI1_I1114_I209_p1 XI1_I1114_I209_An I1_p12_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I209_MP2 (VDD I1_I1114_pn6 XI1_I1114_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I209_MP3 (XI1_I1114_I209_p1 XI1_I1114_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I209_MP0 (VDD I1_I1114_pn6 XI1_I1114_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I208_MP1 (VDD I1_I1114_G4_0 XI1_I1114_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I208_MP5 (I1_p12_5 I1_I1114_G4_0 XI1_I1114_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I208_MP4 (XI1_I1114_I208_p1 XI1_I1114_I208_An I1_p12_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I208_MP2 (VDD I1_I1114_pn5 XI1_I1114_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I208_MP3 (XI1_I1114_I208_p1 XI1_I1114_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I208_MP0 (VDD I1_I1114_pn5 XI1_I1114_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I43_MP1 (VDD I1_b12_11 XI1_I1114_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I43_MP5 (I1_I1114_pn11 I1_b12_11 XI1_I1114_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I43_MP4 (XI1_I1114_I43_p1 XI1_I1114_I43_An I1_I1114_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I43_MP2 (VDD I1_p11_10 XI1_I1114_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I43_MP3 (XI1_I1114_I43_p1 XI1_I1114_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I43_MP0 (VDD I1_p11_10 XI1_I1114_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I44_MP1 (VDD I1_b12_12 XI1_I1114_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I44_MP5 (I1_I1114_pn12 I1_b12_12 XI1_I1114_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I44_MP4 (XI1_I1114_I44_p1 XI1_I1114_I44_An I1_I1114_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I44_MP2 (VDD I1_p11_11 XI1_I1114_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I44_MP3 (XI1_I1114_I44_p1 XI1_I1114_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I44_MP0 (VDD I1_p11_11 XI1_I1114_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I48_MP1 (VDD I1_b11_16 XI1_I1068_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I48_MP5 (I1_I1068_pn16 I1_b11_16 XI1_I1068_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I48_MP4 (XI1_I1068_I48_p1 XI1_I1068_I48_An I1_I1068_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I48_MP2 (VDD I1_p10_15 XI1_I1068_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I48_MP3 (XI1_I1068_I48_p1 XI1_I1068_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I48_MP0 (VDD I1_p10_15 XI1_I1068_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I47_MP1 (VDD I1_b11_15 XI1_I1068_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I47_MP5 (I1_I1068_pn15 I1_b11_15 XI1_I1068_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I47_MP4 (XI1_I1068_I47_p1 XI1_I1068_I47_An I1_I1068_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I47_MP2 (VDD I1_p10_14 XI1_I1068_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I47_MP3 (XI1_I1068_I47_p1 XI1_I1068_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I47_MP0 (VDD I1_p10_14 XI1_I1068_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I222_MP1 (VDD I1_I1022_G18_0 XI1_I1022_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I222_MP5 (I1_p10_19 I1_I1022_G18_0 XI1_I1022_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I222_MP4 (XI1_I1022_I222_p1 XI1_I1022_I222_An I1_p10_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I222_MP2 (VDD I1_I1022_pn19 XI1_I1022_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I222_MP3 (XI1_I1022_I222_p1 XI1_I1022_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I222_MP0 (VDD I1_I1022_pn19 XI1_I1022_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I220_MP1 (VDD I1_I1022_G16_0 XI1_I1022_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I220_MP5 (I1_p10_17 I1_I1022_G16_0 XI1_I1022_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I220_MP4 (XI1_I1022_I220_p1 XI1_I1022_I220_An I1_p10_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I220_MP2 (VDD I1_I1022_pn17 XI1_I1022_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I220_MP3 (XI1_I1022_I220_p1 XI1_I1022_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I220_MP0 (VDD I1_I1022_pn17 XI1_I1022_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I221_MP1 (VDD I1_I1022_G17_0 XI1_I1022_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I221_MP5 (I1_p10_18 I1_I1022_G17_0 XI1_I1022_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I221_MP4 (XI1_I1022_I221_p1 XI1_I1022_I221_An I1_p10_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I221_MP2 (VDD I1_I1022_pn18 XI1_I1022_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I221_MP3 (XI1_I1022_I221_p1 XI1_I1022_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I221_MP0 (VDD I1_I1022_pn18 XI1_I1022_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I223_MP1 (VDD I1_I1022_G19_0 XI1_I1022_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I223_MP5 (I1_p10_20 I1_I1022_G19_0 XI1_I1022_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I223_MP4 (XI1_I1022_I223_p1 XI1_I1022_I223_An I1_p10_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I223_MP2 (VDD I1_I1022_pn20 XI1_I1022_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I223_MP3 (XI1_I1022_I223_p1 XI1_I1022_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I223_MP0 (VDD I1_I1022_pn20 XI1_I1022_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I50_MP1 (VDD I1_b10_18 XI1_I1022_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I50_MP5 (I1_I1022_pn18 I1_b10_18 XI1_I1022_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I50_MP4 (XI1_I1022_I50_p1 XI1_I1022_I50_An I1_I1022_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I50_MP2 (VDD I1_p9_17 XI1_I1022_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I50_MP3 (XI1_I1022_I50_p1 XI1_I1022_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I50_MP0 (VDD I1_p9_17 XI1_I1022_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I49_MP1 (VDD I1_b10_17 XI1_I1022_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I49_MP5 (I1_I1022_pn17 I1_b10_17 XI1_I1022_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I49_MP4 (XI1_I1022_I49_p1 XI1_I1022_I49_An I1_I1022_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I49_MP2 (VDD I1_p9_16 XI1_I1022_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I49_MP3 (XI1_I1022_I49_p1 XI1_I1022_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I49_MP0 (VDD I1_p9_16 XI1_I1022_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I220_MP1 (VDD I1_I976_G16_0 XI1_I976_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I220_MP5 (I1_p9_17 I1_I976_G16_0 XI1_I976_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I220_MP4 (XI1_I976_I220_p1 XI1_I976_I220_An I1_p9_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I220_MP2 (VDD I1_I976_pn17 XI1_I976_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I220_MP3 (XI1_I976_I220_p1 XI1_I976_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I220_MP0 (VDD I1_I976_pn17 XI1_I976_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I34_MP1 (VDD I1_b9_2 XI1_I976_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I34_MP5 (I1_I976_pn2 I1_b9_2 XI1_I976_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I34_MP4 (XI1_I976_I34_p1 XI1_I976_I34_An I1_I976_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I34_MP2 (VDD I1_p8_1 XI1_I976_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I34_MP3 (XI1_I976_I34_p1 XI1_I976_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I34_MP0 (VDD I1_p8_1 XI1_I976_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I203_MP1 (VDD I1_qu31_b3_5 XI1_I608_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I203_MP5 (I1_p1_0 I1_qu31_b3_5 XI1_I608_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I203_MP4 (XI1_I608_I203_p1 XI1_I608_I203_An I1_p1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I203_MP2 (VDD I1_I608_pn0 XI1_I608_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I203_MP3 (XI1_I608_I203_p1 XI1_I608_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I203_MP0 (VDD I1_I608_pn0 XI1_I608_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I35_MP1 (VDD I1_b1_3 XI1_I608_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I35_MP5 (I1_I608_pn3 I1_b1_3 XI1_I608_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I35_MP4 (XI1_I608_I35_p1 XI1_I608_I35_An I1_I608_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I35_MP2 (VDD I1_p0_2 XI1_I608_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I35_MP3 (XI1_I608_I35_p1 XI1_I608_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I35_MP0 (VDD I1_p0_2 XI1_I608_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I225_MP1 (VDD I1_I608_G21_0 XI1_I608_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I225_MP5 (I1_p1_22 I1_I608_G21_0 XI1_I608_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I225_MP4 (XI1_I608_I225_p1 XI1_I608_I225_An I1_p1_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I225_MP2 (VDD I1_I608_pn22 XI1_I608_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I225_MP3 (XI1_I608_I225_p1 XI1_I608_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I225_MP0 (VDD I1_I608_pn22 XI1_I608_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I221_MP1 (VDD I1_I1482_G17_0 XI1_I1482_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I221_MP5 (I1_p20_18 I1_I1482_G17_0 XI1_I1482_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I221_MP4 (XI1_I1482_I221_p1 XI1_I1482_I221_An I1_p20_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I221_MP2 (VDD I1_I1482_pn18 XI1_I1482_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I221_MP3 (XI1_I1482_I221_p1 XI1_I1482_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I221_MP0 (VDD I1_I1482_pn18 XI1_I1482_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I211_MP1 (VDD I1_I1482_G7_0 XI1_I1482_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I211_MP5 (I1_p20_8 I1_I1482_G7_0 XI1_I1482_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I211_MP4 (XI1_I1482_I211_p1 XI1_I1482_I211_An I1_p20_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I211_MP2 (VDD I1_I1482_pn8 XI1_I1482_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I211_MP3 (XI1_I1482_I211_p1 XI1_I1482_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I211_MP0 (VDD I1_I1482_pn8 XI1_I1482_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I209_MP1 (VDD I1_I1482_G5_0 XI1_I1482_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I209_MP5 (I1_p20_6 I1_I1482_G5_0 XI1_I1482_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I209_MP4 (XI1_I1482_I209_p1 XI1_I1482_I209_An I1_p20_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I209_MP2 (VDD I1_I1482_pn6 XI1_I1482_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I209_MP3 (XI1_I1482_I209_p1 XI1_I1482_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I209_MP0 (VDD I1_I1482_pn6 XI1_I1482_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I205_MP1 (VDD I1_I1482_G1_0 XI1_I1482_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I205_MP5 (I1_p20_2 I1_I1482_G1_0 XI1_I1482_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I205_MP4 (XI1_I1482_I205_p1 XI1_I1482_I205_An I1_p20_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I205_MP2 (VDD I1_I1482_pn2 XI1_I1482_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I205_MP3 (XI1_I1482_I205_p1 XI1_I1482_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I205_MP0 (VDD I1_I1482_pn2 XI1_I1482_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I39_MP1 (VDD I1_b21_7 XI1_I1528_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I39_MP5 (I1_I1528_pn7 I1_b21_7 XI1_I1528_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I39_MP4 (XI1_I1528_I39_p1 XI1_I1528_I39_An I1_I1528_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I39_MP2 (VDD I1_p20_6 XI1_I1528_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I39_MP3 (XI1_I1528_I39_p1 XI1_I1528_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I39_MP0 (VDD I1_p20_6 XI1_I1528_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I204_MP1 (VDD I1_I1482_G0_0 XI1_I1482_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I204_MP5 (I1_p20_1 I1_I1482_G0_0 XI1_I1482_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I204_MP4 (XI1_I1482_I204_p1 XI1_I1482_I204_An I1_p20_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I204_MP2 (VDD I1_I1482_pn1 XI1_I1482_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I204_MP3 (XI1_I1482_I204_p1 XI1_I1482_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I204_MP0 (VDD I1_I1482_pn1 XI1_I1482_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I205_MP1 (VDD I1_I1114_G1_0 XI1_I1114_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I205_MP5 (I1_p12_2 I1_I1114_G1_0 XI1_I1114_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I205_MP4 (XI1_I1114_I205_p1 XI1_I1114_I205_An I1_p12_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I205_MP2 (VDD I1_I1114_pn2 XI1_I1114_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I205_MP3 (XI1_I1114_I205_p1 XI1_I1114_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I205_MP0 (VDD I1_I1114_pn2 XI1_I1114_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I204_MP1 (VDD I1_I1114_G0_0 XI1_I1114_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I204_MP5 (I1_p12_1 I1_I1114_G0_0 XI1_I1114_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I204_MP4 (XI1_I1114_I204_p1 XI1_I1114_I204_An I1_p12_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I204_MP2 (VDD I1_I1114_pn1 XI1_I1114_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I204_MP3 (XI1_I1114_I204_p1 XI1_I1114_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I204_MP0 (VDD I1_I1114_pn1 XI1_I1114_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I46_MP1 (VDD I1_b11_14 XI1_I1068_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I46_MP5 (I1_I1068_pn14 I1_b11_14 XI1_I1068_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I46_MP4 (XI1_I1068_I46_p1 XI1_I1068_I46_An I1_I1068_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I46_MP2 (VDD I1_p10_13 XI1_I1068_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I46_MP3 (XI1_I1068_I46_p1 XI1_I1068_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I46_MP0 (VDD I1_p10_13 XI1_I1068_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I48_MP1 (VDD I1_b10_16 XI1_I1022_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I48_MP5 (I1_I1022_pn16 I1_b10_16 XI1_I1022_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I48_MP4 (XI1_I1022_I48_p1 XI1_I1022_I48_An I1_I1022_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I48_MP2 (VDD I1_p9_15 XI1_I1022_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I48_MP3 (XI1_I1022_I48_p1 XI1_I1022_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I48_MP0 (VDD I1_p9_15 XI1_I1022_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I47_MP1 (VDD I1_b10_15 XI1_I1022_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I47_MP5 (I1_I1022_pn15 I1_b10_15 XI1_I1022_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I47_MP4 (XI1_I1022_I47_p1 XI1_I1022_I47_An I1_I1022_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I47_MP2 (VDD I1_p9_14 XI1_I1022_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I47_MP3 (XI1_I1022_I47_p1 XI1_I1022_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I47_MP0 (VDD I1_p9_14 XI1_I1022_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I210_MP1 (VDD I1_I976_G6_0 XI1_I976_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I210_MP5 (I1_p9_7 I1_I976_G6_0 XI1_I976_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I210_MP4 (XI1_I976_I210_p1 XI1_I976_I210_An I1_p9_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I210_MP2 (VDD I1_I976_pn7 XI1_I976_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I210_MP3 (XI1_I976_I210_p1 XI1_I976_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I210_MP0 (VDD I1_I976_pn7 XI1_I976_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I208_MP1 (VDD I1_I976_G4_0 XI1_I976_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I208_MP5 (I1_p9_5 I1_I976_G4_0 XI1_I976_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I208_MP4 (XI1_I976_I208_p1 XI1_I976_I208_An I1_p9_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I208_MP2 (VDD I1_I976_pn5 XI1_I976_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I208_MP3 (XI1_I976_I208_p1 XI1_I976_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I208_MP0 (VDD I1_I976_pn5 XI1_I976_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I203_MP1 (VDD I1_qu24_b3_5 XI1_I930_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I203_MP5 (I1_p8_0 I1_qu24_b3_5 XI1_I930_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I203_MP4 (XI1_I930_I203_p1 XI1_I930_I203_An I1_p8_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I203_MP2 (VDD I1_I930_pn0 XI1_I930_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I203_MP3 (XI1_I930_I203_p1 XI1_I930_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I203_MP0 (VDD I1_I930_pn0 XI1_I930_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I32_MP1 (VDD I1_b1_0 XI1_I608_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I32_MP5 (I1_I608_pn0 I1_b1_0 XI1_I608_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I32_MP4 (XI1_I608_I32_p1 XI1_I608_I32_An I1_I608_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I32_MP2 (VDD I1_aa30 XI1_I608_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I32_MP3 (XI1_I608_I32_p1 XI1_I608_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I32_MP0 (VDD I1_aa30 XI1_I608_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I36_MP1 (VDD I1_b1_4 XI1_I608_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I36_MP5 (I1_I608_pn4 I1_b1_4 XI1_I608_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I36_MP4 (XI1_I608_I36_p1 XI1_I608_I36_An I1_I608_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I36_MP2 (VDD I1_p0_3 XI1_I608_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I36_MP3 (XI1_I608_I36_p1 XI1_I608_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I36_MP0 (VDD I1_p0_3 XI1_I608_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I38_MP1 (VDD I1_b1_6 XI1_I608_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I38_MP5 (I1_I608_pn6 I1_b1_6 XI1_I608_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I38_MP4 (XI1_I608_I38_p1 XI1_I608_I38_An I1_I608_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I38_MP2 (VDD I1_p0_5 XI1_I608_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I38_MP3 (XI1_I608_I38_p1 XI1_I608_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I38_MP0 (VDD I1_p0_5 XI1_I608_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I63_MP1 (VDD I1_b1_31 XI1_I608_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I63_MP5 (I1_I608_pn31 I1_b1_31 XI1_I608_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I63_MP4 (XI1_I608_I63_p1 XI1_I608_I63_An I1_I608_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I63_MP2 (VDD I1_p0_30 XI1_I608_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I63_MP3 (XI1_I608_I63_p1 XI1_I608_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I63_MP0 (VDD I1_p0_30 XI1_I608_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I58_MP1 (VDD I1_b20_26 XI1_I1482_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I58_MP5 (I1_I1482_pn26 I1_b20_26 XI1_I1482_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I58_MP4 (XI1_I1482_I58_p1 XI1_I1482_I58_An I1_I1482_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I58_MP2 (VDD I1_p19_25 XI1_I1482_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I58_MP3 (XI1_I1482_I58_p1 XI1_I1482_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I58_MP0 (VDD I1_p19_25 XI1_I1482_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I225_MP1 (VDD I1_I1482_G21_0 XI1_I1482_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I225_MP5 (I1_p20_22 I1_I1482_G21_0 XI1_I1482_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I225_MP4 (XI1_I1482_I225_p1 XI1_I1482_I225_An I1_p20_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I225_MP2 (VDD I1_I1482_pn22 XI1_I1482_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I225_MP3 (XI1_I1482_I225_p1 XI1_I1482_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I225_MP0 (VDD I1_I1482_pn22 XI1_I1482_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I223_MP1 (VDD I1_I1482_G19_0 XI1_I1482_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I223_MP5 (I1_p20_20 I1_I1482_G19_0 XI1_I1482_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I223_MP4 (XI1_I1482_I223_p1 XI1_I1482_I223_An I1_p20_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I223_MP2 (VDD I1_I1482_pn20 XI1_I1482_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I223_MP3 (XI1_I1482_I223_p1 XI1_I1482_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I223_MP0 (VDD I1_I1482_pn20 XI1_I1482_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I208_MP1 (VDD I1_I1482_G4_0 XI1_I1482_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I208_MP5 (I1_p20_5 I1_I1482_G4_0 XI1_I1482_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I208_MP4 (XI1_I1482_I208_p1 XI1_I1482_I208_An I1_p20_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I208_MP2 (VDD I1_I1482_pn5 XI1_I1482_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I208_MP3 (XI1_I1482_I208_p1 XI1_I1482_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I208_MP0 (VDD I1_I1482_pn5 XI1_I1482_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I41_MP1 (VDD I1_b21_9 XI1_I1528_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I41_MP5 (I1_I1528_pn9 I1_b21_9 XI1_I1528_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I41_MP4 (XI1_I1528_I41_p1 XI1_I1528_I41_An I1_I1528_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I41_MP2 (VDD I1_p20_8 XI1_I1528_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I41_MP3 (XI1_I1528_I41_p1 XI1_I1528_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I41_MP0 (VDD I1_p20_8 XI1_I1528_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I41_MP1 (VDD I1_b12_9 XI1_I1114_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I41_MP5 (I1_I1114_pn9 I1_b12_9 XI1_I1114_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I41_MP4 (XI1_I1114_I41_p1 XI1_I1114_I41_An I1_I1114_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I41_MP2 (VDD I1_p11_8 XI1_I1114_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I41_MP3 (XI1_I1114_I41_p1 XI1_I1114_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I41_MP0 (VDD I1_p11_8 XI1_I1114_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I42_MP1 (VDD I1_b12_10 XI1_I1114_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I42_MP5 (I1_I1114_pn10 I1_b12_10 XI1_I1114_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I42_MP4 (XI1_I1114_I42_p1 XI1_I1114_I42_An I1_I1114_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I42_MP2 (VDD I1_p11_9 XI1_I1114_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I42_MP3 (XI1_I1114_I42_p1 XI1_I1114_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I42_MP0 (VDD I1_p11_9 XI1_I1114_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I39_MP1 (VDD I1_b12_7 XI1_I1114_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I39_MP5 (I1_I1114_pn7 I1_b12_7 XI1_I1114_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I39_MP4 (XI1_I1114_I39_p1 XI1_I1114_I39_An I1_I1114_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I39_MP2 (VDD I1_p11_6 XI1_I1114_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I39_MP3 (XI1_I1114_I39_p1 XI1_I1114_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I39_MP0 (VDD I1_p11_6 XI1_I1114_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I33_MP1 (VDD I1_b12_1 XI1_I1114_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I33_MP5 (I1_I1114_pn1 I1_b12_1 XI1_I1114_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I33_MP4 (XI1_I1114_I33_p1 XI1_I1114_I33_An I1_I1114_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I33_MP2 (VDD I1_p11_0 XI1_I1114_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I33_MP3 (XI1_I1114_I33_p1 XI1_I1114_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I33_MP0 (VDD I1_p11_0 XI1_I1114_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I211_MP1 (VDD I1_I1068_G7_0 XI1_I1068_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I211_MP5 (I1_p11_8 I1_I1068_G7_0 XI1_I1068_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I211_MP4 (XI1_I1068_I211_p1 XI1_I1068_I211_An I1_p11_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I211_MP2 (VDD I1_I1068_pn8 XI1_I1068_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I211_MP3 (XI1_I1068_I211_p1 XI1_I1068_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I211_MP0 (VDD I1_I1068_pn8 XI1_I1068_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I42_MP1 (VDD I1_b11_10 XI1_I1068_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I42_MP5 (I1_I1068_pn10 I1_b11_10 XI1_I1068_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I42_MP4 (XI1_I1068_I42_p1 XI1_I1068_I42_An I1_I1068_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I42_MP2 (VDD I1_p10_9 XI1_I1068_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I42_MP3 (XI1_I1068_I42_p1 XI1_I1068_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I42_MP0 (VDD I1_p10_9 XI1_I1068_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I44_MP1 (VDD I1_b11_12 XI1_I1068_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I44_MP5 (I1_I1068_pn12 I1_b11_12 XI1_I1068_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I44_MP4 (XI1_I1068_I44_p1 XI1_I1068_I44_An I1_I1068_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I44_MP2 (VDD I1_p10_11 XI1_I1068_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I44_MP3 (XI1_I1068_I44_p1 XI1_I1068_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I44_MP0 (VDD I1_p10_11 XI1_I1068_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I45_MP1 (VDD I1_b11_13 XI1_I1068_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I45_MP5 (I1_I1068_pn13 I1_b11_13 XI1_I1068_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I45_MP4 (XI1_I1068_I45_p1 XI1_I1068_I45_An I1_I1068_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I45_MP2 (VDD I1_p10_12 XI1_I1068_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I45_MP3 (XI1_I1068_I45_p1 XI1_I1068_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I45_MP0 (VDD I1_p10_12 XI1_I1068_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I46_MP1 (VDD I1_b10_14 XI1_I1022_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I46_MP5 (I1_I1022_pn14 I1_b10_14 XI1_I1022_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I46_MP4 (XI1_I1022_I46_p1 XI1_I1022_I46_An I1_I1022_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I46_MP2 (VDD I1_p9_13 XI1_I1022_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I46_MP3 (XI1_I1022_I46_p1 XI1_I1022_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I46_MP0 (VDD I1_p9_13 XI1_I1022_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I45_MP1 (VDD I1_b10_13 XI1_I1022_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I45_MP5 (I1_I1022_pn13 I1_b10_13 XI1_I1022_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I45_MP4 (XI1_I1022_I45_p1 XI1_I1022_I45_An I1_I1022_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I45_MP2 (VDD I1_p9_12 XI1_I1022_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I45_MP3 (XI1_I1022_I45_p1 XI1_I1022_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I45_MP0 (VDD I1_p9_12 XI1_I1022_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I43_MP1 (VDD I1_b10_11 XI1_I1022_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I43_MP5 (I1_I1022_pn11 I1_b10_11 XI1_I1022_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I43_MP4 (XI1_I1022_I43_p1 XI1_I1022_I43_An I1_I1022_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I43_MP2 (VDD I1_p9_10 XI1_I1022_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I43_MP3 (XI1_I1022_I43_p1 XI1_I1022_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I43_MP0 (VDD I1_p9_10 XI1_I1022_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I204_MP1 (VDD I1_I976_G0_0 XI1_I976_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I204_MP5 (I1_p9_1 I1_I976_G0_0 XI1_I976_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I204_MP4 (XI1_I976_I204_p1 XI1_I976_I204_An I1_p9_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I204_MP2 (VDD I1_I976_pn1 XI1_I976_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I204_MP3 (XI1_I976_I204_p1 XI1_I976_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I204_MP0 (VDD I1_I976_pn1 XI1_I976_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I205_MP1 (VDD I1_I976_G1_0 XI1_I976_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I205_MP5 (I1_p9_2 I1_I976_G1_0 XI1_I976_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I205_MP4 (XI1_I976_I205_p1 XI1_I976_I205_An I1_p9_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I205_MP2 (VDD I1_I976_pn2 XI1_I976_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I205_MP3 (XI1_I976_I205_p1 XI1_I976_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I205_MP0 (VDD I1_I976_pn2 XI1_I976_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I33_MP1 (VDD I1_b9_1 XI1_I976_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I33_MP5 (I1_I976_pn1 I1_b9_1 XI1_I976_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I33_MP4 (XI1_I976_I33_p1 XI1_I976_I33_An I1_I976_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I33_MP2 (VDD I1_p8_0 XI1_I976_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I33_MP3 (XI1_I976_I33_p1 XI1_I976_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I33_MP0 (VDD I1_p8_0 XI1_I976_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I32_MP1 (VDD I1_b8_0 XI1_I930_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I32_MP5 (I1_I930_pn0 I1_b8_0 XI1_I930_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I32_MP4 (XI1_I930_I32_p1 XI1_I930_I32_An I1_I930_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I32_MP2 (VDD I1_aa23 XI1_I930_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I32_MP3 (XI1_I930_I32_p1 XI1_I930_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I32_MP0 (VDD I1_aa23 XI1_I930_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I203_MP1 (VDD VDD XI1_I562_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I203_MP5 (I1_p0_0 VDD XI1_I562_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I203_MP4 (XI1_I562_I203_p1 XI1_I562_I203_An I1_p0_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I203_MP2 (VDD I1_I562_pn0 XI1_I562_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I203_MP3 (XI1_I562_I203_p1 XI1_I562_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I203_MP0 (VDD I1_I562_pn0 XI1_I562_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I37_MP1 (VDD I1_b1_5 XI1_I608_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I37_MP5 (I1_I608_pn5 I1_b1_5 XI1_I608_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I37_MP4 (XI1_I608_I37_p1 XI1_I608_I37_An I1_I608_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I37_MP2 (VDD I1_p0_4 XI1_I608_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I37_MP3 (XI1_I608_I37_p1 XI1_I608_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I37_MP0 (VDD I1_p0_4 XI1_I608_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I39_MP1 (VDD I1_b1_7 XI1_I608_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I39_MP5 (I1_I608_pn7 I1_b1_7 XI1_I608_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I39_MP4 (XI1_I608_I39_p1 XI1_I608_I39_An I1_I608_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I39_MP2 (VDD I1_p0_6 XI1_I608_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I39_MP3 (XI1_I608_I39_p1 XI1_I608_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I39_MP0 (VDD I1_p0_6 XI1_I608_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I41_MP1 (VDD I1_b1_9 XI1_I608_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I41_MP5 (I1_I608_pn9 I1_b1_9 XI1_I608_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I41_MP4 (XI1_I608_I41_p1 XI1_I608_I41_An I1_I608_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I41_MP2 (VDD I1_p0_8 XI1_I608_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I41_MP3 (XI1_I608_I41_p1 XI1_I608_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I41_MP0 (VDD I1_p0_8 XI1_I608_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I42_MP1 (VDD I1_b1_10 XI1_I608_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I42_MP5 (I1_I608_pn10 I1_b1_10 XI1_I608_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I42_MP4 (XI1_I608_I42_p1 XI1_I608_I42_An I1_I608_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I42_MP2 (VDD I1_p0_9 XI1_I608_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I42_MP3 (XI1_I608_I42_p1 XI1_I608_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I42_MP0 (VDD I1_p0_9 XI1_I608_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I44_MP1 (VDD I1_b1_12 XI1_I608_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I44_MP5 (I1_I608_pn12 I1_b1_12 XI1_I608_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I44_MP4 (XI1_I608_I44_p1 XI1_I608_I44_An I1_I608_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I44_MP2 (VDD I1_p0_11 XI1_I608_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I44_MP3 (XI1_I608_I44_p1 XI1_I608_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I44_MP0 (VDD I1_p0_11 XI1_I608_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I46_MP1 (VDD I1_b1_14 XI1_I608_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I46_MP5 (I1_I608_pn14 I1_b1_14 XI1_I608_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I46_MP4 (XI1_I608_I46_p1 XI1_I608_I46_An I1_I608_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I46_MP2 (VDD I1_p0_13 XI1_I608_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I46_MP3 (XI1_I608_I46_p1 XI1_I608_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I46_MP0 (VDD I1_p0_13 XI1_I608_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I55_MP1 (VDD I1_b1_23 XI1_I608_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I55_MP5 (I1_I608_pn23 I1_b1_23 XI1_I608_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I55_MP4 (XI1_I608_I55_p1 XI1_I608_I55_An I1_I608_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I55_MP2 (VDD I1_p0_22 XI1_I608_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I55_MP3 (XI1_I608_I55_p1 XI1_I608_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I55_MP0 (VDD I1_p0_22 XI1_I608_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I57_MP1 (VDD I1_b1_25 XI1_I608_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I57_MP5 (I1_I608_pn25 I1_b1_25 XI1_I608_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I57_MP4 (XI1_I608_I57_p1 XI1_I608_I57_An I1_I608_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I57_MP2 (VDD I1_p0_24 XI1_I608_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I57_MP3 (XI1_I608_I57_p1 XI1_I608_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I57_MP0 (VDD I1_p0_24 XI1_I608_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I60_MP1 (VDD I1_b1_28 XI1_I608_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I60_MP5 (I1_I608_pn28 I1_b1_28 XI1_I608_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I60_MP4 (XI1_I608_I60_p1 XI1_I608_I60_An I1_I608_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I60_MP2 (VDD I1_p0_27 XI1_I608_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I60_MP3 (XI1_I608_I60_p1 XI1_I608_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I60_MP0 (VDD I1_p0_27 XI1_I608_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I61_MP1 (VDD I1_b1_29 XI1_I608_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I61_MP5 (I1_I608_pn29 I1_b1_29 XI1_I608_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I61_MP4 (XI1_I608_I61_p1 XI1_I608_I61_An I1_I608_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I61_MP2 (VDD I1_p0_28 XI1_I608_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I61_MP3 (XI1_I608_I61_p1 XI1_I608_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I61_MP0 (VDD I1_p0_28 XI1_I608_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I59_MP1 (VDD I1_b20_27 XI1_I1482_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I59_MP5 (I1_I1482_pn27 I1_b20_27 XI1_I1482_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I59_MP4 (XI1_I1482_I59_p1 XI1_I1482_I59_An I1_I1482_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I59_MP2 (VDD I1_p19_26 XI1_I1482_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I59_MP3 (XI1_I1482_I59_p1 XI1_I1482_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I59_MP0 (VDD I1_p19_26 XI1_I1482_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I227_MP1 (VDD I1_I1482_G23_0 XI1_I1482_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I227_MP5 (I1_p20_24 I1_I1482_G23_0 XI1_I1482_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I227_MP4 (XI1_I1482_I227_p1 XI1_I1482_I227_An I1_p20_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I227_MP2 (VDD I1_I1482_pn24 XI1_I1482_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I227_MP3 (XI1_I1482_I227_p1 XI1_I1482_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I227_MP0 (VDD I1_I1482_pn24 XI1_I1482_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I229_MP1 (VDD I1_I1482_G25_0 XI1_I1482_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I229_MP5 (I1_p20_26 I1_I1482_G25_0 XI1_I1482_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I229_MP4 (XI1_I1482_I229_p1 XI1_I1482_I229_An I1_p20_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I229_MP2 (VDD I1_I1482_pn26 XI1_I1482_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I229_MP3 (XI1_I1482_I229_p1 XI1_I1482_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I229_MP0 (VDD I1_I1482_pn26 XI1_I1482_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I220_MP1 (VDD I1_I1482_G16_0 XI1_I1482_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I220_MP5 (I1_p20_17 I1_I1482_G16_0 XI1_I1482_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I220_MP4 (XI1_I1482_I220_p1 XI1_I1482_I220_An I1_p20_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I220_MP2 (VDD I1_I1482_pn17 XI1_I1482_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I220_MP3 (XI1_I1482_I220_p1 XI1_I1482_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I220_MP0 (VDD I1_I1482_pn17 XI1_I1482_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I210_MP1 (VDD I1_I1482_G6_0 XI1_I1482_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I210_MP5 (I1_p20_7 I1_I1482_G6_0 XI1_I1482_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I210_MP4 (XI1_I1482_I210_p1 XI1_I1482_I210_An I1_p20_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I210_MP2 (VDD I1_I1482_pn7 XI1_I1482_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I210_MP3 (XI1_I1482_I210_p1 XI1_I1482_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I210_MP0 (VDD I1_I1482_pn7 XI1_I1482_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I45_MP1 (VDD I1_b21_13 XI1_I1528_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I45_MP5 (I1_I1528_pn13 I1_b21_13 XI1_I1528_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I45_MP4 (XI1_I1528_I45_p1 XI1_I1528_I45_An I1_I1528_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I45_MP2 (VDD I1_p20_12 XI1_I1528_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I45_MP3 (XI1_I1528_I45_p1 XI1_I1528_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I45_MP0 (VDD I1_p20_12 XI1_I1528_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I43_MP1 (VDD I1_b21_11 XI1_I1528_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I43_MP5 (I1_I1528_pn11 I1_b21_11 XI1_I1528_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I43_MP4 (XI1_I1528_I43_p1 XI1_I1528_I43_An I1_I1528_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I43_MP2 (VDD I1_p20_10 XI1_I1528_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I43_MP3 (XI1_I1528_I43_p1 XI1_I1528_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I43_MP0 (VDD I1_p20_10 XI1_I1528_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I42_MP1 (VDD I1_b21_10 XI1_I1528_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I42_MP5 (I1_I1528_pn10 I1_b21_10 XI1_I1528_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I42_MP4 (XI1_I1528_I42_p1 XI1_I1528_I42_An I1_I1528_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I42_MP2 (VDD I1_p20_9 XI1_I1528_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I42_MP3 (XI1_I1528_I42_p1 XI1_I1528_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I42_MP0 (VDD I1_p20_9 XI1_I1528_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I38_MP1 (VDD I1_b21_6 XI1_I1528_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I38_MP5 (I1_I1528_pn6 I1_b21_6 XI1_I1528_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I38_MP4 (XI1_I1528_I38_p1 XI1_I1528_I38_An I1_I1528_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I38_MP2 (VDD I1_p20_5 XI1_I1528_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I38_MP3 (XI1_I1528_I38_p1 XI1_I1528_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I38_MP0 (VDD I1_p20_5 XI1_I1528_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I40_MP1 (VDD I1_b21_8 XI1_I1528_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I40_MP5 (I1_I1528_pn8 I1_b21_8 XI1_I1528_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I40_MP4 (XI1_I1528_I40_p1 XI1_I1528_I40_An I1_I1528_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I40_MP2 (VDD I1_p20_7 XI1_I1528_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I40_MP3 (XI1_I1528_I40_p1 XI1_I1528_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I40_MP0 (VDD I1_p20_7 XI1_I1528_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I32_MP1 (VDD I1_b20_0 XI1_I1482_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I32_MP5 (I1_I1482_pn0 I1_b20_0 XI1_I1482_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I32_MP4 (XI1_I1482_I32_p1 XI1_I1482_I32_An I1_I1482_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I32_MP2 (VDD I1_aa11 XI1_I1482_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I32_MP3 (XI1_I1482_I32_p1 XI1_I1482_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I32_MP0 (VDD I1_aa11 XI1_I1482_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I40_MP1 (VDD I1_b12_8 XI1_I1114_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I40_MP5 (I1_I1114_pn8 I1_b12_8 XI1_I1114_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I40_MP4 (XI1_I1114_I40_p1 XI1_I1114_I40_An I1_I1114_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I40_MP2 (VDD I1_p11_7 XI1_I1114_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I40_MP3 (XI1_I1114_I40_p1 XI1_I1114_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I40_MP0 (VDD I1_p11_7 XI1_I1114_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I210_MP1 (VDD I1_I1068_G6_0 XI1_I1068_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I210_MP5 (I1_p11_7 I1_I1068_G6_0 XI1_I1068_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I210_MP4 (XI1_I1068_I210_p1 XI1_I1068_I210_An I1_p11_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I210_MP2 (VDD I1_I1068_pn7 XI1_I1068_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I210_MP3 (XI1_I1068_I210_p1 XI1_I1068_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I210_MP0 (VDD I1_I1068_pn7 XI1_I1068_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I209_MP1 (VDD I1_I1068_G5_0 XI1_I1068_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I209_MP5 (I1_p11_6 I1_I1068_G5_0 XI1_I1068_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I209_MP4 (XI1_I1068_I209_p1 XI1_I1068_I209_An I1_p11_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I209_MP2 (VDD I1_I1068_pn6 XI1_I1068_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I209_MP3 (XI1_I1068_I209_p1 XI1_I1068_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I209_MP0 (VDD I1_I1068_pn6 XI1_I1068_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I41_MP1 (VDD I1_b11_9 XI1_I1068_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I41_MP5 (I1_I1068_pn9 I1_b11_9 XI1_I1068_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I41_MP4 (XI1_I1068_I41_p1 XI1_I1068_I41_An I1_I1068_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I41_MP2 (VDD I1_p10_8 XI1_I1068_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I41_MP3 (XI1_I1068_I41_p1 XI1_I1068_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I41_MP0 (VDD I1_p10_8 XI1_I1068_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I43_MP1 (VDD I1_b11_11 XI1_I1068_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I43_MP5 (I1_I1068_pn11 I1_b11_11 XI1_I1068_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I43_MP4 (XI1_I1068_I43_p1 XI1_I1068_I43_An I1_I1068_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I43_MP2 (VDD I1_p10_10 XI1_I1068_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I43_MP3 (XI1_I1068_I43_p1 XI1_I1068_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I43_MP0 (VDD I1_p10_10 XI1_I1068_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I32_MP1 (VDD I1_b12_0 XI1_I1114_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I32_MP5 (I1_I1114_pn0 I1_b12_0 XI1_I1114_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I32_MP4 (XI1_I1114_I32_p1 XI1_I1114_I32_An I1_I1114_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I32_MP2 (VDD I1_aa19 XI1_I1114_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I32_MP3 (XI1_I1114_I32_p1 XI1_I1114_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I32_MP0 (VDD I1_aa19 XI1_I1114_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I211_MP1 (VDD I1_I1022_G7_0 XI1_I1022_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I211_MP5 (I1_p10_8 I1_I1022_G7_0 XI1_I1022_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I211_MP4 (XI1_I1022_I211_p1 XI1_I1022_I211_An I1_p10_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I211_MP2 (VDD I1_I1022_pn8 XI1_I1022_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I211_MP3 (XI1_I1022_I211_p1 XI1_I1022_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I211_MP0 (VDD I1_I1022_pn8 XI1_I1022_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I40_MP1 (VDD I1_b10_8 XI1_I1022_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I40_MP5 (I1_I1022_pn8 I1_b10_8 XI1_I1022_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I40_MP4 (XI1_I1022_I40_p1 XI1_I1022_I40_An I1_I1022_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I40_MP2 (VDD I1_p9_7 XI1_I1022_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I40_MP3 (XI1_I1022_I40_p1 XI1_I1022_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I40_MP0 (VDD I1_p9_7 XI1_I1022_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I44_MP1 (VDD I1_b10_12 XI1_I1022_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I44_MP5 (I1_I1022_pn12 I1_b10_12 XI1_I1022_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I44_MP4 (XI1_I1022_I44_p1 XI1_I1022_I44_An I1_I1022_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I44_MP2 (VDD I1_p9_11 XI1_I1022_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I44_MP3 (XI1_I1022_I44_p1 XI1_I1022_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I44_MP0 (VDD I1_p9_11 XI1_I1022_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I41_MP1 (VDD I1_b10_9 XI1_I1022_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I41_MP5 (I1_I1022_pn9 I1_b10_9 XI1_I1022_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I41_MP4 (XI1_I1022_I41_p1 XI1_I1022_I41_An I1_I1022_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I41_MP2 (VDD I1_p9_8 XI1_I1022_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I41_MP3 (XI1_I1022_I41_p1 XI1_I1022_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I41_MP0 (VDD I1_p9_8 XI1_I1022_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I42_MP1 (VDD I1_b10_10 XI1_I1022_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I42_MP5 (I1_I1022_pn10 I1_b10_10 XI1_I1022_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I42_MP4 (XI1_I1022_I42_p1 XI1_I1022_I42_An I1_I1022_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I42_MP2 (VDD I1_p9_9 XI1_I1022_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I42_MP3 (XI1_I1022_I42_p1 XI1_I1022_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I42_MP0 (VDD I1_p9_9 XI1_I1022_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I33_MP1 (VDD I1_b0_1 XI1_I562_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I33_MP5 (I1_I562_pn1 I1_b0_1 XI1_I562_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I33_MP4 (XI1_I562_I33_p1 XI1_I562_I33_An I1_I562_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I33_MP2 (VDD VSS XI1_I562_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I33_MP3 (XI1_I562_I33_p1 XI1_I562_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I33_MP0 (VDD VSS XI1_I562_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I204_MP1 (VDD I1_I562_G0_0 XI1_I562_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I204_MP5 (I1_p0_1 I1_I562_G0_0 XI1_I562_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I204_MP4 (XI1_I562_I204_p1 XI1_I562_I204_An I1_p0_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I204_MP2 (VDD I1_I562_pn1 XI1_I562_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I204_MP3 (XI1_I562_I204_p1 XI1_I562_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I204_MP0 (VDD I1_I562_pn1 XI1_I562_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I43_MP1 (VDD I1_b1_11 XI1_I608_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I43_MP5 (I1_I608_pn11 I1_b1_11 XI1_I608_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I43_MP4 (XI1_I608_I43_p1 XI1_I608_I43_An I1_I608_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I43_MP2 (VDD I1_p0_10 XI1_I608_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I43_MP3 (XI1_I608_I43_p1 XI1_I608_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I43_MP0 (VDD I1_p0_10 XI1_I608_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I45_MP1 (VDD I1_b1_13 XI1_I608_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I45_MP5 (I1_I608_pn13 I1_b1_13 XI1_I608_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I45_MP4 (XI1_I608_I45_p1 XI1_I608_I45_An I1_I608_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I45_MP2 (VDD I1_p0_12 XI1_I608_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I45_MP3 (XI1_I608_I45_p1 XI1_I608_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I45_MP0 (VDD I1_p0_12 XI1_I608_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I47_MP1 (VDD I1_b1_15 XI1_I608_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I47_MP5 (I1_I608_pn15 I1_b1_15 XI1_I608_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I47_MP4 (XI1_I608_I47_p1 XI1_I608_I47_An I1_I608_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I47_MP2 (VDD I1_p0_14 XI1_I608_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I47_MP3 (XI1_I608_I47_p1 XI1_I608_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I47_MP0 (VDD I1_p0_14 XI1_I608_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I48_MP1 (VDD I1_b1_16 XI1_I608_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I48_MP5 (I1_I608_pn16 I1_b1_16 XI1_I608_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I48_MP4 (XI1_I608_I48_p1 XI1_I608_I48_An I1_I608_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I48_MP2 (VDD I1_p0_15 XI1_I608_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I48_MP3 (XI1_I608_I48_p1 XI1_I608_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I48_MP0 (VDD I1_p0_15 XI1_I608_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I50_MP1 (VDD I1_b1_18 XI1_I608_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I50_MP5 (I1_I608_pn18 I1_b1_18 XI1_I608_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I50_MP4 (XI1_I608_I50_p1 XI1_I608_I50_An I1_I608_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I50_MP2 (VDD I1_p0_17 XI1_I608_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I50_MP3 (XI1_I608_I50_p1 XI1_I608_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I50_MP0 (VDD I1_p0_17 XI1_I608_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I51_MP1 (VDD I1_b1_19 XI1_I608_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I51_MP5 (I1_I608_pn19 I1_b1_19 XI1_I608_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I51_MP4 (XI1_I608_I51_p1 XI1_I608_I51_An I1_I608_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I51_MP2 (VDD I1_p0_18 XI1_I608_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I51_MP3 (XI1_I608_I51_p1 XI1_I608_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I51_MP0 (VDD I1_p0_18 XI1_I608_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I52_MP1 (VDD I1_b1_20 XI1_I608_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I52_MP5 (I1_I608_pn20 I1_b1_20 XI1_I608_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I52_MP4 (XI1_I608_I52_p1 XI1_I608_I52_An I1_I608_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I52_MP2 (VDD I1_p0_19 XI1_I608_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I52_MP3 (XI1_I608_I52_p1 XI1_I608_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I52_MP0 (VDD I1_p0_19 XI1_I608_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I53_MP1 (VDD I1_b1_21 XI1_I608_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I53_MP5 (I1_I608_pn21 I1_b1_21 XI1_I608_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I53_MP4 (XI1_I608_I53_p1 XI1_I608_I53_An I1_I608_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I53_MP2 (VDD I1_p0_20 XI1_I608_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I53_MP3 (XI1_I608_I53_p1 XI1_I608_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I53_MP0 (VDD I1_p0_20 XI1_I608_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I54_MP1 (VDD I1_b1_22 XI1_I608_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I54_MP5 (I1_I608_pn22 I1_b1_22 XI1_I608_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I54_MP4 (XI1_I608_I54_p1 XI1_I608_I54_An I1_I608_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I54_MP2 (VDD I1_p0_21 XI1_I608_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I54_MP3 (XI1_I608_I54_p1 XI1_I608_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I54_MP0 (VDD I1_p0_21 XI1_I608_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I56_MP1 (VDD I1_b1_24 XI1_I608_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I56_MP5 (I1_I608_pn24 I1_b1_24 XI1_I608_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I56_MP4 (XI1_I608_I56_p1 XI1_I608_I56_An I1_I608_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I56_MP2 (VDD I1_p0_23 XI1_I608_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I56_MP3 (XI1_I608_I56_p1 XI1_I608_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I56_MP0 (VDD I1_p0_23 XI1_I608_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I59_MP1 (VDD I1_b1_27 XI1_I608_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I59_MP5 (I1_I608_pn27 I1_b1_27 XI1_I608_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I59_MP4 (XI1_I608_I59_p1 XI1_I608_I59_An I1_I608_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I59_MP2 (VDD I1_p0_26 XI1_I608_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I59_MP3 (XI1_I608_I59_p1 XI1_I608_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I59_MP0 (VDD I1_p0_26 XI1_I608_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I60_MP1 (VDD I1_b20_28 XI1_I1482_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I60_MP5 (I1_I1482_pn28 I1_b20_28 XI1_I1482_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I60_MP4 (XI1_I1482_I60_p1 XI1_I1482_I60_An I1_I1482_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I60_MP2 (VDD I1_p19_27 XI1_I1482_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I60_MP3 (XI1_I1482_I60_p1 XI1_I1482_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I60_MP0 (VDD I1_p19_27 XI1_I1482_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I228_MP1 (VDD I1_I1482_G24_0 XI1_I1482_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I228_MP5 (I1_p20_25 I1_I1482_G24_0 XI1_I1482_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I228_MP4 (XI1_I1482_I228_p1 XI1_I1482_I228_An I1_p20_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I228_MP2 (VDD I1_I1482_pn25 XI1_I1482_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I228_MP3 (XI1_I1482_I228_p1 XI1_I1482_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I228_MP0 (VDD I1_I1482_pn25 XI1_I1482_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I49_MP1 (VDD I1_b21_17 XI1_I1528_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I49_MP5 (I1_I1528_pn17 I1_b21_17 XI1_I1528_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I49_MP4 (XI1_I1528_I49_p1 XI1_I1528_I49_An I1_I1528_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I49_MP2 (VDD I1_p20_16 XI1_I1528_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I49_MP3 (XI1_I1528_I49_p1 XI1_I1528_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I49_MP0 (VDD I1_p20_16 XI1_I1528_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I47_MP1 (VDD I1_b21_15 XI1_I1528_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I47_MP5 (I1_I1528_pn15 I1_b21_15 XI1_I1528_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I47_MP4 (XI1_I1528_I47_p1 XI1_I1528_I47_An I1_I1528_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I47_MP2 (VDD I1_p20_14 XI1_I1528_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I47_MP3 (XI1_I1528_I47_p1 XI1_I1528_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I47_MP0 (VDD I1_p20_14 XI1_I1528_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I46_MP1 (VDD I1_b21_14 XI1_I1528_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I46_MP5 (I1_I1528_pn14 I1_b21_14 XI1_I1528_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I46_MP4 (XI1_I1528_I46_p1 XI1_I1528_I46_An I1_I1528_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I46_MP2 (VDD I1_p20_13 XI1_I1528_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I46_MP3 (XI1_I1528_I46_p1 XI1_I1528_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I46_MP0 (VDD I1_p20_13 XI1_I1528_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I44_MP1 (VDD I1_b21_12 XI1_I1528_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I44_MP5 (I1_I1528_pn12 I1_b21_12 XI1_I1528_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I44_MP4 (XI1_I1528_I44_p1 XI1_I1528_I44_An I1_I1528_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I44_MP2 (VDD I1_p20_11 XI1_I1528_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I44_MP3 (XI1_I1528_I44_p1 XI1_I1528_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I44_MP0 (VDD I1_p20_11 XI1_I1528_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I37_MP1 (VDD I1_b21_5 XI1_I1528_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I37_MP5 (I1_I1528_pn5 I1_b21_5 XI1_I1528_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I37_MP4 (XI1_I1528_I37_p1 XI1_I1528_I37_An I1_I1528_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I37_MP2 (VDD I1_p20_4 XI1_I1528_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I37_MP3 (XI1_I1528_I37_p1 XI1_I1528_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I37_MP0 (VDD I1_p20_4 XI1_I1528_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I36_MP1 (VDD I1_b21_4 XI1_I1528_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I36_MP5 (I1_I1528_pn4 I1_b21_4 XI1_I1528_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I36_MP4 (XI1_I1528_I36_p1 XI1_I1528_I36_An I1_I1528_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I36_MP2 (VDD I1_p20_3 XI1_I1528_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I36_MP3 (XI1_I1528_I36_p1 XI1_I1528_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I36_MP0 (VDD I1_p20_3 XI1_I1528_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I35_MP1 (VDD I1_b21_3 XI1_I1528_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I35_MP5 (I1_I1528_pn3 I1_b21_3 XI1_I1528_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I35_MP4 (XI1_I1528_I35_p1 XI1_I1528_I35_An I1_I1528_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I35_MP2 (VDD I1_p20_2 XI1_I1528_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I35_MP3 (XI1_I1528_I35_p1 XI1_I1528_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I35_MP0 (VDD I1_p20_2 XI1_I1528_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I203_MP1 (VDD I1_qu12_b3_5 XI1_I1482_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I203_MP5 (I1_p20_0 I1_qu12_b3_5 XI1_I1482_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I203_MP4 (XI1_I1482_I203_p1 XI1_I1482_I203_An I1_p20_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I203_MP2 (VDD I1_I1482_pn0 XI1_I1482_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I203_MP3 (XI1_I1482_I203_p1 XI1_I1482_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I203_MP0 (VDD I1_I1482_pn0 XI1_I1482_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I38_MP1 (VDD I1_b12_6 XI1_I1114_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I38_MP5 (I1_I1114_pn6 I1_b12_6 XI1_I1114_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I38_MP4 (XI1_I1114_I38_p1 XI1_I1114_I38_An I1_I1114_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I38_MP2 (VDD I1_p11_5 XI1_I1114_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I38_MP3 (XI1_I1114_I38_p1 XI1_I1114_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I38_MP0 (VDD I1_p11_5 XI1_I1114_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I37_MP1 (VDD I1_b12_5 XI1_I1114_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I37_MP5 (I1_I1114_pn5 I1_b12_5 XI1_I1114_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I37_MP4 (XI1_I1114_I37_p1 XI1_I1114_I37_An I1_I1114_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I37_MP2 (VDD I1_p11_4 XI1_I1114_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I37_MP3 (XI1_I1114_I37_p1 XI1_I1114_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I37_MP0 (VDD I1_p11_4 XI1_I1114_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I36_MP1 (VDD I1_b12_4 XI1_I1114_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I36_MP5 (I1_I1114_pn4 I1_b12_4 XI1_I1114_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I36_MP4 (XI1_I1114_I36_p1 XI1_I1114_I36_An I1_I1114_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I36_MP2 (VDD I1_p11_3 XI1_I1114_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I36_MP3 (XI1_I1114_I36_p1 XI1_I1114_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I36_MP0 (VDD I1_p11_3 XI1_I1114_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I34_MP1 (VDD I1_b12_2 XI1_I1114_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I34_MP5 (I1_I1114_pn2 I1_b12_2 XI1_I1114_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I34_MP4 (XI1_I1114_I34_p1 XI1_I1114_I34_An I1_I1114_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I34_MP2 (VDD I1_p11_1 XI1_I1114_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I34_MP3 (XI1_I1114_I34_p1 XI1_I1114_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I34_MP0 (VDD I1_p11_1 XI1_I1114_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I208_MP1 (VDD I1_I1068_G4_0 XI1_I1068_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I208_MP5 (I1_p11_5 I1_I1068_G4_0 XI1_I1068_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I208_MP4 (XI1_I1068_I208_p1 XI1_I1068_I208_An I1_p11_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I208_MP2 (VDD I1_I1068_pn5 XI1_I1068_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I208_MP3 (XI1_I1068_I208_p1 XI1_I1068_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I208_MP0 (VDD I1_I1068_pn5 XI1_I1068_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I39_MP1 (VDD I1_b11_7 XI1_I1068_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I39_MP5 (I1_I1068_pn7 I1_b11_7 XI1_I1068_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I39_MP4 (XI1_I1068_I39_p1 XI1_I1068_I39_An I1_I1068_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I39_MP2 (VDD I1_p10_6 XI1_I1068_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I39_MP3 (XI1_I1068_I39_p1 XI1_I1068_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I39_MP0 (VDD I1_p10_6 XI1_I1068_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I203_MP1 (VDD I1_qu21_b3_5 XI1_I1068_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I203_MP5 (I1_p11_0 I1_qu21_b3_5 XI1_I1068_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I203_MP4 (XI1_I1068_I203_p1 XI1_I1068_I203_An I1_p11_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I203_MP2 (VDD I1_I1068_pn0 XI1_I1068_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I203_MP3 (XI1_I1068_I203_p1 XI1_I1068_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I203_MP0 (VDD I1_I1068_pn0 XI1_I1068_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I210_MP1 (VDD I1_I1022_G6_0 XI1_I1022_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I210_MP5 (I1_p10_7 I1_I1022_G6_0 XI1_I1022_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I210_MP4 (XI1_I1022_I210_p1 XI1_I1022_I210_An I1_p10_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I210_MP2 (VDD I1_I1022_pn7 XI1_I1022_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I210_MP3 (XI1_I1022_I210_p1 XI1_I1022_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I210_MP0 (VDD I1_I1022_pn7 XI1_I1022_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I209_MP1 (VDD I1_I1022_G5_0 XI1_I1022_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I209_MP5 (I1_p10_6 I1_I1022_G5_0 XI1_I1022_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I209_MP4 (XI1_I1022_I209_p1 XI1_I1022_I209_An I1_p10_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I209_MP2 (VDD I1_I1022_pn6 XI1_I1022_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I209_MP3 (XI1_I1022_I209_p1 XI1_I1022_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I209_MP0 (VDD I1_I1022_pn6 XI1_I1022_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I38_MP1 (VDD I1_b10_6 XI1_I1022_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I38_MP5 (I1_I1022_pn6 I1_b10_6 XI1_I1022_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I38_MP4 (XI1_I1022_I38_p1 XI1_I1022_I38_An I1_I1022_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I38_MP2 (VDD I1_p9_5 XI1_I1022_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I38_MP3 (XI1_I1022_I38_p1 XI1_I1022_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I38_MP0 (VDD I1_p9_5 XI1_I1022_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I39_MP1 (VDD I1_b10_7 XI1_I1022_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I39_MP5 (I1_I1022_pn7 I1_b10_7 XI1_I1022_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I39_MP4 (XI1_I1022_I39_p1 XI1_I1022_I39_An I1_I1022_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I39_MP2 (VDD I1_p9_6 XI1_I1022_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I39_MP3 (XI1_I1022_I39_p1 XI1_I1022_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I39_MP0 (VDD I1_p9_6 XI1_I1022_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I37_MP1 (VDD I1_b10_5 XI1_I1022_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I37_MP5 (I1_I1022_pn5 I1_b10_5 XI1_I1022_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I37_MP4 (XI1_I1022_I37_p1 XI1_I1022_I37_An I1_I1022_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I37_MP2 (VDD I1_p9_4 XI1_I1022_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I37_MP3 (XI1_I1022_I37_p1 XI1_I1022_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I37_MP0 (VDD I1_p9_4 XI1_I1022_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I34_MP1 (VDD I1_b0_2 XI1_I562_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I34_MP5 (I1_I562_pn2 I1_b0_2 XI1_I562_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I34_MP4 (XI1_I562_I34_p1 XI1_I562_I34_An I1_I562_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I34_MP2 (VDD VSS XI1_I562_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I34_MP3 (XI1_I562_I34_p1 XI1_I562_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I34_MP0 (VDD VSS XI1_I562_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I205_MP1 (VDD I1_I562_G1_0 XI1_I562_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I205_MP5 (I1_p0_2 I1_I562_G1_0 XI1_I562_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I205_MP4 (XI1_I562_I205_p1 XI1_I562_I205_An I1_p0_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I205_MP2 (VDD I1_I562_pn2 XI1_I562_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I205_MP3 (XI1_I562_I205_p1 XI1_I562_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I205_MP0 (VDD I1_I562_pn2 XI1_I562_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I40_MP1 (VDD I1_b1_8 XI1_I608_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I40_MP5 (I1_I608_pn8 I1_b1_8 XI1_I608_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I40_MP4 (XI1_I608_I40_p1 XI1_I608_I40_An I1_I608_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I40_MP2 (VDD I1_p0_7 XI1_I608_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I40_MP3 (XI1_I608_I40_p1 XI1_I608_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I40_MP0 (VDD I1_p0_7 XI1_I608_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I43_MP1 (VDD I1_b0_11 XI1_I562_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I43_MP5 (I1_I562_pn11 I1_b0_11 XI1_I562_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I43_MP4 (XI1_I562_I43_p1 XI1_I562_I43_An I1_I562_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I43_MP2 (VDD VSS XI1_I562_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I43_MP3 (XI1_I562_I43_p1 XI1_I562_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I43_MP0 (VDD VSS XI1_I562_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I49_MP1 (VDD I1_b1_17 XI1_I608_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I49_MP5 (I1_I608_pn17 I1_b1_17 XI1_I608_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I49_MP4 (XI1_I608_I49_p1 XI1_I608_I49_An I1_I608_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I49_MP2 (VDD I1_p0_16 XI1_I608_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I49_MP3 (XI1_I608_I49_p1 XI1_I608_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I49_MP0 (VDD I1_p0_16 XI1_I608_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I58_MP1 (VDD I1_b1_26 XI1_I608_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I608_I58_MP5 (I1_I608_pn26 I1_b1_26 XI1_I608_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I58_MP4 (XI1_I608_I58_p1 XI1_I608_I58_An I1_I608_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I58_MP2 (VDD I1_p0_25 XI1_I608_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I58_MP3 (XI1_I608_I58_p1 XI1_I608_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I58_MP0 (VDD I1_p0_25 XI1_I608_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I61_MP1 (VDD I1_b20_29 XI1_I1482_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I61_MP5 (I1_I1482_pn29 I1_b20_29 XI1_I1482_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I61_MP4 (XI1_I1482_I61_p1 XI1_I1482_I61_An I1_I1482_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I61_MP2 (VDD I1_p19_28 XI1_I1482_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I61_MP3 (XI1_I1482_I61_p1 XI1_I1482_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I61_MP0 (VDD I1_p19_28 XI1_I1482_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I231_MP1 (VDD I1_I1482_G27_0 XI1_I1482_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I231_MP5 (I1_p20_28 I1_I1482_G27_0 XI1_I1482_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I231_MP4 (XI1_I1482_I231_p1 XI1_I1482_I231_An I1_p20_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I231_MP2 (VDD I1_I1482_pn28 XI1_I1482_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I231_MP3 (XI1_I1482_I231_p1 XI1_I1482_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I231_MP0 (VDD I1_I1482_pn28 XI1_I1482_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I230_MP1 (VDD I1_I1482_G26_0 XI1_I1482_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I230_MP5 (I1_p20_27 I1_I1482_G26_0 XI1_I1482_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I230_MP4 (XI1_I1482_I230_p1 XI1_I1482_I230_An I1_p20_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I230_MP2 (VDD I1_I1482_pn27 XI1_I1482_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I230_MP3 (XI1_I1482_I230_p1 XI1_I1482_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I230_MP0 (VDD I1_I1482_pn27 XI1_I1482_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I224_MP1 (VDD I1_I1482_G20_0 XI1_I1482_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I224_MP5 (I1_p20_21 I1_I1482_G20_0 XI1_I1482_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I224_MP4 (XI1_I1482_I224_p1 XI1_I1482_I224_An I1_p20_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I224_MP2 (VDD I1_I1482_pn21 XI1_I1482_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I224_MP3 (XI1_I1482_I224_p1 XI1_I1482_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I224_MP0 (VDD I1_I1482_pn21 XI1_I1482_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I222_MP1 (VDD I1_I1482_G18_0 XI1_I1482_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I222_MP5 (I1_p20_19 I1_I1482_G18_0 XI1_I1482_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I222_MP4 (XI1_I1482_I222_p1 XI1_I1482_I222_An I1_p20_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I222_MP2 (VDD I1_I1482_pn19 XI1_I1482_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I222_MP3 (XI1_I1482_I222_p1 XI1_I1482_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I222_MP0 (VDD I1_I1482_pn19 XI1_I1482_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I50_MP1 (VDD I1_b21_18 XI1_I1528_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I50_MP5 (I1_I1528_pn18 I1_b21_18 XI1_I1528_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I50_MP4 (XI1_I1528_I50_p1 XI1_I1528_I50_An I1_I1528_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I50_MP2 (VDD I1_p20_17 XI1_I1528_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I50_MP3 (XI1_I1528_I50_p1 XI1_I1528_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I50_MP0 (VDD I1_p20_17 XI1_I1528_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I48_MP1 (VDD I1_b21_16 XI1_I1528_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I48_MP5 (I1_I1528_pn16 I1_b21_16 XI1_I1528_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I48_MP4 (XI1_I1528_I48_p1 XI1_I1528_I48_An I1_I1528_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I48_MP2 (VDD I1_p20_15 XI1_I1528_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I48_MP3 (XI1_I1528_I48_p1 XI1_I1528_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I48_MP0 (VDD I1_p20_15 XI1_I1528_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I34_MP1 (VDD I1_b21_2 XI1_I1528_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I34_MP5 (I1_I1528_pn2 I1_b21_2 XI1_I1528_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I34_MP4 (XI1_I1528_I34_p1 XI1_I1528_I34_An I1_I1528_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I34_MP2 (VDD I1_p20_1 XI1_I1528_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I34_MP3 (XI1_I1528_I34_p1 XI1_I1528_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I34_MP0 (VDD I1_p20_1 XI1_I1528_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I35_MP1 (VDD I1_b12_3 XI1_I1114_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I35_MP5 (I1_I1114_pn3 I1_b12_3 XI1_I1114_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I35_MP4 (XI1_I1114_I35_p1 XI1_I1114_I35_An I1_I1114_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I35_MP2 (VDD I1_p11_2 XI1_I1114_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I35_MP3 (XI1_I1114_I35_p1 XI1_I1114_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I35_MP0 (VDD I1_p11_2 XI1_I1114_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I205_MP1 (VDD I1_I1068_G1_0 XI1_I1068_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I205_MP5 (I1_p11_2 I1_I1068_G1_0 XI1_I1068_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I205_MP4 (XI1_I1068_I205_p1 XI1_I1068_I205_An I1_p11_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I205_MP2 (VDD I1_I1068_pn2 XI1_I1068_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I205_MP3 (XI1_I1068_I205_p1 XI1_I1068_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I205_MP0 (VDD I1_I1068_pn2 XI1_I1068_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I204_MP1 (VDD I1_I1068_G0_0 XI1_I1068_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I204_MP5 (I1_p11_1 I1_I1068_G0_0 XI1_I1068_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I204_MP4 (XI1_I1068_I204_p1 XI1_I1068_I204_An I1_p11_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I204_MP2 (VDD I1_I1068_pn1 XI1_I1068_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I204_MP3 (XI1_I1068_I204_p1 XI1_I1068_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I204_MP0 (VDD I1_I1068_pn1 XI1_I1068_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I37_MP1 (VDD I1_b11_5 XI1_I1068_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I37_MP5 (I1_I1068_pn5 I1_b11_5 XI1_I1068_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I37_MP4 (XI1_I1068_I37_p1 XI1_I1068_I37_An I1_I1068_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I37_MP2 (VDD I1_p10_4 XI1_I1068_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I37_MP3 (XI1_I1068_I37_p1 XI1_I1068_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I37_MP0 (VDD I1_p10_4 XI1_I1068_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I40_MP1 (VDD I1_b11_8 XI1_I1068_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I40_MP5 (I1_I1068_pn8 I1_b11_8 XI1_I1068_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I40_MP4 (XI1_I1068_I40_p1 XI1_I1068_I40_An I1_I1068_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I40_MP2 (VDD I1_p10_7 XI1_I1068_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I40_MP3 (XI1_I1068_I40_p1 XI1_I1068_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I40_MP0 (VDD I1_p10_7 XI1_I1068_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I38_MP1 (VDD I1_b11_6 XI1_I1068_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I38_MP5 (I1_I1068_pn6 I1_b11_6 XI1_I1068_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I38_MP4 (XI1_I1068_I38_p1 XI1_I1068_I38_An I1_I1068_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I38_MP2 (VDD I1_p10_5 XI1_I1068_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I38_MP3 (XI1_I1068_I38_p1 XI1_I1068_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I38_MP0 (VDD I1_p10_5 XI1_I1068_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I32_MP1 (VDD I1_b11_0 XI1_I1068_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I32_MP5 (I1_I1068_pn0 I1_b11_0 XI1_I1068_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I32_MP4 (XI1_I1068_I32_p1 XI1_I1068_I32_An I1_I1068_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I32_MP2 (VDD I1_aa20 XI1_I1068_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I32_MP3 (XI1_I1068_I32_p1 XI1_I1068_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I32_MP0 (VDD I1_aa20 XI1_I1068_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I208_MP1 (VDD I1_I1022_G4_0 XI1_I1022_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I208_MP5 (I1_p10_5 I1_I1022_G4_0 XI1_I1022_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I208_MP4 (XI1_I1022_I208_p1 XI1_I1022_I208_An I1_p10_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I208_MP2 (VDD I1_I1022_pn5 XI1_I1022_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I208_MP3 (XI1_I1022_I208_p1 XI1_I1022_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I208_MP0 (VDD I1_I1022_pn5 XI1_I1022_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I33_MP1 (VDD I1_b10_1 XI1_I1022_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I33_MP5 (I1_I1022_pn1 I1_b10_1 XI1_I1022_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I33_MP4 (XI1_I1022_I33_p1 XI1_I1022_I33_An I1_I1022_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I33_MP2 (VDD I1_p9_0 XI1_I1022_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I33_MP3 (XI1_I1022_I33_p1 XI1_I1022_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I33_MP0 (VDD I1_p9_0 XI1_I1022_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I203_MP1 (VDD I1_qu23_b3_5 XI1_I976_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I203_MP5 (I1_p9_0 I1_qu23_b3_5 XI1_I976_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I203_MP4 (XI1_I976_I203_p1 XI1_I976_I203_An I1_p9_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I203_MP2 (VDD I1_I976_pn0 XI1_I976_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I203_MP3 (XI1_I976_I203_p1 XI1_I976_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I203_MP0 (VDD I1_I976_pn0 XI1_I976_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I34_MP1 (VDD I1_b10_2 XI1_I1022_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I34_MP5 (I1_I1022_pn2 I1_b10_2 XI1_I1022_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I34_MP4 (XI1_I1022_I34_p1 XI1_I1022_I34_An I1_I1022_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I34_MP2 (VDD I1_p9_1 XI1_I1022_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I34_MP3 (XI1_I1022_I34_p1 XI1_I1022_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I34_MP0 (VDD I1_p9_1 XI1_I1022_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I32_MP1 (VDD I1_b9_0 XI1_I976_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I32_MP5 (I1_I976_pn0 I1_b9_0 XI1_I976_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I32_MP4 (XI1_I976_I32_p1 XI1_I976_I32_An I1_I976_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I32_MP2 (VDD I1_aa22 XI1_I976_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I32_MP3 (XI1_I976_I32_p1 XI1_I976_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I32_MP0 (VDD I1_aa22 XI1_I976_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I36_MP1 (VDD I1_b10_4 XI1_I1022_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I36_MP5 (I1_I1022_pn4 I1_b10_4 XI1_I1022_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I36_MP4 (XI1_I1022_I36_p1 XI1_I1022_I36_An I1_I1022_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I36_MP2 (VDD I1_p9_3 XI1_I1022_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I36_MP3 (XI1_I1022_I36_p1 XI1_I1022_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I36_MP0 (VDD I1_p9_3 XI1_I1022_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I35_MP1 (VDD I1_b10_3 XI1_I1022_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I35_MP5 (I1_I1022_pn3 I1_b10_3 XI1_I1022_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I35_MP4 (XI1_I1022_I35_p1 XI1_I1022_I35_An I1_I1022_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I35_MP2 (VDD I1_p9_2 XI1_I1022_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I35_MP3 (XI1_I1022_I35_p1 XI1_I1022_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I35_MP0 (VDD I1_p9_2 XI1_I1022_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2169_MP1 (VDD I1_nqkn31 XI1_I2169_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2169_MP5 (DIVQ_31 I1_nqkn31 XI1_I2169_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2169_MP4 (XI1_I2169_p1 XI1_I2169_An DIVQ_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2169_MP2 (VDD I1_qu31_b3_5 XI1_I2169_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2169_MP3 (XI1_I2169_p1 XI1_I2169_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2169_MP0 (VDD I1_qu31_b3_5 XI1_I2169_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I127_MP1 (VDD I1_nakn31 XI1_I127_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I127_MP5 (I1_aa31 I1_nakn31 XI1_I127_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I127_MP4 (XI1_I127_p1 XI1_I127_An I1_aa31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I127_MP2 (VDD I1_A_31_b3_5 XI1_I127_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I127_MP3 (XI1_I127_p1 XI1_I127_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I127_MP0 (VDD I1_A_31_b3_5 XI1_I127_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I32_MP1 (VDD I1_b0_0 XI1_I562_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I32_MP5 (I1_I562_pn0 I1_b0_0 XI1_I562_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I32_MP4 (XI1_I562_I32_p1 XI1_I562_I32_An I1_I562_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I32_MP2 (VDD I1_aa31 XI1_I562_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I32_MP3 (XI1_I562_I32_p1 XI1_I562_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I32_MP0 (VDD I1_aa31 XI1_I562_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I35_MP1 (VDD I1_b0_3 XI1_I562_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I35_MP5 (I1_I562_pn3 I1_b0_3 XI1_I562_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I35_MP4 (XI1_I562_I35_p1 XI1_I562_I35_An I1_I562_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I35_MP2 (VDD VSS XI1_I562_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I35_MP3 (XI1_I562_I35_p1 XI1_I562_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I35_MP0 (VDD VSS XI1_I562_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I208_MP1 (VDD I1_I562_G4_0 XI1_I562_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I208_MP5 (I1_p0_5 I1_I562_G4_0 XI1_I562_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I208_MP4 (XI1_I562_I208_p1 XI1_I562_I208_An I1_p0_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I208_MP2 (VDD I1_I562_pn5 XI1_I562_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I208_MP3 (XI1_I562_I208_p1 XI1_I562_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I208_MP0 (VDD I1_I562_pn5 XI1_I562_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I39_MP1 (VDD I1_b0_7 XI1_I562_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I39_MP5 (I1_I562_pn7 I1_b0_7 XI1_I562_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I39_MP4 (XI1_I562_I39_p1 XI1_I562_I39_An I1_I562_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I39_MP2 (VDD VSS XI1_I562_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I39_MP3 (XI1_I562_I39_p1 XI1_I562_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I39_MP0 (VDD VSS XI1_I562_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I210_MP1 (VDD I1_I562_G6_0 XI1_I562_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I210_MP5 (I1_p0_7 I1_I562_G6_0 XI1_I562_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I210_MP4 (XI1_I562_I210_p1 XI1_I562_I210_An I1_p0_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I210_MP2 (VDD I1_I562_pn7 XI1_I562_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I210_MP3 (XI1_I562_I210_p1 XI1_I562_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I210_MP0 (VDD I1_I562_pn7 XI1_I562_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I41_MP1 (VDD I1_b0_9 XI1_I562_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I41_MP5 (I1_I562_pn9 I1_b0_9 XI1_I562_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I41_MP4 (XI1_I562_I41_p1 XI1_I562_I41_An I1_I562_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I41_MP2 (VDD VSS XI1_I562_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I41_MP3 (XI1_I562_I41_p1 XI1_I562_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I41_MP0 (VDD VSS XI1_I562_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I45_MP1 (VDD I1_b0_13 XI1_I562_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I45_MP5 (I1_I562_pn13 I1_b0_13 XI1_I562_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I45_MP4 (XI1_I562_I45_p1 XI1_I562_I45_An I1_I562_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I45_MP2 (VDD VSS XI1_I562_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I45_MP3 (XI1_I562_I45_p1 XI1_I562_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I45_MP0 (VDD VSS XI1_I562_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I47_MP1 (VDD I1_b0_15 XI1_I562_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I47_MP5 (I1_I562_pn15 I1_b0_15 XI1_I562_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I47_MP4 (XI1_I562_I47_p1 XI1_I562_I47_An I1_I562_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I47_MP2 (VDD VSS XI1_I562_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I47_MP3 (XI1_I562_I47_p1 XI1_I562_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I47_MP0 (VDD VSS XI1_I562_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I220_MP1 (VDD I1_I562_G16_0 XI1_I562_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I220_MP5 (I1_p0_17 I1_I562_G16_0 XI1_I562_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I220_MP4 (XI1_I562_I220_p1 XI1_I562_I220_An I1_p0_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I220_MP2 (VDD I1_I562_pn17 XI1_I562_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I220_MP3 (XI1_I562_I220_p1 XI1_I562_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I220_MP0 (VDD I1_I562_pn17 XI1_I562_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I49_MP1 (VDD I1_b0_17 XI1_I562_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I49_MP5 (I1_I562_pn17 I1_b0_17 XI1_I562_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I49_MP4 (XI1_I562_I49_p1 XI1_I562_I49_An I1_I562_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I49_MP2 (VDD VSS XI1_I562_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I49_MP3 (XI1_I562_I49_p1 XI1_I562_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I49_MP0 (VDD VSS XI1_I562_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I222_MP1 (VDD I1_I562_G18_0 XI1_I562_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I222_MP5 (I1_p0_19 I1_I562_G18_0 XI1_I562_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I222_MP4 (XI1_I562_I222_p1 XI1_I562_I222_An I1_p0_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I222_MP2 (VDD I1_I562_pn19 XI1_I562_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I222_MP3 (XI1_I562_I222_p1 XI1_I562_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I222_MP0 (VDD I1_I562_pn19 XI1_I562_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I51_MP1 (VDD I1_b0_19 XI1_I562_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I51_MP5 (I1_I562_pn19 I1_b0_19 XI1_I562_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I51_MP4 (XI1_I562_I51_p1 XI1_I562_I51_An I1_I562_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I51_MP2 (VDD VSS XI1_I562_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I51_MP3 (XI1_I562_I51_p1 XI1_I562_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I51_MP0 (VDD VSS XI1_I562_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I53_MP1 (VDD I1_b0_21 XI1_I562_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I53_MP5 (I1_I562_pn21 I1_b0_21 XI1_I562_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I53_MP4 (XI1_I562_I53_p1 XI1_I562_I53_An I1_I562_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I53_MP2 (VDD VSS XI1_I562_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I53_MP3 (XI1_I562_I53_p1 XI1_I562_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I53_MP0 (VDD VSS XI1_I562_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I61_MP1 (VDD I1_b0_29 XI1_I562_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I61_MP5 (I1_I562_pn29 I1_b0_29 XI1_I562_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I61_MP4 (XI1_I562_I61_p1 XI1_I562_I61_An I1_I562_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I61_MP2 (VDD VSS XI1_I562_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I61_MP3 (XI1_I562_I61_p1 XI1_I562_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I61_MP0 (VDD VSS XI1_I562_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I62_MP1 (VDD I1_b20_30 XI1_I1482_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I62_MP5 (I1_I1482_pn30 I1_b20_30 XI1_I1482_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I62_MP4 (XI1_I1482_I62_p1 XI1_I1482_I62_An I1_I1482_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I62_MP2 (VDD I1_p19_29 XI1_I1482_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I62_MP3 (XI1_I1482_I62_p1 XI1_I1482_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I62_MP0 (VDD I1_p19_29 XI1_I1482_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I232_MP1 (VDD I1_I1482_G28_0 XI1_I1482_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I232_MP5 (I1_p20_29 I1_I1482_G28_0 XI1_I1482_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I232_MP4 (XI1_I1482_I232_p1 XI1_I1482_I232_An I1_p20_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I232_MP2 (VDD I1_I1482_pn29 XI1_I1482_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I232_MP3 (XI1_I1482_I232_p1 XI1_I1482_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I232_MP0 (VDD I1_I1482_pn29 XI1_I1482_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I234_MP1 (VDD I1_c20_m XI1_I1482_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I234_MP5 (I1_p20_31 I1_c20_m XI1_I1482_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I234_MP4 (XI1_I1482_I234_p1 XI1_I1482_I234_An I1_p20_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I234_MP2 (VDD I1_I1482_pn31 XI1_I1482_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I234_MP3 (XI1_I1482_I234_p1 XI1_I1482_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I234_MP0 (VDD I1_I1482_pn31 XI1_I1482_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I226_MP1 (VDD I1_I1482_G22_0 XI1_I1482_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I226_MP5 (I1_p20_23 I1_I1482_G22_0 XI1_I1482_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I226_MP4 (XI1_I1482_I226_p1 XI1_I1482_I226_An I1_p20_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I226_MP2 (VDD I1_I1482_pn23 XI1_I1482_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I226_MP3 (XI1_I1482_I226_p1 XI1_I1482_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I226_MP0 (VDD I1_I1482_pn23 XI1_I1482_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I55_MP1 (VDD I1_b21_23 XI1_I1528_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I55_MP5 (I1_I1528_pn23 I1_b21_23 XI1_I1528_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I55_MP4 (XI1_I1528_I55_p1 XI1_I1528_I55_An I1_I1528_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I55_MP2 (VDD I1_p20_22 XI1_I1528_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I55_MP3 (XI1_I1528_I55_p1 XI1_I1528_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I55_MP0 (VDD I1_p20_22 XI1_I1528_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I53_MP1 (VDD I1_b21_21 XI1_I1528_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I53_MP5 (I1_I1528_pn21 I1_b21_21 XI1_I1528_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I53_MP4 (XI1_I1528_I53_p1 XI1_I1528_I53_An I1_I1528_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I53_MP2 (VDD I1_p20_20 XI1_I1528_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I53_MP3 (XI1_I1528_I53_p1 XI1_I1528_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I53_MP0 (VDD I1_p20_20 XI1_I1528_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I52_MP1 (VDD I1_b21_20 XI1_I1528_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I52_MP5 (I1_I1528_pn20 I1_b21_20 XI1_I1528_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I52_MP4 (XI1_I1528_I52_p1 XI1_I1528_I52_An I1_I1528_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I52_MP2 (VDD I1_p20_19 XI1_I1528_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I52_MP3 (XI1_I1528_I52_p1 XI1_I1528_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I52_MP0 (VDD I1_p20_19 XI1_I1528_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I51_MP1 (VDD I1_b21_19 XI1_I1528_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I51_MP5 (I1_I1528_pn19 I1_b21_19 XI1_I1528_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I51_MP4 (XI1_I1528_I51_p1 XI1_I1528_I51_An I1_I1528_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I51_MP2 (VDD I1_p20_18 XI1_I1528_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I51_MP3 (XI1_I1528_I51_p1 XI1_I1528_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I51_MP0 (VDD I1_p20_18 XI1_I1528_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I33_MP1 (VDD I1_b21_1 XI1_I1528_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I33_MP5 (I1_I1528_pn1 I1_b21_1 XI1_I1528_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I33_MP4 (XI1_I1528_I33_p1 XI1_I1528_I33_An I1_I1528_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I33_MP2 (VDD I1_p20_0 XI1_I1528_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I33_MP3 (XI1_I1528_I33_p1 XI1_I1528_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I33_MP0 (VDD I1_p20_0 XI1_I1528_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I33_MP1 (VDD I1_b11_1 XI1_I1068_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I33_MP5 (I1_I1068_pn1 I1_b11_1 XI1_I1068_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I33_MP4 (XI1_I1068_I33_p1 XI1_I1068_I33_An I1_I1068_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I33_MP2 (VDD I1_p10_0 XI1_I1068_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I33_MP3 (XI1_I1068_I33_p1 XI1_I1068_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I33_MP0 (VDD I1_p10_0 XI1_I1068_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I34_MP1 (VDD I1_b11_2 XI1_I1068_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I34_MP5 (I1_I1068_pn2 I1_b11_2 XI1_I1068_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I34_MP4 (XI1_I1068_I34_p1 XI1_I1068_I34_An I1_I1068_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I34_MP2 (VDD I1_p10_1 XI1_I1068_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I34_MP3 (XI1_I1068_I34_p1 XI1_I1068_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I34_MP0 (VDD I1_p10_1 XI1_I1068_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I35_MP1 (VDD I1_b11_3 XI1_I1068_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I35_MP5 (I1_I1068_pn3 I1_b11_3 XI1_I1068_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I35_MP4 (XI1_I1068_I35_p1 XI1_I1068_I35_An I1_I1068_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I35_MP2 (VDD I1_p10_2 XI1_I1068_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I35_MP3 (XI1_I1068_I35_p1 XI1_I1068_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I35_MP0 (VDD I1_p10_2 XI1_I1068_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I36_MP1 (VDD I1_b11_4 XI1_I1068_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I36_MP5 (I1_I1068_pn4 I1_b11_4 XI1_I1068_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I36_MP4 (XI1_I1068_I36_p1 XI1_I1068_I36_An I1_I1068_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I36_MP2 (VDD I1_p10_3 XI1_I1068_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I36_MP3 (XI1_I1068_I36_p1 XI1_I1068_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I36_MP0 (VDD I1_p10_3 XI1_I1068_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2136_MP1 (VDD I1_nqkn20 XI1_I2136_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2136_MP5 (DIVQ_20 I1_nqkn20 XI1_I2136_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2136_MP4 (XI1_I2136_p1 XI1_I2136_An DIVQ_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2136_MP2 (VDD I1_qu20_b3_5 XI1_I2136_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2136_MP3 (XI1_I2136_p1 XI1_I2136_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2136_MP0 (VDD I1_qu20_b3_5 XI1_I2136_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2139_MP1 (VDD I1_nqkn21 XI1_I2139_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2139_MP5 (DIVQ_21 I1_nqkn21 XI1_I2139_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2139_MP4 (XI1_I2139_p1 XI1_I2139_An DIVQ_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2139_MP2 (VDD I1_qu21_b3_5 XI1_I2139_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2139_MP3 (XI1_I2139_p1 XI1_I2139_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2139_MP0 (VDD I1_qu21_b3_5 XI1_I2139_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I91_MP1 (VDD I1_nakn19 XI1_I91_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I91_MP5 (I1_aa19 I1_nakn19 XI1_I91_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I91_MP4 (XI1_I91_p1 XI1_I91_An I1_aa19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I91_MP2 (VDD A_19 XI1_I91_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I91_MP3 (XI1_I91_p1 XI1_I91_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I91_MP0 (VDD A_19 XI1_I91_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I203_MP1 (VDD I1_qu22_b3_5 XI1_I1022_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I203_MP5 (I1_p10_0 I1_qu22_b3_5 XI1_I1022_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I203_MP4 (XI1_I1022_I203_p1 XI1_I1022_I203_An I1_p10_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I203_MP2 (VDD I1_I1022_pn0 XI1_I1022_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I203_MP3 (XI1_I1022_I203_p1 XI1_I1022_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I203_MP0 (VDD I1_I1022_pn0 XI1_I1022_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I94_MP1 (VDD I1_nakn20 XI1_I94_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I94_MP5 (I1_aa20 I1_nakn20 XI1_I94_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I94_MP4 (XI1_I94_p1 XI1_I94_An I1_aa20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I94_MP2 (VDD A_20 XI1_I94_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I94_MP3 (XI1_I94_p1 XI1_I94_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I94_MP0 (VDD A_20 XI1_I94_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I204_MP1 (VDD I1_I1022_G0_0 XI1_I1022_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I204_MP5 (I1_p10_1 I1_I1022_G0_0 XI1_I1022_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I204_MP4 (XI1_I1022_I204_p1 XI1_I1022_I204_An I1_p10_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I204_MP2 (VDD I1_I1022_pn1 XI1_I1022_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I204_MP3 (XI1_I1022_I204_p1 XI1_I1022_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I204_MP0 (VDD I1_I1022_pn1 XI1_I1022_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I205_MP1 (VDD I1_I1022_G1_0 XI1_I1022_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I205_MP5 (I1_p10_2 I1_I1022_G1_0 XI1_I1022_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I205_MP4 (XI1_I1022_I205_p1 XI1_I1022_I205_An I1_p10_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I205_MP2 (VDD I1_I1022_pn2 XI1_I1022_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I205_MP3 (XI1_I1022_I205_p1 XI1_I1022_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I205_MP0 (VDD I1_I1022_pn2 XI1_I1022_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I32_MP1 (VDD I1_b10_0 XI1_I1022_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I32_MP5 (I1_I1022_pn0 I1_b10_0 XI1_I1022_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I32_MP4 (XI1_I1022_I32_p1 XI1_I1022_I32_An I1_I1022_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I32_MP2 (VDD I1_aa21 XI1_I1022_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I32_MP3 (XI1_I1022_I32_p1 XI1_I1022_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I32_MP0 (VDD I1_aa21 XI1_I1022_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2142_MP1 (VDD I1_nqkn22 XI1_I2142_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2142_MP5 (DIVQ_22 I1_nqkn22 XI1_I2142_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2142_MP4 (XI1_I2142_p1 XI1_I2142_An DIVQ_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2142_MP2 (VDD I1_qu22_b3_5 XI1_I2142_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2142_MP3 (XI1_I2142_p1 XI1_I2142_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2142_MP0 (VDD I1_qu22_b3_5 XI1_I2142_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2145_MP1 (VDD I1_nqkn23 XI1_I2145_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2145_MP5 (DIVQ_23 I1_nqkn23 XI1_I2145_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2145_MP4 (XI1_I2145_p1 XI1_I2145_An DIVQ_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2145_MP2 (VDD I1_qu23_b3_5 XI1_I2145_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2145_MP3 (XI1_I2145_p1 XI1_I2145_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2145_MP0 (VDD I1_qu23_b3_5 XI1_I2145_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2148_MP1 (VDD I1_nqkn24 XI1_I2148_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2148_MP5 (DIVQ_24 I1_nqkn24 XI1_I2148_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2148_MP4 (XI1_I2148_p1 XI1_I2148_An DIVQ_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2148_MP2 (VDD I1_qu24_b3_5 XI1_I2148_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2148_MP3 (XI1_I2148_p1 XI1_I2148_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2148_MP0 (VDD I1_qu24_b3_5 XI1_I2148_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2151_MP1 (VDD I1_nqkn25 XI1_I2151_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2151_MP5 (DIVQ_25 I1_nqkn25 XI1_I2151_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2151_MP4 (XI1_I2151_p1 XI1_I2151_An DIVQ_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2151_MP2 (VDD I1_qu25_b3_5 XI1_I2151_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2151_MP3 (XI1_I2151_p1 XI1_I2151_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2151_MP0 (VDD I1_qu25_b3_5 XI1_I2151_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2154_MP1 (VDD I1_nqkn26 XI1_I2154_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2154_MP5 (DIVQ_26 I1_nqkn26 XI1_I2154_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2154_MP4 (XI1_I2154_p1 XI1_I2154_An DIVQ_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2154_MP2 (VDD I1_qu26_b3_5 XI1_I2154_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2154_MP3 (XI1_I2154_p1 XI1_I2154_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2154_MP0 (VDD I1_qu26_b3_5 XI1_I2154_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2157_MP1 (VDD I1_nqkn27 XI1_I2157_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2157_MP5 (DIVQ_27 I1_nqkn27 XI1_I2157_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2157_MP4 (XI1_I2157_p1 XI1_I2157_An DIVQ_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2157_MP2 (VDD I1_qu27_b3_5 XI1_I2157_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2157_MP3 (XI1_I2157_p1 XI1_I2157_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2157_MP0 (VDD I1_qu27_b3_5 XI1_I2157_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2160_MP1 (VDD I1_nqkn28 XI1_I2160_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2160_MP5 (DIVQ_28 I1_nqkn28 XI1_I2160_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2160_MP4 (XI1_I2160_p1 XI1_I2160_An DIVQ_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2160_MP2 (VDD I1_qu28_b3_5 XI1_I2160_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2160_MP3 (XI1_I2160_p1 XI1_I2160_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2160_MP0 (VDD I1_qu28_b3_5 XI1_I2160_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2163_MP1 (VDD I1_nqkn29 XI1_I2163_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2163_MP5 (DIVQ_29 I1_nqkn29 XI1_I2163_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2163_MP4 (XI1_I2163_p1 XI1_I2163_An DIVQ_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2163_MP2 (VDD I1_qu29_b3_5 XI1_I2163_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2163_MP3 (XI1_I2163_p1 XI1_I2163_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2163_MP0 (VDD I1_qu29_b3_5 XI1_I2163_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I103_MP1 (VDD I1_nakn23 XI1_I103_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I103_MP5 (I1_aa23 I1_nakn23 XI1_I103_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I103_MP4 (XI1_I103_p1 XI1_I103_An I1_aa23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I103_MP2 (VDD A_23 XI1_I103_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I103_MP3 (XI1_I103_p1 XI1_I103_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I103_MP0 (VDD A_23 XI1_I103_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2166_MP1 (VDD I1_nqkn30 XI1_I2166_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2166_MP5 (DIVQ_30 I1_nqkn30 XI1_I2166_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2166_MP4 (XI1_I2166_p1 XI1_I2166_An DIVQ_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2166_MP2 (VDD I1_qu30_b3_5 XI1_I2166_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2166_MP3 (XI1_I2166_p1 XI1_I2166_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2166_MP0 (VDD I1_qu30_b3_5 XI1_I2166_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I106_MP1 (VDD I1_nakn24 XI1_I106_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I106_MP5 (I1_aa24 I1_nakn24 XI1_I106_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I106_MP4 (XI1_I106_p1 XI1_I106_An I1_aa24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I106_MP2 (VDD A_24 XI1_I106_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I106_MP3 (XI1_I106_p1 XI1_I106_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I106_MP0 (VDD A_24 XI1_I106_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I124_MP1 (VDD I1_nakn30 XI1_I124_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I124_MP5 (I1_aa30 I1_nakn30 XI1_I124_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I124_MP4 (XI1_I124_p1 XI1_I124_An I1_aa30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I124_MP2 (VDD A_30 XI1_I124_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I124_MP3 (XI1_I124_p1 XI1_I124_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I124_MP0 (VDD A_30 XI1_I124_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I121_MP1 (VDD I1_nakn29 XI1_I121_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I121_MP5 (I1_aa29 I1_nakn29 XI1_I121_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I121_MP4 (XI1_I121_p1 XI1_I121_An I1_aa29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I121_MP2 (VDD A_29 XI1_I121_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I121_MP3 (XI1_I121_p1 XI1_I121_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I121_MP0 (VDD A_29 XI1_I121_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I36_MP1 (VDD I1_b0_4 XI1_I562_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I36_MP5 (I1_I562_pn4 I1_b0_4 XI1_I562_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I36_MP4 (XI1_I562_I36_p1 XI1_I562_I36_An I1_I562_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I36_MP2 (VDD VSS XI1_I562_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I36_MP3 (XI1_I562_I36_p1 XI1_I562_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I36_MP0 (VDD VSS XI1_I562_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I224_MP1 (VDD I1_I562_G20_0 XI1_I562_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I224_MP5 (I1_p0_21 I1_I562_G20_0 XI1_I562_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I224_MP4 (XI1_I562_I224_p1 XI1_I562_I224_An I1_p0_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I224_MP2 (VDD I1_I562_pn21 XI1_I562_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I224_MP3 (XI1_I562_I224_p1 XI1_I562_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I224_MP0 (VDD I1_I562_pn21 XI1_I562_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I226_MP1 (VDD I1_I562_G22_0 XI1_I562_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I226_MP5 (I1_p0_23 I1_I562_G22_0 XI1_I562_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I226_MP4 (XI1_I562_I226_p1 XI1_I562_I226_An I1_p0_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I226_MP2 (VDD I1_I562_pn23 XI1_I562_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I226_MP3 (XI1_I562_I226_p1 XI1_I562_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I226_MP0 (VDD I1_I562_pn23 XI1_I562_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I234_MP1 (VDD I1_c0_m XI1_I562_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I234_MP5 (I1_p0_31 I1_c0_m XI1_I562_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I234_MP4 (XI1_I562_I234_p1 XI1_I562_I234_An I1_p0_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I234_MP2 (VDD I1_I562_pn31 XI1_I562_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I234_MP3 (XI1_I562_I234_p1 XI1_I562_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I234_MP0 (VDD I1_I562_pn31 XI1_I562_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I228_MP1 (VDD I1_I562_G24_0 XI1_I562_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I228_MP5 (I1_p0_25 I1_I562_G24_0 XI1_I562_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I228_MP4 (XI1_I562_I228_p1 XI1_I562_I228_An I1_p0_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I228_MP2 (VDD I1_I562_pn25 XI1_I562_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I228_MP3 (XI1_I562_I228_p1 XI1_I562_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I228_MP0 (VDD I1_I562_pn25 XI1_I562_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I230_MP1 (VDD I1_I562_G26_0 XI1_I562_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I230_MP5 (I1_p0_27 I1_I562_G26_0 XI1_I562_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I230_MP4 (XI1_I562_I230_p1 XI1_I562_I230_An I1_p0_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I230_MP2 (VDD I1_I562_pn27 XI1_I562_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I230_MP3 (XI1_I562_I230_p1 XI1_I562_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I230_MP0 (VDD I1_I562_pn27 XI1_I562_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I232_MP1 (VDD I1_I562_G28_0 XI1_I562_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I232_MP5 (I1_p0_29 I1_I562_G28_0 XI1_I562_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I232_MP4 (XI1_I562_I232_p1 XI1_I562_I232_An I1_p0_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I232_MP2 (VDD I1_I562_pn29 XI1_I562_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I232_MP3 (XI1_I562_I232_p1 XI1_I562_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I232_MP0 (VDD I1_I562_pn29 XI1_I562_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I59_MP1 (VDD I1_b0_27 XI1_I562_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I59_MP5 (I1_I562_pn27 I1_b0_27 XI1_I562_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I59_MP4 (XI1_I562_I59_p1 XI1_I562_I59_An I1_I562_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I59_MP2 (VDD VSS XI1_I562_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I59_MP3 (XI1_I562_I59_p1 XI1_I562_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I59_MP0 (VDD VSS XI1_I562_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I63_MP1 (VDD I1_b0_31 XI1_I562_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I63_MP5 (I1_I562_pn31 I1_b0_31 XI1_I562_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I63_MP4 (XI1_I562_I63_p1 XI1_I562_I63_An I1_I562_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I63_MP2 (VDD VSS XI1_I562_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I63_MP3 (XI1_I562_I63_p1 XI1_I562_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I63_MP0 (VDD VSS XI1_I562_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I63_MP1 (VDD I1_b20_31 XI1_I1482_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I63_MP5 (I1_I1482_pn31 I1_b20_31 XI1_I1482_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I63_MP4 (XI1_I1482_I63_p1 XI1_I1482_I63_An I1_I1482_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I63_MP2 (VDD I1_p19_30 XI1_I1482_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I63_MP3 (XI1_I1482_I63_p1 XI1_I1482_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I63_MP0 (VDD I1_p19_30 XI1_I1482_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I233_MP1 (VDD I1_I1482_G29_0 XI1_I1482_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1482_I233_MP5 (I1_p20_30 I1_I1482_G29_0 XI1_I1482_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I233_MP4 (XI1_I1482_I233_p1 XI1_I1482_I233_An I1_p20_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I233_MP2 (VDD I1_I1482_pn30 XI1_I1482_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I233_MP3 (XI1_I1482_I233_p1 XI1_I1482_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I233_MP0 (VDD I1_I1482_pn30 XI1_I1482_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I57_MP1 (VDD I1_b21_25 XI1_I1528_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I57_MP5 (I1_I1528_pn25 I1_b21_25 XI1_I1528_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I57_MP4 (XI1_I1528_I57_p1 XI1_I1528_I57_An I1_I1528_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I57_MP2 (VDD I1_p20_24 XI1_I1528_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I57_MP3 (XI1_I1528_I57_p1 XI1_I1528_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I57_MP0 (VDD I1_p20_24 XI1_I1528_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I56_MP1 (VDD I1_b21_24 XI1_I1528_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I56_MP5 (I1_I1528_pn24 I1_b21_24 XI1_I1528_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I56_MP4 (XI1_I1528_I56_p1 XI1_I1528_I56_An I1_I1528_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I56_MP2 (VDD I1_p20_23 XI1_I1528_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I56_MP3 (XI1_I1528_I56_p1 XI1_I1528_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I56_MP0 (VDD I1_p20_23 XI1_I1528_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I58_MP1 (VDD I1_b21_26 XI1_I1528_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I58_MP5 (I1_I1528_pn26 I1_b21_26 XI1_I1528_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I58_MP4 (XI1_I1528_I58_p1 XI1_I1528_I58_An I1_I1528_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I58_MP2 (VDD I1_p20_25 XI1_I1528_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I58_MP3 (XI1_I1528_I58_p1 XI1_I1528_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I58_MP0 (VDD I1_p20_25 XI1_I1528_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I54_MP1 (VDD I1_b21_22 XI1_I1528_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I54_MP5 (I1_I1528_pn22 I1_b21_22 XI1_I1528_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I54_MP4 (XI1_I1528_I54_p1 XI1_I1528_I54_An I1_I1528_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I54_MP2 (VDD I1_p20_21 XI1_I1528_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I54_MP3 (XI1_I1528_I54_p1 XI1_I1528_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I54_MP0 (VDD I1_p20_21 XI1_I1528_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I210_MP1 (VDD I1_I1528_G6_0 XI1_I1528_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I210_MP5 (I1_p21_7 I1_I1528_G6_0 XI1_I1528_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I210_MP4 (XI1_I1528_I210_p1 XI1_I1528_I210_An I1_p21_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I210_MP2 (VDD I1_I1528_pn7 XI1_I1528_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I210_MP3 (XI1_I1528_I210_p1 XI1_I1528_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I210_MP0 (VDD I1_I1528_pn7 XI1_I1528_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I222_MP1 (VDD I1_I1528_G18_0 XI1_I1528_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I222_MP5 (I1_p21_19 I1_I1528_G18_0 XI1_I1528_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I222_MP4 (XI1_I1528_I222_p1 XI1_I1528_I222_An I1_p21_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I222_MP2 (VDD I1_I1528_pn19 XI1_I1528_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I222_MP3 (XI1_I1528_I222_p1 XI1_I1528_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I222_MP0 (VDD I1_I1528_pn19 XI1_I1528_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I208_MP1 (VDD I1_I1528_G4_0 XI1_I1528_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I208_MP5 (I1_p21_5 I1_I1528_G4_0 XI1_I1528_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I208_MP4 (XI1_I1528_I208_p1 XI1_I1528_I208_An I1_p21_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I208_MP2 (VDD I1_I1528_pn5 XI1_I1528_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I208_MP3 (XI1_I1528_I208_p1 XI1_I1528_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I208_MP0 (VDD I1_I1528_pn5 XI1_I1528_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I43_MP1 (VDD I1_b22_11 XI1_I1574_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I43_MP5 (I1_I1574_pn11 I1_b22_11 XI1_I1574_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I43_MP4 (XI1_I1574_I43_p1 XI1_I1574_I43_An I1_I1574_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I43_MP2 (VDD I1_p21_10 XI1_I1574_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I43_MP3 (XI1_I1574_I43_p1 XI1_I1574_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I43_MP0 (VDD I1_p21_10 XI1_I1574_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I204_MP1 (VDD I1_I1528_G0_0 XI1_I1528_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I204_MP5 (I1_p21_1 I1_I1528_G0_0 XI1_I1528_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I204_MP4 (XI1_I1528_I204_p1 XI1_I1528_I204_An I1_p21_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I204_MP2 (VDD I1_I1528_pn1 XI1_I1528_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I204_MP3 (XI1_I1528_I204_p1 XI1_I1528_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I204_MP0 (VDD I1_I1528_pn1 XI1_I1528_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I42_MP1 (VDD I1_b22_10 XI1_I1574_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I42_MP5 (I1_I1574_pn10 I1_b22_10 XI1_I1574_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I42_MP4 (XI1_I1574_I42_p1 XI1_I1574_I42_An I1_I1574_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I42_MP2 (VDD I1_p21_9 XI1_I1574_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I42_MP3 (XI1_I1574_I42_p1 XI1_I1574_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I42_MP0 (VDD I1_p21_9 XI1_I1574_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I40_MP1 (VDD I1_b22_8 XI1_I1574_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I40_MP5 (I1_I1574_pn8 I1_b22_8 XI1_I1574_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I40_MP4 (XI1_I1574_I40_p1 XI1_I1574_I40_An I1_I1574_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I40_MP2 (VDD I1_p21_7 XI1_I1574_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I40_MP3 (XI1_I1574_I40_p1 XI1_I1574_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I40_MP0 (VDD I1_p21_7 XI1_I1574_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I79_MP1 (VDD I1_nakn15 XI1_I79_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I79_MP5 (I1_aa15 I1_nakn15 XI1_I79_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I79_MP4 (XI1_I79_p1 XI1_I79_An I1_aa15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I79_MP2 (VDD A_15 XI1_I79_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I79_MP3 (XI1_I79_p1 XI1_I79_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I79_MP0 (VDD A_15 XI1_I79_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I32_MP1 (VDD I1_b21_0 XI1_I1528_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I32_MP5 (I1_I1528_pn0 I1_b21_0 XI1_I1528_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I32_MP4 (XI1_I1528_I32_p1 XI1_I1528_I32_An I1_I1528_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I32_MP2 (VDD I1_aa10 XI1_I1528_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I32_MP3 (XI1_I1528_I32_p1 XI1_I1528_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I32_MP0 (VDD I1_aa10 XI1_I1528_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I203_MP1 (VDD I1_qu11_b3_5 XI1_I1528_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I203_MP5 (I1_p21_0 I1_qu11_b3_5 XI1_I1528_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I203_MP4 (XI1_I1528_I203_p1 XI1_I1528_I203_An I1_p21_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I203_MP2 (VDD I1_I1528_pn0 XI1_I1528_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I203_MP3 (XI1_I1528_I203_p1 XI1_I1528_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I203_MP0 (VDD I1_I1528_pn0 XI1_I1528_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2118_MP1 (VDD I1_nqkn14 XI1_I2118_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2118_MP5 (DIVQ_14 I1_nqkn14 XI1_I2118_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2118_MP4 (XI1_I2118_p1 XI1_I2118_An DIVQ_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2118_MP2 (VDD I1_qu14_b3_5 XI1_I2118_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2118_MP3 (XI1_I2118_p1 XI1_I2118_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2118_MP0 (VDD I1_qu14_b3_5 XI1_I2118_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2121_MP1 (VDD I1_nqkn15 XI1_I2121_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2121_MP5 (DIVQ_15 I1_nqkn15 XI1_I2121_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2121_MP4 (XI1_I2121_p1 XI1_I2121_An DIVQ_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2121_MP2 (VDD I1_qu15_b3_5 XI1_I2121_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2121_MP3 (XI1_I2121_p1 XI1_I2121_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2121_MP0 (VDD I1_qu15_b3_5 XI1_I2121_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2124_MP1 (VDD I1_nqkn16 XI1_I2124_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2124_MP5 (DIVQ_16 I1_nqkn16 XI1_I2124_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2124_MP4 (XI1_I2124_p1 XI1_I2124_An DIVQ_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2124_MP2 (VDD I1_qu16_b3_5 XI1_I2124_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2124_MP3 (XI1_I2124_p1 XI1_I2124_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2124_MP0 (VDD I1_qu16_b3_5 XI1_I2124_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2127_MP1 (VDD I1_nqkn17 XI1_I2127_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2127_MP5 (DIVQ_17 I1_nqkn17 XI1_I2127_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2127_MP4 (XI1_I2127_p1 XI1_I2127_An DIVQ_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2127_MP2 (VDD I1_qu17_b3_5 XI1_I2127_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2127_MP3 (XI1_I2127_p1 XI1_I2127_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2127_MP0 (VDD I1_qu17_b3_5 XI1_I2127_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2130_MP1 (VDD I1_nqkn18 XI1_I2130_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2130_MP5 (DIVQ_18 I1_nqkn18 XI1_I2130_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2130_MP4 (XI1_I2130_p1 XI1_I2130_An DIVQ_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2130_MP2 (VDD I1_qu18_b3_5 XI1_I2130_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2130_MP3 (XI1_I2130_p1 XI1_I2130_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2130_MP0 (VDD I1_qu18_b3_5 XI1_I2130_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2133_MP1 (VDD I1_nqkn19 XI1_I2133_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2133_MP5 (DIVQ_19 I1_nqkn19 XI1_I2133_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2133_MP4 (XI1_I2133_p1 XI1_I2133_An DIVQ_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2133_MP2 (VDD I1_qu19_b3_5 XI1_I2133_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2133_MP3 (XI1_I2133_p1 XI1_I2133_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2133_MP0 (VDD I1_qu19_b3_5 XI1_I2133_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I85_MP1 (VDD I1_nakn17 XI1_I85_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I85_MP5 (I1_aa17 I1_nakn17 XI1_I85_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I85_MP4 (XI1_I85_p1 XI1_I85_An I1_aa17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I85_MP2 (VDD A_17 XI1_I85_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I85_MP3 (XI1_I85_p1 XI1_I85_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I85_MP0 (VDD A_17 XI1_I85_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I88_MP1 (VDD I1_nakn18 XI1_I88_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I88_MP5 (I1_aa18 I1_nakn18 XI1_I88_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I88_MP4 (XI1_I88_p1 XI1_I88_An I1_aa18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I88_MP2 (VDD A_18 XI1_I88_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I88_MP3 (XI1_I88_p1 XI1_I88_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I88_MP0 (VDD A_18 XI1_I88_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I376_MP1 (VDD I1_nbkn20 XI1_I376_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I376_MP5 (I1_dd20 I1_nbkn20 XI1_I376_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I376_MP4 (XI1_I376_p1 XI1_I376_An I1_dd20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I376_MP2 (VDD B_20 XI1_I376_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I376_MP3 (XI1_I376_p1 XI1_I376_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I376_MP0 (VDD B_20 XI1_I376_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I389_MP1 (VDD I1_nbkn21 XI1_I389_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I389_MP5 (I1_dd21 I1_nbkn21 XI1_I389_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I389_MP4 (XI1_I389_p1 XI1_I389_An I1_dd21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I389_MP2 (VDD B_21 XI1_I389_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I389_MP3 (XI1_I389_p1 XI1_I389_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I389_MP0 (VDD B_21 XI1_I389_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I402_MP1 (VDD I1_nbkn22 XI1_I402_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I402_MP5 (I1_dd22 I1_nbkn22 XI1_I402_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I402_MP4 (XI1_I402_p1 XI1_I402_An I1_dd22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I402_MP2 (VDD B_22 XI1_I402_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I402_MP3 (XI1_I402_p1 XI1_I402_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I402_MP0 (VDD B_22 XI1_I402_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I97_MP1 (VDD I1_nakn21 XI1_I97_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I97_MP5 (I1_aa21 I1_nakn21 XI1_I97_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I97_MP4 (XI1_I97_p1 XI1_I97_An I1_aa21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I97_MP2 (VDD A_21 XI1_I97_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I97_MP3 (XI1_I97_p1 XI1_I97_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I97_MP0 (VDD A_21 XI1_I97_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I519_MP1 (VDD I1_nbkn31 XI1_I519_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I519_MP5 (I1_dd31 I1_nbkn31 XI1_I519_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I519_MP4 (XI1_I519_p1 XI1_I519_An I1_dd31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I519_MP2 (VDD I1_B_31_b3_5 XI1_I519_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I519_MP3 (XI1_I519_p1 XI1_I519_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I519_MP0 (VDD I1_B_31_b3_5 XI1_I519_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I506_MP1 (VDD I1_nbkn30 XI1_I506_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I506_MP5 (I1_dd30 I1_nbkn30 XI1_I506_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I506_MP4 (XI1_I506_p1 XI1_I506_An I1_dd30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I506_MP2 (VDD B_30 XI1_I506_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I506_MP3 (XI1_I506_p1 XI1_I506_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I506_MP0 (VDD B_30 XI1_I506_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I493_MP1 (VDD I1_nbkn29 XI1_I493_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I493_MP5 (I1_dd29 I1_nbkn29 XI1_I493_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I493_MP4 (XI1_I493_p1 XI1_I493_An I1_dd29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I493_MP2 (VDD B_29 XI1_I493_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I493_MP3 (XI1_I493_p1 XI1_I493_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I493_MP0 (VDD B_29 XI1_I493_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I480_MP1 (VDD I1_nbkn28 XI1_I480_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I480_MP5 (I1_dd28 I1_nbkn28 XI1_I480_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I480_MP4 (XI1_I480_p1 XI1_I480_An I1_dd28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I480_MP2 (VDD B_28 XI1_I480_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I480_MP3 (XI1_I480_p1 XI1_I480_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I480_MP0 (VDD B_28 XI1_I480_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I100_MP1 (VDD I1_nakn22 XI1_I100_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I100_MP5 (I1_aa22 I1_nakn22 XI1_I100_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I100_MP4 (XI1_I100_p1 XI1_I100_An I1_aa22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I100_MP2 (VDD A_22 XI1_I100_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I100_MP3 (XI1_I100_p1 XI1_I100_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I100_MP0 (VDD A_22 XI1_I100_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I109_MP1 (VDD I1_nakn25 XI1_I109_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I109_MP5 (I1_aa25 I1_nakn25 XI1_I109_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I109_MP4 (XI1_I109_p1 XI1_I109_An I1_aa25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I109_MP2 (VDD A_25 XI1_I109_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I109_MP3 (XI1_I109_p1 XI1_I109_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I109_MP0 (VDD A_25 XI1_I109_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I112_MP1 (VDD I1_nakn26 XI1_I112_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I112_MP5 (I1_aa26 I1_nakn26 XI1_I112_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I112_MP4 (XI1_I112_p1 XI1_I112_An I1_aa26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I112_MP2 (VDD A_26 XI1_I112_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I112_MP3 (XI1_I112_p1 XI1_I112_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I112_MP0 (VDD A_26 XI1_I112_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I115_MP1 (VDD I1_nakn27 XI1_I115_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I115_MP5 (I1_aa27 I1_nakn27 XI1_I115_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I115_MP4 (XI1_I115_p1 XI1_I115_An I1_aa27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I115_MP2 (VDD A_27 XI1_I115_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I115_MP3 (XI1_I115_p1 XI1_I115_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I115_MP0 (VDD A_27 XI1_I115_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I118_MP1 (VDD I1_nakn28 XI1_I118_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I118_MP5 (I1_aa28 I1_nakn28 XI1_I118_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I118_MP4 (XI1_I118_p1 XI1_I118_An I1_aa28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I118_MP2 (VDD A_28 XI1_I118_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I118_MP3 (XI1_I118_p1 XI1_I118_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I118_MP0 (VDD A_28 XI1_I118_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I37_MP1 (VDD I1_b0_5 XI1_I562_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I37_MP5 (I1_I562_pn5 I1_b0_5 XI1_I562_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I37_MP4 (XI1_I562_I37_p1 XI1_I562_I37_An I1_I562_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I37_MP2 (VDD VSS XI1_I562_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I37_MP3 (XI1_I562_I37_p1 XI1_I562_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I37_MP0 (VDD VSS XI1_I562_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I233_MP1 (VDD I1_I562_G29_0 XI1_I562_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I233_MP5 (I1_p0_30 I1_I562_G29_0 XI1_I562_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I233_MP4 (XI1_I562_I233_p1 XI1_I562_I233_An I1_p0_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I233_MP2 (VDD I1_I562_pn30 XI1_I562_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I233_MP3 (XI1_I562_I233_p1 XI1_I562_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I233_MP0 (VDD I1_I562_pn30 XI1_I562_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I57_MP1 (VDD I1_b0_25 XI1_I562_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I57_MP5 (I1_I562_pn25 I1_b0_25 XI1_I562_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I57_MP4 (XI1_I562_I57_p1 XI1_I562_I57_An I1_I562_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I57_MP2 (VDD VSS XI1_I562_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I57_MP3 (XI1_I562_I57_p1 XI1_I562_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I57_MP0 (VDD VSS XI1_I562_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I62_MP1 (VDD I1_b21_30 XI1_I1528_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I62_MP5 (I1_I1528_pn30 I1_b21_30 XI1_I1528_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I62_MP4 (XI1_I1528_I62_p1 XI1_I1528_I62_An I1_I1528_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I62_MP2 (VDD I1_p20_29 XI1_I1528_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I62_MP3 (XI1_I1528_I62_p1 XI1_I1528_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I62_MP0 (VDD I1_p20_29 XI1_I1528_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I61_MP1 (VDD I1_b21_29 XI1_I1528_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I61_MP5 (I1_I1528_pn29 I1_b21_29 XI1_I1528_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I61_MP4 (XI1_I1528_I61_p1 XI1_I1528_I61_An I1_I1528_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I61_MP2 (VDD I1_p20_28 XI1_I1528_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I61_MP3 (XI1_I1528_I61_p1 XI1_I1528_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I61_MP0 (VDD I1_p20_28 XI1_I1528_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I60_MP1 (VDD I1_b21_28 XI1_I1528_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I60_MP5 (I1_I1528_pn28 I1_b21_28 XI1_I1528_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I60_MP4 (XI1_I1528_I60_p1 XI1_I1528_I60_An I1_I1528_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I60_MP2 (VDD I1_p20_27 XI1_I1528_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I60_MP3 (XI1_I1528_I60_p1 XI1_I1528_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I60_MP0 (VDD I1_p20_27 XI1_I1528_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I59_MP1 (VDD I1_b21_27 XI1_I1528_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I59_MP5 (I1_I1528_pn27 I1_b21_27 XI1_I1528_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I59_MP4 (XI1_I1528_I59_p1 XI1_I1528_I59_An I1_I1528_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I59_MP2 (VDD I1_p20_26 XI1_I1528_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I59_MP3 (XI1_I1528_I59_p1 XI1_I1528_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I59_MP0 (VDD I1_p20_26 XI1_I1528_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I226_MP1 (VDD I1_I1528_G22_0 XI1_I1528_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I226_MP5 (I1_p21_23 I1_I1528_G22_0 XI1_I1528_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I226_MP4 (XI1_I1528_I226_p1 XI1_I1528_I226_An I1_p21_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I226_MP2 (VDD I1_I1528_pn23 XI1_I1528_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I226_MP3 (XI1_I1528_I226_p1 XI1_I1528_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I226_MP0 (VDD I1_I1528_pn23 XI1_I1528_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I230_MP1 (VDD I1_I1528_G26_0 XI1_I1528_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I230_MP5 (I1_p21_27 I1_I1528_G26_0 XI1_I1528_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I230_MP4 (XI1_I1528_I230_p1 XI1_I1528_I230_An I1_p21_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I230_MP2 (VDD I1_I1528_pn27 XI1_I1528_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I230_MP3 (XI1_I1528_I230_p1 XI1_I1528_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I230_MP0 (VDD I1_I1528_pn27 XI1_I1528_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I224_MP1 (VDD I1_I1528_G20_0 XI1_I1528_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I224_MP5 (I1_p21_21 I1_I1528_G20_0 XI1_I1528_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I224_MP4 (XI1_I1528_I224_p1 XI1_I1528_I224_An I1_p21_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I224_MP2 (VDD I1_I1528_pn21 XI1_I1528_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I224_MP3 (XI1_I1528_I224_p1 XI1_I1528_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I224_MP0 (VDD I1_I1528_pn21 XI1_I1528_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I205_MP1 (VDD I1_I1528_G1_0 XI1_I1528_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I205_MP5 (I1_p21_2 I1_I1528_G1_0 XI1_I1528_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I205_MP4 (XI1_I1528_I205_p1 XI1_I1528_I205_An I1_p21_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I205_MP2 (VDD I1_I1528_pn2 XI1_I1528_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I205_MP3 (XI1_I1528_I205_p1 XI1_I1528_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I205_MP0 (VDD I1_I1528_pn2 XI1_I1528_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I44_MP1 (VDD I1_b22_12 XI1_I1574_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I44_MP5 (I1_I1574_pn12 I1_b22_12 XI1_I1574_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I44_MP4 (XI1_I1574_I44_p1 XI1_I1574_I44_An I1_I1574_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I44_MP2 (VDD I1_p21_11 XI1_I1574_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I44_MP3 (XI1_I1574_I44_p1 XI1_I1574_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I44_MP0 (VDD I1_p21_11 XI1_I1574_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I39_MP1 (VDD I1_b22_7 XI1_I1574_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I39_MP5 (I1_I1574_pn7 I1_b22_7 XI1_I1574_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I39_MP4 (XI1_I1574_I39_p1 XI1_I1574_I39_An I1_I1574_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I39_MP2 (VDD I1_p21_6 XI1_I1574_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I39_MP3 (XI1_I1574_I39_p1 XI1_I1574_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I39_MP0 (VDD I1_p21_6 XI1_I1574_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I76_MP1 (VDD I1_nakn14 XI1_I76_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I76_MP5 (I1_aa14 I1_nakn14 XI1_I76_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I76_MP4 (XI1_I76_p1 XI1_I76_An I1_aa14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I76_MP2 (VDD A_14 XI1_I76_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I76_MP3 (XI1_I76_p1 XI1_I76_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I76_MP0 (VDD A_14 XI1_I76_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I73_MP1 (VDD I1_nakn13 XI1_I73_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I73_MP5 (I1_aa13 I1_nakn13 XI1_I73_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I73_MP4 (XI1_I73_p1 XI1_I73_An I1_aa13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I73_MP2 (VDD A_13 XI1_I73_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I73_MP3 (XI1_I73_p1 XI1_I73_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I73_MP0 (VDD A_13 XI1_I73_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2115_MP1 (VDD I1_nqkn13 XI1_I2115_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2115_MP5 (DIVQ_13 I1_nqkn13 XI1_I2115_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2115_MP4 (XI1_I2115_p1 XI1_I2115_An DIVQ_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2115_MP2 (VDD I1_qu13_b3_5 XI1_I2115_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2115_MP3 (XI1_I2115_p1 XI1_I2115_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2115_MP0 (VDD I1_qu13_b3_5 XI1_I2115_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I246_MP1 (VDD I1_nbkn10 XI1_I246_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I246_MP5 (I1_dd10 I1_nbkn10 XI1_I246_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I246_MP4 (XI1_I246_p1 XI1_I246_An I1_dd10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I246_MP2 (VDD B_10 XI1_I246_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I246_MP3 (XI1_I246_p1 XI1_I246_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I246_MP0 (VDD B_10 XI1_I246_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I259_MP1 (VDD I1_nbkn11 XI1_I259_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I259_MP5 (I1_dd11 I1_nbkn11 XI1_I259_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I259_MP4 (XI1_I259_p1 XI1_I259_An I1_dd11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I259_MP2 (VDD B_11 XI1_I259_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I259_MP3 (XI1_I259_p1 XI1_I259_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I259_MP0 (VDD B_11 XI1_I259_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I82_MP1 (VDD I1_nakn16 XI1_I82_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I82_MP5 (I1_aa16 I1_nakn16 XI1_I82_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I82_MP4 (XI1_I82_p1 XI1_I82_An I1_aa16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I82_MP2 (VDD A_16 XI1_I82_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I82_MP3 (XI1_I82_p1 XI1_I82_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I82_MP0 (VDD A_16 XI1_I82_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I272_MP1 (VDD I1_nbkn12 XI1_I272_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I272_MP5 (I1_dd12 I1_nbkn12 XI1_I272_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I272_MP4 (XI1_I272_p1 XI1_I272_An I1_dd12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I272_MP2 (VDD B_12 XI1_I272_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I272_MP3 (XI1_I272_p1 XI1_I272_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I272_MP0 (VDD B_12 XI1_I272_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I168_MP1 (VDD I1_nbkn4 XI1_I168_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I168_MP5 (I1_dd4 I1_nbkn4 XI1_I168_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I168_MP4 (XI1_I168_p1 XI1_I168_An I1_dd4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I168_MP2 (VDD B_4 XI1_I168_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I168_MP3 (XI1_I168_p1 XI1_I168_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I168_MP0 (VDD B_4 XI1_I168_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I285_MP1 (VDD I1_nbkn13 XI1_I285_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I285_MP5 (I1_dd13 I1_nbkn13 XI1_I285_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I285_MP4 (XI1_I285_p1 XI1_I285_An I1_dd13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I285_MP2 (VDD B_13 XI1_I285_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I285_MP3 (XI1_I285_p1 XI1_I285_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I285_MP0 (VDD B_13 XI1_I285_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I298_MP1 (VDD I1_nbkn14 XI1_I298_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I298_MP5 (I1_dd14 I1_nbkn14 XI1_I298_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I298_MP4 (XI1_I298_p1 XI1_I298_An I1_dd14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I298_MP2 (VDD B_14 XI1_I298_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I298_MP3 (XI1_I298_p1 XI1_I298_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I298_MP0 (VDD B_14 XI1_I298_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I311_MP1 (VDD I1_nbkn15 XI1_I311_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I311_MP5 (I1_dd15 I1_nbkn15 XI1_I311_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I311_MP4 (XI1_I311_p1 XI1_I311_An I1_dd15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I311_MP2 (VDD B_15 XI1_I311_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I311_MP3 (XI1_I311_p1 XI1_I311_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I311_MP0 (VDD B_15 XI1_I311_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I324_MP1 (VDD I1_nbkn16 XI1_I324_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I324_MP5 (I1_dd16 I1_nbkn16 XI1_I324_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I324_MP4 (XI1_I324_p1 XI1_I324_An I1_dd16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I324_MP2 (VDD B_16 XI1_I324_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I324_MP3 (XI1_I324_p1 XI1_I324_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I324_MP0 (VDD B_16 XI1_I324_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I350_MP1 (VDD I1_nbkn18 XI1_I350_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I350_MP5 (I1_dd18 I1_nbkn18 XI1_I350_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I350_MP4 (XI1_I350_p1 XI1_I350_An I1_dd18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I350_MP2 (VDD B_18 XI1_I350_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I350_MP3 (XI1_I350_p1 XI1_I350_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I350_MP0 (VDD B_18 XI1_I350_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I363_MP1 (VDD I1_nbkn19 XI1_I363_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I363_MP5 (I1_dd19 I1_nbkn19 XI1_I363_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I363_MP4 (XI1_I363_p1 XI1_I363_An I1_dd19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I363_MP2 (VDD B_19 XI1_I363_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I363_MP3 (XI1_I363_p1 XI1_I363_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I363_MP0 (VDD B_19 XI1_I363_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I415_MP1 (VDD I1_nbkn23 XI1_I415_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I415_MP5 (I1_dd23 I1_nbkn23 XI1_I415_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I415_MP4 (XI1_I415_p1 XI1_I415_An I1_dd23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I415_MP2 (VDD B_23 XI1_I415_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I415_MP3 (XI1_I415_p1 XI1_I415_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I415_MP0 (VDD B_23 XI1_I415_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I454_MP1 (VDD I1_nbkn26 XI1_I454_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I454_MP5 (I1_dd26 I1_nbkn26 XI1_I454_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I454_MP4 (XI1_I454_p1 XI1_I454_An I1_dd26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I454_MP2 (VDD B_26 XI1_I454_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I454_MP3 (XI1_I454_p1 XI1_I454_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I454_MP0 (VDD B_26 XI1_I454_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I467_MP1 (VDD I1_nbkn27 XI1_I467_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I467_MP5 (I1_dd27 I1_nbkn27 XI1_I467_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I467_MP4 (XI1_I467_p1 XI1_I467_An I1_dd27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I467_MP2 (VDD B_27 XI1_I467_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I467_MP3 (XI1_I467_p1 XI1_I467_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I467_MP0 (VDD B_27 XI1_I467_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I38_MP1 (VDD I1_b0_6 XI1_I562_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I38_MP5 (I1_I562_pn6 I1_b0_6 XI1_I562_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I38_MP4 (XI1_I562_I38_p1 XI1_I562_I38_An I1_I562_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I38_MP2 (VDD VSS XI1_I562_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I38_MP3 (XI1_I562_I38_p1 XI1_I562_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I38_MP0 (VDD VSS XI1_I562_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I40_MP1 (VDD I1_b0_8 XI1_I562_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I40_MP5 (I1_I562_pn8 I1_b0_8 XI1_I562_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I40_MP4 (XI1_I562_I40_p1 XI1_I562_I40_An I1_I562_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I40_MP2 (VDD VSS XI1_I562_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I40_MP3 (XI1_I562_I40_p1 XI1_I562_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I40_MP0 (VDD VSS XI1_I562_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I42_MP1 (VDD I1_b0_10 XI1_I562_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I42_MP5 (I1_I562_pn10 I1_b0_10 XI1_I562_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I42_MP4 (XI1_I562_I42_p1 XI1_I562_I42_An I1_I562_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I42_MP2 (VDD VSS XI1_I562_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I42_MP3 (XI1_I562_I42_p1 XI1_I562_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I42_MP0 (VDD VSS XI1_I562_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I55_MP1 (VDD I1_b0_23 XI1_I562_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I55_MP5 (I1_I562_pn23 I1_b0_23 XI1_I562_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I55_MP4 (XI1_I562_I55_p1 XI1_I562_I55_An I1_I562_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I55_MP2 (VDD VSS XI1_I562_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I55_MP3 (XI1_I562_I55_p1 XI1_I562_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I55_MP0 (VDD VSS XI1_I562_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I62_MP1 (VDD I1_b0_30 XI1_I562_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I62_MP5 (I1_I562_pn30 I1_b0_30 XI1_I562_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I62_MP4 (XI1_I562_I62_p1 XI1_I562_I62_An I1_I562_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I62_MP2 (VDD VSS XI1_I562_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I62_MP3 (XI1_I562_I62_p1 XI1_I562_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I62_MP0 (VDD VSS XI1_I562_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I63_MP1 (VDD I1_b21_31 XI1_I1528_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I63_MP5 (I1_I1528_pn31 I1_b21_31 XI1_I1528_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I63_MP4 (XI1_I1528_I63_p1 XI1_I1528_I63_An I1_I1528_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I63_MP2 (VDD I1_p20_30 XI1_I1528_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I63_MP3 (XI1_I1528_I63_p1 XI1_I1528_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I63_MP0 (VDD I1_p20_30 XI1_I1528_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I234_MP1 (VDD I1_c21_m XI1_I1528_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I234_MP5 (I1_p21_31 I1_c21_m XI1_I1528_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I234_MP4 (XI1_I1528_I234_p1 XI1_I1528_I234_An I1_p21_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I234_MP2 (VDD I1_I1528_pn31 XI1_I1528_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I234_MP3 (XI1_I1528_I234_p1 XI1_I1528_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I234_MP0 (VDD I1_I1528_pn31 XI1_I1528_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I232_MP1 (VDD I1_I1528_G28_0 XI1_I1528_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I232_MP5 (I1_p21_29 I1_I1528_G28_0 XI1_I1528_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I232_MP4 (XI1_I1528_I232_p1 XI1_I1528_I232_An I1_p21_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I232_MP2 (VDD I1_I1528_pn29 XI1_I1528_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I232_MP3 (XI1_I1528_I232_p1 XI1_I1528_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I232_MP0 (VDD I1_I1528_pn29 XI1_I1528_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I228_MP1 (VDD I1_I1528_G24_0 XI1_I1528_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I228_MP5 (I1_p21_25 I1_I1528_G24_0 XI1_I1528_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I228_MP4 (XI1_I1528_I228_p1 XI1_I1528_I228_An I1_p21_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I228_MP2 (VDD I1_I1528_pn25 XI1_I1528_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I228_MP3 (XI1_I1528_I228_p1 XI1_I1528_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I228_MP0 (VDD I1_I1528_pn25 XI1_I1528_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I211_MP1 (VDD I1_I1528_G7_0 XI1_I1528_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I211_MP5 (I1_p21_8 I1_I1528_G7_0 XI1_I1528_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I211_MP4 (XI1_I1528_I211_p1 XI1_I1528_I211_An I1_p21_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I211_MP2 (VDD I1_I1528_pn8 XI1_I1528_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I211_MP3 (XI1_I1528_I211_p1 XI1_I1528_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I211_MP0 (VDD I1_I1528_pn8 XI1_I1528_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I209_MP1 (VDD I1_I1528_G5_0 XI1_I1528_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I209_MP5 (I1_p21_6 I1_I1528_G5_0 XI1_I1528_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I209_MP4 (XI1_I1528_I209_p1 XI1_I1528_I209_An I1_p21_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I209_MP2 (VDD I1_I1528_pn6 XI1_I1528_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I209_MP3 (XI1_I1528_I209_p1 XI1_I1528_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I209_MP0 (VDD I1_I1528_pn6 XI1_I1528_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I220_MP1 (VDD I1_I1528_G16_0 XI1_I1528_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I220_MP5 (I1_p21_17 I1_I1528_G16_0 XI1_I1528_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I220_MP4 (XI1_I1528_I220_p1 XI1_I1528_I220_An I1_p21_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I220_MP2 (VDD I1_I1528_pn17 XI1_I1528_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I220_MP3 (XI1_I1528_I220_p1 XI1_I1528_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I220_MP0 (VDD I1_I1528_pn17 XI1_I1528_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I41_MP1 (VDD I1_b22_9 XI1_I1574_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I41_MP5 (I1_I1574_pn9 I1_b22_9 XI1_I1574_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I41_MP4 (XI1_I1574_I41_p1 XI1_I1574_I41_An I1_I1574_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I41_MP2 (VDD I1_p21_8 XI1_I1574_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I41_MP3 (XI1_I1574_I41_p1 XI1_I1574_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I41_MP0 (VDD I1_p21_8 XI1_I1574_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I38_MP1 (VDD I1_b22_6 XI1_I1574_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I38_MP5 (I1_I1574_pn6 I1_b22_6 XI1_I1574_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I38_MP4 (XI1_I1574_I38_p1 XI1_I1574_I38_An I1_I1574_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I38_MP2 (VDD I1_p21_5 XI1_I1574_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I38_MP3 (XI1_I1574_I38_p1 XI1_I1574_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I38_MP0 (VDD I1_p21_5 XI1_I1574_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I70_MP1 (VDD I1_nakn12 XI1_I70_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I70_MP5 (I1_aa12 I1_nakn12 XI1_I70_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I70_MP4 (XI1_I70_p1 XI1_I70_An I1_aa12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I70_MP2 (VDD A_12 XI1_I70_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I70_MP3 (XI1_I70_p1 XI1_I70_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I70_MP0 (VDD A_12 XI1_I70_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I220_MP1 (VDD I1_nbkn8 XI1_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I220_MP5 (I1_dd8 I1_nbkn8 XI1_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I220_MP4 (XI1_I220_p1 XI1_I220_An I1_dd8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I220_MP2 (VDD B_8 XI1_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I220_MP3 (XI1_I220_p1 XI1_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I220_MP0 (VDD B_8 XI1_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I181_MP1 (VDD I1_nbkn5 XI1_I181_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I181_MP5 (I1_dd5 I1_nbkn5 XI1_I181_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I181_MP4 (XI1_I181_p1 XI1_I181_An I1_dd5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I181_MP2 (VDD B_5 XI1_I181_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I181_MP3 (XI1_I181_p1 XI1_I181_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I181_MP0 (VDD B_5 XI1_I181_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I155_MP1 (VDD I1_nbkn3 XI1_I155_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I155_MP5 (I1_dd3 I1_nbkn3 XI1_I155_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I155_MP4 (XI1_I155_p1 XI1_I155_An I1_dd3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I155_MP2 (VDD B_3 XI1_I155_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I155_MP3 (XI1_I155_p1 XI1_I155_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I155_MP0 (VDD B_3 XI1_I155_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I142_MP1 (VDD I1_nbkn2 XI1_I142_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I142_MP5 (I1_dd2 I1_nbkn2 XI1_I142_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I142_MP4 (XI1_I142_p1 XI1_I142_An I1_dd2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I142_MP2 (VDD B_2 XI1_I142_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I142_MP3 (XI1_I142_p1 XI1_I142_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I142_MP0 (VDD B_2 XI1_I142_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I129_MP1 (VDD I1_nbkn1 XI1_I129_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I129_MP5 (I1_dd1 I1_nbkn1 XI1_I129_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I129_MP4 (XI1_I129_p1 XI1_I129_An I1_dd1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I129_MP2 (VDD B_1 XI1_I129_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I129_MP3 (XI1_I129_p1 XI1_I129_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I129_MP0 (VDD B_1 XI1_I129_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I48_MP1 (VDD I2_I1_bx16 XI2_I1_I42_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I48_MP5 (I2_I1_I42_pn16 I2_I1_bx16 XI2_I1_I42_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I48_MP4 (XI2_I1_I42_I48_p1 XI2_I1_I42_I48_An I2_I1_I42_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I48_MP2 (VDD A_16 XI2_I1_I42_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I48_MP3 (XI2_I1_I42_I48_p1 XI2_I1_I42_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I48_MP0 (VDD A_16 XI2_I1_I42_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I337_MP1 (VDD I1_nbkn17 XI1_I337_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I337_MP5 (I1_dd17 I1_nbkn17 XI1_I337_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I337_MP4 (XI1_I337_p1 XI1_I337_An I1_dd17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I337_MP2 (VDD B_17 XI1_I337_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I337_MP3 (XI1_I337_p1 XI1_I337_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I337_MP0 (VDD B_17 XI1_I337_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I49_MP1 (VDD I2_I1_bx17 XI2_I1_I42_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I49_MP5 (I2_I1_I42_pn17 I2_I1_bx17 XI2_I1_I42_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I49_MP4 (XI2_I1_I42_I49_p1 XI2_I1_I42_I49_An I2_I1_I42_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I49_MP2 (VDD A_17 XI2_I1_I42_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I49_MP3 (XI2_I1_I42_I49_p1 XI2_I1_I42_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I49_MP0 (VDD A_17 XI2_I1_I42_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I223_MP1 (VDD I2_I1_I42_G19_0 XI2_I1_I42_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I223_MP5 (I2_S_20 I2_I1_I42_G19_0 XI2_I1_I42_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I223_MP4 (XI2_I1_I42_I223_p1 XI2_I1_I42_I223_An I2_S_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I223_MP2 (VDD I2_I1_I42_pn20 XI2_I1_I42_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I223_MP3 (XI2_I1_I42_I223_p1 XI2_I1_I42_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I223_MP0 (VDD I2_I1_I42_pn20 XI2_I1_I42_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I52_MP1 (VDD I2_I1_bx20 XI2_I1_I42_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I52_MP5 (I2_I1_I42_pn20 I2_I1_bx20 XI2_I1_I42_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I52_MP4 (XI2_I1_I42_I52_p1 XI2_I1_I42_I52_An I2_I1_I42_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I52_MP2 (VDD A_20 XI2_I1_I42_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I52_MP3 (XI2_I1_I42_I52_p1 XI2_I1_I42_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I52_MP0 (VDD A_20 XI2_I1_I42_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I428_MP1 (VDD I1_nbkn24 XI1_I428_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I428_MP5 (I1_dd24 I1_nbkn24 XI1_I428_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I428_MP4 (XI1_I428_p1 XI1_I428_An I1_dd24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I428_MP2 (VDD B_24 XI1_I428_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I428_MP3 (XI1_I428_p1 XI1_I428_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I428_MP0 (VDD B_24 XI1_I428_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I441_MP1 (VDD I1_nbkn25 XI1_I441_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I441_MP5 (I1_dd25 I1_nbkn25 XI1_I441_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I441_MP4 (XI1_I441_p1 XI1_I441_An I1_dd25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I441_MP2 (VDD B_25 XI1_I441_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I441_MP3 (XI1_I441_p1 XI1_I441_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I441_MP0 (VDD B_25 XI1_I441_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I209_MP1 (VDD I1_I562_G5_0 XI1_I562_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I209_MP5 (I1_p0_6 I1_I562_G5_0 XI1_I562_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I209_MP4 (XI1_I562_I209_p1 XI1_I562_I209_An I1_p0_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I209_MP2 (VDD I1_I562_pn6 XI1_I562_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I209_MP3 (XI1_I562_I209_p1 XI1_I562_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I209_MP0 (VDD I1_I562_pn6 XI1_I562_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I211_MP1 (VDD I1_I562_G7_0 XI1_I562_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I211_MP5 (I1_p0_8 I1_I562_G7_0 XI1_I562_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I211_MP4 (XI1_I562_I211_p1 XI1_I562_I211_An I1_p0_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I211_MP2 (VDD I1_I562_pn8 XI1_I562_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I211_MP3 (XI1_I562_I211_p1 XI1_I562_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I211_MP0 (VDD I1_I562_pn8 XI1_I562_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I44_MP1 (VDD I1_b0_12 XI1_I562_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I44_MP5 (I1_I562_pn12 I1_b0_12 XI1_I562_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I44_MP4 (XI1_I562_I44_p1 XI1_I562_I44_An I1_I562_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I44_MP2 (VDD VSS XI1_I562_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I44_MP3 (XI1_I562_I44_p1 XI1_I562_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I44_MP0 (VDD VSS XI1_I562_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I46_MP1 (VDD I1_b0_14 XI1_I562_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I46_MP5 (I1_I562_pn14 I1_b0_14 XI1_I562_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I46_MP4 (XI1_I562_I46_p1 XI1_I562_I46_An I1_I562_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I46_MP2 (VDD VSS XI1_I562_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I46_MP3 (XI1_I562_I46_p1 XI1_I562_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I46_MP0 (VDD VSS XI1_I562_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I48_MP1 (VDD I1_b0_16 XI1_I562_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I48_MP5 (I1_I562_pn16 I1_b0_16 XI1_I562_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I48_MP4 (XI1_I562_I48_p1 XI1_I562_I48_An I1_I562_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I48_MP2 (VDD VSS XI1_I562_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I48_MP3 (XI1_I562_I48_p1 XI1_I562_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I48_MP0 (VDD VSS XI1_I562_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I50_MP1 (VDD I1_b0_18 XI1_I562_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I50_MP5 (I1_I562_pn18 I1_b0_18 XI1_I562_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I50_MP4 (XI1_I562_I50_p1 XI1_I562_I50_An I1_I562_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I50_MP2 (VDD VSS XI1_I562_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I50_MP3 (XI1_I562_I50_p1 XI1_I562_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I50_MP0 (VDD VSS XI1_I562_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I223_MP1 (VDD I1_I562_G19_0 XI1_I562_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I223_MP5 (I1_p0_20 I1_I562_G19_0 XI1_I562_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I223_MP4 (XI1_I562_I223_p1 XI1_I562_I223_An I1_p0_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I223_MP2 (VDD I1_I562_pn20 XI1_I562_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I223_MP3 (XI1_I562_I223_p1 XI1_I562_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I223_MP0 (VDD I1_I562_pn20 XI1_I562_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I52_MP1 (VDD I1_b0_20 XI1_I562_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I52_MP5 (I1_I562_pn20 I1_b0_20 XI1_I562_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I52_MP4 (XI1_I562_I52_p1 XI1_I562_I52_An I1_I562_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I52_MP2 (VDD VSS XI1_I562_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I52_MP3 (XI1_I562_I52_p1 XI1_I562_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I52_MP0 (VDD VSS XI1_I562_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I54_MP1 (VDD I1_b0_22 XI1_I562_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I54_MP5 (I1_I562_pn22 I1_b0_22 XI1_I562_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I54_MP4 (XI1_I562_I54_p1 XI1_I562_I54_An I1_I562_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I54_MP2 (VDD VSS XI1_I562_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I54_MP3 (XI1_I562_I54_p1 XI1_I562_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I54_MP0 (VDD VSS XI1_I562_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I229_MP1 (VDD I1_I562_G25_0 XI1_I562_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I229_MP5 (I1_p0_26 I1_I562_G25_0 XI1_I562_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I229_MP4 (XI1_I562_I229_p1 XI1_I562_I229_An I1_p0_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I229_MP2 (VDD I1_I562_pn26 XI1_I562_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I229_MP3 (XI1_I562_I229_p1 XI1_I562_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I229_MP0 (VDD I1_I562_pn26 XI1_I562_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I60_MP1 (VDD I1_b0_28 XI1_I562_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I60_MP5 (I1_I562_pn28 I1_b0_28 XI1_I562_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I60_MP4 (XI1_I562_I60_p1 XI1_I562_I60_An I1_I562_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I60_MP2 (VDD VSS XI1_I562_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I60_MP3 (XI1_I562_I60_p1 XI1_I562_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I60_MP0 (VDD VSS XI1_I562_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I231_MP1 (VDD I1_I562_G27_0 XI1_I562_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I231_MP5 (I1_p0_28 I1_I562_G27_0 XI1_I562_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I231_MP4 (XI1_I562_I231_p1 XI1_I562_I231_An I1_p0_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I231_MP2 (VDD I1_I562_pn28 XI1_I562_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I231_MP3 (XI1_I562_I231_p1 XI1_I562_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I231_MP0 (VDD I1_I562_pn28 XI1_I562_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I231_MP1 (VDD I1_I1712_G27_0 XI1_I1712_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I231_MP5 (I1_p25_28 I1_I1712_G27_0 XI1_I1712_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I231_MP4 (XI1_I1712_I231_p1 XI1_I1712_I231_An I1_p25_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I231_MP2 (VDD I1_I1712_pn28 XI1_I1712_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I231_MP3 (XI1_I1712_I231_p1 XI1_I1712_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I231_MP0 (VDD I1_I1712_pn28 XI1_I1712_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I229_MP1 (VDD I1_I1528_G25_0 XI1_I1528_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I229_MP5 (I1_p21_26 I1_I1528_G25_0 XI1_I1528_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I229_MP4 (XI1_I1528_I229_p1 XI1_I1528_I229_An I1_p21_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I229_MP2 (VDD I1_I1528_pn26 XI1_I1528_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I229_MP3 (XI1_I1528_I229_p1 XI1_I1528_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I229_MP0 (VDD I1_I1528_pn26 XI1_I1528_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I221_MP1 (VDD I1_I1528_G17_0 XI1_I1528_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I221_MP5 (I1_p21_18 I1_I1528_G17_0 XI1_I1528_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I221_MP4 (XI1_I1528_I221_p1 XI1_I1528_I221_An I1_p21_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I221_MP2 (VDD I1_I1528_pn18 XI1_I1528_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I221_MP3 (XI1_I1528_I221_p1 XI1_I1528_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I221_MP0 (VDD I1_I1528_pn18 XI1_I1528_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I46_MP1 (VDD I1_b22_14 XI1_I1574_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I46_MP5 (I1_I1574_pn14 I1_b22_14 XI1_I1574_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I46_MP4 (XI1_I1574_I46_p1 XI1_I1574_I46_An I1_I1574_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I46_MP2 (VDD I1_p21_13 XI1_I1574_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I46_MP3 (XI1_I1574_I46_p1 XI1_I1574_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I46_MP0 (VDD I1_p21_13 XI1_I1574_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I45_MP1 (VDD I1_b22_13 XI1_I1574_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I45_MP5 (I1_I1574_pn13 I1_b22_13 XI1_I1574_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I45_MP4 (XI1_I1574_I45_p1 XI1_I1574_I45_An I1_I1574_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I45_MP2 (VDD I1_p21_12 XI1_I1574_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I45_MP3 (XI1_I1574_I45_p1 XI1_I1574_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I45_MP0 (VDD I1_p21_12 XI1_I1574_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I211_MP1 (VDD I1_I1574_G7_0 XI1_I1574_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I211_MP5 (I1_p22_8 I1_I1574_G7_0 XI1_I1574_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I211_MP4 (XI1_I1574_I211_p1 XI1_I1574_I211_An I1_p22_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I211_MP2 (VDD I1_I1574_pn8 XI1_I1574_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I211_MP3 (XI1_I1574_I211_p1 XI1_I1574_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I211_MP0 (VDD I1_I1574_pn8 XI1_I1574_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I37_MP1 (VDD I1_b22_5 XI1_I1574_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I37_MP5 (I1_I1574_pn5 I1_b22_5 XI1_I1574_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I37_MP4 (XI1_I1574_I37_p1 XI1_I1574_I37_An I1_I1574_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I37_MP2 (VDD I1_p21_4 XI1_I1574_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I37_MP3 (XI1_I1574_I37_p1 XI1_I1574_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I37_MP0 (VDD I1_p21_4 XI1_I1574_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I67_MP1 (VDD I1_nakn11 XI1_I67_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I67_MP5 (I1_aa11 I1_nakn11 XI1_I67_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I67_MP4 (XI1_I67_p1 XI1_I67_An I1_aa11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I67_MP2 (VDD A_11 XI1_I67_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I67_MP3 (XI1_I67_p1 XI1_I67_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I67_MP0 (VDD A_11 XI1_I67_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2112_MP1 (VDD I1_nqkn12 XI1_I2112_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2112_MP5 (DIVQ_12 I1_nqkn12 XI1_I2112_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2112_MP4 (XI1_I2112_p1 XI1_I2112_An DIVQ_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2112_MP2 (VDD I1_qu12_b3_5 XI1_I2112_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2112_MP3 (XI1_I2112_p1 XI1_I2112_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2112_MP0 (VDD I1_qu12_b3_5 XI1_I2112_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2109_MP1 (VDD I1_nqkn11 XI1_I2109_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2109_MP5 (DIVQ_11 I1_nqkn11 XI1_I2109_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2109_MP4 (XI1_I2109_p1 XI1_I2109_An DIVQ_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2109_MP2 (VDD I1_qu11_b3_5 XI1_I2109_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2109_MP3 (XI1_I2109_p1 XI1_I2109_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2109_MP0 (VDD I1_qu11_b3_5 XI1_I2109_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I233_MP1 (VDD I1_nbkn9 XI1_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I233_MP5 (I1_dd9 I1_nbkn9 XI1_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I233_MP4 (XI1_I233_p1 XI1_I233_An I1_dd9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I233_MP2 (VDD B_9 XI1_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I233_MP3 (XI1_I233_p1 XI1_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I233_MP0 (VDD B_9 XI1_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I207_MP1 (VDD I1_nbkn7 XI1_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I207_MP5 (I1_dd7 I1_nbkn7 XI1_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I207_MP4 (XI1_I207_p1 XI1_I207_An I1_dd7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I207_MP2 (VDD B_7 XI1_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I207_MP3 (XI1_I207_p1 XI1_I207_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I207_MP0 (VDD B_7 XI1_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I47_MP1 (VDD I2_I1_bx15 XI2_I1_I42_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I47_MP5 (I2_I1_I42_pn15 I2_I1_bx15 XI2_I1_I42_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I47_MP4 (XI2_I1_I42_I47_p1 XI2_I1_I42_I47_An I2_I1_I42_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I47_MP2 (VDD A_15 XI2_I1_I42_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I47_MP3 (XI2_I1_I42_I47_p1 XI2_I1_I42_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I47_MP0 (VDD A_15 XI2_I1_I42_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I220_MP1 (VDD I2_I1_I42_G16_0 XI2_I1_I42_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I220_MP5 (I2_S_17 I2_I1_I42_G16_0 XI2_I1_I42_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I220_MP4 (XI2_I1_I42_I220_p1 XI2_I1_I42_I220_An I2_S_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I220_MP2 (VDD I2_I1_I42_pn17 XI2_I1_I42_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I220_MP3 (XI2_I1_I42_I220_p1 XI2_I1_I42_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I220_MP0 (VDD I2_I1_I42_pn17 XI2_I1_I42_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I221_MP1 (VDD I2_I1_I42_G17_0 XI2_I1_I42_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I221_MP5 (I2_S_18 I2_I1_I42_G17_0 XI2_I1_I42_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I221_MP4 (XI2_I1_I42_I221_p1 XI2_I1_I42_I221_An I2_S_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I221_MP2 (VDD I2_I1_I42_pn18 XI2_I1_I42_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I221_MP3 (XI2_I1_I42_I221_p1 XI2_I1_I42_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I221_MP0 (VDD I2_I1_I42_pn18 XI2_I1_I42_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I50_MP1 (VDD I2_I1_bx18 XI2_I1_I42_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I50_MP5 (I2_I1_I42_pn18 I2_I1_bx18 XI2_I1_I42_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I50_MP4 (XI2_I1_I42_I50_p1 XI2_I1_I42_I50_An I2_I1_I42_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I50_MP2 (VDD A_18 XI2_I1_I42_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I50_MP3 (XI2_I1_I42_I50_p1 XI2_I1_I42_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I50_MP0 (VDD A_18 XI2_I1_I42_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I51_MP1 (VDD I2_I1_bx19 XI2_I1_I42_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I51_MP5 (I2_I1_I42_pn19 I2_I1_bx19 XI2_I1_I42_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I51_MP4 (XI2_I1_I42_I51_p1 XI2_I1_I42_I51_An I2_I1_I42_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I51_MP2 (VDD A_19 XI2_I1_I42_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I51_MP3 (XI2_I1_I42_I51_p1 XI2_I1_I42_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I51_MP0 (VDD A_19 XI2_I1_I42_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I224_MP1 (VDD I2_I1_I42_G20_0 XI2_I1_I42_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I224_MP5 (I2_S_21 I2_I1_I42_G20_0 XI2_I1_I42_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I224_MP4 (XI2_I1_I42_I224_p1 XI2_I1_I42_I224_An I2_S_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I224_MP2 (VDD I2_I1_I42_pn21 XI2_I1_I42_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I224_MP3 (XI2_I1_I42_I224_p1 XI2_I1_I42_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I224_MP0 (VDD I2_I1_I42_pn21 XI2_I1_I42_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I53_MP1 (VDD I2_I1_bx21 XI2_I1_I42_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I53_MP5 (I2_I1_I42_pn21 I2_I1_bx21 XI2_I1_I42_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I53_MP4 (XI2_I1_I42_I53_p1 XI2_I1_I42_I53_An I2_I1_I42_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I53_MP2 (VDD A_21 XI2_I1_I42_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I53_MP3 (XI2_I1_I42_I53_p1 XI2_I1_I42_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I53_MP0 (VDD A_21 XI2_I1_I42_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I226_MP1 (VDD I2_I1_I42_G22_0 XI2_I1_I42_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I226_MP5 (I2_S_23 I2_I1_I42_G22_0 XI2_I1_I42_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I226_MP4 (XI2_I1_I42_I226_p1 XI2_I1_I42_I226_An I2_S_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I226_MP2 (VDD I2_I1_I42_pn23 XI2_I1_I42_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I226_MP3 (XI2_I1_I42_I226_p1 XI2_I1_I42_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I226_MP0 (VDD I2_I1_I42_pn23 XI2_I1_I42_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I55_MP1 (VDD I2_I1_bx23 XI2_I1_I42_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I55_MP5 (I2_I1_I42_pn23 I2_I1_bx23 XI2_I1_I42_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I55_MP4 (XI2_I1_I42_I55_p1 XI2_I1_I42_I55_An I2_I1_I42_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I55_MP2 (VDD A_23 XI2_I1_I42_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I55_MP3 (XI2_I1_I42_I55_p1 XI2_I1_I42_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I55_MP0 (VDD A_23 XI2_I1_I42_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I221_MP1 (VDD I1_I562_G17_0 XI1_I562_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I221_MP5 (I1_p0_18 I1_I562_G17_0 XI1_I562_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I221_MP4 (XI1_I562_I221_p1 XI1_I562_I221_An I1_p0_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I221_MP2 (VDD I1_I562_pn18 XI1_I562_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I221_MP3 (XI1_I562_I221_p1 XI1_I562_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I221_MP0 (VDD I1_I562_pn18 XI1_I562_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I225_MP1 (VDD I1_I562_G21_0 XI1_I562_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I225_MP5 (I1_p0_22 I1_I562_G21_0 XI1_I562_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I225_MP4 (XI1_I562_I225_p1 XI1_I562_I225_An I1_p0_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I225_MP2 (VDD I1_I562_pn22 XI1_I562_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I225_MP3 (XI1_I562_I225_p1 XI1_I562_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I225_MP0 (VDD I1_I562_pn22 XI1_I562_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I58_MP1 (VDD I1_b0_26 XI1_I562_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I58_MP5 (I1_I562_pn26 I1_b0_26 XI1_I562_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I58_MP4 (XI1_I562_I58_p1 XI1_I562_I58_An I1_I562_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I58_MP2 (VDD VSS XI1_I562_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I58_MP3 (XI1_I562_I58_p1 XI1_I562_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I58_MP0 (VDD VSS XI1_I562_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I227_MP1 (VDD I1_I1528_G23_0 XI1_I1528_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I227_MP5 (I1_p21_24 I1_I1528_G23_0 XI1_I1528_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I227_MP4 (XI1_I1528_I227_p1 XI1_I1528_I227_An I1_p21_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I227_MP2 (VDD I1_I1528_pn24 XI1_I1528_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I227_MP3 (XI1_I1528_I227_p1 XI1_I1528_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I227_MP0 (VDD I1_I1528_pn24 XI1_I1528_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I231_MP1 (VDD I1_I1528_G27_0 XI1_I1528_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I231_MP5 (I1_p21_28 I1_I1528_G27_0 XI1_I1528_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I231_MP4 (XI1_I1528_I231_p1 XI1_I1528_I231_An I1_p21_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I231_MP2 (VDD I1_I1528_pn28 XI1_I1528_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I231_MP3 (XI1_I1528_I231_p1 XI1_I1528_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I231_MP0 (VDD I1_I1528_pn28 XI1_I1528_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I223_MP1 (VDD I1_I1528_G19_0 XI1_I1528_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I223_MP5 (I1_p21_20 I1_I1528_G19_0 XI1_I1528_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I223_MP4 (XI1_I1528_I223_p1 XI1_I1528_I223_An I1_p21_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I223_MP2 (VDD I1_I1528_pn20 XI1_I1528_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I223_MP3 (XI1_I1528_I223_p1 XI1_I1528_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I223_MP0 (VDD I1_I1528_pn20 XI1_I1528_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I36_MP1 (VDD I1_b22_4 XI1_I1574_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I36_MP5 (I1_I1574_pn4 I1_b22_4 XI1_I1574_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I36_MP4 (XI1_I1574_I36_p1 XI1_I1574_I36_An I1_I1574_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I36_MP2 (VDD I1_p21_3 XI1_I1574_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I36_MP3 (XI1_I1574_I36_p1 XI1_I1574_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I36_MP0 (VDD I1_p21_3 XI1_I1574_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I35_MP1 (VDD I1_b22_3 XI1_I1574_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I35_MP5 (I1_I1574_pn3 I1_b22_3 XI1_I1574_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I35_MP4 (XI1_I1574_I35_p1 XI1_I1574_I35_An I1_I1574_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I35_MP2 (VDD I1_p21_2 XI1_I1574_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I35_MP3 (XI1_I1574_I35_p1 XI1_I1574_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I35_MP0 (VDD I1_p21_2 XI1_I1574_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I194_MP1 (VDD I1_nbkn6 XI1_I194_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I194_MP5 (I1_dd6 I1_nbkn6 XI1_I194_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I194_MP4 (XI1_I194_p1 XI1_I194_An I1_dd6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I194_MP2 (VDD B_6 XI1_I194_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I194_MP3 (XI1_I194_p1 XI1_I194_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I194_MP0 (VDD B_6 XI1_I194_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I46_MP1 (VDD I2_I1_bx14 XI2_I1_I42_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I46_MP5 (I2_I1_I42_pn14 I2_I1_bx14 XI2_I1_I42_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I46_MP4 (XI2_I1_I42_I46_p1 XI2_I1_I42_I46_An I2_I1_I42_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I46_MP2 (VDD A_14 XI2_I1_I42_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I46_MP3 (XI2_I1_I42_I46_p1 XI2_I1_I42_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I46_MP0 (VDD A_14 XI2_I1_I42_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
