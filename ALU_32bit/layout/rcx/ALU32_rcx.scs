    I_MXI0_I1660_I361_XP_MP0 (VDD I0_I1660_P50_43 I0_I1660_P50_35n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I371_XP_MP1 (I0_I1660_P60_45n I0_I1660_P52_45 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I371_XP_MP0 (VDD I0_I1660_P60_53 I0_I1660_P60_45n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I240_XP_MP1 (I0_I1660_P48_45n I0_I1660_P46_45 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I240_XP_MP0 (VDD I0_I1660_P48_47 I0_I1660_P48_45n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I238_XP_MP1 (I0_I1660_P46_43n I0_I1660_P44_43 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I238_XP_MP0 (VDD I0_I1660_P46_45 I0_I1660_P46_43n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I372_XP_MP1 (I0_I1660_P61_46n I0_I1660_P53_46 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I372_XP_MP0 (VDD I0_I1660_P61_54 I0_I1660_P61_46n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I243_XP_MP1 (I0_I1660_P51_48n I0_I1660_P49_48 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I243_XP_MP0 (VDD I0_I1660_P51_50 I0_I1660_P51_48n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I48_MP1 (I0_I1660_gn48 I0_ha292_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I48_MP0 (VDD I0_fa291_1 I0_I1660_gn48 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I178_XP_MP1 (I1_I1850_P27_12n I1_I1850_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I178_XP_MP0 (VDD I1_I1850_P27_20 I1_I1850_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I119_XP_MP1 (I1_I1850_P23_20n I1_I1850_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I119_XP_MP0 (VDD I1_I1850_P23_22 I1_I1850_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I180_XP_MP1 (I1_I1850_P29_14n I1_I1850_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I180_XP_MP0 (VDD I1_I1850_P29_22 I1_I1850_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I20_MP1 (I1_I1850_gn20 I1_b28_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I20_MP0 (VDD I1_p27_19 I1_I1850_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I116_XP_MP1 (I1_I1850_P20_17n I1_I1850_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I116_XP_MP0 (VDD I1_I1850_P20_19 I1_I1850_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I171_XP_MP1 (I1_I1850_P20_5n I1_I1850_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I171_XP_MP0 (VDD I1_I1850_P20_13 I1_I1850_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I175_XP_MP1 (I1_I1850_P24_9n I1_I1850_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I175_XP_MP0 (VDD I1_I1850_P24_17 I1_I1850_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I19_MP1 (I1_I1896_gn19 I1_b29_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I19_MP0 (VDD I1_p28_18 I1_I1896_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I117_XP_MP1 (I1_I1896_P21_18n I1_I1896_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I117_XP_MP0 (VDD I1_I1896_P21_20 I1_I1896_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I176_XP_MP1 (I1_I1896_P25_10n I1_I1896_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I176_XP_MP0 (VDD I1_I1896_P25_18 I1_I1896_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I178_XP_MP1 (I1_I1896_P27_12n I1_I1896_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I178_XP_MP0 (VDD I1_I1896_P27_20 I1_I1896_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I116_XP_MP1 (I1_I1896_P20_17n I1_I1896_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I116_XP_MP0 (VDD I1_I1896_P20_19 I1_I1896_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I177_XP_MP1 (I1_I1896_P26_11n I1_I1896_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I177_XP_MP0 (VDD I1_I1896_P26_19 I1_I1896_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I175_XP_MP1 (I1_I1896_P24_9n I1_I1896_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I175_XP_MP0 (VDD I1_I1896_P24_17 I1_I1896_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I21_MP1 (I1_I1942_gn21 I1_b30_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I21_MP0 (VDD I1_p29_20 I1_I1942_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I20_MP1 (I1_I1942_gn20 I1_b30_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I20_MP0 (VDD I1_p29_19 I1_I1942_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I119_XP_MP1 (I1_I1942_P23_20n I1_I1942_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I119_XP_MP0 (VDD I1_I1942_P23_22 I1_I1942_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I174_XP_MP1 (I1_I1942_P23_8n I1_I1942_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I174_XP_MP0 (VDD I1_I1942_P23_16 I1_I1942_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I120_XP_MP1 (I1_I1942_P24_21n I1_I1942_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I120_XP_MP0 (VDD I1_I1942_P24_23 I1_I1942_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I179_XP_MP1 (I1_I1942_P28_13n I1_I1942_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I179_XP_MP0 (VDD I1_I1942_P28_21 I1_I1942_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I21_MP1 (I1_I1988_gn21 I1_b31_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I21_MP0 (VDD I1_p30_20 I1_I1988_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I180_XP_MP1 (I1_I1988_P29_14n I1_I1988_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I180_XP_MP0 (VDD I1_I1988_P29_22 I1_I1988_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I120_XP_MP1 (I1_I1988_P24_21n I1_I1988_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I120_XP_MP0 (VDD I1_I1988_P24_23 I1_I1988_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I179_XP_MP1 (I1_I1988_P28_13n I1_I1988_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I179_XP_MP0 (VDD I1_I1988_P28_21 I1_I1988_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I20_MP1 (I1_I2066_gn20 I1_dm20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I20_MP0 (VDD I1_p31_20 I1_I2066_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I19_MP1 (I1_I2066_gn19 I1_dm19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I19_MP0 (VDD I1_p31_19 I1_I2066_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I116_XP_MP1 (I1_I2066_P20_17n I1_I2066_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I116_XP_MP0 (VDD I1_I2066_P20_19 I1_I2066_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I179_XP_MP1 (I1_I2066_P28_13n I1_I2066_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I179_XP_MP0 (VDD I1_I2066_P28_21 I1_I2066_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I117_XP_MP1 (I1_I2066_P21_18n I1_I2066_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I117_XP_MP0 (VDD I1_I2066_P21_20 I1_I2066_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I170_XP_MP1 (I1_I2066_P19_4n I1_I2066_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I170_XP_MP0 (VDD I1_I2066_P19_12 I1_I2066_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I506_MP1 (I2_I3_hd45 DIVR_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I506_MP0 (VDD I2_I3_SEL_DIV_b3_7 I2_I3_hd45 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I507_MP1 (Y_45 I2_I3_hd45 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I507_MP0 (VDD I2_I3_hm45 Y_45 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I510_MP1 (Y_46 I2_I3_hd46 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I510_MP0 (VDD I2_I3_hm46 Y_46 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I505_MP1 (I2_I3_hm45 MULP_45 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I505_MP0 (VDD I2_I3_SEL_MUL_b3_7 I2_I3_hm45 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I508_MP1 (I2_I3_hm46 MULP_46 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I508_MP0 (VDD I2_I3_SEL_MUL_b3_7 I2_I3_hm46 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I357_XP_MP1 (I0_I1660_P46_31n I0_I1660_P38_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I357_XP_MP0 (VDD I0_I1660_P46_39 I0_I1660_P46_31n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I369_XP_MP1 (I0_I1660_P58_43n I0_I1660_P50_43 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I369_XP_MP0 (VDD I0_I1660_P58_51 I0_I1660_P58_43n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I244_XP_MP1 (I0_I1660_P52_49n I0_I1660_P50_49 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I244_XP_MP0 (VDD I0_I1660_P52_51 I0_I1660_P52_49n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I242_XP_MP1 (I0_I1660_P50_47n I0_I1660_P48_47 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I242_XP_MP0 (VDD I0_I1660_P50_49 I0_I1660_P50_47n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I245_XP_MP1 (I0_I1660_P53_50n I0_I1660_P51_50 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I245_XP_MP0 (VDD I0_I1660_P53_52 I0_I1660_P53_50n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I123_XP_MP1 (I1_I1850_P27_24n I1_I1850_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I123_XP_MP0 (VDD I1_I1850_P27_26 I1_I1850_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I121_XP_MP1 (I1_I1850_P25_22n I1_I1850_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I121_XP_MP0 (VDD I1_I1850_P25_24 I1_I1850_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I21_MP1 (I1_I1850_gn21 I1_b28_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I21_MP0 (VDD I1_p27_20 I1_I1850_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I22_MP1 (I1_I1850_gn22 I1_b28_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I22_MP0 (VDD I1_p27_21 I1_I1850_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I118_XP_MP1 (I1_I1850_P22_19n I1_I1850_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I118_XP_MP0 (VDD I1_I1850_P22_21 I1_I1850_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I173_XP_MP1 (I1_I1850_P22_7n I1_I1850_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I173_XP_MP0 (VDD I1_I1850_P22_15 I1_I1850_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I21_MP1 (I1_I1896_gn21 I1_b29_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I21_MP0 (VDD I1_p28_20 I1_I1896_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I20_MP1 (I1_I1896_gn20 I1_b29_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I20_MP0 (VDD I1_p28_19 I1_I1896_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I119_XP_MP1 (I1_I1896_P23_20n I1_I1896_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I119_XP_MP0 (VDD I1_I1896_P23_22 I1_I1896_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I174_XP_MP1 (I1_I1896_P23_8n I1_I1896_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I174_XP_MP0 (VDD I1_I1896_P23_16 I1_I1896_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I118_XP_MP1 (I1_I1896_P22_19n I1_I1896_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I118_XP_MP0 (VDD I1_I1896_P22_21 I1_I1896_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I173_XP_MP1 (I1_I1896_P22_7n I1_I1896_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I173_XP_MP0 (VDD I1_I1896_P22_15 I1_I1896_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I22_MP1 (I1_I1942_gn22 I1_b30_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I22_MP0 (VDD I1_p29_21 I1_I1942_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I23_MP1 (I1_I1942_gn23 I1_b30_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I23_MP0 (VDD I1_p29_22 I1_I1942_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I121_XP_MP1 (I1_I1942_P25_22n I1_I1942_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I121_XP_MP0 (VDD I1_I1942_P25_24 I1_I1942_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I180_XP_MP1 (I1_I1942_P29_14n I1_I1942_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I180_XP_MP0 (VDD I1_I1942_P29_22 I1_I1942_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I181_XP_MP1 (I1_I1942_P30_15n I1_I1942_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I181_XP_MP0 (VDD I1_I1942_P30_23 I1_I1942_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I23_MP1 (I1_I1988_gn23 I1_b31_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I23_MP0 (VDD I1_p30_22 I1_I1988_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2046_MP1 (I1_dmn22 I1_p31_32_b3_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2046_MP0 (VDD I1_dd22_b3_5 I1_dmn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2044_MP1 (I1_dmn21 I1_p31_32_b3_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2044_MP0 (VDD I1_dd21_b3_5 I1_dmn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I121_XP_MP1 (I1_I1988_P25_22n I1_I1988_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I121_XP_MP0 (VDD I1_I1988_P25_24 I1_I1988_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I182_XP_MP1 (I1_I1988_P31_16n I1_I1988_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I182_XP_MP0 (VDD I1_I1988_P31_24 I1_I1988_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I122_XP_MP1 (I1_I1988_P26_23n I1_I1988_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I122_XP_MP0 (VDD I1_I1988_P26_25 I1_I1988_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I181_XP_MP1 (I1_I1988_P30_15n I1_I1988_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I181_XP_MP0 (VDD I1_I1988_P30_23 I1_I1988_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I21_MP1 (I1_I2066_gn21 I1_dm21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I21_MP0 (VDD I1_p31_21 I1_I2066_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I118_XP_MP1 (I1_I2066_P22_19n I1_I2066_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I118_XP_MP0 (VDD I1_I2066_P22_21 I1_I2066_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I120_XP_MP1 (I1_I2066_P24_21n I1_I2066_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I120_XP_MP0 (VDD I1_I2066_P24_23 I1_I2066_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I177_XP_MP1 (I1_I2066_P26_11n I1_I2066_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I177_XP_MP0 (VDD I1_I2066_P26_19 I1_I2066_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I172_XP_MP1 (I1_I2066_P21_6n I1_I2066_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I172_XP_MP0 (VDD I1_I2066_P21_14 I1_I2066_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I524_MP1 (I2_I3_hd51 DIVR_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I524_MP0 (VDD I2_I3_SEL_DIV_b3_8 I2_I3_hd51 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I518_MP1 (I2_I3_hd49 DIVR_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I518_MP0 (VDD I2_I3_SEL_DIV_b3_8 I2_I3_hd49 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I521_MP1 (I2_I3_hd50 DIVR_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I521_MP0 (VDD I2_I3_SEL_DIV_b3_8 I2_I3_hd50 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I42_MP1 (I2_I4_z1_10 I2_I4_z0_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I42_MP0 (VDD I2_I4_z0_20 I2_I4_z1_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I522_MP1 (Y_50 I2_I3_hd50 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I522_MP0 (VDD I2_I3_hm50 Y_50 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I523_MP1 (I2_I3_hm51 MULP_51 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I523_MP0 (VDD I2_I3_SEL_MUL_b3_8 I2_I3_hm51 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I520_MP1 (I2_I3_hm50 MULP_50 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I520_MP0 (VDD I2_I3_SEL_MUL_b3_8 I2_I3_hm50 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I365_XP_MP1 (I0_I1660_P54_39n I0_I1660_P46_39 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I365_XP_MP0 (VDD I0_I1660_P54_47 I0_I1660_P54_39n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I58_MP1 (I0_I1660_gn58 VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I58_MP0 (VDD I0_fa298_0 I0_I1660_gn58 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I253_XP_MP1 (I0_I1660_P61_58n I0_I1660_P59_58 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I253_XP_MP0 (VDD I0_I1660_P61_60 I0_I1660_P61_58n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I251_XP_MP1 (I0_I1660_P59_56n I0_I1660_P57_56 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I251_XP_MP0 (VDD I0_I1660_P59_58 I0_I1660_P59_56n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I249_XP_MP1 (I0_I1660_P57_54n I0_I1660_P55_54 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I249_XP_MP0 (VDD I0_I1660_P57_56 I0_I1660_P57_54n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I247_XP_MP1 (I0_I1660_P55_52n I0_I1660_P53_52 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I247_XP_MP0 (VDD I0_I1660_P55_54 I0_I1660_P55_52n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I49_MP1 (I0_I1660_gn49 I0_fa293_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I49_MP0 (VDD I0_ha292_1 I0_I1660_gn49 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I127_XP_MP1 (I1_I1850_P31_28n I1_I1850_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I127_XP_MP0 (VDD I1_I1850_P31_30 I1_I1850_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I125_XP_MP1 (I1_I1850_P29_26n I1_I1850_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I125_XP_MP0 (VDD I1_I1850_P29_28 I1_I1850_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I23_MP1 (I1_I1850_gn23 I1_b28_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I23_MP0 (VDD I1_p27_22 I1_I1850_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I120_XP_MP1 (I1_I1850_P24_21n I1_I1850_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I120_XP_MP0 (VDD I1_I1850_P24_23 I1_I1850_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I177_XP_MP1 (I1_I1850_P26_11n I1_I1850_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I177_XP_MP0 (VDD I1_I1850_P26_19 I1_I1850_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I22_MP1 (I1_I1896_gn22 I1_b29_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I22_MP0 (VDD I1_p28_21 I1_I1896_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I121_XP_MP1 (I1_I1896_P25_22n I1_I1896_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I121_XP_MP0 (VDD I1_I1896_P25_24 I1_I1896_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I180_XP_MP1 (I1_I1896_P29_14n I1_I1896_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I180_XP_MP0 (VDD I1_I1896_P29_22 I1_I1896_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I120_XP_MP1 (I1_I1896_P24_21n I1_I1896_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I120_XP_MP0 (VDD I1_I1896_P24_23 I1_I1896_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I179_XP_MP1 (I1_I1896_P28_13n I1_I1896_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I179_XP_MP0 (VDD I1_I1896_P28_21 I1_I1896_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I24_MP1 (I1_I1942_gn24 I1_b30_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I24_MP0 (VDD I1_p29_23 I1_I1942_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I123_XP_MP1 (I1_I1942_P27_24n I1_I1942_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I123_XP_MP0 (VDD I1_I1942_P27_26 I1_I1942_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I182_XP_MP1 (I1_I1942_P31_16n I1_I1942_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I182_XP_MP0 (VDD I1_I1942_P31_24 I1_I1942_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I122_XP_MP1 (I1_I1942_P26_23n I1_I1942_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I122_XP_MP0 (VDD I1_I1942_P26_25 I1_I1942_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I24_MP1 (I1_I1988_gn24 I1_b31_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I24_MP0 (VDD I1_p30_23 I1_I1988_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I25_MP1 (I1_I1988_gn25 I1_b31_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I25_MP0 (VDD I1_p30_24 I1_I1988_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2048_MP1 (I1_dmn23 I1_p31_32_b3_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2048_MP0 (VDD I1_dd23_b3_5 I1_dmn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I123_XP_MP1 (I1_I1988_P27_24n I1_I1988_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I123_XP_MP0 (VDD I1_I1988_P27_26 I1_I1988_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I124_XP_MP1 (I1_I1988_P28_25n I1_I1988_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I124_XP_MP0 (VDD I1_I1988_P28_27 I1_I1988_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I23_MP1 (I1_I2066_gn23 I1_dm23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I23_MP0 (VDD I1_p31_23 I1_I2066_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I22_MP1 (I1_I2066_gn22 I1_dm22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I22_MP0 (VDD I1_p31_22 I1_I2066_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I173_XP_MP1 (I1_I2066_P22_7n I1_I2066_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I173_XP_MP0 (VDD I1_I2066_P22_15 I1_I2066_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I119_XP_MP1 (I1_I2066_P23_20n I1_I2066_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I119_XP_MP0 (VDD I1_I2066_P23_22 I1_I2066_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I178_XP_MP1 (I1_I2066_P27_12n I1_I2066_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I178_XP_MP0 (VDD I1_I2066_P27_20 I1_I2066_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I174_XP_MP1 (I1_I2066_P23_8n I1_I2066_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I174_XP_MP0 (VDD I1_I2066_P23_16 I1_I2066_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I530_MP1 (I2_I3_hd53 DIVR_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I530_MP0 (VDD I2_I3_SEL_DIV_b3_9 I2_I3_hd53 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I515_MP1 (I2_I3_hd48 DIVR_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I515_MP0 (VDD I2_I3_SEL_DIV_b3_8 I2_I3_hd48 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I512_MP1 (I2_I3_hd47 DIVR_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I512_MP0 (VDD I2_I3_SEL_DIV_b3_8 I2_I3_hd47 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I513_MP1 (Y_47 I2_I3_hd47 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I513_MP0 (VDD I2_I3_hm47 Y_47 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I516_MP1 (Y_48 I2_I3_hd48 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I516_MP0 (VDD I2_I3_hm48 Y_48 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I528_MP1 (Y_52 I2_I3_hd52 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I528_MP0 (VDD I2_I3_hm52 Y_52 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I529_MP1 (I2_I3_hm53 MULP_53 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I529_MP0 (VDD I2_I3_SEL_MUL_b3_9 I2_I3_hm53 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I526_MP1 (I2_I3_hm52 MULP_52 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I526_MP0 (VDD I2_I3_SEL_MUL_b3_8 I2_I3_hm52 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I246_XP_MP1 (I0_I1660_P54_51n I0_I1660_P52_51 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I246_XP_MP0 (VDD I0_I1660_P54_53 I0_I1660_P54_51n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I248_XP_MP1 (I0_I1660_P56_53n I0_I1660_P54_53 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I248_XP_MP0 (VDD I0_I1660_P56_55 I0_I1660_P56_53n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I255_XP_MP1 (I0_I1660_P63_60n I0_I1660_P61_60 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I255_XP_MP0 (VDD I0_I1660_P63_62 I0_I1660_P63_60n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I50_MP1 (I0_I1660_gn50 I0_ha294_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I50_MP0 (VDD I0_fa293_1 I0_I1660_gn50 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I31_MP1 (I1_I1850_gn31 I1_b28_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I31_MP0 (VDD I1_p27_30 I1_I1850_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I30_MP1 (I1_I1850_gn30 I1_b28_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I30_MP0 (VDD I1_p27_29 I1_I1850_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I25_MP1 (I1_I1850_gn25 I1_b28_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I25_MP0 (VDD I1_p27_24 I1_I1850_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I24_MP1 (I1_I1850_gn24 I1_b28_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I24_MP0 (VDD I1_p27_23 I1_I1850_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I124_XP_MP1 (I1_I1850_P28_25n I1_I1850_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I124_XP_MP0 (VDD I1_I1850_P28_27 I1_I1850_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I122_XP_MP1 (I1_I1850_P26_23n I1_I1850_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I122_XP_MP0 (VDD I1_I1850_P26_25 I1_I1850_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I179_XP_MP1 (I1_I1850_P28_13n I1_I1850_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I179_XP_MP0 (VDD I1_I1850_P28_21 I1_I1850_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I24_MP1 (I1_I1896_gn24 I1_b29_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I24_MP0 (VDD I1_p28_23 I1_I1896_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I25_MP1 (I1_I1896_gn25 I1_b29_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I25_MP0 (VDD I1_p28_24 I1_I1896_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I23_MP1 (I1_I1896_gn23 I1_b29_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I23_MP0 (VDD I1_p28_22 I1_I1896_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I123_XP_MP1 (I1_I1896_P27_24n I1_I1896_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I123_XP_MP0 (VDD I1_I1896_P27_26 I1_I1896_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I182_XP_MP1 (I1_I1896_P31_16n I1_I1896_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I182_XP_MP0 (VDD I1_I1896_P31_24 I1_I1896_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I122_XP_MP1 (I1_I1896_P26_23n I1_I1896_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I122_XP_MP0 (VDD I1_I1896_P26_25 I1_I1896_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I181_XP_MP1 (I1_I1896_P30_15n I1_I1896_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I181_XP_MP0 (VDD I1_I1896_P30_23 I1_I1896_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I25_MP1 (I1_I1942_gn25 I1_b30_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I25_MP0 (VDD I1_p29_24 I1_I1942_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I26_MP1 (I1_I1942_gn26 I1_b30_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I26_MP0 (VDD I1_p29_25 I1_I1942_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I124_XP_MP1 (I1_I1942_P28_25n I1_I1942_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I124_XP_MP0 (VDD I1_I1942_P28_27 I1_I1942_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I126_XP_MP1 (I1_I1942_P30_27n I1_I1942_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I126_XP_MP0 (VDD I1_I1942_P30_29 I1_I1942_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I26_MP1 (I1_I1988_gn26 I1_b31_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I26_MP0 (VDD I1_p30_25 I1_I1988_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2052_MP1 (I1_dmn25 I1_p31_32_b3_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2052_MP0 (VDD I1_dd25_b3_5 I1_dmn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2050_MP1 (I1_dmn24 I1_p31_32_b3_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2050_MP0 (VDD I1_dd24_b3_5 I1_dmn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2054_MP1 (I1_dmn26 I1_p31_32_b3_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2054_MP0 (VDD I1_dd26_b3_5 I1_dmn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I125_XP_MP1 (I1_I1988_P29_26n I1_I1988_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I125_XP_MP0 (VDD I1_I1988_P29_28 I1_I1988_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I127_XP_MP1 (I1_I1988_P31_28n I1_I1988_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I127_XP_MP0 (VDD I1_I1988_P31_30 I1_I1988_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I126_XP_MP1 (I1_I1988_P30_27n I1_I1988_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I126_XP_MP0 (VDD I1_I1988_P30_29 I1_I1988_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I24_MP1 (I1_I2066_gn24 I1_dm24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I24_MP0 (VDD I1_p31_24 I1_I2066_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I25_MP1 (I1_I2066_gn25 I1_dm25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I25_MP0 (VDD I1_p31_25 I1_I2066_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I122_XP_MP1 (I1_I2066_P26_23n I1_I2066_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I122_XP_MP0 (VDD I1_I2066_P26_25 I1_I2066_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I124_XP_MP1 (I1_I2066_P28_25n I1_I2066_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I124_XP_MP0 (VDD I1_I2066_P28_27 I1_I2066_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I181_XP_MP1 (I1_I2066_P30_15n I1_I2066_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I181_XP_MP0 (VDD I1_I2066_P30_23 I1_I2066_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I121_XP_MP1 (I1_I2066_P25_22n I1_I2066_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I121_XP_MP0 (VDD I1_I2066_P25_24 I1_I2066_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I180_XP_MP1 (I1_I2066_P29_14n I1_I2066_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I180_XP_MP0 (VDD I1_I2066_P29_22 I1_I2066_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I182_XP_MP1 (I1_I2066_P31_16n I1_I2066_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I182_XP_MP0 (VDD I1_I2066_P31_24 I1_I2066_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I536_MP1 (I2_I3_hd55 DIVR_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I536_MP0 (VDD I2_I3_SEL_DIV_b3_9 I2_I3_hd55 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I539_MP1 (I2_I3_hd56 DIVR_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I539_MP0 (VDD I2_I3_SEL_DIV_b3_9 I2_I3_hd56 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I542_MP1 (I2_I3_hd57 DIVR_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I542_MP0 (VDD I2_I3_SEL_DIV_b3_9 I2_I3_hd57 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I43_MP1 (I2_I4_z1_11 I2_I4_z0_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I43_MP0 (VDD I2_I4_z0_22 I2_I4_z1_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I531_MP1 (Y_53 I2_I3_hd53 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I531_MP0 (VDD I2_I3_hm53 Y_53 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I543_MP1 (Y_57 I2_I3_hd57 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I543_MP0 (VDD I2_I3_hm57 Y_57 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I540_MP1 (Y_56 I2_I3_hd56 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I540_MP0 (VDD I2_I3_hm56 Y_56 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I537_MP1 (Y_55 I2_I3_hd55 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I537_MP0 (VDD I2_I3_hm55 Y_55 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I535_MP1 (I2_I3_hm55 MULP_55 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I535_MP0 (VDD I2_I3_SEL_MUL_b3_9 I2_I3_hm55 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I373_XP_MP1 (I0_I1660_P62_47n I0_I1660_P54_47 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I373_XP_MP0 (VDD I0_I1660_P62_55 I0_I1660_P62_47n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I252_XP_MP1 (I0_I1660_P60_57n I0_I1660_P58_57 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I252_XP_MP0 (VDD I0_I1660_P60_59 I0_I1660_P60_57n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I250_XP_MP1 (I0_I1660_P58_55n I0_I1660_P56_55 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I250_XP_MP0 (VDD I0_I1660_P58_57 I0_I1660_P58_55n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I56_MP1 (I0_I1660_gn56 VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I56_MP0 (VDD I0_fa297_0 I0_I1660_gn56 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I57_MP1 (I0_I1660_gn57 I0_fa246_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I57_MP0 (VDD I0_fa297_1 I0_I1660_gn57 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I59_MP1 (I0_I1660_gn59 I0_fa207_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I59_MP0 (VDD I0_fa298_1 I0_I1660_gn59 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I55_MP1 (I0_I1660_gn55 I0_fa245_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I55_MP0 (VDD I0_fa296_1 I0_I1660_gn55 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I29_MP1 (I1_I1850_gn29 I1_b28_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I29_MP0 (VDD I1_p27_28 I1_I1850_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I126_XP_MP1 (I1_I1850_P30_27n I1_I1850_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I126_XP_MP0 (VDD I1_I1850_P30_29 I1_I1850_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I26_MP1 (I1_I1850_gn26 I1_b28_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I26_MP0 (VDD I1_p27_25 I1_I1850_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I181_XP_MP1 (I1_I1850_P30_15n I1_I1850_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I181_XP_MP0 (VDD I1_I1850_P30_23 I1_I1850_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I26_MP1 (I1_I1896_gn26 I1_b29_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I26_MP0 (VDD I1_p28_25 I1_I1896_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I31_MP1 (I1_I1896_gn31 I1_b29_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I31_MP0 (VDD I1_p28_30 I1_I1896_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I125_XP_MP1 (I1_I1896_P29_26n I1_I1896_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I125_XP_MP0 (VDD I1_I1896_P29_28 I1_I1896_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I124_XP_MP1 (I1_I1896_P28_25n I1_I1896_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I124_XP_MP0 (VDD I1_I1896_P28_27 I1_I1896_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I27_MP1 (I1_I1942_gn27 I1_b30_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I27_MP0 (VDD I1_p29_26 I1_I1942_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I28_MP1 (I1_I1942_gn28 I1_b30_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I28_MP0 (VDD I1_p29_27 I1_I1942_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I27_MP1 (I1_I1988_gn27 I1_b31_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I27_MP0 (VDD I1_p30_26 I1_I1988_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I28_MP1 (I1_I1988_gn28 I1_b31_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I28_MP0 (VDD I1_p30_27 I1_I1988_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2056_MP1 (I1_dmn27 I1_p31_32_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2056_MP0 (VDD I1_dd27_b3_5 I1_dmn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I28_MP1 (I1_I2066_gn28 I1_dm28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I28_MP0 (VDD I1_p31_28 I1_I2066_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I26_MP1 (I1_I2066_gn26 I1_dm26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I26_MP0 (VDD I1_p31_26 I1_I2066_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I27_MP1 (I1_I2066_gn27 I1_dm27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I27_MP0 (VDD I1_p31_27 I1_I2066_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I126_XP_MP1 (I1_I2066_P30_27n I1_I2066_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I126_XP_MP0 (VDD I1_I2066_P30_29 I1_I2066_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I123_XP_MP1 (I1_I2066_P27_24n I1_I2066_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I123_XP_MP0 (VDD I1_I2066_P27_26 I1_I2066_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I125_XP_MP1 (I1_I2066_P29_26n I1_I2066_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I125_XP_MP0 (VDD I1_I2066_P29_28 I1_I2066_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I40_MP1 (I2_I4_z1_8 I2_I4_z0_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I40_MP0 (VDD I2_I4_z0_16 I2_I4_z1_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I533_MP1 (I2_I3_hd54 DIVR_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I533_MP0 (VDD I2_I3_SEL_DIV_b3_9 I2_I3_hd54 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I545_MP1 (I2_I3_hd58 DIVR_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I545_MP0 (VDD I2_I3_SEL_DIV_b3_9 I2_I3_hd58 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I554_MP1 (I2_I3_hd61 DIVR_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I554_MP0 (VDD I2_I3_SEL_DIV_b3_10 I2_I3_hd61 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I58_MP1 (I2_I4_z3_2 I2_I4_z2_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I58_MP0 (VDD I2_I4_z2_4 I2_I4_z3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I44_MP1 (I2_I4_z1_12 I2_I4_z0_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I44_MP0 (VDD I2_I4_z0_24 I2_I4_z1_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I45_MP1 (I2_I4_z1_13 I2_I4_z0_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I45_MP0 (VDD I2_I4_z0_26 I2_I4_z1_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I534_MP1 (Y_54 I2_I3_hd54 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I534_MP0 (VDD I2_I3_hm54 Y_54 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I546_MP1 (Y_58 I2_I3_hd58 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I546_MP0 (VDD I2_I3_hm58 Y_58 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I555_MP1 (Y_61 I2_I3_hd61 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I555_MP0 (VDD I2_I3_hm61 Y_61 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I547_MP1 (I2_I3_hm59 MULP_59 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I547_MP0 (VDD I2_I3_SEL_MUL_b3_10 I2_I3_hm59 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I553_MP1 (I2_I3_hm61 MULP_61 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I553_MP0 (VDD I2_I3_SEL_MUL_b3_10 I2_I3_hm61 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I254_XP_MP1 (I0_I1660_P62_59n I0_I1660_P60_59 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I254_XP_MP0 (VDD I0_I1660_P62_61 I0_I1660_P62_59n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I60_MP1 (I0_I1660_gn60 VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I60_MP0 (VDD I0_fa247_0 I0_I1660_gn60 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I54_MP1 (I0_I1660_gn54 VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I54_MP0 (VDD I0_fa296_0 I0_I1660_gn54 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I52_MP1 (I0_I1660_gn52 VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I52_MP0 (VDD I0_fa295_0 I0_I1660_gn52 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I51_MP1 (I0_I1660_gn51 I0_fa243_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I51_MP0 (VDD I0_ha294_1 I0_I1660_gn51 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I28_MP1 (I1_I1850_gn28 I1_b28_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I28_MP0 (VDD I1_p27_27 I1_I1850_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I27_MP1 (I1_I1850_gn27 I1_b28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I27_MP0 (VDD I1_p27_26 I1_I1850_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I27_MP1 (I1_I1896_gn27 I1_b29_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I27_MP0 (VDD I1_p28_26 I1_I1896_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I28_MP1 (I1_I1896_gn28 I1_b29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I28_MP0 (VDD I1_p28_27 I1_I1896_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I29_MP1 (I1_I1896_gn29 I1_b29_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I29_MP0 (VDD I1_p28_28 I1_I1896_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I30_MP1 (I1_I1896_gn30 I1_b29_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I30_MP0 (VDD I1_p28_29 I1_I1896_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I127_XP_MP1 (I1_I1896_P31_28n I1_I1896_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I127_XP_MP0 (VDD I1_I1896_P31_30 I1_I1896_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I126_XP_MP1 (I1_I1896_P30_27n I1_I1896_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I126_XP_MP0 (VDD I1_I1896_P30_29 I1_I1896_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I29_MP1 (I1_I1942_gn29 I1_b30_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I29_MP0 (VDD I1_p29_28 I1_I1942_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I31_MP1 (I1_I1942_gn31 I1_b30_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I31_MP0 (VDD I1_p29_30 I1_I1942_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I30_MP1 (I1_I1942_gn30 I1_b30_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I30_MP0 (VDD I1_p29_29 I1_I1942_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I29_MP1 (I1_I1988_gn29 I1_b31_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I29_MP0 (VDD I1_p30_28 I1_I1988_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I31_MP1 (I1_I1988_gn31 I1_b31_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I31_MP0 (VDD I1_p30_30 I1_I1988_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2058_MP1 (I1_dmn28 I1_p31_32_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2058_MP0 (VDD I1_dd28_b3_5 I1_dmn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2060_MP1 (I1_dmn29 I1_p31_32_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2060_MP0 (VDD I1_dd29_b3_5 I1_dmn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2064_MP1 (I1_dmn31 I1_p31_32_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2064_MP0 (VDD I1_dd31_b3_5 I1_dmn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I30_MP1 (I1_I2066_gn30 I1_dm30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I30_MP0 (VDD I1_p31_30 I1_I2066_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I31_MP1 (I1_I2066_gn31 I1_dm31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I31_MP0 (VDD I1_p31_31 I1_I2066_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I29_MP1 (I1_I2066_gn29 I1_dm29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I29_MP0 (VDD I1_p31_29 I1_I2066_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I127_XP_MP1 (I1_I2066_P31_28n I1_I2066_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I127_XP_MP0 (VDD I1_I2066_P31_30 I1_I2066_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I62_MP1 (I2_I4_z5_0 I2_I4_z4_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I62_MP0 (VDD I2_I4_z4_0 I2_I4_z5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I59_MP1 (I2_I4_z3_3 I2_I4_z2_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I59_MP0 (VDD I2_I4_z2_6 I2_I4_z3_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I46_MP1 (I2_I4_z1_14 I2_I4_z0_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I46_MP0 (VDD I2_I4_z0_28 I2_I4_z1_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I549_MP1 (Y_59 I2_I3_hd59 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I549_MP0 (VDD I2_I3_hm59 Y_59 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I558_MP1 (Y_62 I2_I3_hd62 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I558_MP0 (VDD I2_I3_hm62 Y_62 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I47_MP1 (I2_I4_z1_15 I2_I4_z0_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I47_MP0 (VDD I2_I4_z0_30 I2_I4_z1_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I561_MP1 (Y_63 I2_I3_hd63 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I561_MP0 (VDD I2_I3_hm63 Y_63 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I552_MP1 (Y_60 I2_I3_hd60 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I552_MP0 (VDD I2_I3_hm60 Y_60 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I559_MP1 (I2_I3_hm63 MULP_63 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I559_MP0 (VDD I2_I3_SEL_MUL_b3_10 I2_I3_hm63 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I550_MP1 (I2_I3_hm60 MULP_60 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I550_MP0 (VDD I2_I3_SEL_MUL_b3_10 I2_I3_hm60 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I556_MP1 (I2_I3_hm62 MULP_62 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I556_MP0 (VDD I2_I3_SEL_MUL_b3_10 I2_I3_hm62 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I62_MP1 (I0_I1660_gn62 VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I62_MP0 (VDD I0_fa248_0 I0_I1660_gn62 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I63_MP1 (I0_I1660_gn63 I0_sn15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I63_MP0 (VDD I0_fa248_1 I0_I1660_gn63 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I53_MP1 (I0_I1660_gn53 I0_fa244_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I53_MP0 (VDD I0_fa295_1 I0_I1660_gn53 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I61_MP1 (I0_I1660_gn61 I0_fa208_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I61_MP0 (VDD I0_fa247_1 I0_I1660_gn61 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I97_XP_MP0 (XI1_I1298_I97_XP_p1 I1_I1298_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I97_XP_MP1 (I1_I1298_P31_30 I1_I1298_pn30 XI1_I1298_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I95_XP_MP0 (XI1_I1298_I95_XP_p1 I1_I1298_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I95_XP_MP1 (I1_I1298_P29_28 I1_I1298_pn28 XI1_I1298_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I96_XP_MP0 (XI1_I1298_I96_XP_p1 I1_I1298_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I96_XP_MP1 (I1_I1298_P30_29 I1_I1298_pn29 XI1_I1298_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I94_XP_MP0 (XI1_I1252_I94_XP_p1 I1_I1252_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I94_XP_MP1 (I1_I1252_P28_27 I1_I1252_pn27 XI1_I1252_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I96_XP_MP0 (XI1_I1252_I96_XP_p1 I1_I1252_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I96_XP_MP1 (I1_I1252_P30_29 I1_I1252_pn29 XI1_I1252_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I97_XP_MP0 (XI1_I1252_I97_XP_p1 I1_I1252_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I97_XP_MP1 (I1_I1252_P31_30 I1_I1252_pn30 XI1_I1252_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I95_XP_MP0 (XI1_I1252_I95_XP_p1 I1_I1252_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I95_XP_MP1 (I1_I1252_P29_28 I1_I1252_pn28 XI1_I1252_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I95_XP_MP0 (XI1_I1206_I95_XP_p1 I1_I1206_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I95_XP_MP1 (I1_I1206_P29_28 I1_I1206_pn28 XI1_I1206_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I94_XP_MP0 (XI1_I1206_I94_XP_p1 I1_I1206_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I94_XP_MP1 (I1_I1206_P28_27 I1_I1206_pn27 XI1_I1206_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I97_XP_MP0 (XI1_I838_I97_XP_p1 I1_I838_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I97_XP_MP1 (I1_I838_P31_30 I1_I838_pn30 XI1_I838_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I156_XP_MP0 (XI1_I838_I156_XP_p1 I1_I838_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I156_XP_MP1 (I1_I838_P31_24 I1_I838_P27_24n XI1_I838_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I154_XP_MP0 (XI1_I838_I154_XP_p1 I1_I838_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I154_XP_MP1 (I1_I838_P29_22 I1_I838_P25_22n XI1_I838_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I152_XP_MP0 (XI1_I838_I152_XP_p1 I1_I838_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I152_XP_MP1 (I1_I838_P27_20 I1_I838_P23_20n XI1_I838_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I148_XP_MP0 (XI1_I838_I148_XP_p1 I1_I838_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I148_XP_MP1 (I1_I838_P23_16 I1_I838_P19_16n XI1_I838_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I144_XP_MP0 (XI1_I838_I144_XP_p1 I1_I838_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I144_XP_MP1 (I1_I838_P19_12 I1_I838_P15_12n XI1_I838_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I140_XP_MP0 (XI1_I838_I140_XP_p1 I1_I838_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I140_XP_MP1 (I1_I838_P15_8 I1_I838_P11_8n XI1_I838_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I136_XP_MP0 (XI1_I838_I136_XP_p1 I1_I838_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I136_XP_MP1 (I1_I838_P11_4 I1_I838_P7_4n XI1_I838_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I154_XP_MP0 (XI1_I792_I154_XP_p1 I1_I792_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I154_XP_MP1 (I1_I792_P29_22 I1_I792_P25_22n XI1_I792_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I152_XP_MP0 (XI1_I792_I152_XP_p1 I1_I792_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I152_XP_MP1 (I1_I792_P27_20 I1_I792_P23_20n XI1_I792_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I156_XP_MP0 (XI1_I792_I156_XP_p1 I1_I792_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I156_XP_MP1 (I1_I792_P31_24 I1_I792_P27_24n XI1_I792_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I95_XP_MP0 (XI1_I792_I95_XP_p1 I1_I792_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I95_XP_MP1 (I1_I792_P29_28 I1_I792_pn28 XI1_I792_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I97_XP_MP0 (XI1_I792_I97_XP_p1 I1_I792_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I97_XP_MP1 (I1_I792_P31_30 I1_I792_pn30 XI1_I792_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I155_XP_MP0 (XI1_I792_I155_XP_p1 I1_I792_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I155_XP_MP1 (I1_I792_P30_23 I1_I792_P26_23n XI1_I792_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I94_XP_MP0 (XI1_I792_I94_XP_p1 I1_I792_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I94_XP_MP1 (I1_I792_P28_27 I1_I792_pn27 XI1_I792_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I96_XP_MP0 (XI1_I792_I96_XP_p1 I1_I792_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I96_XP_MP1 (I1_I792_P30_29 I1_I792_pn29 XI1_I792_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I97_XP_MP0 (XI1_I1344_I97_XP_p1 I1_I1344_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I97_XP_MP1 (I1_I1344_P31_30 I1_I1344_pn30 XI1_I1344_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I156_XP_MP0 (XI1_I1344_I156_XP_p1 I1_I1344_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I156_XP_MP1 (I1_I1344_P31_24 I1_I1344_P27_24n XI1_I1344_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I152_XP_MP0 (XI1_I1344_I152_XP_p1 I1_I1344_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I152_XP_MP1 (I1_I1344_P27_20 I1_I1344_P23_20n XI1_I1344_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I148_XP_MP0 (XI1_I1344_I148_XP_p1 I1_I1344_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I148_XP_MP1 (I1_I1344_P23_16 I1_I1344_P19_16n XI1_I1344_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I156_XP_MP0 (XI1_I1298_I156_XP_p1 I1_I1298_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I156_XP_MP1 (I1_I1298_P31_24 I1_I1298_P27_24n XI1_I1298_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I93_XP_MP0 (XI1_I1298_I93_XP_p1 I1_I1298_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I93_XP_MP1 (I1_I1298_P27_26 I1_I1298_pn26 XI1_I1298_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I94_XP_MP0 (XI1_I1298_I94_XP_p1 I1_I1298_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I94_XP_MP1 (I1_I1298_P28_27 I1_I1298_pn27 XI1_I1298_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I155_XP_MP0 (XI1_I1252_I155_XP_p1 I1_I1252_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I155_XP_MP1 (I1_I1252_P30_23 I1_I1252_P26_23n XI1_I1252_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I92_XP_MP0 (XI1_I1252_I92_XP_p1 I1_I1252_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I92_XP_MP1 (I1_I1252_P26_25 I1_I1252_pn25 XI1_I1252_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I93_XP_MP0 (XI1_I1252_I93_XP_p1 I1_I1252_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I93_XP_MP1 (I1_I1252_P27_26 I1_I1252_pn26 XI1_I1252_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I97_XP_MP0 (XI1_I1206_I97_XP_p1 I1_I1206_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I97_XP_MP1 (I1_I1206_P31_30 I1_I1206_pn30 XI1_I1206_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I96_XP_MP0 (XI1_I1206_I96_XP_p1 I1_I1206_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I96_XP_MP1 (I1_I1206_P30_29 I1_I1206_pn29 XI1_I1206_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I93_XP_MP0 (XI1_I1206_I93_XP_p1 I1_I1206_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I93_XP_MP1 (I1_I1206_P27_26 I1_I1206_pn26 XI1_I1206_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I93_XP_MP0 (XI1_I838_I93_XP_p1 I1_I838_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I93_XP_MP1 (I1_I838_P27_26 I1_I838_pn26 XI1_I838_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I91_XP_MP0 (XI1_I838_I91_XP_p1 I1_I838_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I91_XP_MP1 (I1_I838_P25_24 I1_I838_pn24 XI1_I838_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I89_XP_MP0 (XI1_I838_I89_XP_p1 I1_I838_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I89_XP_MP1 (I1_I838_P23_22 I1_I838_pn22 XI1_I838_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I87_XP_MP0 (XI1_I838_I87_XP_p1 I1_I838_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I87_XP_MP1 (I1_I838_P21_20 I1_I838_pn20 XI1_I838_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I150_XP_MP0 (XI1_I838_I150_XP_p1 I1_I838_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I150_XP_MP1 (I1_I838_P25_18 I1_I838_P21_18n XI1_I838_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I146_XP_MP0 (XI1_I838_I146_XP_p1 I1_I838_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I146_XP_MP1 (I1_I838_P21_14 I1_I838_P17_14n XI1_I838_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I142_XP_MP0 (XI1_I838_I142_XP_p1 I1_I838_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I142_XP_MP1 (I1_I838_P17_10 I1_I838_P13_10n XI1_I838_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I138_XP_MP0 (XI1_I838_I138_XP_p1 I1_I838_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I138_XP_MP1 (I1_I838_P13_6 I1_I838_P9_6n XI1_I838_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I134_XP_MP0 (XI1_I838_I134_XP_p1 I1_I838_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I134_XP_MP1 (I1_I838_P9_2 I1_I838_P5_2n XI1_I838_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I150_XP_MP0 (XI1_I792_I150_XP_p1 I1_I792_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I150_XP_MP1 (I1_I792_P25_18 I1_I792_P21_18n XI1_I792_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I148_XP_MP0 (XI1_I792_I148_XP_p1 I1_I792_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I148_XP_MP1 (I1_I792_P23_16 I1_I792_P19_16n XI1_I792_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I89_XP_MP0 (XI1_I792_I89_XP_p1 I1_I792_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I89_XP_MP1 (I1_I792_P23_22 I1_I792_pn22 XI1_I792_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I91_XP_MP0 (XI1_I792_I91_XP_p1 I1_I792_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I91_XP_MP1 (I1_I792_P25_24 I1_I792_pn24 XI1_I792_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I93_XP_MP0 (XI1_I792_I93_XP_p1 I1_I792_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I93_XP_MP1 (I1_I792_P27_26 I1_I792_pn26 XI1_I792_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I153_XP_MP0 (XI1_I792_I153_XP_p1 I1_I792_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I153_XP_MP1 (I1_I792_P28_21 I1_I792_P24_21n XI1_I792_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I90_XP_MP0 (XI1_I792_I90_XP_p1 I1_I792_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I90_XP_MP1 (I1_I792_P24_23 I1_I792_pn23 XI1_I792_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I92_XP_MP0 (XI1_I792_I92_XP_p1 I1_I792_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I92_XP_MP1 (I1_I792_P26_25 I1_I792_pn25 XI1_I792_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I95_XP_MP0 (XI1_I1344_I95_XP_p1 I1_I1344_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I95_XP_MP1 (I1_I1344_P29_28 I1_I1344_pn28 XI1_I1344_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I94_XP_MP0 (XI1_I1344_I94_XP_p1 I1_I1344_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I94_XP_MP1 (I1_I1344_P28_27 I1_I1344_pn27 XI1_I1344_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I96_XP_MP0 (XI1_I1344_I96_XP_p1 I1_I1344_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I96_XP_MP1 (I1_I1344_P30_29 I1_I1344_pn29 XI1_I1344_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I154_XP_MP0 (XI1_I1344_I154_XP_p1 I1_I1344_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I154_XP_MP1 (I1_I1344_P29_22 I1_I1344_P25_22n XI1_I1344_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I144_XP_MP0 (XI1_I1344_I144_XP_p1 I1_I1344_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I144_XP_MP1 (I1_I1344_P19_12 I1_I1344_P15_12n XI1_I1344_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I140_XP_MP0 (XI1_I1344_I140_XP_p1 I1_I1344_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I140_XP_MP1 (I1_I1344_P15_8 I1_I1344_P11_8n XI1_I1344_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I152_XP_MP0 (XI1_I1298_I152_XP_p1 I1_I1298_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I152_XP_MP1 (I1_I1298_P27_20 I1_I1298_P23_20n XI1_I1298_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I154_XP_MP0 (XI1_I1298_I154_XP_p1 I1_I1298_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I154_XP_MP1 (I1_I1298_P29_22 I1_I1298_P25_22n XI1_I1298_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I91_XP_MP0 (XI1_I1298_I91_XP_p1 I1_I1298_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I91_XP_MP1 (I1_I1298_P25_24 I1_I1298_pn24 XI1_I1298_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I155_XP_MP0 (XI1_I1298_I155_XP_p1 I1_I1298_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I155_XP_MP1 (I1_I1298_P30_23 I1_I1298_P26_23n XI1_I1298_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I92_XP_MP0 (XI1_I1298_I92_XP_p1 I1_I1298_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I92_XP_MP1 (I1_I1298_P26_25 I1_I1298_pn25 XI1_I1298_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I90_XP_MP0 (XI1_I1298_I90_XP_p1 I1_I1298_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I90_XP_MP1 (I1_I1298_P24_23 I1_I1298_pn23 XI1_I1298_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I153_XP_MP0 (XI1_I1252_I153_XP_p1 I1_I1252_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I153_XP_MP1 (I1_I1252_P28_21 I1_I1252_P24_21n XI1_I1252_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I90_XP_MP0 (XI1_I1252_I90_XP_p1 I1_I1252_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I90_XP_MP1 (I1_I1252_P24_23 I1_I1252_pn23 XI1_I1252_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I156_XP_MP0 (XI1_I1252_I156_XP_p1 I1_I1252_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I156_XP_MP1 (I1_I1252_P31_24 I1_I1252_P27_24n XI1_I1252_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I91_XP_MP0 (XI1_I1252_I91_XP_p1 I1_I1252_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I91_XP_MP1 (I1_I1252_P25_24 I1_I1252_pn24 XI1_I1252_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I156_XP_MP0 (XI1_I1206_I156_XP_p1 I1_I1206_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I156_XP_MP1 (I1_I1206_P31_24 I1_I1206_P27_24n XI1_I1206_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I92_XP_MP0 (XI1_I1206_I92_XP_p1 I1_I1206_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I92_XP_MP1 (I1_I1206_P26_25 I1_I1206_pn25 XI1_I1206_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I96_XP_MP0 (XI1_I838_I96_XP_p1 I1_I838_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I96_XP_MP1 (I1_I838_P30_29 I1_I838_pn29 XI1_I838_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I95_XP_MP0 (XI1_I838_I95_XP_p1 I1_I838_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I95_XP_MP1 (I1_I838_P29_28 I1_I838_pn28 XI1_I838_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I90_XP_MP0 (XI1_I838_I90_XP_p1 I1_I838_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I90_XP_MP1 (I1_I838_P24_23 I1_I838_pn23 XI1_I838_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I85_XP_MP0 (XI1_I838_I85_XP_p1 I1_I838_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I85_XP_MP1 (I1_I838_P19_18 I1_I838_pn18 XI1_I838_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I83_XP_MP0 (XI1_I838_I83_XP_p1 I1_I838_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I83_XP_MP1 (I1_I838_P17_16 I1_I838_pn16 XI1_I838_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I81_XP_MP0 (XI1_I838_I81_XP_p1 I1_I838_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I81_XP_MP1 (I1_I838_P15_14 I1_I838_pn14 XI1_I838_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I79_XP_MP0 (XI1_I838_I79_XP_p1 I1_I838_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I79_XP_MP1 (I1_I838_P13_12 I1_I838_pn12 XI1_I838_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I146_XP_MP0 (XI1_I792_I146_XP_p1 I1_I792_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I146_XP_MP1 (I1_I792_P21_14 I1_I792_P17_14n XI1_I792_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I144_XP_MP0 (XI1_I792_I144_XP_p1 I1_I792_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I144_XP_MP1 (I1_I792_P19_12 I1_I792_P15_12n XI1_I792_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I87_XP_MP0 (XI1_I792_I87_XP_p1 I1_I792_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I87_XP_MP1 (I1_I792_P21_20 I1_I792_pn20 XI1_I792_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I147_XP_MP0 (XI1_I792_I147_XP_p1 I1_I792_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I147_XP_MP1 (I1_I792_P22_15 I1_I792_P18_15n XI1_I792_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I149_XP_MP0 (XI1_I792_I149_XP_p1 I1_I792_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I149_XP_MP1 (I1_I792_P24_17 I1_I792_P20_17n XI1_I792_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I151_XP_MP0 (XI1_I792_I151_XP_p1 I1_I792_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I151_XP_MP1 (I1_I792_P26_19 I1_I792_P22_19n XI1_I792_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I88_XP_MP0 (XI1_I792_I88_XP_p1 I1_I792_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I88_XP_MP1 (I1_I792_P22_21 I1_I792_pn21 XI1_I792_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I94_XP_MP0 (XI1_I746_I94_XP_p1 I1_I746_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I94_XP_MP1 (I1_I746_P28_27 I1_I746_pn27 XI1_I746_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I93_XP_MP0 (XI1_I1344_I93_XP_p1 I1_I1344_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I93_XP_MP1 (I1_I1344_P27_26 I1_I1344_pn26 XI1_I1344_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I91_XP_MP0 (XI1_I1344_I91_XP_p1 I1_I1344_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I91_XP_MP1 (I1_I1344_P25_24 I1_I1344_pn24 XI1_I1344_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I89_XP_MP0 (XI1_I1344_I89_XP_p1 I1_I1344_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I89_XP_MP1 (I1_I1344_P23_22 I1_I1344_pn22 XI1_I1344_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I150_XP_MP0 (XI1_I1344_I150_XP_p1 I1_I1344_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I150_XP_MP1 (I1_I1344_P25_18 I1_I1344_P21_18n XI1_I1344_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I146_XP_MP0 (XI1_I1344_I146_XP_p1 I1_I1344_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I146_XP_MP1 (I1_I1344_P21_14 I1_I1344_P17_14n XI1_I1344_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I136_XP_MP0 (XI1_I1344_I136_XP_p1 I1_I1344_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I136_XP_MP1 (I1_I1344_P11_4 I1_I1344_P7_4n XI1_I1344_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I148_XP_MP0 (XI1_I1298_I148_XP_p1 I1_I1298_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I148_XP_MP1 (I1_I1298_P23_16 I1_I1298_P19_16n XI1_I1298_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I150_XP_MP0 (XI1_I1298_I150_XP_p1 I1_I1298_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I150_XP_MP1 (I1_I1298_P25_18 I1_I1298_P21_18n XI1_I1298_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I89_XP_MP0 (XI1_I1298_I89_XP_p1 I1_I1298_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I89_XP_MP1 (I1_I1298_P23_22 I1_I1298_pn22 XI1_I1298_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I153_XP_MP0 (XI1_I1298_I153_XP_p1 I1_I1298_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I153_XP_MP1 (I1_I1298_P28_21 I1_I1298_P24_21n XI1_I1298_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I151_XP_MP0 (XI1_I1252_I151_XP_p1 I1_I1252_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I151_XP_MP1 (I1_I1252_P26_19 I1_I1252_P22_19n XI1_I1252_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I88_XP_MP0 (XI1_I1252_I88_XP_p1 I1_I1252_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I88_XP_MP1 (I1_I1252_P22_21 I1_I1252_pn21 XI1_I1252_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I154_XP_MP0 (XI1_I1252_I154_XP_p1 I1_I1252_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I154_XP_MP1 (I1_I1252_P29_22 I1_I1252_P25_22n XI1_I1252_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I89_XP_MP0 (XI1_I1252_I89_XP_p1 I1_I1252_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I89_XP_MP1 (I1_I1252_P23_22 I1_I1252_pn22 XI1_I1252_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I89_XP_MP0 (XI1_I1206_I89_XP_p1 I1_I1206_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I89_XP_MP1 (I1_I1206_P23_22 I1_I1206_pn22 XI1_I1206_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I90_XP_MP0 (XI1_I1206_I90_XP_p1 I1_I1206_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I90_XP_MP1 (I1_I1206_P24_23 I1_I1206_pn23 XI1_I1206_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I91_XP_MP0 (XI1_I1206_I91_XP_p1 I1_I1206_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I91_XP_MP1 (I1_I1206_P25_24 I1_I1206_pn24 XI1_I1206_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I155_XP_MP0 (XI1_I1206_I155_XP_p1 I1_I1206_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I155_XP_MP1 (I1_I1206_P30_23 I1_I1206_P26_23n XI1_I1206_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I153_XP_MP0 (XI1_I1206_I153_XP_p1 I1_I1206_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I153_XP_MP1 (I1_I1206_P28_21 I1_I1206_P24_21n XI1_I1206_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I94_XP_MP0 (XI1_I838_I94_XP_p1 I1_I838_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I94_XP_MP1 (I1_I838_P28_27 I1_I838_pn27 XI1_I838_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I92_XP_MP0 (XI1_I838_I92_XP_p1 I1_I838_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I92_XP_MP1 (I1_I838_P26_25 I1_I838_pn25 XI1_I838_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I88_XP_MP0 (XI1_I838_I88_XP_p1 I1_I838_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I88_XP_MP1 (I1_I838_P22_21 I1_I838_pn21 XI1_I838_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I86_XP_MP0 (XI1_I838_I86_XP_p1 I1_I838_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I86_XP_MP1 (I1_I838_P20_19 I1_I838_pn19 XI1_I838_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I84_XP_MP0 (XI1_I838_I84_XP_p1 I1_I838_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I84_XP_MP1 (I1_I838_P18_17 I1_I838_pn17 XI1_I838_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I82_XP_MP0 (XI1_I838_I82_XP_p1 I1_I838_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I82_XP_MP1 (I1_I838_P16_15 I1_I838_pn15 XI1_I838_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I77_XP_MP0 (XI1_I838_I77_XP_p1 I1_I838_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I77_XP_MP1 (I1_I838_P11_10 I1_I838_pn10 XI1_I838_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I142_XP_MP0 (XI1_I792_I142_XP_p1 I1_I792_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I142_XP_MP1 (I1_I792_P17_10 I1_I792_P13_10n XI1_I792_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I140_XP_MP0 (XI1_I792_I140_XP_p1 I1_I792_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I140_XP_MP1 (I1_I792_P15_8 I1_I792_P11_8n XI1_I792_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I85_XP_MP0 (XI1_I792_I85_XP_p1 I1_I792_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I85_XP_MP1 (I1_I792_P19_18 I1_I792_pn18 XI1_I792_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I81_XP_MP0 (XI1_I792_I81_XP_p1 I1_I792_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I81_XP_MP1 (I1_I792_P15_14 I1_I792_pn14 XI1_I792_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I145_XP_MP0 (XI1_I792_I145_XP_p1 I1_I792_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I145_XP_MP1 (I1_I792_P20_13 I1_I792_P16_13n XI1_I792_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I86_XP_MP0 (XI1_I792_I86_XP_p1 I1_I792_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I86_XP_MP1 (I1_I792_P20_19 I1_I792_pn19 XI1_I792_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I151_XP_MP0 (XI1_I746_I151_XP_p1 I1_I746_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I151_XP_MP1 (I1_I746_P26_19 I1_I746_P22_19n XI1_I746_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I92_XP_MP0 (XI1_I746_I92_XP_p1 I1_I746_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I92_XP_MP1 (I1_I746_P26_25 I1_I746_pn25 XI1_I746_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I155_XP_MP0 (XI1_I746_I155_XP_p1 I1_I746_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I155_XP_MP1 (I1_I746_P30_23 I1_I746_P26_23n XI1_I746_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I96_XP_MP0 (XI1_I746_I96_XP_p1 I1_I746_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I96_XP_MP1 (I1_I746_P30_29 I1_I746_pn29 XI1_I746_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I93_XP_MP0 (XI1_I746_I93_XP_p1 I1_I746_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I93_XP_MP1 (I1_I746_P27_26 I1_I746_pn26 XI1_I746_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I90_XP_MP0 (XI1_I1344_I90_XP_p1 I1_I1344_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I90_XP_MP1 (I1_I1344_P24_23 I1_I1344_pn23 XI1_I1344_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I87_XP_MP0 (XI1_I1344_I87_XP_p1 I1_I1344_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I87_XP_MP1 (I1_I1344_P21_20 I1_I1344_pn20 XI1_I1344_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I142_XP_MP0 (XI1_I1344_I142_XP_p1 I1_I1344_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I142_XP_MP1 (I1_I1344_P17_10 I1_I1344_P13_10n XI1_I1344_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I138_XP_MP0 (XI1_I1344_I138_XP_p1 I1_I1344_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I138_XP_MP1 (I1_I1344_P13_6 I1_I1344_P9_6n XI1_I1344_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I87_XP_MP0 (XI1_I1298_I87_XP_p1 I1_I1298_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I87_XP_MP1 (I1_I1298_P21_20 I1_I1298_pn20 XI1_I1298_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I151_XP_MP0 (XI1_I1298_I151_XP_p1 I1_I1298_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I151_XP_MP1 (I1_I1298_P26_19 I1_I1298_P22_19n XI1_I1298_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I88_XP_MP0 (XI1_I1298_I88_XP_p1 I1_I1298_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I88_XP_MP1 (I1_I1298_P22_21 I1_I1298_pn21 XI1_I1298_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I147_XP_MP0 (XI1_I1252_I147_XP_p1 I1_I1252_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I147_XP_MP1 (I1_I1252_P22_15 I1_I1252_P18_15n XI1_I1252_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I86_XP_MP0 (XI1_I1252_I86_XP_p1 I1_I1252_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I86_XP_MP1 (I1_I1252_P20_19 I1_I1252_pn19 XI1_I1252_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I148_XP_MP0 (XI1_I1252_I148_XP_p1 I1_I1252_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I148_XP_MP1 (I1_I1252_P23_16 I1_I1252_P19_16n XI1_I1252_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I152_XP_MP0 (XI1_I1252_I152_XP_p1 I1_I1252_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I152_XP_MP1 (I1_I1252_P27_20 I1_I1252_P23_20n XI1_I1252_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I87_XP_MP0 (XI1_I1252_I87_XP_p1 I1_I1252_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I87_XP_MP1 (I1_I1252_P21_20 I1_I1252_pn20 XI1_I1252_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I87_XP_MP0 (XI1_I1206_I87_XP_p1 I1_I1206_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I87_XP_MP1 (I1_I1206_P21_20 I1_I1206_pn20 XI1_I1206_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I88_XP_MP0 (XI1_I1206_I88_XP_p1 I1_I1206_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I88_XP_MP1 (I1_I1206_P22_21 I1_I1206_pn21 XI1_I1206_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I152_XP_MP0 (XI1_I1206_I152_XP_p1 I1_I1206_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I152_XP_MP1 (I1_I1206_P27_20 I1_I1206_P23_20n XI1_I1206_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I154_XP_MP0 (XI1_I1206_I154_XP_p1 I1_I1206_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I154_XP_MP1 (I1_I1206_P29_22 I1_I1206_P25_22n XI1_I1206_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I151_XP_MP0 (XI1_I1206_I151_XP_p1 I1_I1206_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I151_XP_MP1 (I1_I1206_P26_19 I1_I1206_P22_19n XI1_I1206_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I155_XP_MP0 (XI1_I838_I155_XP_p1 I1_I838_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I155_XP_MP1 (I1_I838_P30_23 I1_I838_P26_23n XI1_I838_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I153_XP_MP0 (XI1_I838_I153_XP_p1 I1_I838_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I153_XP_MP1 (I1_I838_P28_21 I1_I838_P24_21n XI1_I838_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I151_XP_MP0 (XI1_I838_I151_XP_p1 I1_I838_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I151_XP_MP1 (I1_I838_P26_19 I1_I838_P22_19n XI1_I838_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I147_XP_MP0 (XI1_I838_I147_XP_p1 I1_I838_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I147_XP_MP1 (I1_I838_P22_15 I1_I838_P18_15n XI1_I838_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I80_XP_MP0 (XI1_I838_I80_XP_p1 I1_I838_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I80_XP_MP1 (I1_I838_P14_13 I1_I838_pn13 XI1_I838_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I78_XP_MP0 (XI1_I838_I78_XP_p1 I1_I838_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I78_XP_MP1 (I1_I838_P12_11 I1_I838_pn11 XI1_I838_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I75_XP_MP0 (XI1_I838_I75_XP_p1 I1_I838_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I75_XP_MP1 (I1_I838_P9_8 I1_I838_pn8 XI1_I838_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I138_XP_MP0 (XI1_I792_I138_XP_p1 I1_I792_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I138_XP_MP1 (I1_I792_P13_6 I1_I792_P9_6n XI1_I792_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I136_XP_MP0 (XI1_I792_I136_XP_p1 I1_I792_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I136_XP_MP1 (I1_I792_P11_4 I1_I792_P7_4n XI1_I792_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I83_XP_MP0 (XI1_I792_I83_XP_p1 I1_I792_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I83_XP_MP1 (I1_I792_P17_16 I1_I792_pn16 XI1_I792_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I79_XP_MP0 (XI1_I792_I79_XP_p1 I1_I792_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I79_XP_MP1 (I1_I792_P13_12 I1_I792_pn12 XI1_I792_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I139_XP_MP0 (XI1_I792_I139_XP_p1 I1_I792_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I139_XP_MP1 (I1_I792_P14_7 I1_I792_P10_7n XI1_I792_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I143_XP_MP0 (XI1_I792_I143_XP_p1 I1_I792_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I143_XP_MP1 (I1_I792_P18_11 I1_I792_P14_11n XI1_I792_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I82_XP_MP0 (XI1_I792_I82_XP_p1 I1_I792_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I82_XP_MP1 (I1_I792_P16_15 I1_I792_pn15 XI1_I792_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I84_XP_MP0 (XI1_I792_I84_XP_p1 I1_I792_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I84_XP_MP1 (I1_I792_P18_17 I1_I792_pn17 XI1_I792_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I147_XP_MP0 (XI1_I746_I147_XP_p1 I1_I746_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I147_XP_MP1 (I1_I746_P22_15 I1_I746_P18_15n XI1_I746_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I153_XP_MP0 (XI1_I746_I153_XP_p1 I1_I746_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I153_XP_MP1 (I1_I746_P28_21 I1_I746_P24_21n XI1_I746_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I95_XP_MP0 (XI1_I746_I95_XP_p1 I1_I746_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I95_XP_MP1 (I1_I746_P29_28 I1_I746_pn28 XI1_I746_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I92_XP_MP0 (XI1_I1344_I92_XP_p1 I1_I1344_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I92_XP_MP1 (I1_I1344_P26_25 I1_I1344_pn25 XI1_I1344_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I85_XP_MP0 (XI1_I1344_I85_XP_p1 I1_I1344_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I85_XP_MP1 (I1_I1344_P19_18 I1_I1344_pn18 XI1_I1344_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I83_XP_MP0 (XI1_I1344_I83_XP_p1 I1_I1344_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I83_XP_MP1 (I1_I1344_P17_16 I1_I1344_pn16 XI1_I1344_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I144_XP_MP0 (XI1_I1298_I144_XP_p1 I1_I1298_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I144_XP_MP1 (I1_I1298_P19_12 I1_I1298_P15_12n XI1_I1298_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I146_XP_MP0 (XI1_I1298_I146_XP_p1 I1_I1298_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I146_XP_MP1 (I1_I1298_P21_14 I1_I1298_P17_14n XI1_I1298_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I85_XP_MP0 (XI1_I1298_I85_XP_p1 I1_I1298_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I85_XP_MP1 (I1_I1298_P19_18 I1_I1298_pn18 XI1_I1298_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I147_XP_MP0 (XI1_I1298_I147_XP_p1 I1_I1298_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I147_XP_MP1 (I1_I1298_P22_15 I1_I1298_P18_15n XI1_I1298_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I149_XP_MP0 (XI1_I1298_I149_XP_p1 I1_I1298_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I149_XP_MP1 (I1_I1298_P24_17 I1_I1298_P20_17n XI1_I1298_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I86_XP_MP0 (XI1_I1298_I86_XP_p1 I1_I1298_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I86_XP_MP1 (I1_I1298_P20_19 I1_I1298_pn19 XI1_I1298_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I145_XP_MP0 (XI1_I1252_I145_XP_p1 I1_I1252_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I145_XP_MP1 (I1_I1252_P20_13 I1_I1252_P16_13n XI1_I1252_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I149_XP_MP0 (XI1_I1252_I149_XP_p1 I1_I1252_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I149_XP_MP1 (I1_I1252_P24_17 I1_I1252_P20_17n XI1_I1252_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I146_XP_MP0 (XI1_I1252_I146_XP_p1 I1_I1252_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I146_XP_MP1 (I1_I1252_P21_14 I1_I1252_P17_14n XI1_I1252_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I150_XP_MP0 (XI1_I1252_I150_XP_p1 I1_I1252_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I150_XP_MP1 (I1_I1252_P25_18 I1_I1252_P21_18n XI1_I1252_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I86_XP_MP0 (XI1_I1206_I86_XP_p1 I1_I1206_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I86_XP_MP1 (I1_I1206_P20_19 I1_I1206_pn19 XI1_I1206_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I148_XP_MP0 (XI1_I1206_I148_XP_p1 I1_I1206_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I148_XP_MP1 (I1_I1206_P23_16 I1_I1206_P19_16n XI1_I1206_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I147_XP_MP0 (XI1_I1206_I147_XP_p1 I1_I1206_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I147_XP_MP1 (I1_I1206_P22_15 I1_I1206_P18_15n XI1_I1206_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I149_XP_MP0 (XI1_I1206_I149_XP_p1 I1_I1206_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I149_XP_MP1 (I1_I1206_P24_17 I1_I1206_P20_17n XI1_I1206_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I149_XP_MP0 (XI1_I838_I149_XP_p1 I1_I838_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I149_XP_MP1 (I1_I838_P24_17 I1_I838_P20_17n XI1_I838_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I145_XP_MP0 (XI1_I838_I145_XP_p1 I1_I838_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I145_XP_MP1 (I1_I838_P20_13 I1_I838_P16_13n XI1_I838_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I143_XP_MP0 (XI1_I838_I143_XP_p1 I1_I838_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I143_XP_MP1 (I1_I838_P18_11 I1_I838_P14_11n XI1_I838_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I139_XP_MP0 (XI1_I838_I139_XP_p1 I1_I838_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I139_XP_MP1 (I1_I838_P14_7 I1_I838_P10_7n XI1_I838_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I141_XP_MP0 (XI1_I838_I141_XP_p1 I1_I838_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I141_XP_MP1 (I1_I838_P16_9 I1_I838_P12_9n XI1_I838_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I135_XP_MP0 (XI1_I838_I135_XP_p1 I1_I838_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I135_XP_MP1 (I1_I838_P10_3 I1_I838_P6_3n XI1_I838_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I76_XP_MP0 (XI1_I838_I76_XP_p1 I1_I838_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I76_XP_MP1 (I1_I838_P10_9 I1_I838_pn9 XI1_I838_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I74_XP_MP0 (XI1_I838_I74_XP_p1 I1_I838_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I74_XP_MP1 (I1_I838_P8_7 I1_I838_pn7 XI1_I838_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I134_XP_MP0 (XI1_I792_I134_XP_p1 I1_I792_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I134_XP_MP1 (I1_I792_P9_2 I1_I792_P5_2n XI1_I792_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I75_XP_MP0 (XI1_I792_I75_XP_p1 I1_I792_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I75_XP_MP1 (I1_I792_P9_8 I1_I792_pn8 XI1_I792_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I77_XP_MP0 (XI1_I792_I77_XP_p1 I1_I792_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I77_XP_MP1 (I1_I792_P11_10 I1_I792_pn10 XI1_I792_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I135_XP_MP0 (XI1_I792_I135_XP_p1 I1_I792_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I135_XP_MP1 (I1_I792_P10_3 I1_I792_P6_3n XI1_I792_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I141_XP_MP0 (XI1_I792_I141_XP_p1 I1_I792_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I141_XP_MP1 (I1_I792_P16_9 I1_I792_P12_9n XI1_I792_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I78_XP_MP0 (XI1_I792_I78_XP_p1 I1_I792_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I78_XP_MP1 (I1_I792_P12_11 I1_I792_pn11 XI1_I792_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I135_XP_MP0 (XI1_I746_I135_XP_p1 I1_I746_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I135_XP_MP1 (I1_I746_P10_3 I1_I746_P6_3n XI1_I746_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I139_XP_MP0 (XI1_I746_I139_XP_p1 I1_I746_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I139_XP_MP1 (I1_I746_P14_7 I1_I746_P10_7n XI1_I746_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I143_XP_MP0 (XI1_I746_I143_XP_p1 I1_I746_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I143_XP_MP1 (I1_I746_P18_11 I1_I746_P14_11n XI1_I746_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I149_XP_MP0 (XI1_I746_I149_XP_p1 I1_I746_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I149_XP_MP1 (I1_I746_P24_17 I1_I746_P20_17n XI1_I746_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I90_XP_MP0 (XI1_I746_I90_XP_p1 I1_I746_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I90_XP_MP1 (I1_I746_P24_23 I1_I746_pn23 XI1_I746_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I91_XP_MP0 (XI1_I746_I91_XP_p1 I1_I746_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I91_XP_MP1 (I1_I746_P25_24 I1_I746_pn24 XI1_I746_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I97_XP_MP0 (XI1_I746_I97_XP_p1 I1_I746_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I97_XP_MP1 (I1_I746_P31_30 I1_I746_pn30 XI1_I746_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I155_XP_MP0 (XI1_I1344_I155_XP_p1 I1_I1344_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I155_XP_MP1 (I1_I1344_P30_23 I1_I1344_P26_23n XI1_I1344_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I153_XP_MP0 (XI1_I1344_I153_XP_p1 I1_I1344_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I153_XP_MP1 (I1_I1344_P28_21 I1_I1344_P24_21n XI1_I1344_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I88_XP_MP0 (XI1_I1344_I88_XP_p1 I1_I1344_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I88_XP_MP1 (I1_I1344_P22_21 I1_I1344_pn21 XI1_I1344_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I86_XP_MP0 (XI1_I1344_I86_XP_p1 I1_I1344_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I86_XP_MP1 (I1_I1344_P20_19 I1_I1344_pn19 XI1_I1344_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I84_XP_MP0 (XI1_I1344_I84_XP_p1 I1_I1344_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I84_XP_MP1 (I1_I1344_P18_17 I1_I1344_pn17 XI1_I1344_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I82_XP_MP0 (XI1_I1344_I82_XP_p1 I1_I1344_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I82_XP_MP1 (I1_I1344_P16_15 I1_I1344_pn15 XI1_I1344_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I81_XP_MP0 (XI1_I1344_I81_XP_p1 I1_I1344_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I81_XP_MP1 (I1_I1344_P15_14 I1_I1344_pn14 XI1_I1344_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I134_XP_MP0 (XI1_I1344_I134_XP_p1 I1_I1344_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I134_XP_MP1 (I1_I1344_P9_2 I1_I1344_P5_2n XI1_I1344_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I140_XP_MP0 (XI1_I1298_I140_XP_p1 I1_I1298_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I140_XP_MP1 (I1_I1298_P15_8 I1_I1298_P11_8n XI1_I1298_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I83_XP_MP0 (XI1_I1298_I83_XP_p1 I1_I1298_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I83_XP_MP1 (I1_I1298_P17_16 I1_I1298_pn16 XI1_I1298_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I145_XP_MP0 (XI1_I1298_I145_XP_p1 I1_I1298_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I145_XP_MP1 (I1_I1298_P20_13 I1_I1298_P16_13n XI1_I1298_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I84_XP_MP0 (XI1_I1298_I84_XP_p1 I1_I1298_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I84_XP_MP1 (I1_I1298_P18_17 I1_I1298_pn17 XI1_I1298_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I84_XP_MP0 (XI1_I1252_I84_XP_p1 I1_I1252_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I84_XP_MP1 (I1_I1252_P18_17 I1_I1252_pn17 XI1_I1252_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I144_XP_MP0 (XI1_I1252_I144_XP_p1 I1_I1252_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I144_XP_MP1 (I1_I1252_P19_12 I1_I1252_P15_12n XI1_I1252_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I85_XP_MP0 (XI1_I1252_I85_XP_p1 I1_I1252_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I85_XP_MP1 (I1_I1252_P19_18 I1_I1252_pn18 XI1_I1252_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I85_XP_MP0 (XI1_I1206_I85_XP_p1 I1_I1206_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I85_XP_MP1 (I1_I1206_P19_18 I1_I1206_pn18 XI1_I1206_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I150_XP_MP0 (XI1_I1206_I150_XP_p1 I1_I1206_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I150_XP_MP1 (I1_I1206_P25_18 I1_I1206_P21_18n XI1_I1206_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I146_XP_MP0 (XI1_I1206_I146_XP_p1 I1_I1206_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I146_XP_MP1 (I1_I1206_P21_14 I1_I1206_P17_14n XI1_I1206_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I145_XP_MP0 (XI1_I1206_I145_XP_p1 I1_I1206_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I145_XP_MP1 (I1_I1206_P20_13 I1_I1206_P16_13n XI1_I1206_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I137_XP_MP0 (XI1_I838_I137_XP_p1 I1_I838_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I137_XP_MP1 (I1_I838_P12_5 I1_I838_P8_5n XI1_I838_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I73_XP_MP0 (XI1_I838_I73_XP_p1 I1_I838_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I73_XP_MP1 (I1_I838_P7_6 I1_I838_pn6 XI1_I838_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I73_XP_MP0 (XI1_I792_I73_XP_p1 I1_I792_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I73_XP_MP1 (I1_I792_P7_6 I1_I792_pn6 XI1_I792_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I133_XP_MP0 (XI1_I792_I133_XP_p1 I1_I792_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I133_XP_MP1 (I1_I792_P8_1 I1_I792_P4_1n XI1_I792_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I74_XP_MP0 (XI1_I792_I74_XP_p1 I1_I792_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I74_XP_MP1 (I1_I792_P8_7 I1_I792_pn7 XI1_I792_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I76_XP_MP0 (XI1_I792_I76_XP_p1 I1_I792_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I76_XP_MP1 (I1_I792_P10_9 I1_I792_pn9 XI1_I792_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I137_XP_MP0 (XI1_I792_I137_XP_p1 I1_I792_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I137_XP_MP1 (I1_I792_P12_5 I1_I792_P8_5n XI1_I792_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I80_XP_MP0 (XI1_I792_I80_XP_p1 I1_I792_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I80_XP_MP1 (I1_I792_P14_13 I1_I792_pn13 XI1_I792_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I137_XP_MP0 (XI1_I746_I137_XP_p1 I1_I746_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I137_XP_MP1 (I1_I746_P12_5 I1_I746_P8_5n XI1_I746_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I141_XP_MP0 (XI1_I746_I141_XP_p1 I1_I746_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I141_XP_MP1 (I1_I746_P16_9 I1_I746_P12_9n XI1_I746_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I145_XP_MP0 (XI1_I746_I145_XP_p1 I1_I746_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I145_XP_MP1 (I1_I746_P20_13 I1_I746_P16_13n XI1_I746_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I84_XP_MP0 (XI1_I746_I84_XP_p1 I1_I746_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I84_XP_MP1 (I1_I746_P18_17 I1_I746_pn17 XI1_I746_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I86_XP_MP0 (XI1_I746_I86_XP_p1 I1_I746_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I86_XP_MP1 (I1_I746_P20_19 I1_I746_pn19 XI1_I746_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I88_XP_MP0 (XI1_I746_I88_XP_p1 I1_I746_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I88_XP_MP1 (I1_I746_P22_21 I1_I746_pn21 XI1_I746_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I154_XP_MP0 (XI1_I746_I154_XP_p1 I1_I746_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I154_XP_MP1 (I1_I746_P29_22 I1_I746_P25_22n XI1_I746_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I151_XP_MP0 (XI1_I1344_I151_XP_p1 I1_I1344_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I151_XP_MP1 (I1_I1344_P26_19 I1_I1344_P22_19n XI1_I1344_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I147_XP_MP0 (XI1_I1344_I147_XP_p1 I1_I1344_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I147_XP_MP1 (I1_I1344_P22_15 I1_I1344_P18_15n XI1_I1344_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I149_XP_MP0 (XI1_I1344_I149_XP_p1 I1_I1344_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I149_XP_MP1 (I1_I1344_P24_17 I1_I1344_P20_17n XI1_I1344_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I80_XP_MP0 (XI1_I1344_I80_XP_p1 I1_I1344_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I80_XP_MP1 (I1_I1344_P14_13 I1_I1344_pn13 XI1_I1344_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I138_XP_MP0 (XI1_I1298_I138_XP_p1 I1_I1298_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I138_XP_MP1 (I1_I1298_P13_6 I1_I1298_P9_6n XI1_I1298_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I142_XP_MP0 (XI1_I1298_I142_XP_p1 I1_I1298_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I142_XP_MP1 (I1_I1298_P17_10 I1_I1298_P13_10n XI1_I1298_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I81_XP_MP0 (XI1_I1298_I81_XP_p1 I1_I1298_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I81_XP_MP1 (I1_I1298_P15_14 I1_I1298_pn14 XI1_I1298_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I143_XP_MP0 (XI1_I1298_I143_XP_p1 I1_I1298_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I143_XP_MP1 (I1_I1298_P18_11 I1_I1298_P14_11n XI1_I1298_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I139_XP_MP0 (XI1_I1298_I139_XP_p1 I1_I1298_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I139_XP_MP1 (I1_I1298_P14_7 I1_I1298_P10_7n XI1_I1298_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I82_XP_MP0 (XI1_I1298_I82_XP_p1 I1_I1298_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I82_XP_MP1 (I1_I1298_P16_15 I1_I1298_pn15 XI1_I1298_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I143_XP_MP0 (XI1_I1252_I143_XP_p1 I1_I1252_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I143_XP_MP1 (I1_I1252_P18_11 I1_I1252_P14_11n XI1_I1252_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I82_XP_MP0 (XI1_I1252_I82_XP_p1 I1_I1252_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I82_XP_MP1 (I1_I1252_P16_15 I1_I1252_pn15 XI1_I1252_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I140_XP_MP0 (XI1_I1252_I140_XP_p1 I1_I1252_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I140_XP_MP1 (I1_I1252_P15_8 I1_I1252_P11_8n XI1_I1252_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I83_XP_MP0 (XI1_I1252_I83_XP_p1 I1_I1252_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I83_XP_MP1 (I1_I1252_P17_16 I1_I1252_pn16 XI1_I1252_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I83_XP_MP0 (XI1_I1206_I83_XP_p1 I1_I1206_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I83_XP_MP1 (I1_I1206_P17_16 I1_I1206_pn16 XI1_I1206_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I84_XP_MP0 (XI1_I1206_I84_XP_p1 I1_I1206_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I84_XP_MP1 (I1_I1206_P18_17 I1_I1206_pn17 XI1_I1206_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I144_XP_MP0 (XI1_I1206_I144_XP_p1 I1_I1206_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I144_XP_MP1 (I1_I1206_P19_12 I1_I1206_P15_12n XI1_I1206_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I143_XP_MP0 (XI1_I1206_I143_XP_p1 I1_I1206_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I143_XP_MP1 (I1_I1206_P18_11 I1_I1206_P14_11n XI1_I1206_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I133_XP_MP0 (XI1_I838_I133_XP_p1 I1_I838_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I133_XP_MP1 (I1_I838_P8_1 I1_I838_P4_1n XI1_I838_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I72_XP_MP0 (XI1_I838_I72_XP_p1 I1_I838_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I72_XP_MP1 (I1_I838_P6_5 I1_I838_pn5 XI1_I838_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I71_XP_MP0 (XI1_I838_I71_XP_p1 I1_I838_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I71_XP_MP1 (I1_I838_P5_4 I1_I838_pn4 XI1_I838_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I71_XP_MP0 (XI1_I792_I71_XP_p1 I1_I792_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I71_XP_MP1 (I1_I792_P5_4 I1_I792_pn4 XI1_I792_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I72_XP_MP0 (XI1_I792_I72_XP_p1 I1_I792_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I72_XP_MP1 (I1_I792_P6_5 I1_I792_pn5 XI1_I792_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I133_XP_MP0 (XI1_I746_I133_XP_p1 I1_I746_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I133_XP_MP1 (I1_I746_P8_1 I1_I746_P4_1n XI1_I746_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I76_XP_MP0 (XI1_I746_I76_XP_p1 I1_I746_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I76_XP_MP1 (I1_I746_P10_9 I1_I746_pn9 XI1_I746_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I78_XP_MP0 (XI1_I746_I78_XP_p1 I1_I746_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I78_XP_MP1 (I1_I746_P12_11 I1_I746_pn11 XI1_I746_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I80_XP_MP0 (XI1_I746_I80_XP_p1 I1_I746_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I80_XP_MP1 (I1_I746_P14_13 I1_I746_pn13 XI1_I746_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I82_XP_MP0 (XI1_I746_I82_XP_p1 I1_I746_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I82_XP_MP1 (I1_I746_P16_15 I1_I746_pn15 XI1_I746_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I89_XP_MP0 (XI1_I746_I89_XP_p1 I1_I746_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I89_XP_MP1 (I1_I746_P23_22 I1_I746_pn22 XI1_I746_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I145_XP_MP0 (XI1_I1344_I145_XP_p1 I1_I1344_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I145_XP_MP1 (I1_I1344_P20_13 I1_I1344_P16_13n XI1_I1344_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I143_XP_MP0 (XI1_I1344_I143_XP_p1 I1_I1344_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I143_XP_MP1 (I1_I1344_P18_11 I1_I1344_P14_11n XI1_I1344_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I141_XP_MP0 (XI1_I1344_I141_XP_p1 I1_I1344_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I141_XP_MP1 (I1_I1344_P16_9 I1_I1344_P12_9n XI1_I1344_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I78_XP_MP0 (XI1_I1344_I78_XP_p1 I1_I1344_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I78_XP_MP1 (I1_I1344_P12_11 I1_I1344_pn11 XI1_I1344_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I79_XP_MP0 (XI1_I1344_I79_XP_p1 I1_I1344_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I79_XP_MP1 (I1_I1344_P13_12 I1_I1344_pn12 XI1_I1344_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I136_XP_MP0 (XI1_I1298_I136_XP_p1 I1_I1298_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I136_XP_MP1 (I1_I1298_P11_4 I1_I1298_P7_4n XI1_I1298_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I79_XP_MP0 (XI1_I1298_I79_XP_p1 I1_I1298_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I79_XP_MP1 (I1_I1298_P13_12 I1_I1298_pn12 XI1_I1298_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I141_XP_MP0 (XI1_I1298_I141_XP_p1 I1_I1298_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I141_XP_MP1 (I1_I1298_P16_9 I1_I1298_P12_9n XI1_I1298_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I80_XP_MP0 (XI1_I1298_I80_XP_p1 I1_I1298_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I80_XP_MP1 (I1_I1298_P14_13 I1_I1298_pn13 XI1_I1298_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I141_XP_MP0 (XI1_I1252_I141_XP_p1 I1_I1252_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I141_XP_MP1 (I1_I1252_P16_9 I1_I1252_P12_9n XI1_I1252_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I139_XP_MP0 (XI1_I1252_I139_XP_p1 I1_I1252_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I139_XP_MP1 (I1_I1252_P14_7 I1_I1252_P10_7n XI1_I1252_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I80_XP_MP0 (XI1_I1252_I80_XP_p1 I1_I1252_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I80_XP_MP1 (I1_I1252_P14_13 I1_I1252_pn13 XI1_I1252_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I138_XP_MP0 (XI1_I1252_I138_XP_p1 I1_I1252_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I138_XP_MP1 (I1_I1252_P13_6 I1_I1252_P9_6n XI1_I1252_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I142_XP_MP0 (XI1_I1252_I142_XP_p1 I1_I1252_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I142_XP_MP1 (I1_I1252_P17_10 I1_I1252_P13_10n XI1_I1252_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I79_XP_MP0 (XI1_I1252_I79_XP_p1 I1_I1252_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I79_XP_MP1 (I1_I1252_P13_12 I1_I1252_pn12 XI1_I1252_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I81_XP_MP0 (XI1_I1252_I81_XP_p1 I1_I1252_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I81_XP_MP1 (I1_I1252_P15_14 I1_I1252_pn14 XI1_I1252_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I81_XP_MP0 (XI1_I1206_I81_XP_p1 I1_I1206_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I81_XP_MP1 (I1_I1206_P15_14 I1_I1206_pn14 XI1_I1206_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I82_XP_MP0 (XI1_I1206_I82_XP_p1 I1_I1206_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I82_XP_MP1 (I1_I1206_P16_15 I1_I1206_pn15 XI1_I1206_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I140_XP_MP0 (XI1_I1206_I140_XP_p1 I1_I1206_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I140_XP_MP1 (I1_I1206_P15_8 I1_I1206_P11_8n XI1_I1206_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I142_XP_MP0 (XI1_I1206_I142_XP_p1 I1_I1206_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I142_XP_MP1 (I1_I1206_P17_10 I1_I1206_P13_10n XI1_I1206_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I138_XP_MP0 (XI1_I1206_I138_XP_p1 I1_I1206_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I138_XP_MP1 (I1_I1206_P13_6 I1_I1206_P9_6n XI1_I1206_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I139_XP_MP0 (XI1_I1206_I139_XP_p1 I1_I1206_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I139_XP_MP1 (I1_I1206_P14_7 I1_I1206_P10_7n XI1_I1206_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I141_XP_MP0 (XI1_I1206_I141_XP_p1 I1_I1206_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I141_XP_MP1 (I1_I1206_P16_9 I1_I1206_P12_9n XI1_I1206_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I95_XP_MP0 (XI1_I884_I95_XP_p1 I1_I884_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I95_XP_MP1 (I1_I884_P29_28 I1_I884_pn28 XI1_I884_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I93_XP_MP0 (XI1_I884_I93_XP_p1 I1_I884_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I93_XP_MP1 (I1_I884_P27_26 I1_I884_pn26 XI1_I884_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I91_XP_MP0 (XI1_I884_I91_XP_p1 I1_I884_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I91_XP_MP1 (I1_I884_P25_24 I1_I884_pn24 XI1_I884_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I87_XP_MP0 (XI1_I884_I87_XP_p1 I1_I884_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I87_XP_MP1 (I1_I884_P21_20 I1_I884_pn20 XI1_I884_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I70_XP_MP0 (XI1_I838_I70_XP_p1 I1_I838_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I70_XP_MP1 (I1_I838_P4_3 I1_I838_pn3 XI1_I838_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I69_XP_MP0 (XI1_I838_I69_XP_p1 I1_I838_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I69_XP_MP1 (I1_I838_P3_2 I1_I838_pn2 XI1_I838_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I70_XP_MP0 (XI1_I792_I70_XP_p1 I1_I792_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I70_XP_MP1 (I1_I792_P4_3 I1_I792_pn3 XI1_I792_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I74_XP_MP0 (XI1_I746_I74_XP_p1 I1_I746_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I74_XP_MP1 (I1_I746_P8_7 I1_I746_pn7 XI1_I746_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I134_XP_MP0 (XI1_I746_I134_XP_p1 I1_I746_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I134_XP_MP1 (I1_I746_P9_2 I1_I746_P5_2n XI1_I746_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I138_XP_MP0 (XI1_I746_I138_XP_p1 I1_I746_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I138_XP_MP1 (I1_I746_P13_6 I1_I746_P9_6n XI1_I746_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I81_XP_MP0 (XI1_I746_I81_XP_p1 I1_I746_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I81_XP_MP1 (I1_I746_P15_14 I1_I746_pn14 XI1_I746_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I142_XP_MP0 (XI1_I746_I142_XP_p1 I1_I746_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I142_XP_MP1 (I1_I746_P17_10 I1_I746_P13_10n XI1_I746_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I83_XP_MP0 (XI1_I746_I83_XP_p1 I1_I746_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I83_XP_MP1 (I1_I746_P17_16 I1_I746_pn16 XI1_I746_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I85_XP_MP0 (XI1_I746_I85_XP_p1 I1_I746_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I85_XP_MP1 (I1_I746_P19_18 I1_I746_pn18 XI1_I746_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I87_XP_MP0 (XI1_I746_I87_XP_p1 I1_I746_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I87_XP_MP1 (I1_I746_P21_20 I1_I746_pn20 XI1_I746_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I152_XP_MP0 (XI1_I746_I152_XP_p1 I1_I746_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I152_XP_MP1 (I1_I746_P27_20 I1_I746_P23_20n XI1_I746_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I156_XP_MP0 (XI1_I746_I156_XP_p1 I1_I746_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I156_XP_MP1 (I1_I746_P31_24 I1_I746_P27_24n XI1_I746_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I139_XP_MP0 (XI1_I1344_I139_XP_p1 I1_I1344_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I139_XP_MP1 (I1_I1344_P14_7 I1_I1344_P10_7n XI1_I1344_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I137_XP_MP0 (XI1_I1344_I137_XP_p1 I1_I1344_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I137_XP_MP1 (I1_I1344_P12_5 I1_I1344_P8_5n XI1_I1344_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I76_XP_MP0 (XI1_I1344_I76_XP_p1 I1_I1344_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I76_XP_MP1 (I1_I1344_P10_9 I1_I1344_pn9 XI1_I1344_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I77_XP_MP0 (XI1_I1344_I77_XP_p1 I1_I1344_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I77_XP_MP1 (I1_I1344_P11_10 I1_I1344_pn10 XI1_I1344_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I134_XP_MP0 (XI1_I1298_I134_XP_p1 I1_I1298_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I134_XP_MP1 (I1_I1298_P9_2 I1_I1298_P5_2n XI1_I1298_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I77_XP_MP0 (XI1_I1298_I77_XP_p1 I1_I1298_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I77_XP_MP1 (I1_I1298_P11_10 I1_I1298_pn10 XI1_I1298_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I137_XP_MP0 (XI1_I1298_I137_XP_p1 I1_I1298_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I137_XP_MP1 (I1_I1298_P12_5 I1_I1298_P8_5n XI1_I1298_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I78_XP_MP0 (XI1_I1298_I78_XP_p1 I1_I1298_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I78_XP_MP1 (I1_I1298_P12_11 I1_I1298_pn11 XI1_I1298_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I137_XP_MP0 (XI1_I1252_I137_XP_p1 I1_I1252_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I137_XP_MP1 (I1_I1252_P12_5 I1_I1252_P8_5n XI1_I1252_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I78_XP_MP0 (XI1_I1252_I78_XP_p1 I1_I1252_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I78_XP_MP1 (I1_I1252_P12_11 I1_I1252_pn11 XI1_I1252_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I136_XP_MP0 (XI1_I1252_I136_XP_p1 I1_I1252_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I136_XP_MP1 (I1_I1252_P11_4 I1_I1252_P7_4n XI1_I1252_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I77_XP_MP0 (XI1_I1252_I77_XP_p1 I1_I1252_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I77_XP_MP1 (I1_I1252_P11_10 I1_I1252_pn10 XI1_I1252_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I80_XP_MP0 (XI1_I1206_I80_XP_p1 I1_I1206_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I80_XP_MP1 (I1_I1206_P14_13 I1_I1206_pn13 XI1_I1206_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I79_XP_MP0 (XI1_I1206_I79_XP_p1 I1_I1206_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I79_XP_MP1 (I1_I1206_P13_12 I1_I1206_pn12 XI1_I1206_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I77_XP_MP0 (XI1_I1206_I77_XP_p1 I1_I1206_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I77_XP_MP1 (I1_I1206_P11_10 I1_I1206_pn10 XI1_I1206_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I136_XP_MP0 (XI1_I1206_I136_XP_p1 I1_I1206_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I136_XP_MP1 (I1_I1206_P11_4 I1_I1206_P7_4n XI1_I1206_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I134_XP_MP0 (XI1_I1206_I134_XP_p1 I1_I1206_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I134_XP_MP1 (I1_I1206_P9_2 I1_I1206_P5_2n XI1_I1206_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I135_XP_MP0 (XI1_I1206_I135_XP_p1 I1_I1206_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I135_XP_MP1 (I1_I1206_P10_3 I1_I1206_P6_3n XI1_I1206_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I137_XP_MP0 (XI1_I1206_I137_XP_p1 I1_I1206_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I137_XP_MP1 (I1_I1206_P12_5 I1_I1206_P8_5n XI1_I1206_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I156_XP_MP0 (XI1_I884_I156_XP_p1 I1_I884_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I156_XP_MP1 (I1_I884_P31_24 I1_I884_P27_24n XI1_I884_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I154_XP_MP0 (XI1_I884_I154_XP_p1 I1_I884_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I154_XP_MP1 (I1_I884_P29_22 I1_I884_P25_22n XI1_I884_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I89_XP_MP0 (XI1_I884_I89_XP_p1 I1_I884_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I89_XP_MP1 (I1_I884_P23_22 I1_I884_pn22 XI1_I884_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I152_XP_MP0 (XI1_I884_I152_XP_p1 I1_I884_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I152_XP_MP1 (I1_I884_P27_20 I1_I884_P23_20n XI1_I884_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I150_XP_MP0 (XI1_I884_I150_XP_p1 I1_I884_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I150_XP_MP1 (I1_I884_P25_18 I1_I884_P21_18n XI1_I884_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I144_XP_MP0 (XI1_I884_I144_XP_p1 I1_I884_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I144_XP_MP1 (I1_I884_P19_12 I1_I884_P15_12n XI1_I884_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I85_XP_MP0 (XI1_I884_I85_XP_p1 I1_I884_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I85_XP_MP1 (I1_I884_P19_18 I1_I884_pn18 XI1_I884_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I83_XP_MP0 (XI1_I884_I83_XP_p1 I1_I884_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I83_XP_MP1 (I1_I884_P17_16 I1_I884_pn16 XI1_I884_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I81_XP_MP0 (XI1_I884_I81_XP_p1 I1_I884_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I81_XP_MP1 (I1_I884_P15_14 I1_I884_pn14 XI1_I884_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I68_XP_MP0 (XI1_I838_I68_XP_p1 I1_I838_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I68_XP_MP1 (I1_I838_P2_1 I1_I838_pn1 XI1_I838_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I69_XP_MP0 (XI1_I792_I69_XP_p1 I1_I792_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I69_XP_MP1 (I1_I792_P3_2 I1_I792_pn2 XI1_I792_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I68_XP_MP0 (XI1_I792_I68_XP_p1 I1_I792_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I68_XP_MP1 (I1_I792_P2_1 I1_I792_pn1 XI1_I792_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I72_XP_MP0 (XI1_I746_I72_XP_p1 I1_I746_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I72_XP_MP1 (I1_I746_P6_5 I1_I746_pn5 XI1_I746_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I73_XP_MP0 (XI1_I746_I73_XP_p1 I1_I746_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I73_XP_MP1 (I1_I746_P7_6 I1_I746_pn6 XI1_I746_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I75_XP_MP0 (XI1_I746_I75_XP_p1 I1_I746_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I75_XP_MP1 (I1_I746_P9_8 I1_I746_pn8 XI1_I746_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I77_XP_MP0 (XI1_I746_I77_XP_p1 I1_I746_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I77_XP_MP1 (I1_I746_P11_10 I1_I746_pn10 XI1_I746_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I136_XP_MP0 (XI1_I746_I136_XP_p1 I1_I746_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I136_XP_MP1 (I1_I746_P11_4 I1_I746_P7_4n XI1_I746_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I79_XP_MP0 (XI1_I746_I79_XP_p1 I1_I746_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I79_XP_MP1 (I1_I746_P13_12 I1_I746_pn12 XI1_I746_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I140_XP_MP0 (XI1_I746_I140_XP_p1 I1_I746_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I140_XP_MP1 (I1_I746_P15_8 I1_I746_P11_8n XI1_I746_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I144_XP_MP0 (XI1_I746_I144_XP_p1 I1_I746_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I144_XP_MP1 (I1_I746_P19_12 I1_I746_P15_12n XI1_I746_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I148_XP_MP0 (XI1_I746_I148_XP_p1 I1_I746_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I148_XP_MP1 (I1_I746_P23_16 I1_I746_P19_16n XI1_I746_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I135_XP_MP0 (XI1_I1344_I135_XP_p1 I1_I1344_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I135_XP_MP1 (I1_I1344_P10_3 I1_I1344_P6_3n XI1_I1344_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I75_XP_MP0 (XI1_I1344_I75_XP_p1 I1_I1344_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I75_XP_MP1 (I1_I1344_P9_8 I1_I1344_pn8 XI1_I1344_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I75_XP_MP0 (XI1_I1298_I75_XP_p1 I1_I1298_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I75_XP_MP1 (I1_I1298_P9_8 I1_I1298_pn8 XI1_I1298_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I135_XP_MP0 (XI1_I1298_I135_XP_p1 I1_I1298_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I135_XP_MP1 (I1_I1298_P10_3 I1_I1298_P6_3n XI1_I1298_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I74_XP_MP0 (XI1_I1298_I74_XP_p1 I1_I1298_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I74_XP_MP1 (I1_I1298_P8_7 I1_I1298_pn7 XI1_I1298_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I76_XP_MP0 (XI1_I1298_I76_XP_p1 I1_I1298_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I76_XP_MP1 (I1_I1298_P10_9 I1_I1298_pn9 XI1_I1298_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I135_XP_MP0 (XI1_I1252_I135_XP_p1 I1_I1252_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I135_XP_MP1 (I1_I1252_P10_3 I1_I1252_P6_3n XI1_I1252_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I76_XP_MP0 (XI1_I1252_I76_XP_p1 I1_I1252_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I76_XP_MP1 (I1_I1252_P10_9 I1_I1252_pn9 XI1_I1252_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I134_XP_MP0 (XI1_I1252_I134_XP_p1 I1_I1252_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I134_XP_MP1 (I1_I1252_P9_2 I1_I1252_P5_2n XI1_I1252_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I75_XP_MP0 (XI1_I1252_I75_XP_p1 I1_I1252_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I75_XP_MP1 (I1_I1252_P9_8 I1_I1252_pn8 XI1_I1252_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I78_XP_MP0 (XI1_I1206_I78_XP_p1 I1_I1206_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I78_XP_MP1 (I1_I1206_P12_11 I1_I1206_pn11 XI1_I1206_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I76_XP_MP0 (XI1_I1206_I76_XP_p1 I1_I1206_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I76_XP_MP1 (I1_I1206_P10_9 I1_I1206_pn9 XI1_I1206_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I75_XP_MP0 (XI1_I1206_I75_XP_p1 I1_I1206_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I75_XP_MP1 (I1_I1206_P9_8 I1_I1206_pn8 XI1_I1206_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I97_XP_MP0 (XI1_I884_I97_XP_p1 I1_I884_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I97_XP_MP1 (I1_I884_P31_30 I1_I884_pn30 XI1_I884_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I94_XP_MP0 (XI1_I884_I94_XP_p1 I1_I884_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I94_XP_MP1 (I1_I884_P28_27 I1_I884_pn27 XI1_I884_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I148_XP_MP0 (XI1_I884_I148_XP_p1 I1_I884_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I148_XP_MP1 (I1_I884_P23_16 I1_I884_P19_16n XI1_I884_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I146_XP_MP0 (XI1_I884_I146_XP_p1 I1_I884_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I146_XP_MP1 (I1_I884_P21_14 I1_I884_P17_14n XI1_I884_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I140_XP_MP0 (XI1_I884_I140_XP_p1 I1_I884_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I140_XP_MP1 (I1_I884_P15_8 I1_I884_P11_8n XI1_I884_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I142_XP_MP0 (XI1_I884_I142_XP_p1 I1_I884_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I142_XP_MP1 (I1_I884_P17_10 I1_I884_P13_10n XI1_I884_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I138_XP_MP0 (XI1_I884_I138_XP_p1 I1_I884_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I138_XP_MP1 (I1_I884_P13_6 I1_I884_P9_6n XI1_I884_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I79_XP_MP0 (XI1_I884_I79_XP_p1 I1_I884_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I79_XP_MP1 (I1_I884_P13_12 I1_I884_pn12 XI1_I884_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I136_XP_MP0 (XI1_I884_I136_XP_p1 I1_I884_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I136_XP_MP1 (I1_I884_P11_4 I1_I884_P7_4n XI1_I884_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I77_XP_MP0 (XI1_I884_I77_XP_p1 I1_I884_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I77_XP_MP1 (I1_I884_P11_10 I1_I884_pn10 XI1_I884_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I75_XP_MP0 (XI1_I884_I75_XP_p1 I1_I884_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I75_XP_MP1 (I1_I884_P9_8 I1_I884_pn8 XI1_I884_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I68_XP_MP0 (XI1_I746_I68_XP_p1 I1_I746_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I68_XP_MP1 (I1_I746_P2_1 I1_I746_pn1 XI1_I746_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I69_XP_MP0 (XI1_I746_I69_XP_p1 I1_I746_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I69_XP_MP1 (I1_I746_P3_2 I1_I746_pn2 XI1_I746_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I70_XP_MP0 (XI1_I746_I70_XP_p1 I1_I746_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I70_XP_MP1 (I1_I746_P4_3 I1_I746_pn3 XI1_I746_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I71_XP_MP0 (XI1_I746_I71_XP_p1 I1_I746_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I71_XP_MP1 (I1_I746_P5_4 I1_I746_pn4 XI1_I746_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I133_XP_MP0 (XI1_I1344_I133_XP_p1 I1_I1344_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I133_XP_MP1 (I1_I1344_P8_1 I1_I1344_P4_1n XI1_I1344_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I74_XP_MP0 (XI1_I1344_I74_XP_p1 I1_I1344_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I74_XP_MP1 (I1_I1344_P8_7 I1_I1344_pn7 XI1_I1344_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I73_XP_MP0 (XI1_I1344_I73_XP_p1 I1_I1344_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I73_XP_MP1 (I1_I1344_P7_6 I1_I1344_pn6 XI1_I1344_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I73_XP_MP0 (XI1_I1298_I73_XP_p1 I1_I1298_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I73_XP_MP1 (I1_I1298_P7_6 I1_I1298_pn6 XI1_I1298_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I133_XP_MP0 (XI1_I1298_I133_XP_p1 I1_I1298_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I133_XP_MP1 (I1_I1298_P8_1 I1_I1298_P4_1n XI1_I1298_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I133_XP_MP0 (XI1_I1252_I133_XP_p1 I1_I1252_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I133_XP_MP1 (I1_I1252_P8_1 I1_I1252_P4_1n XI1_I1252_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I74_XP_MP0 (XI1_I1252_I74_XP_p1 I1_I1252_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I74_XP_MP1 (I1_I1252_P8_7 I1_I1252_pn7 XI1_I1252_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I73_XP_MP0 (XI1_I1252_I73_XP_p1 I1_I1252_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I73_XP_MP1 (I1_I1252_P7_6 I1_I1252_pn6 XI1_I1252_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I73_XP_MP0 (XI1_I1206_I73_XP_p1 I1_I1206_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I73_XP_MP1 (I1_I1206_P7_6 I1_I1206_pn6 XI1_I1206_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I74_XP_MP0 (XI1_I1206_I74_XP_p1 I1_I1206_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I74_XP_MP1 (I1_I1206_P8_7 I1_I1206_pn7 XI1_I1206_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I72_XP_MP0 (XI1_I1206_I72_XP_p1 I1_I1206_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I72_XP_MP1 (I1_I1206_P6_5 I1_I1206_pn5 XI1_I1206_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I133_XP_MP0 (XI1_I1206_I133_XP_p1 I1_I1206_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I133_XP_MP1 (I1_I1206_P8_1 I1_I1206_P4_1n XI1_I1206_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I96_XP_MP0 (XI1_I884_I96_XP_p1 I1_I884_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I96_XP_MP1 (I1_I884_P30_29 I1_I884_pn29 XI1_I884_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I92_XP_MP0 (XI1_I884_I92_XP_p1 I1_I884_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I92_XP_MP1 (I1_I884_P26_25 I1_I884_pn25 XI1_I884_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I90_XP_MP0 (XI1_I884_I90_XP_p1 I1_I884_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I90_XP_MP1 (I1_I884_P24_23 I1_I884_pn23 XI1_I884_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I88_XP_MP0 (XI1_I884_I88_XP_p1 I1_I884_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I88_XP_MP1 (I1_I884_P22_21 I1_I884_pn21 XI1_I884_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I86_XP_MP0 (XI1_I884_I86_XP_p1 I1_I884_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I86_XP_MP1 (I1_I884_P20_19 I1_I884_pn19 XI1_I884_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I84_XP_MP0 (XI1_I884_I84_XP_p1 I1_I884_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I84_XP_MP1 (I1_I884_P18_17 I1_I884_pn17 XI1_I884_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I82_XP_MP0 (XI1_I884_I82_XP_p1 I1_I884_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I82_XP_MP1 (I1_I884_P16_15 I1_I884_pn15 XI1_I884_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I80_XP_MP0 (XI1_I884_I80_XP_p1 I1_I884_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I80_XP_MP1 (I1_I884_P14_13 I1_I884_pn13 XI1_I884_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I134_XP_MP0 (XI1_I884_I134_XP_p1 I1_I884_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I134_XP_MP1 (I1_I884_P9_2 I1_I884_P5_2n XI1_I884_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I73_XP_MP0 (XI1_I884_I73_XP_p1 I1_I884_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I73_XP_MP1 (I1_I884_P7_6 I1_I884_pn6 XI1_I884_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I93_XP_MP0 (XI1_I1390_I93_XP_p1 I1_I1390_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I93_XP_MP1 (I1_I1390_P27_26 I1_I1390_pn26 XI1_I1390_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I91_XP_MP0 (XI1_I1390_I91_XP_p1 I1_I1390_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I91_XP_MP1 (I1_I1390_P25_24 I1_I1390_pn24 XI1_I1390_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I89_XP_MP0 (XI1_I1390_I89_XP_p1 I1_I1390_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I89_XP_MP1 (I1_I1390_P23_22 I1_I1390_pn22 XI1_I1390_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I87_XP_MP0 (XI1_I1390_I87_XP_p1 I1_I1390_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I87_XP_MP1 (I1_I1390_P21_20 I1_I1390_pn20 XI1_I1390_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I72_XP_MP0 (XI1_I1344_I72_XP_p1 I1_I1344_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I72_XP_MP1 (I1_I1344_P6_5 I1_I1344_pn5 XI1_I1344_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I71_XP_MP0 (XI1_I1344_I71_XP_p1 I1_I1344_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I71_XP_MP1 (I1_I1344_P5_4 I1_I1344_pn4 XI1_I1344_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I71_XP_MP0 (XI1_I1298_I71_XP_p1 I1_I1298_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I71_XP_MP1 (I1_I1298_P5_4 I1_I1298_pn4 XI1_I1298_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I72_XP_MP0 (XI1_I1298_I72_XP_p1 I1_I1298_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I72_XP_MP1 (I1_I1298_P6_5 I1_I1298_pn5 XI1_I1298_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I72_XP_MP0 (XI1_I1252_I72_XP_p1 I1_I1252_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I72_XP_MP1 (I1_I1252_P6_5 I1_I1252_pn5 XI1_I1252_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I71_XP_MP0 (XI1_I1206_I71_XP_p1 I1_I1206_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I71_XP_MP1 (I1_I1206_P5_4 I1_I1206_pn4 XI1_I1206_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I70_XP_MP0 (XI1_I1206_I70_XP_p1 I1_I1206_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I70_XP_MP1 (I1_I1206_P4_3 I1_I1206_pn3 XI1_I1206_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I155_XP_MP0 (XI1_I884_I155_XP_p1 I1_I884_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I155_XP_MP1 (I1_I884_P30_23 I1_I884_P26_23n XI1_I884_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I153_XP_MP0 (XI1_I884_I153_XP_p1 I1_I884_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I153_XP_MP1 (I1_I884_P28_21 I1_I884_P24_21n XI1_I884_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I151_XP_MP0 (XI1_I884_I151_XP_p1 I1_I884_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I151_XP_MP1 (I1_I884_P26_19 I1_I884_P22_19n XI1_I884_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I147_XP_MP0 (XI1_I884_I147_XP_p1 I1_I884_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I147_XP_MP1 (I1_I884_P22_15 I1_I884_P18_15n XI1_I884_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I149_XP_MP0 (XI1_I884_I149_XP_p1 I1_I884_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I149_XP_MP1 (I1_I884_P24_17 I1_I884_P20_17n XI1_I884_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I145_XP_MP0 (XI1_I884_I145_XP_p1 I1_I884_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I145_XP_MP1 (I1_I884_P20_13 I1_I884_P16_13n XI1_I884_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I143_XP_MP0 (XI1_I884_I143_XP_p1 I1_I884_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I143_XP_MP1 (I1_I884_P18_11 I1_I884_P14_11n XI1_I884_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I139_XP_MP0 (XI1_I884_I139_XP_p1 I1_I884_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I139_XP_MP1 (I1_I884_P14_7 I1_I884_P10_7n XI1_I884_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I141_XP_MP0 (XI1_I884_I141_XP_p1 I1_I884_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I141_XP_MP1 (I1_I884_P16_9 I1_I884_P12_9n XI1_I884_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I78_XP_MP0 (XI1_I884_I78_XP_p1 I1_I884_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I78_XP_MP1 (I1_I884_P12_11 I1_I884_pn11 XI1_I884_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I76_XP_MP0 (XI1_I884_I76_XP_p1 I1_I884_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I76_XP_MP1 (I1_I884_P10_9 I1_I884_pn9 XI1_I884_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I74_XP_MP0 (XI1_I884_I74_XP_p1 I1_I884_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I74_XP_MP1 (I1_I884_P8_7 I1_I884_pn7 XI1_I884_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I72_XP_MP0 (XI1_I884_I72_XP_p1 I1_I884_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I72_XP_MP1 (I1_I884_P6_5 I1_I884_pn5 XI1_I884_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I71_XP_MP0 (XI1_I884_I71_XP_p1 I1_I884_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I71_XP_MP1 (I1_I884_P5_4 I1_I884_pn4 XI1_I884_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I136_XP_MP0 (XI1_I700_I136_XP_p1 I1_I700_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I136_XP_MP1 (I1_I700_P11_4 I1_I700_P7_4n XI1_I700_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I138_XP_MP0 (XI1_I700_I138_XP_p1 I1_I700_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I138_XP_MP1 (I1_I700_P13_6 I1_I700_P9_6n XI1_I700_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I140_XP_MP0 (XI1_I700_I140_XP_p1 I1_I700_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I140_XP_MP1 (I1_I700_P15_8 I1_I700_P11_8n XI1_I700_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I144_XP_MP0 (XI1_I700_I144_XP_p1 I1_I700_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I144_XP_MP1 (I1_I700_P19_12 I1_I700_P15_12n XI1_I700_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I148_XP_MP0 (XI1_I700_I148_XP_p1 I1_I700_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I148_XP_MP1 (I1_I700_P23_16 I1_I700_P19_16n XI1_I700_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I152_XP_MP0 (XI1_I700_I152_XP_p1 I1_I700_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I152_XP_MP1 (I1_I700_P27_20 I1_I700_P23_20n XI1_I700_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I156_XP_MP0 (XI1_I700_I156_XP_p1 I1_I700_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I156_XP_MP1 (I1_I700_P31_24 I1_I700_P27_24n XI1_I700_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I95_XP_MP0 (XI1_I1390_I95_XP_p1 I1_I1390_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I95_XP_MP1 (I1_I1390_P29_28 I1_I1390_pn28 XI1_I1390_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I154_XP_MP0 (XI1_I1390_I154_XP_p1 I1_I1390_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I154_XP_MP1 (I1_I1390_P29_22 I1_I1390_P25_22n XI1_I1390_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I85_XP_MP0 (XI1_I1390_I85_XP_p1 I1_I1390_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I85_XP_MP1 (I1_I1390_P19_18 I1_I1390_pn18 XI1_I1390_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I83_XP_MP0 (XI1_I1390_I83_XP_p1 I1_I1390_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I83_XP_MP1 (I1_I1390_P17_16 I1_I1390_pn16 XI1_I1390_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I70_XP_MP0 (XI1_I1344_I70_XP_p1 I1_I1344_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I70_XP_MP1 (I1_I1344_P4_3 I1_I1344_pn3 XI1_I1344_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I70_XP_MP0 (XI1_I1298_I70_XP_p1 I1_I1298_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I70_XP_MP1 (I1_I1298_P4_3 I1_I1298_pn3 XI1_I1298_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I68_XP_MP0 (XI1_I1252_I68_XP_p1 I1_I1252_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I68_XP_MP1 (I1_I1252_P2_1 I1_I1252_pn1 XI1_I1252_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I70_XP_MP0 (XI1_I1252_I70_XP_p1 I1_I1252_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I70_XP_MP1 (I1_I1252_P4_3 I1_I1252_pn3 XI1_I1252_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I69_XP_MP0 (XI1_I1252_I69_XP_p1 I1_I1252_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I69_XP_MP1 (I1_I1252_P3_2 I1_I1252_pn2 XI1_I1252_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I71_XP_MP0 (XI1_I1252_I71_XP_p1 I1_I1252_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I71_XP_MP1 (I1_I1252_P5_4 I1_I1252_pn4 XI1_I1252_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I144_XP_MP0 (XI1_I1160_I144_XP_p1 I1_I1160_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I144_XP_MP1 (I1_I1160_P19_12 I1_I1160_P15_12n XI1_I1160_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I140_XP_MP0 (XI1_I1160_I140_XP_p1 I1_I1160_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I140_XP_MP1 (I1_I1160_P15_8 I1_I1160_P11_8n XI1_I1160_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I136_XP_MP0 (XI1_I1160_I136_XP_p1 I1_I1160_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I136_XP_MP1 (I1_I1160_P11_4 I1_I1160_P7_4n XI1_I1160_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I69_XP_MP0 (XI1_I1206_I69_XP_p1 I1_I1206_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I69_XP_MP1 (I1_I1206_P3_2 I1_I1206_pn2 XI1_I1206_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I68_XP_MP0 (XI1_I1206_I68_XP_p1 I1_I1206_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I68_XP_MP1 (I1_I1206_P2_1 I1_I1206_pn1 XI1_I1206_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I137_XP_MP0 (XI1_I884_I137_XP_p1 I1_I884_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I137_XP_MP1 (I1_I884_P12_5 I1_I884_P8_5n XI1_I884_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I135_XP_MP0 (XI1_I884_I135_XP_p1 I1_I884_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I135_XP_MP1 (I1_I884_P10_3 I1_I884_P6_3n XI1_I884_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I70_XP_MP0 (XI1_I884_I70_XP_p1 I1_I884_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I70_XP_MP1 (I1_I884_P4_3 I1_I884_pn3 XI1_I884_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I69_XP_MP0 (XI1_I884_I69_XP_p1 I1_I884_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I69_XP_MP1 (I1_I884_P3_2 I1_I884_pn2 XI1_I884_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I134_XP_MP0 (XI1_I700_I134_XP_p1 I1_I700_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I134_XP_MP1 (I1_I700_P9_2 I1_I700_P5_2n XI1_I700_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I142_XP_MP0 (XI1_I700_I142_XP_p1 I1_I700_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I142_XP_MP1 (I1_I700_P17_10 I1_I700_P13_10n XI1_I700_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I83_XP_MP0 (XI1_I700_I83_XP_p1 I1_I700_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I83_XP_MP1 (I1_I700_P17_16 I1_I700_pn16 XI1_I700_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I146_XP_MP0 (XI1_I700_I146_XP_p1 I1_I700_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I146_XP_MP1 (I1_I700_P21_14 I1_I700_P17_14n XI1_I700_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I150_XP_MP0 (XI1_I700_I150_XP_p1 I1_I700_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I150_XP_MP1 (I1_I700_P25_18 I1_I700_P21_18n XI1_I700_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I154_XP_MP0 (XI1_I700_I154_XP_p1 I1_I700_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I154_XP_MP1 (I1_I700_P29_22 I1_I700_P25_22n XI1_I700_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I97_XP_MP0 (XI1_I1390_I97_XP_p1 I1_I1390_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I97_XP_MP1 (I1_I1390_P31_30 I1_I1390_pn30 XI1_I1390_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I96_XP_MP0 (XI1_I1390_I96_XP_p1 I1_I1390_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I96_XP_MP1 (I1_I1390_P30_29 I1_I1390_pn29 XI1_I1390_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I156_XP_MP0 (XI1_I1390_I156_XP_p1 I1_I1390_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I156_XP_MP1 (I1_I1390_P31_24 I1_I1390_P27_24n XI1_I1390_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I152_XP_MP0 (XI1_I1390_I152_XP_p1 I1_I1390_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I152_XP_MP1 (I1_I1390_P27_20 I1_I1390_P23_20n XI1_I1390_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I148_XP_MP0 (XI1_I1390_I148_XP_p1 I1_I1390_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I148_XP_MP1 (I1_I1390_P23_16 I1_I1390_P19_16n XI1_I1390_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I150_XP_MP0 (XI1_I1390_I150_XP_p1 I1_I1390_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I150_XP_MP1 (I1_I1390_P25_18 I1_I1390_P21_18n XI1_I1390_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I146_XP_MP0 (XI1_I1390_I146_XP_p1 I1_I1390_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I146_XP_MP1 (I1_I1390_P21_14 I1_I1390_P17_14n XI1_I1390_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I144_XP_MP0 (XI1_I1390_I144_XP_p1 I1_I1390_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I144_XP_MP1 (I1_I1390_P19_12 I1_I1390_P15_12n XI1_I1390_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I81_XP_MP0 (XI1_I1390_I81_XP_p1 I1_I1390_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I81_XP_MP1 (I1_I1390_P15_14 I1_I1390_pn14 XI1_I1390_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I79_XP_MP0 (XI1_I1390_I79_XP_p1 I1_I1390_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I79_XP_MP1 (I1_I1390_P13_12 I1_I1390_pn12 XI1_I1390_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I68_XP_MP0 (XI1_I1344_I68_XP_p1 I1_I1344_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I68_XP_MP1 (I1_I1344_P2_1 I1_I1344_pn1 XI1_I1344_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I69_XP_MP0 (XI1_I1344_I69_XP_p1 I1_I1344_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I69_XP_MP1 (I1_I1344_P3_2 I1_I1344_pn2 XI1_I1344_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I69_XP_MP0 (XI1_I1298_I69_XP_p1 I1_I1298_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I69_XP_MP1 (I1_I1298_P3_2 I1_I1298_pn2 XI1_I1298_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I68_XP_MP0 (XI1_I1298_I68_XP_p1 I1_I1298_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I68_XP_MP1 (I1_I1298_P2_1 I1_I1298_pn1 XI1_I1298_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I156_XP_MP0 (XI1_I1160_I156_XP_p1 I1_I1160_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I156_XP_MP1 (I1_I1160_P31_24 I1_I1160_P27_24n XI1_I1160_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I154_XP_MP0 (XI1_I1160_I154_XP_p1 I1_I1160_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I154_XP_MP1 (I1_I1160_P29_22 I1_I1160_P25_22n XI1_I1160_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I152_XP_MP0 (XI1_I1160_I152_XP_p1 I1_I1160_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I152_XP_MP1 (I1_I1160_P27_20 I1_I1160_P23_20n XI1_I1160_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I148_XP_MP0 (XI1_I1160_I148_XP_p1 I1_I1160_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I148_XP_MP1 (I1_I1160_P23_16 I1_I1160_P19_16n XI1_I1160_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I150_XP_MP0 (XI1_I1160_I150_XP_p1 I1_I1160_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I150_XP_MP1 (I1_I1160_P25_18 I1_I1160_P21_18n XI1_I1160_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I146_XP_MP0 (XI1_I1160_I146_XP_p1 I1_I1160_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I146_XP_MP1 (I1_I1160_P21_14 I1_I1160_P17_14n XI1_I1160_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I142_XP_MP0 (XI1_I1160_I142_XP_p1 I1_I1160_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I142_XP_MP1 (I1_I1160_P17_10 I1_I1160_P13_10n XI1_I1160_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I138_XP_MP0 (XI1_I1160_I138_XP_p1 I1_I1160_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I138_XP_MP1 (I1_I1160_P13_6 I1_I1160_P9_6n XI1_I1160_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I134_XP_MP0 (XI1_I1160_I134_XP_p1 I1_I1160_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I134_XP_MP1 (I1_I1160_P9_2 I1_I1160_P5_2n XI1_I1160_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I133_XP_MP0 (XI1_I884_I133_XP_p1 I1_I884_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I133_XP_MP1 (I1_I884_P8_1 I1_I884_P4_1n XI1_I884_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I68_XP_MP0 (XI1_I884_I68_XP_p1 I1_I884_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I68_XP_MP1 (I1_I884_P2_1 I1_I884_pn1 XI1_I884_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I69_XP_MP0 (XI1_I700_I69_XP_p1 I1_I700_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I69_XP_MP1 (I1_I700_P3_2 I1_I700_pn2 XI1_I700_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I71_XP_MP0 (XI1_I700_I71_XP_p1 I1_I700_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I71_XP_MP1 (I1_I700_P5_4 I1_I700_pn4 XI1_I700_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I73_XP_MP0 (XI1_I700_I73_XP_p1 I1_I700_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I73_XP_MP1 (I1_I700_P7_6 I1_I700_pn6 XI1_I700_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I75_XP_MP0 (XI1_I700_I75_XP_p1 I1_I700_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I75_XP_MP1 (I1_I700_P9_8 I1_I700_pn8 XI1_I700_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I77_XP_MP0 (XI1_I700_I77_XP_p1 I1_I700_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I77_XP_MP1 (I1_I700_P11_10 I1_I700_pn10 XI1_I700_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I79_XP_MP0 (XI1_I700_I79_XP_p1 I1_I700_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I79_XP_MP1 (I1_I700_P13_12 I1_I700_pn12 XI1_I700_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I81_XP_MP0 (XI1_I700_I81_XP_p1 I1_I700_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I81_XP_MP1 (I1_I700_P15_14 I1_I700_pn14 XI1_I700_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I85_XP_MP0 (XI1_I700_I85_XP_p1 I1_I700_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I85_XP_MP1 (I1_I700_P19_18 I1_I700_pn18 XI1_I700_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I87_XP_MP0 (XI1_I700_I87_XP_p1 I1_I700_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I87_XP_MP1 (I1_I700_P21_20 I1_I700_pn20 XI1_I700_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I89_XP_MP0 (XI1_I700_I89_XP_p1 I1_I700_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I89_XP_MP1 (I1_I700_P23_22 I1_I700_pn22 XI1_I700_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I91_XP_MP0 (XI1_I700_I91_XP_p1 I1_I700_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I91_XP_MP1 (I1_I700_P25_24 I1_I700_pn24 XI1_I700_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I93_XP_MP0 (XI1_I700_I93_XP_p1 I1_I700_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I93_XP_MP1 (I1_I700_P27_26 I1_I700_pn26 XI1_I700_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I95_XP_MP0 (XI1_I700_I95_XP_p1 I1_I700_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I95_XP_MP1 (I1_I700_P29_28 I1_I700_pn28 XI1_I700_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I97_XP_MP0 (XI1_I700_I97_XP_p1 I1_I700_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I97_XP_MP1 (I1_I700_P31_30 I1_I700_pn30 XI1_I700_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I94_XP_MP0 (XI1_I1390_I94_XP_p1 I1_I1390_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I94_XP_MP1 (I1_I1390_P28_27 I1_I1390_pn27 XI1_I1390_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I90_XP_MP0 (XI1_I1390_I90_XP_p1 I1_I1390_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I90_XP_MP1 (I1_I1390_P24_23 I1_I1390_pn23 XI1_I1390_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I140_XP_MP0 (XI1_I1390_I140_XP_p1 I1_I1390_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I140_XP_MP1 (I1_I1390_P15_8 I1_I1390_P11_8n XI1_I1390_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I142_XP_MP0 (XI1_I1390_I142_XP_p1 I1_I1390_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I142_XP_MP1 (I1_I1390_P17_10 I1_I1390_P13_10n XI1_I1390_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I138_XP_MP0 (XI1_I1390_I138_XP_p1 I1_I1390_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I138_XP_MP1 (I1_I1390_P13_6 I1_I1390_P9_6n XI1_I1390_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I136_XP_MP0 (XI1_I1390_I136_XP_p1 I1_I1390_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I136_XP_MP1 (I1_I1390_P11_4 I1_I1390_P7_4n XI1_I1390_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I77_XP_MP0 (XI1_I1390_I77_XP_p1 I1_I1390_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I77_XP_MP1 (I1_I1390_P11_10 I1_I1390_pn10 XI1_I1390_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I75_XP_MP0 (XI1_I1390_I75_XP_p1 I1_I1390_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I75_XP_MP1 (I1_I1390_P9_8 I1_I1390_pn8 XI1_I1390_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I97_XP_MP0 (XI1_I1160_I97_XP_p1 I1_I1160_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I97_XP_MP1 (I1_I1160_P31_30 I1_I1160_pn30 XI1_I1160_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I95_XP_MP0 (XI1_I1160_I95_XP_p1 I1_I1160_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I95_XP_MP1 (I1_I1160_P29_28 I1_I1160_pn28 XI1_I1160_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I87_XP_MP0 (XI1_I1160_I87_XP_p1 I1_I1160_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I87_XP_MP1 (I1_I1160_P21_20 I1_I1160_pn20 XI1_I1160_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I85_XP_MP0 (XI1_I1160_I85_XP_p1 I1_I1160_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I85_XP_MP1 (I1_I1160_P19_18 I1_I1160_pn18 XI1_I1160_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I79_XP_MP0 (XI1_I1160_I79_XP_p1 I1_I1160_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I79_XP_MP1 (I1_I1160_P13_12 I1_I1160_pn12 XI1_I1160_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I75_XP_MP0 (XI1_I1160_I75_XP_p1 I1_I1160_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I75_XP_MP1 (I1_I1160_P9_8 I1_I1160_pn8 XI1_I1160_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I73_XP_MP0 (XI1_I1160_I73_XP_p1 I1_I1160_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I73_XP_MP1 (I1_I1160_P7_6 I1_I1160_pn6 XI1_I1160_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I71_XP_MP0 (XI1_I1160_I71_XP_p1 I1_I1160_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I71_XP_MP1 (I1_I1160_P5_4 I1_I1160_pn4 XI1_I1160_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I133_XP_MP0 (XI1_I700_I133_XP_p1 I1_I700_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I133_XP_MP1 (I1_I700_P8_1 I1_I700_P4_1n XI1_I700_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I135_XP_MP0 (XI1_I700_I135_XP_p1 I1_I700_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I135_XP_MP1 (I1_I700_P10_3 I1_I700_P6_3n XI1_I700_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I137_XP_MP0 (XI1_I700_I137_XP_p1 I1_I700_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I137_XP_MP1 (I1_I700_P12_5 I1_I700_P8_5n XI1_I700_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I141_XP_MP0 (XI1_I700_I141_XP_p1 I1_I700_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I141_XP_MP1 (I1_I700_P16_9 I1_I700_P12_9n XI1_I700_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I139_XP_MP0 (XI1_I700_I139_XP_p1 I1_I700_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I139_XP_MP1 (I1_I700_P14_7 I1_I700_P10_7n XI1_I700_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I147_XP_MP0 (XI1_I700_I147_XP_p1 I1_I700_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I147_XP_MP1 (I1_I700_P22_15 I1_I700_P18_15n XI1_I700_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I151_XP_MP0 (XI1_I700_I151_XP_p1 I1_I700_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I151_XP_MP1 (I1_I700_P26_19 I1_I700_P22_19n XI1_I700_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I155_XP_MP0 (XI1_I700_I155_XP_p1 I1_I700_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I155_XP_MP1 (I1_I700_P30_23 I1_I700_P26_23n XI1_I700_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I94_XP_MP0 (XI1_I700_I94_XP_p1 I1_I700_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I94_XP_MP1 (I1_I700_P28_27 I1_I700_pn27 XI1_I700_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I96_XP_MP0 (XI1_I700_I96_XP_p1 I1_I700_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I96_XP_MP1 (I1_I700_P30_29 I1_I700_pn29 XI1_I700_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I155_XP_MP0 (XI1_I1390_I155_XP_p1 I1_I1390_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I155_XP_MP1 (I1_I1390_P30_23 I1_I1390_P26_23n XI1_I1390_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I92_XP_MP0 (XI1_I1390_I92_XP_p1 I1_I1390_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I92_XP_MP1 (I1_I1390_P26_25 I1_I1390_pn25 XI1_I1390_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I88_XP_MP0 (XI1_I1390_I88_XP_p1 I1_I1390_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I88_XP_MP1 (I1_I1390_P22_21 I1_I1390_pn21 XI1_I1390_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I86_XP_MP0 (XI1_I1390_I86_XP_p1 I1_I1390_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I86_XP_MP1 (I1_I1390_P20_19 I1_I1390_pn19 XI1_I1390_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I84_XP_MP0 (XI1_I1390_I84_XP_p1 I1_I1390_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I84_XP_MP1 (I1_I1390_P18_17 I1_I1390_pn17 XI1_I1390_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I82_XP_MP0 (XI1_I1390_I82_XP_p1 I1_I1390_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I82_XP_MP1 (I1_I1390_P16_15 I1_I1390_pn15 XI1_I1390_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I80_XP_MP0 (XI1_I1390_I80_XP_p1 I1_I1390_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I80_XP_MP1 (I1_I1390_P14_13 I1_I1390_pn13 XI1_I1390_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I134_XP_MP0 (XI1_I1390_I134_XP_p1 I1_I1390_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I134_XP_MP1 (I1_I1390_P9_2 I1_I1390_P5_2n XI1_I1390_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I73_XP_MP0 (XI1_I1390_I73_XP_p1 I1_I1390_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I73_XP_MP1 (I1_I1390_P7_6 I1_I1390_pn6 XI1_I1390_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I96_XP_MP0 (XI1_I1160_I96_XP_p1 I1_I1160_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I96_XP_MP1 (I1_I1160_P30_29 I1_I1160_pn29 XI1_I1160_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I94_XP_MP0 (XI1_I1160_I94_XP_p1 I1_I1160_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I94_XP_MP1 (I1_I1160_P28_27 I1_I1160_pn27 XI1_I1160_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I93_XP_MP0 (XI1_I1160_I93_XP_p1 I1_I1160_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I93_XP_MP1 (I1_I1160_P27_26 I1_I1160_pn26 XI1_I1160_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I92_XP_MP0 (XI1_I1160_I92_XP_p1 I1_I1160_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I92_XP_MP1 (I1_I1160_P26_25 I1_I1160_pn25 XI1_I1160_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I91_XP_MP0 (XI1_I1160_I91_XP_p1 I1_I1160_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I91_XP_MP1 (I1_I1160_P25_24 I1_I1160_pn24 XI1_I1160_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I155_XP_MP0 (XI1_I1160_I155_XP_p1 I1_I1160_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I155_XP_MP1 (I1_I1160_P30_23 I1_I1160_P26_23n XI1_I1160_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I89_XP_MP0 (XI1_I1160_I89_XP_p1 I1_I1160_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I89_XP_MP1 (I1_I1160_P23_22 I1_I1160_pn22 XI1_I1160_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I83_XP_MP0 (XI1_I1160_I83_XP_p1 I1_I1160_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I83_XP_MP1 (I1_I1160_P17_16 I1_I1160_pn16 XI1_I1160_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I81_XP_MP0 (XI1_I1160_I81_XP_p1 I1_I1160_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I81_XP_MP1 (I1_I1160_P15_14 I1_I1160_pn14 XI1_I1160_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I77_XP_MP0 (XI1_I1160_I77_XP_p1 I1_I1160_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I77_XP_MP1 (I1_I1160_P11_10 I1_I1160_pn10 XI1_I1160_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I69_XP_MP0 (XI1_I1160_I69_XP_p1 I1_I1160_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I69_XP_MP1 (I1_I1160_P3_2 I1_I1160_pn2 XI1_I1160_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I95_XP_MP0 (XI1_I930_I95_XP_p1 I1_I930_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I95_XP_MP1 (I1_I930_P29_28 I1_I930_pn28 XI1_I930_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I93_XP_MP0 (XI1_I930_I93_XP_p1 I1_I930_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I93_XP_MP1 (I1_I930_P27_26 I1_I930_pn26 XI1_I930_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I91_XP_MP0 (XI1_I930_I91_XP_p1 I1_I930_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I91_XP_MP1 (I1_I930_P25_24 I1_I930_pn24 XI1_I930_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I89_XP_MP0 (XI1_I930_I89_XP_p1 I1_I930_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I89_XP_MP1 (I1_I930_P23_22 I1_I930_pn22 XI1_I930_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I87_XP_MP0 (XI1_I930_I87_XP_p1 I1_I930_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I87_XP_MP1 (I1_I930_P21_20 I1_I930_pn20 XI1_I930_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I85_XP_MP0 (XI1_I930_I85_XP_p1 I1_I930_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I85_XP_MP1 (I1_I930_P19_18 I1_I930_pn18 XI1_I930_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I83_XP_MP0 (XI1_I930_I83_XP_p1 I1_I930_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I83_XP_MP1 (I1_I930_P17_16 I1_I930_pn16 XI1_I930_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I81_XP_MP0 (XI1_I930_I81_XP_p1 I1_I930_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I81_XP_MP1 (I1_I930_P15_14 I1_I930_pn14 XI1_I930_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I79_XP_MP0 (XI1_I930_I79_XP_p1 I1_I930_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I79_XP_MP1 (I1_I930_P13_12 I1_I930_pn12 XI1_I930_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I77_XP_MP0 (XI1_I930_I77_XP_p1 I1_I930_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I77_XP_MP1 (I1_I930_P11_10 I1_I930_pn10 XI1_I930_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I68_XP_MP0 (XI1_I700_I68_XP_p1 I1_I700_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I68_XP_MP1 (I1_I700_P2_1 I1_I700_pn1 XI1_I700_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I70_XP_MP0 (XI1_I700_I70_XP_p1 I1_I700_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I70_XP_MP1 (I1_I700_P4_3 I1_I700_pn3 XI1_I700_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I72_XP_MP0 (XI1_I700_I72_XP_p1 I1_I700_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I72_XP_MP1 (I1_I700_P6_5 I1_I700_pn5 XI1_I700_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I74_XP_MP0 (XI1_I700_I74_XP_p1 I1_I700_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I74_XP_MP1 (I1_I700_P8_7 I1_I700_pn7 XI1_I700_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I76_XP_MP0 (XI1_I700_I76_XP_p1 I1_I700_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I76_XP_MP1 (I1_I700_P10_9 I1_I700_pn9 XI1_I700_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I80_XP_MP0 (XI1_I700_I80_XP_p1 I1_I700_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I80_XP_MP1 (I1_I700_P14_13 I1_I700_pn13 XI1_I700_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I149_XP_MP0 (XI1_I700_I149_XP_p1 I1_I700_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I149_XP_MP1 (I1_I700_P24_17 I1_I700_P20_17n XI1_I700_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I86_XP_MP0 (XI1_I700_I86_XP_p1 I1_I700_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I86_XP_MP1 (I1_I700_P20_19 I1_I700_pn19 XI1_I700_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I88_XP_MP0 (XI1_I700_I88_XP_p1 I1_I700_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I88_XP_MP1 (I1_I700_P22_21 I1_I700_pn21 XI1_I700_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I153_XP_MP0 (XI1_I700_I153_XP_p1 I1_I700_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I153_XP_MP1 (I1_I700_P28_21 I1_I700_P24_21n XI1_I700_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I90_XP_MP0 (XI1_I700_I90_XP_p1 I1_I700_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I90_XP_MP1 (I1_I700_P24_23 I1_I700_pn23 XI1_I700_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I92_XP_MP0 (XI1_I700_I92_XP_p1 I1_I700_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I92_XP_MP1 (I1_I700_P26_25 I1_I700_pn25 XI1_I700_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I153_XP_MP0 (XI1_I1390_I153_XP_p1 I1_I1390_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I153_XP_MP1 (I1_I1390_P28_21 I1_I1390_P24_21n XI1_I1390_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I151_XP_MP0 (XI1_I1390_I151_XP_p1 I1_I1390_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I151_XP_MP1 (I1_I1390_P26_19 I1_I1390_P22_19n XI1_I1390_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I147_XP_MP0 (XI1_I1390_I147_XP_p1 I1_I1390_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I147_XP_MP1 (I1_I1390_P22_15 I1_I1390_P18_15n XI1_I1390_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I149_XP_MP0 (XI1_I1390_I149_XP_p1 I1_I1390_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I149_XP_MP1 (I1_I1390_P24_17 I1_I1390_P20_17n XI1_I1390_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I145_XP_MP0 (XI1_I1390_I145_XP_p1 I1_I1390_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I145_XP_MP1 (I1_I1390_P20_13 I1_I1390_P16_13n XI1_I1390_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I143_XP_MP0 (XI1_I1390_I143_XP_p1 I1_I1390_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I143_XP_MP1 (I1_I1390_P18_11 I1_I1390_P14_11n XI1_I1390_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I78_XP_MP0 (XI1_I1390_I78_XP_p1 I1_I1390_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I78_XP_MP1 (I1_I1390_P12_11 I1_I1390_pn11 XI1_I1390_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I76_XP_MP0 (XI1_I1390_I76_XP_p1 I1_I1390_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I76_XP_MP1 (I1_I1390_P10_9 I1_I1390_pn9 XI1_I1390_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I74_XP_MP0 (XI1_I1390_I74_XP_p1 I1_I1390_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I74_XP_MP1 (I1_I1390_P8_7 I1_I1390_pn7 XI1_I1390_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I71_XP_MP0 (XI1_I1390_I71_XP_p1 I1_I1390_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I71_XP_MP1 (I1_I1390_P5_4 I1_I1390_pn4 XI1_I1390_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I153_XP_MP0 (XI1_I1160_I153_XP_p1 I1_I1160_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I153_XP_MP1 (I1_I1160_P28_21 I1_I1160_P24_21n XI1_I1160_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I151_XP_MP0 (XI1_I1160_I151_XP_p1 I1_I1160_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I151_XP_MP1 (I1_I1160_P26_19 I1_I1160_P22_19n XI1_I1160_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I135_XP_MP0 (XI1_I1160_I135_XP_p1 I1_I1160_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I135_XP_MP1 (I1_I1160_P10_3 I1_I1160_P6_3n XI1_I1160_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I137_XP_MP0 (XI1_I1160_I137_XP_p1 I1_I1160_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I137_XP_MP1 (I1_I1160_P12_5 I1_I1160_P8_5n XI1_I1160_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I133_XP_MP0 (XI1_I1160_I133_XP_p1 I1_I1160_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I133_XP_MP1 (I1_I1160_P8_1 I1_I1160_P4_1n XI1_I1160_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I68_XP_MP0 (XI1_I1160_I68_XP_p1 I1_I1160_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I68_XP_MP1 (I1_I1160_P2_1 I1_I1160_pn1 XI1_I1160_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I97_XP_MP0 (XI1_I930_I97_XP_p1 I1_I930_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I97_XP_MP1 (I1_I930_P31_30 I1_I930_pn30 XI1_I930_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I156_XP_MP0 (XI1_I930_I156_XP_p1 I1_I930_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I156_XP_MP1 (I1_I930_P31_24 I1_I930_P27_24n XI1_I930_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I154_XP_MP0 (XI1_I930_I154_XP_p1 I1_I930_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I154_XP_MP1 (I1_I930_P29_22 I1_I930_P25_22n XI1_I930_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I152_XP_MP0 (XI1_I930_I152_XP_p1 I1_I930_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I152_XP_MP1 (I1_I930_P27_20 I1_I930_P23_20n XI1_I930_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I148_XP_MP0 (XI1_I930_I148_XP_p1 I1_I930_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I148_XP_MP1 (I1_I930_P23_16 I1_I930_P19_16n XI1_I930_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I150_XP_MP0 (XI1_I930_I150_XP_p1 I1_I930_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I150_XP_MP1 (I1_I930_P25_18 I1_I930_P21_18n XI1_I930_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I146_XP_MP0 (XI1_I930_I146_XP_p1 I1_I930_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I146_XP_MP1 (I1_I930_P21_14 I1_I930_P17_14n XI1_I930_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I144_XP_MP0 (XI1_I930_I144_XP_p1 I1_I930_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I144_XP_MP1 (I1_I930_P19_12 I1_I930_P15_12n XI1_I930_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I140_XP_MP0 (XI1_I930_I140_XP_p1 I1_I930_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I140_XP_MP1 (I1_I930_P15_8 I1_I930_P11_8n XI1_I930_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I142_XP_MP0 (XI1_I930_I142_XP_p1 I1_I930_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I142_XP_MP1 (I1_I930_P17_10 I1_I930_P13_10n XI1_I930_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I138_XP_MP0 (XI1_I930_I138_XP_p1 I1_I930_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I138_XP_MP1 (I1_I930_P13_6 I1_I930_P9_6n XI1_I930_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I136_XP_MP0 (XI1_I930_I136_XP_p1 I1_I930_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I136_XP_MP1 (I1_I930_P11_4 I1_I930_P7_4n XI1_I930_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I75_XP_MP0 (XI1_I930_I75_XP_p1 I1_I930_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I75_XP_MP1 (I1_I930_P9_8 I1_I930_pn8 XI1_I930_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I73_XP_MP0 (XI1_I930_I73_XP_p1 I1_I930_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I73_XP_MP1 (I1_I930_P7_6 I1_I930_pn6 XI1_I930_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I78_XP_MP0 (XI1_I700_I78_XP_p1 I1_I700_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I78_XP_MP1 (I1_I700_P12_11 I1_I700_pn11 XI1_I700_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I82_XP_MP0 (XI1_I700_I82_XP_p1 I1_I700_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I82_XP_MP1 (I1_I700_P16_15 I1_I700_pn15 XI1_I700_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I84_XP_MP0 (XI1_I700_I84_XP_p1 I1_I700_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I84_XP_MP1 (I1_I700_P18_17 I1_I700_pn17 XI1_I700_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I139_XP_MP0 (XI1_I1390_I139_XP_p1 I1_I1390_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I139_XP_MP1 (I1_I1390_P14_7 I1_I1390_P10_7n XI1_I1390_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I141_XP_MP0 (XI1_I1390_I141_XP_p1 I1_I1390_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I141_XP_MP1 (I1_I1390_P16_9 I1_I1390_P12_9n XI1_I1390_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I137_XP_MP0 (XI1_I1390_I137_XP_p1 I1_I1390_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I137_XP_MP1 (I1_I1390_P12_5 I1_I1390_P8_5n XI1_I1390_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I135_XP_MP0 (XI1_I1390_I135_XP_p1 I1_I1390_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I135_XP_MP1 (I1_I1390_P10_3 I1_I1390_P6_3n XI1_I1390_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I72_XP_MP0 (XI1_I1390_I72_XP_p1 I1_I1390_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I72_XP_MP1 (I1_I1390_P6_5 I1_I1390_pn5 XI1_I1390_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I70_XP_MP0 (XI1_I1390_I70_XP_p1 I1_I1390_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I70_XP_MP1 (I1_I1390_P4_3 I1_I1390_pn3 XI1_I1390_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I90_XP_MP0 (XI1_I1160_I90_XP_p1 I1_I1160_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I90_XP_MP1 (I1_I1160_P24_23 I1_I1160_pn23 XI1_I1160_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I88_XP_MP0 (XI1_I1160_I88_XP_p1 I1_I1160_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I88_XP_MP1 (I1_I1160_P22_21 I1_I1160_pn21 XI1_I1160_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I86_XP_MP0 (XI1_I1160_I86_XP_p1 I1_I1160_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I86_XP_MP1 (I1_I1160_P20_19 I1_I1160_pn19 XI1_I1160_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I147_XP_MP0 (XI1_I1160_I147_XP_p1 I1_I1160_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I147_XP_MP1 (I1_I1160_P22_15 I1_I1160_P18_15n XI1_I1160_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I149_XP_MP0 (XI1_I1160_I149_XP_p1 I1_I1160_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I149_XP_MP1 (I1_I1160_P24_17 I1_I1160_P20_17n XI1_I1160_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I145_XP_MP0 (XI1_I1160_I145_XP_p1 I1_I1160_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I145_XP_MP1 (I1_I1160_P20_13 I1_I1160_P16_13n XI1_I1160_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I143_XP_MP0 (XI1_I1160_I143_XP_p1 I1_I1160_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I143_XP_MP1 (I1_I1160_P18_11 I1_I1160_P14_11n XI1_I1160_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I139_XP_MP0 (XI1_I1160_I139_XP_p1 I1_I1160_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I139_XP_MP1 (I1_I1160_P14_7 I1_I1160_P10_7n XI1_I1160_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I74_XP_MP0 (XI1_I1160_I74_XP_p1 I1_I1160_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I74_XP_MP1 (I1_I1160_P8_7 I1_I1160_pn7 XI1_I1160_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I141_XP_MP0 (XI1_I1160_I141_XP_p1 I1_I1160_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I141_XP_MP1 (I1_I1160_P16_9 I1_I1160_P12_9n XI1_I1160_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I72_XP_MP0 (XI1_I1160_I72_XP_p1 I1_I1160_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I72_XP_MP1 (I1_I1160_P6_5 I1_I1160_pn5 XI1_I1160_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I70_XP_MP0 (XI1_I1160_I70_XP_p1 I1_I1160_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I70_XP_MP1 (I1_I1160_P4_3 I1_I1160_pn3 XI1_I1160_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I96_XP_MP0 (XI1_I930_I96_XP_p1 I1_I930_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I96_XP_MP1 (I1_I930_P30_29 I1_I930_pn29 XI1_I930_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I94_XP_MP0 (XI1_I930_I94_XP_p1 I1_I930_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I94_XP_MP1 (I1_I930_P28_27 I1_I930_pn27 XI1_I930_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I92_XP_MP0 (XI1_I930_I92_XP_p1 I1_I930_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I92_XP_MP1 (I1_I930_P26_25 I1_I930_pn25 XI1_I930_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I90_XP_MP0 (XI1_I930_I90_XP_p1 I1_I930_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I90_XP_MP1 (I1_I930_P24_23 I1_I930_pn23 XI1_I930_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I88_XP_MP0 (XI1_I930_I88_XP_p1 I1_I930_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I88_XP_MP1 (I1_I930_P22_21 I1_I930_pn21 XI1_I930_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I84_XP_MP0 (XI1_I930_I84_XP_p1 I1_I930_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I84_XP_MP1 (I1_I930_P18_17 I1_I930_pn17 XI1_I930_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I82_XP_MP0 (XI1_I930_I82_XP_p1 I1_I930_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I82_XP_MP1 (I1_I930_P16_15 I1_I930_pn15 XI1_I930_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I80_XP_MP0 (XI1_I930_I80_XP_p1 I1_I930_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I80_XP_MP1 (I1_I930_P14_13 I1_I930_pn13 XI1_I930_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I78_XP_MP0 (XI1_I930_I78_XP_p1 I1_I930_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I78_XP_MP1 (I1_I930_P12_11 I1_I930_pn11 XI1_I930_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I134_XP_MP0 (XI1_I930_I134_XP_p1 I1_I930_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I134_XP_MP1 (I1_I930_P9_2 I1_I930_P5_2n XI1_I930_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I71_XP_MP0 (XI1_I930_I71_XP_p1 I1_I930_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I71_XP_MP1 (I1_I930_P5_4 I1_I930_pn4 XI1_I930_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I133_XP_MP0 (XI1_I1390_I133_XP_p1 I1_I1390_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I133_XP_MP1 (I1_I1390_P8_1 I1_I1390_P4_1n XI1_I1390_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I69_XP_MP0 (XI1_I1390_I69_XP_p1 I1_I1390_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I69_XP_MP1 (I1_I1390_P3_2 I1_I1390_pn2 XI1_I1390_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I68_XP_MP0 (XI1_I1390_I68_XP_p1 I1_I1390_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I68_XP_MP1 (I1_I1390_P2_1 I1_I1390_pn1 XI1_I1390_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I84_XP_MP0 (XI1_I1160_I84_XP_p1 I1_I1160_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I84_XP_MP1 (I1_I1160_P18_17 I1_I1160_pn17 XI1_I1160_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I82_XP_MP0 (XI1_I1160_I82_XP_p1 I1_I1160_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I82_XP_MP1 (I1_I1160_P16_15 I1_I1160_pn15 XI1_I1160_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I80_XP_MP0 (XI1_I1160_I80_XP_p1 I1_I1160_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I80_XP_MP1 (I1_I1160_P14_13 I1_I1160_pn13 XI1_I1160_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I78_XP_MP0 (XI1_I1160_I78_XP_p1 I1_I1160_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I78_XP_MP1 (I1_I1160_P12_11 I1_I1160_pn11 XI1_I1160_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I76_XP_MP0 (XI1_I1160_I76_XP_p1 I1_I1160_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I76_XP_MP1 (I1_I1160_P10_9 I1_I1160_pn9 XI1_I1160_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I155_XP_MP0 (XI1_I930_I155_XP_p1 I1_I930_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I155_XP_MP1 (I1_I930_P30_23 I1_I930_P26_23n XI1_I930_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I153_XP_MP0 (XI1_I930_I153_XP_p1 I1_I930_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I153_XP_MP1 (I1_I930_P28_21 I1_I930_P24_21n XI1_I930_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I151_XP_MP0 (XI1_I930_I151_XP_p1 I1_I930_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I151_XP_MP1 (I1_I930_P26_19 I1_I930_P22_19n XI1_I930_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I147_XP_MP0 (XI1_I930_I147_XP_p1 I1_I930_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I147_XP_MP1 (I1_I930_P22_15 I1_I930_P18_15n XI1_I930_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I86_XP_MP0 (XI1_I930_I86_XP_p1 I1_I930_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I86_XP_MP1 (I1_I930_P20_19 I1_I930_pn19 XI1_I930_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I143_XP_MP0 (XI1_I930_I143_XP_p1 I1_I930_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I143_XP_MP1 (I1_I930_P18_11 I1_I930_P14_11n XI1_I930_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I76_XP_MP0 (XI1_I930_I76_XP_p1 I1_I930_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I76_XP_MP1 (I1_I930_P10_9 I1_I930_pn9 XI1_I930_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I74_XP_MP0 (XI1_I930_I74_XP_p1 I1_I930_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I74_XP_MP1 (I1_I930_P8_7 I1_I930_pn7 XI1_I930_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I72_XP_MP0 (XI1_I930_I72_XP_p1 I1_I930_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I72_XP_MP1 (I1_I930_P6_5 I1_I930_pn5 XI1_I930_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I136_XP_MP0 (XI1_I654_I136_XP_p1 I1_I654_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I136_XP_MP1 (I1_I654_P11_4 I1_I654_P7_4n XI1_I654_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I140_XP_MP0 (XI1_I654_I140_XP_p1 I1_I654_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I140_XP_MP1 (I1_I654_P15_8 I1_I654_P11_8n XI1_I654_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I95_XP_MP0 (XI1_I1114_I95_XP_p1 I1_I1114_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I95_XP_MP1 (I1_I1114_P29_28 I1_I1114_pn28 XI1_I1114_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I96_XP_MP0 (XI1_I1114_I96_XP_p1 I1_I1114_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I96_XP_MP1 (I1_I1114_P30_29 I1_I1114_pn29 XI1_I1114_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I149_XP_MP0 (XI1_I930_I149_XP_p1 I1_I930_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I149_XP_MP1 (I1_I930_P24_17 I1_I930_P20_17n XI1_I930_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I145_XP_MP0 (XI1_I930_I145_XP_p1 I1_I930_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I145_XP_MP1 (I1_I930_P20_13 I1_I930_P16_13n XI1_I930_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I139_XP_MP0 (XI1_I930_I139_XP_p1 I1_I930_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I139_XP_MP1 (I1_I930_P14_7 I1_I930_P10_7n XI1_I930_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I141_XP_MP0 (XI1_I930_I141_XP_p1 I1_I930_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I141_XP_MP1 (I1_I930_P16_9 I1_I930_P12_9n XI1_I930_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I137_XP_MP0 (XI1_I930_I137_XP_p1 I1_I930_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I137_XP_MP1 (I1_I930_P12_5 I1_I930_P8_5n XI1_I930_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I135_XP_MP0 (XI1_I930_I135_XP_p1 I1_I930_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I135_XP_MP1 (I1_I930_P10_3 I1_I930_P6_3n XI1_I930_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I70_XP_MP0 (XI1_I930_I70_XP_p1 I1_I930_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I70_XP_MP1 (I1_I930_P4_3 I1_I930_pn3 XI1_I930_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I69_XP_MP0 (XI1_I930_I69_XP_p1 I1_I930_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I69_XP_MP1 (I1_I930_P3_2 I1_I930_pn2 XI1_I930_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I69_XP_MP0 (XI1_I654_I69_XP_p1 I1_I654_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I69_XP_MP1 (I1_I654_P3_2 I1_I654_pn2 XI1_I654_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I71_XP_MP0 (XI1_I654_I71_XP_p1 I1_I654_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I71_XP_MP1 (I1_I654_P5_4 I1_I654_pn4 XI1_I654_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I134_XP_MP0 (XI1_I654_I134_XP_p1 I1_I654_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I134_XP_MP1 (I1_I654_P9_2 I1_I654_P5_2n XI1_I654_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I138_XP_MP0 (XI1_I654_I138_XP_p1 I1_I654_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I138_XP_MP1 (I1_I654_P13_6 I1_I654_P9_6n XI1_I654_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I142_XP_MP0 (XI1_I654_I142_XP_p1 I1_I654_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I142_XP_MP1 (I1_I654_P17_10 I1_I654_P13_10n XI1_I654_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I144_XP_MP0 (XI1_I654_I144_XP_p1 I1_I654_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I144_XP_MP1 (I1_I654_P19_12 I1_I654_P15_12n XI1_I654_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I146_XP_MP0 (XI1_I654_I146_XP_p1 I1_I654_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I146_XP_MP1 (I1_I654_P21_14 I1_I654_P17_14n XI1_I654_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I150_XP_MP0 (XI1_I654_I150_XP_p1 I1_I654_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I150_XP_MP1 (I1_I654_P25_18 I1_I654_P21_18n XI1_I654_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I148_XP_MP0 (XI1_I654_I148_XP_p1 I1_I654_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I148_XP_MP1 (I1_I654_P23_16 I1_I654_P19_16n XI1_I654_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I156_XP_MP0 (XI1_I654_I156_XP_p1 I1_I654_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I156_XP_MP1 (I1_I654_P31_24 I1_I654_P27_24n XI1_I654_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I86_XP_MP0 (XI1_I1436_I86_XP_p1 I1_I1436_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I86_XP_MP1 (I1_I1436_P20_19 I1_I1436_pn19 XI1_I1436_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I84_XP_MP0 (XI1_I1436_I84_XP_p1 I1_I1436_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I84_XP_MP1 (I1_I1436_P18_17 I1_I1436_pn17 XI1_I1436_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I82_XP_MP0 (XI1_I1436_I82_XP_p1 I1_I1436_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I82_XP_MP1 (I1_I1436_P16_15 I1_I1436_pn15 XI1_I1436_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I80_XP_MP0 (XI1_I1436_I80_XP_p1 I1_I1436_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I80_XP_MP1 (I1_I1436_P14_13 I1_I1436_pn13 XI1_I1436_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I94_XP_MP0 (XI1_I1114_I94_XP_p1 I1_I1114_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I94_XP_MP1 (I1_I1114_P28_27 I1_I1114_pn27 XI1_I1114_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I93_XP_MP0 (XI1_I1114_I93_XP_p1 I1_I1114_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I93_XP_MP1 (I1_I1114_P27_26 I1_I1114_pn26 XI1_I1114_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I97_XP_MP0 (XI1_I1114_I97_XP_p1 I1_I1114_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I97_XP_MP1 (I1_I1114_P31_30 I1_I1114_pn30 XI1_I1114_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I133_XP_MP0 (XI1_I930_I133_XP_p1 I1_I930_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I133_XP_MP1 (I1_I930_P8_1 I1_I930_P4_1n XI1_I930_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I68_XP_MP0 (XI1_I930_I68_XP_p1 I1_I930_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I68_XP_MP1 (I1_I930_P2_1 I1_I930_pn1 XI1_I930_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I68_XP_MP0 (XI1_I654_I68_XP_p1 I1_I654_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I68_XP_MP1 (I1_I654_P2_1 I1_I654_pn1 XI1_I654_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I73_XP_MP0 (XI1_I654_I73_XP_p1 I1_I654_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I73_XP_MP1 (I1_I654_P7_6 I1_I654_pn6 XI1_I654_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I75_XP_MP0 (XI1_I654_I75_XP_p1 I1_I654_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I75_XP_MP1 (I1_I654_P9_8 I1_I654_pn8 XI1_I654_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I77_XP_MP0 (XI1_I654_I77_XP_p1 I1_I654_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I77_XP_MP1 (I1_I654_P11_10 I1_I654_pn10 XI1_I654_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I79_XP_MP0 (XI1_I654_I79_XP_p1 I1_I654_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I79_XP_MP1 (I1_I654_P13_12 I1_I654_pn12 XI1_I654_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I81_XP_MP0 (XI1_I654_I81_XP_p1 I1_I654_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I81_XP_MP1 (I1_I654_P15_14 I1_I654_pn14 XI1_I654_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I83_XP_MP0 (XI1_I654_I83_XP_p1 I1_I654_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I83_XP_MP1 (I1_I654_P17_16 I1_I654_pn16 XI1_I654_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I85_XP_MP0 (XI1_I654_I85_XP_p1 I1_I654_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I85_XP_MP1 (I1_I654_P19_18 I1_I654_pn18 XI1_I654_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I152_XP_MP0 (XI1_I654_I152_XP_p1 I1_I654_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I152_XP_MP1 (I1_I654_P27_20 I1_I654_P23_20n XI1_I654_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I89_XP_MP0 (XI1_I654_I89_XP_p1 I1_I654_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I89_XP_MP1 (I1_I654_P23_22 I1_I654_pn22 XI1_I654_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I154_XP_MP0 (XI1_I654_I154_XP_p1 I1_I654_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I154_XP_MP1 (I1_I654_P29_22 I1_I654_P25_22n XI1_I654_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I93_XP_MP0 (XI1_I654_I93_XP_p1 I1_I654_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I93_XP_MP1 (I1_I654_P27_26 I1_I654_pn26 XI1_I654_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I95_XP_MP0 (XI1_I654_I95_XP_p1 I1_I654_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I95_XP_MP1 (I1_I654_P29_28 I1_I654_pn28 XI1_I654_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I94_XP_MP0 (XI1_I1436_I94_XP_p1 I1_I1436_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I94_XP_MP1 (I1_I1436_P28_27 I1_I1436_pn27 XI1_I1436_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I92_XP_MP0 (XI1_I1436_I92_XP_p1 I1_I1436_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I92_XP_MP1 (I1_I1436_P26_25 I1_I1436_pn25 XI1_I1436_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I90_XP_MP0 (XI1_I1436_I90_XP_p1 I1_I1436_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I90_XP_MP1 (I1_I1436_P24_23 I1_I1436_pn23 XI1_I1436_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I153_XP_MP0 (XI1_I1436_I153_XP_p1 I1_I1436_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I153_XP_MP1 (I1_I1436_P28_21 I1_I1436_P24_21n XI1_I1436_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I88_XP_MP0 (XI1_I1436_I88_XP_p1 I1_I1436_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I88_XP_MP1 (I1_I1436_P22_21 I1_I1436_pn21 XI1_I1436_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I151_XP_MP0 (XI1_I1436_I151_XP_p1 I1_I1436_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I151_XP_MP1 (I1_I1436_P26_19 I1_I1436_P22_19n XI1_I1436_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I147_XP_MP0 (XI1_I1436_I147_XP_p1 I1_I1436_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I147_XP_MP1 (I1_I1436_P22_15 I1_I1436_P18_15n XI1_I1436_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I149_XP_MP0 (XI1_I1436_I149_XP_p1 I1_I1436_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I149_XP_MP1 (I1_I1436_P24_17 I1_I1436_P20_17n XI1_I1436_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I143_XP_MP0 (XI1_I1436_I143_XP_p1 I1_I1436_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I143_XP_MP1 (I1_I1436_P18_11 I1_I1436_P14_11n XI1_I1436_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I78_XP_MP0 (XI1_I1436_I78_XP_p1 I1_I1436_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I78_XP_MP1 (I1_I1436_P12_11 I1_I1436_pn11 XI1_I1436_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I76_XP_MP0 (XI1_I1436_I76_XP_p1 I1_I1436_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I76_XP_MP1 (I1_I1436_P10_9 I1_I1436_pn9 XI1_I1436_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I72_XP_MP0 (XI1_I1436_I72_XP_p1 I1_I1436_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I72_XP_MP1 (I1_I1436_P6_5 I1_I1436_pn5 XI1_I1436_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I156_XP_MP0 (XI1_I1114_I156_XP_p1 I1_I1114_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I156_XP_MP1 (I1_I1114_P31_24 I1_I1114_P27_24n XI1_I1114_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I92_XP_MP0 (XI1_I1114_I92_XP_p1 I1_I1114_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I92_XP_MP1 (I1_I1114_P26_25 I1_I1114_pn25 XI1_I1114_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I155_XP_MP0 (XI1_I1114_I155_XP_p1 I1_I1114_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I155_XP_MP1 (I1_I1114_P30_23 I1_I1114_P26_23n XI1_I1114_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I96_XP_MP0 (XI1_I1068_I96_XP_p1 I1_I1068_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I96_XP_MP1 (I1_I1068_P30_29 I1_I1068_pn29 XI1_I1068_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I94_XP_MP0 (XI1_I1068_I94_XP_p1 I1_I1068_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I94_XP_MP1 (I1_I1068_P28_27 I1_I1068_pn27 XI1_I1068_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I93_XP_MP0 (XI1_I1068_I93_XP_p1 I1_I1068_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I93_XP_MP1 (I1_I1068_P27_26 I1_I1068_pn26 XI1_I1068_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I97_XP_MP0 (XI1_I1068_I97_XP_p1 I1_I1068_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I97_XP_MP1 (I1_I1068_P31_30 I1_I1068_pn30 XI1_I1068_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I95_XP_MP0 (XI1_I1068_I95_XP_p1 I1_I1068_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I95_XP_MP1 (I1_I1068_P29_28 I1_I1068_pn28 XI1_I1068_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I70_XP_MP0 (XI1_I654_I70_XP_p1 I1_I654_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I70_XP_MP1 (I1_I654_P4_3 I1_I654_pn3 XI1_I654_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I133_XP_MP0 (XI1_I654_I133_XP_p1 I1_I654_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I133_XP_MP1 (I1_I654_P8_1 I1_I654_P4_1n XI1_I654_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I135_XP_MP0 (XI1_I654_I135_XP_p1 I1_I654_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I135_XP_MP1 (I1_I654_P10_3 I1_I654_P6_3n XI1_I654_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I137_XP_MP0 (XI1_I654_I137_XP_p1 I1_I654_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I137_XP_MP1 (I1_I654_P12_5 I1_I654_P8_5n XI1_I654_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I139_XP_MP0 (XI1_I654_I139_XP_p1 I1_I654_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I139_XP_MP1 (I1_I654_P14_7 I1_I654_P10_7n XI1_I654_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I143_XP_MP0 (XI1_I654_I143_XP_p1 I1_I654_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I143_XP_MP1 (I1_I654_P18_11 I1_I654_P14_11n XI1_I654_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I87_XP_MP0 (XI1_I654_I87_XP_p1 I1_I654_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I87_XP_MP1 (I1_I654_P21_20 I1_I654_pn20 XI1_I654_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I155_XP_MP0 (XI1_I654_I155_XP_p1 I1_I654_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I155_XP_MP1 (I1_I654_P30_23 I1_I654_P26_23n XI1_I654_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I91_XP_MP0 (XI1_I654_I91_XP_p1 I1_I654_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I91_XP_MP1 (I1_I654_P25_24 I1_I654_pn24 XI1_I654_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I92_XP_MP0 (XI1_I654_I92_XP_p1 I1_I654_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I92_XP_MP1 (I1_I654_P26_25 I1_I654_pn25 XI1_I654_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I97_XP_MP0 (XI1_I654_I97_XP_p1 I1_I654_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I97_XP_MP1 (I1_I654_P31_30 I1_I654_pn30 XI1_I654_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I96_XP_MP0 (XI1_I654_I96_XP_p1 I1_I654_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I96_XP_MP1 (I1_I654_P30_29 I1_I654_pn29 XI1_I654_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I96_XP_MP0 (XI1_I1436_I96_XP_p1 I1_I1436_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I96_XP_MP1 (I1_I1436_P30_29 I1_I1436_pn29 XI1_I1436_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I155_XP_MP0 (XI1_I1436_I155_XP_p1 I1_I1436_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I155_XP_MP1 (I1_I1436_P30_23 I1_I1436_P26_23n XI1_I1436_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I145_XP_MP0 (XI1_I1436_I145_XP_p1 I1_I1436_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I145_XP_MP1 (I1_I1436_P20_13 I1_I1436_P16_13n XI1_I1436_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I139_XP_MP0 (XI1_I1436_I139_XP_p1 I1_I1436_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I139_XP_MP1 (I1_I1436_P14_7 I1_I1436_P10_7n XI1_I1436_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I141_XP_MP0 (XI1_I1436_I141_XP_p1 I1_I1436_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I141_XP_MP1 (I1_I1436_P16_9 I1_I1436_P12_9n XI1_I1436_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I137_XP_MP0 (XI1_I1436_I137_XP_p1 I1_I1436_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I137_XP_MP1 (I1_I1436_P12_5 I1_I1436_P8_5n XI1_I1436_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I135_XP_MP0 (XI1_I1436_I135_XP_p1 I1_I1436_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I135_XP_MP1 (I1_I1436_P10_3 I1_I1436_P6_3n XI1_I1436_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I74_XP_MP0 (XI1_I1436_I74_XP_p1 I1_I1436_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I74_XP_MP1 (I1_I1436_P8_7 I1_I1436_pn7 XI1_I1436_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I70_XP_MP0 (XI1_I1436_I70_XP_p1 I1_I1436_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I70_XP_MP1 (I1_I1436_P4_3 I1_I1436_pn3 XI1_I1436_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I154_XP_MP0 (XI1_I1114_I154_XP_p1 I1_I1114_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I154_XP_MP1 (I1_I1114_P29_22 I1_I1114_P25_22n XI1_I1114_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I91_XP_MP0 (XI1_I1114_I91_XP_p1 I1_I1114_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I91_XP_MP1 (I1_I1114_P25_24 I1_I1114_pn24 XI1_I1114_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I89_XP_MP0 (XI1_I1114_I89_XP_p1 I1_I1114_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I89_XP_MP1 (I1_I1114_P23_22 I1_I1114_pn22 XI1_I1114_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I90_XP_MP0 (XI1_I1114_I90_XP_p1 I1_I1114_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I90_XP_MP1 (I1_I1114_P24_23 I1_I1114_pn23 XI1_I1114_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I155_XP_MP0 (XI1_I1068_I155_XP_p1 I1_I1068_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I155_XP_MP1 (I1_I1068_P30_23 I1_I1068_P26_23n XI1_I1068_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I92_XP_MP0 (XI1_I1068_I92_XP_p1 I1_I1068_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I92_XP_MP1 (I1_I1068_P26_25 I1_I1068_pn25 XI1_I1068_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I97_XP_MP0 (XI1_I976_I97_XP_p1 I1_I976_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I97_XP_MP1 (I1_I976_P31_30 I1_I976_pn30 XI1_I976_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I95_XP_MP0 (XI1_I976_I95_XP_p1 I1_I976_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I95_XP_MP1 (I1_I976_P29_28 I1_I976_pn28 XI1_I976_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I94_XP_MP0 (XI1_I976_I94_XP_p1 I1_I976_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I94_XP_MP1 (I1_I976_P28_27 I1_I976_pn27 XI1_I976_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I93_XP_MP0 (XI1_I976_I93_XP_p1 I1_I976_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I93_XP_MP1 (I1_I976_P27_26 I1_I976_pn26 XI1_I976_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I91_XP_MP0 (XI1_I976_I91_XP_p1 I1_I976_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I91_XP_MP1 (I1_I976_P25_24 I1_I976_pn24 XI1_I976_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I89_XP_MP0 (XI1_I976_I89_XP_p1 I1_I976_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I89_XP_MP1 (I1_I976_P23_22 I1_I976_pn22 XI1_I976_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I154_XP_MP0 (XI1_I976_I154_XP_p1 I1_I976_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I154_XP_MP1 (I1_I976_P29_22 I1_I976_P25_22n XI1_I976_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I87_XP_MP0 (XI1_I976_I87_XP_p1 I1_I976_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I87_XP_MP1 (I1_I976_P21_20 I1_I976_pn20 XI1_I976_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I150_XP_MP0 (XI1_I976_I150_XP_p1 I1_I976_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I150_XP_MP1 (I1_I976_P25_18 I1_I976_P21_18n XI1_I976_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I146_XP_MP0 (XI1_I976_I146_XP_p1 I1_I976_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I146_XP_MP1 (I1_I976_P21_14 I1_I976_P17_14n XI1_I976_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I72_XP_MP0 (XI1_I654_I72_XP_p1 I1_I654_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I72_XP_MP1 (I1_I654_P6_5 I1_I654_pn5 XI1_I654_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I74_XP_MP0 (XI1_I654_I74_XP_p1 I1_I654_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I74_XP_MP1 (I1_I654_P8_7 I1_I654_pn7 XI1_I654_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I141_XP_MP0 (XI1_I654_I141_XP_p1 I1_I654_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I141_XP_MP1 (I1_I654_P16_9 I1_I654_P12_9n XI1_I654_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I145_XP_MP0 (XI1_I654_I145_XP_p1 I1_I654_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I145_XP_MP1 (I1_I654_P20_13 I1_I654_P16_13n XI1_I654_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I149_XP_MP0 (XI1_I654_I149_XP_p1 I1_I654_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I149_XP_MP1 (I1_I654_P24_17 I1_I654_P20_17n XI1_I654_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I147_XP_MP0 (XI1_I654_I147_XP_p1 I1_I654_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I147_XP_MP1 (I1_I654_P22_15 I1_I654_P18_15n XI1_I654_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I151_XP_MP0 (XI1_I654_I151_XP_p1 I1_I654_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I151_XP_MP1 (I1_I654_P26_19 I1_I654_P22_19n XI1_I654_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I153_XP_MP0 (XI1_I654_I153_XP_p1 I1_I654_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I153_XP_MP1 (I1_I654_P28_21 I1_I654_P24_21n XI1_I654_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I90_XP_MP0 (XI1_I654_I90_XP_p1 I1_I654_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I90_XP_MP1 (I1_I654_P24_23 I1_I654_pn23 XI1_I654_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I94_XP_MP0 (XI1_I654_I94_XP_p1 I1_I654_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I94_XP_MP1 (I1_I654_P28_27 I1_I654_pn27 XI1_I654_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I95_XP_MP0 (XI1_I1436_I95_XP_p1 I1_I1436_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I95_XP_MP1 (I1_I1436_P29_28 I1_I1436_pn28 XI1_I1436_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I93_XP_MP0 (XI1_I1436_I93_XP_p1 I1_I1436_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I93_XP_MP1 (I1_I1436_P27_26 I1_I1436_pn26 XI1_I1436_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I91_XP_MP0 (XI1_I1436_I91_XP_p1 I1_I1436_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I91_XP_MP1 (I1_I1436_P25_24 I1_I1436_pn24 XI1_I1436_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I89_XP_MP0 (XI1_I1436_I89_XP_p1 I1_I1436_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I89_XP_MP1 (I1_I1436_P23_22 I1_I1436_pn22 XI1_I1436_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I87_XP_MP0 (XI1_I1436_I87_XP_p1 I1_I1436_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I87_XP_MP1 (I1_I1436_P21_20 I1_I1436_pn20 XI1_I1436_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I85_XP_MP0 (XI1_I1436_I85_XP_p1 I1_I1436_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I85_XP_MP1 (I1_I1436_P19_18 I1_I1436_pn18 XI1_I1436_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I83_XP_MP0 (XI1_I1436_I83_XP_p1 I1_I1436_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I83_XP_MP1 (I1_I1436_P17_16 I1_I1436_pn16 XI1_I1436_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I81_XP_MP0 (XI1_I1436_I81_XP_p1 I1_I1436_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I81_XP_MP1 (I1_I1436_P15_14 I1_I1436_pn14 XI1_I1436_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I79_XP_MP0 (XI1_I1436_I79_XP_p1 I1_I1436_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I79_XP_MP1 (I1_I1436_P13_12 I1_I1436_pn12 XI1_I1436_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I77_XP_MP0 (XI1_I1436_I77_XP_p1 I1_I1436_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I77_XP_MP1 (I1_I1436_P11_10 I1_I1436_pn10 XI1_I1436_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I75_XP_MP0 (XI1_I1436_I75_XP_p1 I1_I1436_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I75_XP_MP1 (I1_I1436_P9_8 I1_I1436_pn8 XI1_I1436_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I73_XP_MP0 (XI1_I1436_I73_XP_p1 I1_I1436_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I73_XP_MP1 (I1_I1436_P7_6 I1_I1436_pn6 XI1_I1436_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I133_XP_MP0 (XI1_I1436_I133_XP_p1 I1_I1436_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I133_XP_MP1 (I1_I1436_P8_1 I1_I1436_P4_1n XI1_I1436_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I68_XP_MP0 (XI1_I1436_I68_XP_p1 I1_I1436_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I68_XP_MP1 (I1_I1436_P2_1 I1_I1436_pn1 XI1_I1436_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I152_XP_MP0 (XI1_I1114_I152_XP_p1 I1_I1114_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I152_XP_MP1 (I1_I1114_P27_20 I1_I1114_P23_20n XI1_I1114_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I153_XP_MP0 (XI1_I1114_I153_XP_p1 I1_I1114_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I153_XP_MP1 (I1_I1114_P28_21 I1_I1114_P24_21n XI1_I1114_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I151_XP_MP0 (XI1_I1114_I151_XP_p1 I1_I1114_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I151_XP_MP1 (I1_I1114_P26_19 I1_I1114_P22_19n XI1_I1114_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I147_XP_MP0 (XI1_I1114_I147_XP_p1 I1_I1114_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I147_XP_MP1 (I1_I1114_P22_15 I1_I1114_P18_15n XI1_I1114_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I88_XP_MP0 (XI1_I1114_I88_XP_p1 I1_I1114_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I88_XP_MP1 (I1_I1114_P22_21 I1_I1114_pn21 XI1_I1114_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I87_XP_MP0 (XI1_I1114_I87_XP_p1 I1_I1114_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I87_XP_MP1 (I1_I1114_P21_20 I1_I1114_pn20 XI1_I1114_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I86_XP_MP0 (XI1_I1114_I86_XP_p1 I1_I1114_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I86_XP_MP1 (I1_I1114_P20_19 I1_I1114_pn19 XI1_I1114_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I153_XP_MP0 (XI1_I1068_I153_XP_p1 I1_I1068_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I153_XP_MP1 (I1_I1068_P28_21 I1_I1068_P24_21n XI1_I1068_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I90_XP_MP0 (XI1_I1068_I90_XP_p1 I1_I1068_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I90_XP_MP1 (I1_I1068_P24_23 I1_I1068_pn23 XI1_I1068_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I154_XP_MP0 (XI1_I1068_I154_XP_p1 I1_I1068_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I154_XP_MP1 (I1_I1068_P29_22 I1_I1068_P25_22n XI1_I1068_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I156_XP_MP0 (XI1_I1068_I156_XP_p1 I1_I1068_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I156_XP_MP1 (I1_I1068_P31_24 I1_I1068_P27_24n XI1_I1068_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I91_XP_MP0 (XI1_I1068_I91_XP_p1 I1_I1068_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I91_XP_MP1 (I1_I1068_P25_24 I1_I1068_pn24 XI1_I1068_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I96_XP_MP0 (XI1_I1022_I96_XP_p1 I1_I1022_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I96_XP_MP1 (I1_I1022_P30_29 I1_I1022_pn29 XI1_I1022_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I97_XP_MP0 (XI1_I1022_I97_XP_p1 I1_I1022_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I97_XP_MP1 (I1_I1022_P31_30 I1_I1022_pn30 XI1_I1022_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I96_XP_MP0 (XI1_I976_I96_XP_p1 I1_I976_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I96_XP_MP1 (I1_I976_P30_29 I1_I976_pn29 XI1_I976_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I92_XP_MP0 (XI1_I976_I92_XP_p1 I1_I976_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I92_XP_MP1 (I1_I976_P26_25 I1_I976_pn25 XI1_I976_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I156_XP_MP0 (XI1_I976_I156_XP_p1 I1_I976_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I156_XP_MP1 (I1_I976_P31_24 I1_I976_P27_24n XI1_I976_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I152_XP_MP0 (XI1_I976_I152_XP_p1 I1_I976_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I152_XP_MP1 (I1_I976_P27_20 I1_I976_P23_20n XI1_I976_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I85_XP_MP0 (XI1_I976_I85_XP_p1 I1_I976_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I85_XP_MP1 (I1_I976_P19_18 I1_I976_pn18 XI1_I976_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I83_XP_MP0 (XI1_I976_I83_XP_p1 I1_I976_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I83_XP_MP1 (I1_I976_P17_16 I1_I976_pn16 XI1_I976_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I144_XP_MP0 (XI1_I976_I144_XP_p1 I1_I976_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I144_XP_MP1 (I1_I976_P19_12 I1_I976_P15_12n XI1_I976_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I81_XP_MP0 (XI1_I976_I81_XP_p1 I1_I976_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I81_XP_MP1 (I1_I976_P15_14 I1_I976_pn14 XI1_I976_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I79_XP_MP0 (XI1_I976_I79_XP_p1 I1_I976_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I79_XP_MP1 (I1_I976_P13_12 I1_I976_pn12 XI1_I976_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I142_XP_MP0 (XI1_I976_I142_XP_p1 I1_I976_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I142_XP_MP1 (I1_I976_P17_10 I1_I976_P13_10n XI1_I976_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I76_XP_MP0 (XI1_I654_I76_XP_p1 I1_I654_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I76_XP_MP1 (I1_I654_P10_9 I1_I654_pn9 XI1_I654_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I78_XP_MP0 (XI1_I654_I78_XP_p1 I1_I654_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I78_XP_MP1 (I1_I654_P12_11 I1_I654_pn11 XI1_I654_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I80_XP_MP0 (XI1_I654_I80_XP_p1 I1_I654_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I80_XP_MP1 (I1_I654_P14_13 I1_I654_pn13 XI1_I654_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I82_XP_MP0 (XI1_I654_I82_XP_p1 I1_I654_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I82_XP_MP1 (I1_I654_P16_15 I1_I654_pn15 XI1_I654_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I84_XP_MP0 (XI1_I654_I84_XP_p1 I1_I654_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I84_XP_MP1 (I1_I654_P18_17 I1_I654_pn17 XI1_I654_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I86_XP_MP0 (XI1_I654_I86_XP_p1 I1_I654_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I86_XP_MP1 (I1_I654_P20_19 I1_I654_pn19 XI1_I654_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I88_XP_MP0 (XI1_I654_I88_XP_p1 I1_I654_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I88_XP_MP1 (I1_I654_P22_21 I1_I654_pn21 XI1_I654_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I97_XP_MP0 (XI1_I1436_I97_XP_p1 I1_I1436_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I97_XP_MP1 (I1_I1436_P31_30 I1_I1436_pn30 XI1_I1436_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I156_XP_MP0 (XI1_I1436_I156_XP_p1 I1_I1436_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I156_XP_MP1 (I1_I1436_P31_24 I1_I1436_P27_24n XI1_I1436_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I152_XP_MP0 (XI1_I1436_I152_XP_p1 I1_I1436_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I152_XP_MP1 (I1_I1436_P27_20 I1_I1436_P23_20n XI1_I1436_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I154_XP_MP0 (XI1_I1436_I154_XP_p1 I1_I1436_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I154_XP_MP1 (I1_I1436_P29_22 I1_I1436_P25_22n XI1_I1436_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I150_XP_MP0 (XI1_I1436_I150_XP_p1 I1_I1436_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I150_XP_MP1 (I1_I1436_P25_18 I1_I1436_P21_18n XI1_I1436_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I146_XP_MP0 (XI1_I1436_I146_XP_p1 I1_I1436_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I146_XP_MP1 (I1_I1436_P21_14 I1_I1436_P17_14n XI1_I1436_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I142_XP_MP0 (XI1_I1436_I142_XP_p1 I1_I1436_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I142_XP_MP1 (I1_I1436_P17_10 I1_I1436_P13_10n XI1_I1436_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I138_XP_MP0 (XI1_I1436_I138_XP_p1 I1_I1436_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I138_XP_MP1 (I1_I1436_P13_6 I1_I1436_P9_6n XI1_I1436_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I134_XP_MP0 (XI1_I1436_I134_XP_p1 I1_I1436_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I134_XP_MP1 (I1_I1436_P9_2 I1_I1436_P5_2n XI1_I1436_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I71_XP_MP0 (XI1_I1436_I71_XP_p1 I1_I1436_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I71_XP_MP1 (I1_I1436_P5_4 I1_I1436_pn4 XI1_I1436_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I69_XP_MP0 (XI1_I1436_I69_XP_p1 I1_I1436_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I69_XP_MP1 (I1_I1436_P3_2 I1_I1436_pn2 XI1_I1436_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I148_XP_MP0 (XI1_I1114_I148_XP_p1 I1_I1114_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I148_XP_MP1 (I1_I1114_P23_16 I1_I1114_P19_16n XI1_I1114_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I150_XP_MP0 (XI1_I1114_I150_XP_p1 I1_I1114_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I150_XP_MP1 (I1_I1114_P25_18 I1_I1114_P21_18n XI1_I1114_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I146_XP_MP0 (XI1_I1114_I146_XP_p1 I1_I1114_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I146_XP_MP1 (I1_I1114_P21_14 I1_I1114_P17_14n XI1_I1114_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I143_XP_MP0 (XI1_I1114_I143_XP_p1 I1_I1114_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I143_XP_MP1 (I1_I1114_P18_11 I1_I1114_P14_11n XI1_I1114_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I85_XP_MP0 (XI1_I1114_I85_XP_p1 I1_I1114_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I85_XP_MP1 (I1_I1114_P19_18 I1_I1114_pn18 XI1_I1114_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I84_XP_MP0 (XI1_I1114_I84_XP_p1 I1_I1114_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I84_XP_MP1 (I1_I1114_P18_17 I1_I1114_pn17 XI1_I1114_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I147_XP_MP0 (XI1_I1068_I147_XP_p1 I1_I1068_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I147_XP_MP1 (I1_I1068_P22_15 I1_I1068_P18_15n XI1_I1068_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I88_XP_MP0 (XI1_I1068_I88_XP_p1 I1_I1068_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I88_XP_MP1 (I1_I1068_P22_21 I1_I1068_pn21 XI1_I1068_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I152_XP_MP0 (XI1_I1068_I152_XP_p1 I1_I1068_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I152_XP_MP1 (I1_I1068_P27_20 I1_I1068_P23_20n XI1_I1068_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I89_XP_MP0 (XI1_I1068_I89_XP_p1 I1_I1068_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I89_XP_MP1 (I1_I1068_P23_22 I1_I1068_pn22 XI1_I1068_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I95_XP_MP0 (XI1_I1022_I95_XP_p1 I1_I1022_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I95_XP_MP1 (I1_I1022_P29_28 I1_I1022_pn28 XI1_I1022_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I93_XP_MP0 (XI1_I1022_I93_XP_p1 I1_I1022_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I93_XP_MP1 (I1_I1022_P27_26 I1_I1022_pn26 XI1_I1022_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I90_XP_MP0 (XI1_I976_I90_XP_p1 I1_I976_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I90_XP_MP1 (I1_I976_P24_23 I1_I976_pn23 XI1_I976_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I88_XP_MP0 (XI1_I976_I88_XP_p1 I1_I976_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I88_XP_MP1 (I1_I976_P22_21 I1_I976_pn21 XI1_I976_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I148_XP_MP0 (XI1_I976_I148_XP_p1 I1_I976_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I148_XP_MP1 (I1_I976_P23_16 I1_I976_P19_16n XI1_I976_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I86_XP_MP0 (XI1_I976_I86_XP_p1 I1_I976_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I86_XP_MP1 (I1_I976_P20_19 I1_I976_pn19 XI1_I976_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I82_XP_MP0 (XI1_I976_I82_XP_p1 I1_I976_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I82_XP_MP1 (I1_I976_P16_15 I1_I976_pn15 XI1_I976_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I80_XP_MP0 (XI1_I976_I80_XP_p1 I1_I976_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I80_XP_MP1 (I1_I976_P14_13 I1_I976_pn13 XI1_I976_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I140_XP_MP0 (XI1_I976_I140_XP_p1 I1_I976_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I140_XP_MP1 (I1_I976_P15_8 I1_I976_P11_8n XI1_I976_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I136_XP_MP0 (XI1_I976_I136_XP_p1 I1_I976_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I136_XP_MP1 (I1_I976_P11_4 I1_I976_P7_4n XI1_I976_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I138_XP_MP0 (XI1_I976_I138_XP_p1 I1_I976_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I138_XP_MP1 (I1_I976_P13_6 I1_I976_P9_6n XI1_I976_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I77_XP_MP0 (XI1_I976_I77_XP_p1 I1_I976_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I77_XP_MP1 (I1_I976_P11_10 I1_I976_pn10 XI1_I976_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I75_XP_MP0 (XI1_I976_I75_XP_p1 I1_I976_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I75_XP_MP1 (I1_I976_P9_8 I1_I976_pn8 XI1_I976_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I73_XP_MP0 (XI1_I976_I73_XP_p1 I1_I976_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I73_XP_MP1 (I1_I976_P7_6 I1_I976_pn6 XI1_I976_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I148_XP_MP0 (XI1_I1436_I148_XP_p1 I1_I1436_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I148_XP_MP1 (I1_I1436_P23_16 I1_I1436_P19_16n XI1_I1436_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I144_XP_MP0 (XI1_I1436_I144_XP_p1 I1_I1436_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I144_XP_MP1 (I1_I1436_P19_12 I1_I1436_P15_12n XI1_I1436_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I140_XP_MP0 (XI1_I1436_I140_XP_p1 I1_I1436_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I140_XP_MP1 (I1_I1436_P15_8 I1_I1436_P11_8n XI1_I1436_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I136_XP_MP0 (XI1_I1436_I136_XP_p1 I1_I1436_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I136_XP_MP1 (I1_I1436_P11_4 I1_I1436_P7_4n XI1_I1436_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I144_XP_MP0 (XI1_I1114_I144_XP_p1 I1_I1114_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I144_XP_MP1 (I1_I1114_P19_12 I1_I1114_P15_12n XI1_I1114_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I149_XP_MP0 (XI1_I1114_I149_XP_p1 I1_I1114_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I149_XP_MP1 (I1_I1114_P24_17 I1_I1114_P20_17n XI1_I1114_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I145_XP_MP0 (XI1_I1114_I145_XP_p1 I1_I1114_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I145_XP_MP1 (I1_I1114_P20_13 I1_I1114_P16_13n XI1_I1114_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I83_XP_MP0 (XI1_I1114_I83_XP_p1 I1_I1114_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I83_XP_MP1 (I1_I1114_P17_16 I1_I1114_pn16 XI1_I1114_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I82_XP_MP0 (XI1_I1114_I82_XP_p1 I1_I1114_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I82_XP_MP1 (I1_I1114_P16_15 I1_I1114_pn15 XI1_I1114_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I151_XP_MP0 (XI1_I1068_I151_XP_p1 I1_I1068_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I151_XP_MP1 (I1_I1068_P26_19 I1_I1068_P22_19n XI1_I1068_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I86_XP_MP0 (XI1_I1068_I86_XP_p1 I1_I1068_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I86_XP_MP1 (I1_I1068_P20_19 I1_I1068_pn19 XI1_I1068_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I150_XP_MP0 (XI1_I1068_I150_XP_p1 I1_I1068_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I150_XP_MP1 (I1_I1068_P25_18 I1_I1068_P21_18n XI1_I1068_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I148_XP_MP0 (XI1_I1068_I148_XP_p1 I1_I1068_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I148_XP_MP1 (I1_I1068_P23_16 I1_I1068_P19_16n XI1_I1068_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I87_XP_MP0 (XI1_I1068_I87_XP_p1 I1_I1068_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I87_XP_MP1 (I1_I1068_P21_20 I1_I1068_pn20 XI1_I1068_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I94_XP_MP0 (XI1_I1022_I94_XP_p1 I1_I1022_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I94_XP_MP1 (I1_I1022_P28_27 I1_I1022_pn27 XI1_I1022_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I92_XP_MP0 (XI1_I1022_I92_XP_p1 I1_I1022_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I92_XP_MP1 (I1_I1022_P26_25 I1_I1022_pn25 XI1_I1022_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I91_XP_MP0 (XI1_I1022_I91_XP_p1 I1_I1022_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I91_XP_MP1 (I1_I1022_P25_24 I1_I1022_pn24 XI1_I1022_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I155_XP_MP0 (XI1_I976_I155_XP_p1 I1_I976_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I155_XP_MP1 (I1_I976_P30_23 I1_I976_P26_23n XI1_I976_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I153_XP_MP0 (XI1_I976_I153_XP_p1 I1_I976_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I153_XP_MP1 (I1_I976_P28_21 I1_I976_P24_21n XI1_I976_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I84_XP_MP0 (XI1_I976_I84_XP_p1 I1_I976_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I84_XP_MP1 (I1_I976_P18_17 I1_I976_pn17 XI1_I976_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I78_XP_MP0 (XI1_I976_I78_XP_p1 I1_I976_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I78_XP_MP1 (I1_I976_P12_11 I1_I976_pn11 XI1_I976_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I134_XP_MP0 (XI1_I976_I134_XP_p1 I1_I976_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I134_XP_MP1 (I1_I976_P9_2 I1_I976_P5_2n XI1_I976_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I140_XP_MP0 (XI1_I1114_I140_XP_p1 I1_I1114_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I140_XP_MP1 (I1_I1114_P15_8 I1_I1114_P11_8n XI1_I1114_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I142_XP_MP0 (XI1_I1114_I142_XP_p1 I1_I1114_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I142_XP_MP1 (I1_I1114_P17_10 I1_I1114_P13_10n XI1_I1114_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I81_XP_MP0 (XI1_I1114_I81_XP_p1 I1_I1114_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I81_XP_MP1 (I1_I1114_P15_14 I1_I1114_pn14 XI1_I1114_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I80_XP_MP0 (XI1_I1114_I80_XP_p1 I1_I1114_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I80_XP_MP1 (I1_I1114_P14_13 I1_I1114_pn13 XI1_I1114_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I145_XP_MP0 (XI1_I1068_I145_XP_p1 I1_I1068_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I145_XP_MP1 (I1_I1068_P20_13 I1_I1068_P16_13n XI1_I1068_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I149_XP_MP0 (XI1_I1068_I149_XP_p1 I1_I1068_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I149_XP_MP1 (I1_I1068_P24_17 I1_I1068_P20_17n XI1_I1068_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I146_XP_MP0 (XI1_I1068_I146_XP_p1 I1_I1068_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I146_XP_MP1 (I1_I1068_P21_14 I1_I1068_P17_14n XI1_I1068_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I144_XP_MP0 (XI1_I1068_I144_XP_p1 I1_I1068_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I144_XP_MP1 (I1_I1068_P19_12 I1_I1068_P15_12n XI1_I1068_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I85_XP_MP0 (XI1_I1068_I85_XP_p1 I1_I1068_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I85_XP_MP1 (I1_I1068_P19_18 I1_I1068_pn18 XI1_I1068_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I155_XP_MP0 (XI1_I1022_I155_XP_p1 I1_I1022_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I155_XP_MP1 (I1_I1022_P30_23 I1_I1022_P26_23n XI1_I1022_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I90_XP_MP0 (XI1_I1022_I90_XP_p1 I1_I1022_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I90_XP_MP1 (I1_I1022_P24_23 I1_I1022_pn23 XI1_I1022_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I89_XP_MP0 (XI1_I1022_I89_XP_p1 I1_I1022_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I89_XP_MP1 (I1_I1022_P23_22 I1_I1022_pn22 XI1_I1022_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I151_XP_MP0 (XI1_I976_I151_XP_p1 I1_I976_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I151_XP_MP1 (I1_I976_P26_19 I1_I976_P22_19n XI1_I976_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I147_XP_MP0 (XI1_I976_I147_XP_p1 I1_I976_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I147_XP_MP1 (I1_I976_P22_15 I1_I976_P18_15n XI1_I976_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I149_XP_MP0 (XI1_I976_I149_XP_p1 I1_I976_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I149_XP_MP1 (I1_I976_P24_17 I1_I976_P20_17n XI1_I976_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I145_XP_MP0 (XI1_I976_I145_XP_p1 I1_I976_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I145_XP_MP1 (I1_I976_P20_13 I1_I976_P16_13n XI1_I976_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I143_XP_MP0 (XI1_I976_I143_XP_p1 I1_I976_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I143_XP_MP1 (I1_I976_P18_11 I1_I976_P14_11n XI1_I976_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I141_XP_MP0 (XI1_I976_I141_XP_p1 I1_I976_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I141_XP_MP1 (I1_I976_P16_9 I1_I976_P12_9n XI1_I976_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I76_XP_MP0 (XI1_I976_I76_XP_p1 I1_I976_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I76_XP_MP1 (I1_I976_P10_9 I1_I976_pn9 XI1_I976_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I74_XP_MP0 (XI1_I976_I74_XP_p1 I1_I976_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I74_XP_MP1 (I1_I976_P8_7 I1_I976_pn7 XI1_I976_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I71_XP_MP0 (XI1_I976_I71_XP_p1 I1_I976_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I71_XP_MP1 (I1_I976_P5_4 I1_I976_pn4 XI1_I976_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I68_XP_MP0 (XI1_I608_I68_XP_p1 I1_I608_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I68_XP_MP1 (I1_I608_P2_1 I1_I608_pn1 XI1_I608_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I133_XP_MP0 (XI1_I608_I133_XP_p1 I1_I608_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I133_XP_MP1 (I1_I608_P8_1 I1_I608_P4_1n XI1_I608_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I135_XP_MP0 (XI1_I608_I135_XP_p1 I1_I608_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I135_XP_MP1 (I1_I608_P10_3 I1_I608_P6_3n XI1_I608_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I137_XP_MP0 (XI1_I608_I137_XP_p1 I1_I608_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I137_XP_MP1 (I1_I608_P12_5 I1_I608_P8_5n XI1_I608_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I141_XP_MP0 (XI1_I608_I141_XP_p1 I1_I608_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I141_XP_MP1 (I1_I608_P16_9 I1_I608_P12_9n XI1_I608_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I139_XP_MP0 (XI1_I608_I139_XP_p1 I1_I608_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I139_XP_MP1 (I1_I608_P14_7 I1_I608_P10_7n XI1_I608_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I143_XP_MP0 (XI1_I608_I143_XP_p1 I1_I608_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I143_XP_MP1 (I1_I608_P18_11 I1_I608_P14_11n XI1_I608_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I145_XP_MP0 (XI1_I608_I145_XP_p1 I1_I608_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I145_XP_MP1 (I1_I608_P20_13 I1_I608_P16_13n XI1_I608_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I149_XP_MP0 (XI1_I608_I149_XP_p1 I1_I608_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I149_XP_MP1 (I1_I608_P24_17 I1_I608_P20_17n XI1_I608_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I147_XP_MP0 (XI1_I608_I147_XP_p1 I1_I608_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I147_XP_MP1 (I1_I608_P22_15 I1_I608_P18_15n XI1_I608_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I151_XP_MP0 (XI1_I608_I151_XP_p1 I1_I608_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I151_XP_MP1 (I1_I608_P26_19 I1_I608_P22_19n XI1_I608_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I155_XP_MP0 (XI1_I608_I155_XP_p1 I1_I608_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I155_XP_MP1 (I1_I608_P30_23 I1_I608_P26_23n XI1_I608_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I96_XP_MP0 (XI1_I608_I96_XP_p1 I1_I608_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I96_XP_MP1 (I1_I608_P30_29 I1_I608_pn29 XI1_I608_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I79_XP_MP0 (XI1_I1482_I79_XP_p1 I1_I1482_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I79_XP_MP1 (I1_I1482_P13_12 I1_I1482_pn12 XI1_I1482_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I138_XP_MP0 (XI1_I1114_I138_XP_p1 I1_I1114_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I138_XP_MP1 (I1_I1114_P13_6 I1_I1114_P9_6n XI1_I1114_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I137_XP_MP0 (XI1_I1114_I137_XP_p1 I1_I1114_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I137_XP_MP1 (I1_I1114_P12_5 I1_I1114_P8_5n XI1_I1114_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I141_XP_MP0 (XI1_I1114_I141_XP_p1 I1_I1114_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I141_XP_MP1 (I1_I1114_P16_9 I1_I1114_P12_9n XI1_I1114_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I135_XP_MP0 (XI1_I1114_I135_XP_p1 I1_I1114_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I135_XP_MP1 (I1_I1114_P10_3 I1_I1114_P6_3n XI1_I1114_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I139_XP_MP0 (XI1_I1114_I139_XP_p1 I1_I1114_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I139_XP_MP1 (I1_I1114_P14_7 I1_I1114_P10_7n XI1_I1114_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I79_XP_MP0 (XI1_I1114_I79_XP_p1 I1_I1114_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I79_XP_MP1 (I1_I1114_P13_12 I1_I1114_pn12 XI1_I1114_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I84_XP_MP0 (XI1_I1068_I84_XP_p1 I1_I1068_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I84_XP_MP1 (I1_I1068_P18_17 I1_I1068_pn17 XI1_I1068_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I140_XP_MP0 (XI1_I1068_I140_XP_p1 I1_I1068_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I140_XP_MP1 (I1_I1068_P15_8 I1_I1068_P11_8n XI1_I1068_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I81_XP_MP0 (XI1_I1068_I81_XP_p1 I1_I1068_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I81_XP_MP1 (I1_I1068_P15_14 I1_I1068_pn14 XI1_I1068_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I83_XP_MP0 (XI1_I1068_I83_XP_p1 I1_I1068_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I83_XP_MP1 (I1_I1068_P17_16 I1_I1068_pn16 XI1_I1068_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I86_XP_MP0 (XI1_I1022_I86_XP_p1 I1_I1022_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I86_XP_MP1 (I1_I1022_P20_19 I1_I1022_pn19 XI1_I1022_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I156_XP_MP0 (XI1_I1022_I156_XP_p1 I1_I1022_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I156_XP_MP1 (I1_I1022_P31_24 I1_I1022_P27_24n XI1_I1022_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I88_XP_MP0 (XI1_I1022_I88_XP_p1 I1_I1022_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I88_XP_MP1 (I1_I1022_P22_21 I1_I1022_pn21 XI1_I1022_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I87_XP_MP0 (XI1_I1022_I87_XP_p1 I1_I1022_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I87_XP_MP1 (I1_I1022_P21_20 I1_I1022_pn20 XI1_I1022_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I139_XP_MP0 (XI1_I976_I139_XP_p1 I1_I976_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I139_XP_MP1 (I1_I976_P14_7 I1_I976_P10_7n XI1_I976_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I135_XP_MP0 (XI1_I976_I135_XP_p1 I1_I976_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I135_XP_MP1 (I1_I976_P10_3 I1_I976_P6_3n XI1_I976_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I137_XP_MP0 (XI1_I976_I137_XP_p1 I1_I976_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I137_XP_MP1 (I1_I976_P12_5 I1_I976_P8_5n XI1_I976_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I72_XP_MP0 (XI1_I976_I72_XP_p1 I1_I976_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I72_XP_MP1 (I1_I976_P6_5 I1_I976_pn5 XI1_I976_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I69_XP_MP0 (XI1_I608_I69_XP_p1 I1_I608_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I69_XP_MP1 (I1_I608_P3_2 I1_I608_pn2 XI1_I608_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I70_XP_MP0 (XI1_I608_I70_XP_p1 I1_I608_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I70_XP_MP1 (I1_I608_P4_3 I1_I608_pn3 XI1_I608_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I72_XP_MP0 (XI1_I608_I72_XP_p1 I1_I608_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I72_XP_MP1 (I1_I608_P6_5 I1_I608_pn5 XI1_I608_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I74_XP_MP0 (XI1_I608_I74_XP_p1 I1_I608_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I74_XP_MP1 (I1_I608_P8_7 I1_I608_pn7 XI1_I608_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I76_XP_MP0 (XI1_I608_I76_XP_p1 I1_I608_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I76_XP_MP1 (I1_I608_P10_9 I1_I608_pn9 XI1_I608_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I78_XP_MP0 (XI1_I608_I78_XP_p1 I1_I608_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I78_XP_MP1 (I1_I608_P12_11 I1_I608_pn11 XI1_I608_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I80_XP_MP0 (XI1_I608_I80_XP_p1 I1_I608_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I80_XP_MP1 (I1_I608_P14_13 I1_I608_pn13 XI1_I608_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I82_XP_MP0 (XI1_I608_I82_XP_p1 I1_I608_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I82_XP_MP1 (I1_I608_P16_15 I1_I608_pn15 XI1_I608_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I84_XP_MP0 (XI1_I608_I84_XP_p1 I1_I608_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I84_XP_MP1 (I1_I608_P18_17 I1_I608_pn17 XI1_I608_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I86_XP_MP0 (XI1_I608_I86_XP_p1 I1_I608_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I86_XP_MP1 (I1_I608_P20_19 I1_I608_pn19 XI1_I608_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I88_XP_MP0 (XI1_I608_I88_XP_p1 I1_I608_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I88_XP_MP1 (I1_I608_P22_21 I1_I608_pn21 XI1_I608_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I153_XP_MP0 (XI1_I608_I153_XP_p1 I1_I608_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I153_XP_MP1 (I1_I608_P28_21 I1_I608_P24_21n XI1_I608_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I90_XP_MP0 (XI1_I608_I90_XP_p1 I1_I608_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I90_XP_MP1 (I1_I608_P24_23 I1_I608_pn23 XI1_I608_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I92_XP_MP0 (XI1_I608_I92_XP_p1 I1_I608_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I92_XP_MP1 (I1_I608_P26_25 I1_I608_pn25 XI1_I608_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I94_XP_MP0 (XI1_I608_I94_XP_p1 I1_I608_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I94_XP_MP1 (I1_I608_P28_27 I1_I608_pn27 XI1_I608_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I97_XP_MP0 (XI1_I608_I97_XP_p1 I1_I608_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I97_XP_MP1 (I1_I608_P31_30 I1_I608_pn30 XI1_I608_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I89_XP_MP0 (XI1_I1482_I89_XP_p1 I1_I1482_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I89_XP_MP1 (I1_I1482_P23_22 I1_I1482_pn22 XI1_I1482_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I148_XP_MP0 (XI1_I1482_I148_XP_p1 I1_I1482_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I148_XP_MP1 (I1_I1482_P23_16 I1_I1482_P19_16n XI1_I1482_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I87_XP_MP0 (XI1_I1482_I87_XP_p1 I1_I1482_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I87_XP_MP1 (I1_I1482_P21_20 I1_I1482_pn20 XI1_I1482_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I85_XP_MP0 (XI1_I1482_I85_XP_p1 I1_I1482_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I85_XP_MP1 (I1_I1482_P19_18 I1_I1482_pn18 XI1_I1482_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I83_XP_MP0 (XI1_I1482_I83_XP_p1 I1_I1482_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I83_XP_MP1 (I1_I1482_P17_16 I1_I1482_pn16 XI1_I1482_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I140_XP_MP0 (XI1_I1482_I140_XP_p1 I1_I1482_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I140_XP_MP1 (I1_I1482_P15_8 I1_I1482_P11_8n XI1_I1482_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I81_XP_MP0 (XI1_I1482_I81_XP_p1 I1_I1482_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I81_XP_MP1 (I1_I1482_P15_14 I1_I1482_pn14 XI1_I1482_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I138_XP_MP0 (XI1_I1482_I138_XP_p1 I1_I1482_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I138_XP_MP1 (I1_I1482_P13_6 I1_I1482_P9_6n XI1_I1482_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I77_XP_MP0 (XI1_I1482_I77_XP_p1 I1_I1482_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I77_XP_MP1 (I1_I1482_P11_10 I1_I1482_pn10 XI1_I1482_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I75_XP_MP0 (XI1_I1482_I75_XP_p1 I1_I1482_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I75_XP_MP1 (I1_I1482_P9_8 I1_I1482_pn8 XI1_I1482_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I73_XP_MP0 (XI1_I1482_I73_XP_p1 I1_I1482_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I73_XP_MP1 (I1_I1482_P7_6 I1_I1482_pn6 XI1_I1482_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I71_XP_MP0 (XI1_I1482_I71_XP_p1 I1_I1482_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I71_XP_MP1 (I1_I1482_P5_4 I1_I1482_pn4 XI1_I1482_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I69_XP_MP0 (XI1_I1482_I69_XP_p1 I1_I1482_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I69_XP_MP1 (I1_I1482_P3_2 I1_I1482_pn2 XI1_I1482_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I136_XP_MP0 (XI1_I1114_I136_XP_p1 I1_I1114_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I136_XP_MP1 (I1_I1114_P11_4 I1_I1114_P7_4n XI1_I1114_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I134_XP_MP0 (XI1_I1114_I134_XP_p1 I1_I1114_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I134_XP_MP1 (I1_I1114_P9_2 I1_I1114_P5_2n XI1_I1114_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I77_XP_MP0 (XI1_I1114_I77_XP_p1 I1_I1114_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I77_XP_MP1 (I1_I1114_P11_10 I1_I1114_pn10 XI1_I1114_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I78_XP_MP0 (XI1_I1114_I78_XP_p1 I1_I1114_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I78_XP_MP1 (I1_I1114_P12_11 I1_I1114_pn11 XI1_I1114_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I143_XP_MP0 (XI1_I1068_I143_XP_p1 I1_I1068_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I143_XP_MP1 (I1_I1068_P18_11 I1_I1068_P14_11n XI1_I1068_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I82_XP_MP0 (XI1_I1068_I82_XP_p1 I1_I1068_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I82_XP_MP1 (I1_I1068_P16_15 I1_I1068_pn15 XI1_I1068_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I80_XP_MP0 (XI1_I1068_I80_XP_p1 I1_I1068_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I80_XP_MP1 (I1_I1068_P14_13 I1_I1068_pn13 XI1_I1068_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I138_XP_MP0 (XI1_I1068_I138_XP_p1 I1_I1068_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I138_XP_MP1 (I1_I1068_P13_6 I1_I1068_P9_6n XI1_I1068_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I142_XP_MP0 (XI1_I1068_I142_XP_p1 I1_I1068_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I142_XP_MP1 (I1_I1068_P17_10 I1_I1068_P13_10n XI1_I1068_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I79_XP_MP0 (XI1_I1068_I79_XP_p1 I1_I1068_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I79_XP_MP1 (I1_I1068_P13_12 I1_I1068_pn12 XI1_I1068_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I151_XP_MP0 (XI1_I1022_I151_XP_p1 I1_I1022_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I151_XP_MP1 (I1_I1022_P26_19 I1_I1022_P22_19n XI1_I1022_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I153_XP_MP0 (XI1_I1022_I153_XP_p1 I1_I1022_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I153_XP_MP1 (I1_I1022_P28_21 I1_I1022_P24_21n XI1_I1022_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I152_XP_MP0 (XI1_I1022_I152_XP_p1 I1_I1022_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I152_XP_MP1 (I1_I1022_P27_20 I1_I1022_P23_20n XI1_I1022_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I148_XP_MP0 (XI1_I1022_I148_XP_p1 I1_I1022_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I148_XP_MP1 (I1_I1022_P23_16 I1_I1022_P19_16n XI1_I1022_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I85_XP_MP0 (XI1_I1022_I85_XP_p1 I1_I1022_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I85_XP_MP1 (I1_I1022_P19_18 I1_I1022_pn18 XI1_I1022_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I133_XP_MP0 (XI1_I976_I133_XP_p1 I1_I976_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I133_XP_MP1 (I1_I976_P8_1 I1_I976_P4_1n XI1_I976_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I70_XP_MP0 (XI1_I976_I70_XP_p1 I1_I976_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I70_XP_MP1 (I1_I976_P4_3 I1_I976_pn3 XI1_I976_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I69_XP_MP0 (XI1_I976_I69_XP_p1 I1_I976_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I69_XP_MP1 (I1_I976_P3_2 I1_I976_pn2 XI1_I976_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I71_XP_MP0 (XI1_I608_I71_XP_p1 I1_I608_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I71_XP_MP1 (I1_I608_P5_4 I1_I608_pn4 XI1_I608_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I73_XP_MP0 (XI1_I608_I73_XP_p1 I1_I608_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I73_XP_MP1 (I1_I608_P7_6 I1_I608_pn6 XI1_I608_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I134_XP_MP0 (XI1_I608_I134_XP_p1 I1_I608_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I134_XP_MP1 (I1_I608_P9_2 I1_I608_P5_2n XI1_I608_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I136_XP_MP0 (XI1_I608_I136_XP_p1 I1_I608_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I136_XP_MP1 (I1_I608_P11_4 I1_I608_P7_4n XI1_I608_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I138_XP_MP0 (XI1_I608_I138_XP_p1 I1_I608_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I138_XP_MP1 (I1_I608_P13_6 I1_I608_P9_6n XI1_I608_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I140_XP_MP0 (XI1_I608_I140_XP_p1 I1_I608_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I140_XP_MP1 (I1_I608_P15_8 I1_I608_P11_8n XI1_I608_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I144_XP_MP0 (XI1_I608_I144_XP_p1 I1_I608_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I144_XP_MP1 (I1_I608_P19_12 I1_I608_P15_12n XI1_I608_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I156_XP_MP0 (XI1_I608_I156_XP_p1 I1_I608_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I156_XP_MP1 (I1_I608_P31_24 I1_I608_P27_24n XI1_I608_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I95_XP_MP0 (XI1_I608_I95_XP_p1 I1_I608_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I95_XP_MP1 (I1_I608_P29_28 I1_I608_pn28 XI1_I608_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I156_XP_MP0 (XI1_I1482_I156_XP_p1 I1_I1482_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I156_XP_MP1 (I1_I1482_P31_24 I1_I1482_P27_24n XI1_I1482_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I91_XP_MP0 (XI1_I1482_I91_XP_p1 I1_I1482_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I91_XP_MP1 (I1_I1482_P25_24 I1_I1482_pn24 XI1_I1482_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I152_XP_MP0 (XI1_I1482_I152_XP_p1 I1_I1482_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I152_XP_MP1 (I1_I1482_P27_20 I1_I1482_P23_20n XI1_I1482_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I146_XP_MP0 (XI1_I1482_I146_XP_p1 I1_I1482_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I146_XP_MP1 (I1_I1482_P21_14 I1_I1482_P17_14n XI1_I1482_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I144_XP_MP0 (XI1_I1482_I144_XP_p1 I1_I1482_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I144_XP_MP1 (I1_I1482_P19_12 I1_I1482_P15_12n XI1_I1482_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I142_XP_MP0 (XI1_I1482_I142_XP_p1 I1_I1482_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I142_XP_MP1 (I1_I1482_P17_10 I1_I1482_P13_10n XI1_I1482_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I136_XP_MP0 (XI1_I1482_I136_XP_p1 I1_I1482_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I136_XP_MP1 (I1_I1482_P11_4 I1_I1482_P7_4n XI1_I1482_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I134_XP_MP0 (XI1_I1482_I134_XP_p1 I1_I1482_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I134_XP_MP1 (I1_I1482_P9_2 I1_I1482_P5_2n XI1_I1482_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I74_XP_MP0 (XI1_I1482_I74_XP_p1 I1_I1482_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I74_XP_MP1 (I1_I1482_P8_7 I1_I1482_pn7 XI1_I1482_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I72_XP_MP0 (XI1_I1482_I72_XP_p1 I1_I1482_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I72_XP_MP1 (I1_I1482_P6_5 I1_I1482_pn5 XI1_I1482_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I70_XP_MP0 (XI1_I1482_I70_XP_p1 I1_I1482_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I70_XP_MP1 (I1_I1482_P4_3 I1_I1482_pn3 XI1_I1482_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I68_XP_MP0 (XI1_I1482_I68_XP_p1 I1_I1482_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I68_XP_MP1 (I1_I1482_P2_1 I1_I1482_pn1 XI1_I1482_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I75_XP_MP0 (XI1_I1114_I75_XP_p1 I1_I1114_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I75_XP_MP1 (I1_I1114_P9_8 I1_I1114_pn8 XI1_I1114_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I76_XP_MP0 (XI1_I1114_I76_XP_p1 I1_I1114_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I76_XP_MP1 (I1_I1114_P10_9 I1_I1114_pn9 XI1_I1114_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I73_XP_MP0 (XI1_I1114_I73_XP_p1 I1_I1114_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I73_XP_MP1 (I1_I1114_P7_6 I1_I1114_pn6 XI1_I1114_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I72_XP_MP0 (XI1_I1114_I72_XP_p1 I1_I1114_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I72_XP_MP1 (I1_I1114_P6_5 I1_I1114_pn5 XI1_I1114_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I133_XP_MP0 (XI1_I1114_I133_XP_p1 I1_I1114_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I133_XP_MP1 (I1_I1114_P8_1 I1_I1114_P4_1n XI1_I1114_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I141_XP_MP0 (XI1_I1068_I141_XP_p1 I1_I1068_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I141_XP_MP1 (I1_I1068_P16_9 I1_I1068_P12_9n XI1_I1068_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I139_XP_MP0 (XI1_I1068_I139_XP_p1 I1_I1068_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I139_XP_MP1 (I1_I1068_P14_7 I1_I1068_P10_7n XI1_I1068_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I78_XP_MP0 (XI1_I1068_I78_XP_p1 I1_I1068_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I78_XP_MP1 (I1_I1068_P12_11 I1_I1068_pn11 XI1_I1068_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I136_XP_MP0 (XI1_I1068_I136_XP_p1 I1_I1068_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I136_XP_MP1 (I1_I1068_P11_4 I1_I1068_P7_4n XI1_I1068_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I147_XP_MP0 (XI1_I1022_I147_XP_p1 I1_I1022_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I147_XP_MP1 (I1_I1022_P22_15 I1_I1022_P18_15n XI1_I1022_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I82_XP_MP0 (XI1_I1022_I82_XP_p1 I1_I1022_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I82_XP_MP1 (I1_I1022_P16_15 I1_I1022_pn15 XI1_I1022_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I84_XP_MP0 (XI1_I1022_I84_XP_p1 I1_I1022_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I84_XP_MP1 (I1_I1022_P18_17 I1_I1022_pn17 XI1_I1022_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I154_XP_MP0 (XI1_I1022_I154_XP_p1 I1_I1022_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I154_XP_MP1 (I1_I1022_P29_22 I1_I1022_P25_22n XI1_I1022_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I144_XP_MP0 (XI1_I1022_I144_XP_p1 I1_I1022_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I144_XP_MP1 (I1_I1022_P19_12 I1_I1022_P15_12n XI1_I1022_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I83_XP_MP0 (XI1_I1022_I83_XP_p1 I1_I1022_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I83_XP_MP1 (I1_I1022_P17_16 I1_I1022_pn16 XI1_I1022_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I81_XP_MP0 (XI1_I1022_I81_XP_p1 I1_I1022_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I81_XP_MP1 (I1_I1022_P15_14 I1_I1022_pn14 XI1_I1022_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I68_XP_MP0 (XI1_I976_I68_XP_p1 I1_I976_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I68_XP_MP1 (I1_I976_P2_1 I1_I976_pn1 XI1_I976_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I75_XP_MP0 (XI1_I608_I75_XP_p1 I1_I608_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I75_XP_MP1 (I1_I608_P9_8 I1_I608_pn8 XI1_I608_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I77_XP_MP0 (XI1_I608_I77_XP_p1 I1_I608_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I77_XP_MP1 (I1_I608_P11_10 I1_I608_pn10 XI1_I608_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I79_XP_MP0 (XI1_I608_I79_XP_p1 I1_I608_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I79_XP_MP1 (I1_I608_P13_12 I1_I608_pn12 XI1_I608_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I142_XP_MP0 (XI1_I608_I142_XP_p1 I1_I608_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I142_XP_MP1 (I1_I608_P17_10 I1_I608_P13_10n XI1_I608_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I83_XP_MP0 (XI1_I608_I83_XP_p1 I1_I608_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I83_XP_MP1 (I1_I608_P17_16 I1_I608_pn16 XI1_I608_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I146_XP_MP0 (XI1_I608_I146_XP_p1 I1_I608_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I146_XP_MP1 (I1_I608_P21_14 I1_I608_P17_14n XI1_I608_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I150_XP_MP0 (XI1_I608_I150_XP_p1 I1_I608_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I150_XP_MP1 (I1_I608_P25_18 I1_I608_P21_18n XI1_I608_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I148_XP_MP0 (XI1_I608_I148_XP_p1 I1_I608_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I148_XP_MP1 (I1_I608_P23_16 I1_I608_P19_16n XI1_I608_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I152_XP_MP0 (XI1_I608_I152_XP_p1 I1_I608_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I152_XP_MP1 (I1_I608_P27_20 I1_I608_P23_20n XI1_I608_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I154_XP_MP0 (XI1_I608_I154_XP_p1 I1_I608_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I154_XP_MP1 (I1_I608_P29_22 I1_I608_P25_22n XI1_I608_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I91_XP_MP0 (XI1_I608_I91_XP_p1 I1_I608_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I91_XP_MP1 (I1_I608_P25_24 I1_I608_pn24 XI1_I608_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I93_XP_MP0 (XI1_I608_I93_XP_p1 I1_I608_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I93_XP_MP1 (I1_I608_P27_26 I1_I608_pn26 XI1_I608_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I154_XP_MP0 (XI1_I1482_I154_XP_p1 I1_I1482_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I154_XP_MP1 (I1_I1482_P29_22 I1_I1482_P25_22n XI1_I1482_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I150_XP_MP0 (XI1_I1482_I150_XP_p1 I1_I1482_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I150_XP_MP1 (I1_I1482_P25_18 I1_I1482_P21_18n XI1_I1482_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I88_XP_MP0 (XI1_I1482_I88_XP_p1 I1_I1482_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I88_XP_MP1 (I1_I1482_P22_21 I1_I1482_pn21 XI1_I1482_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I86_XP_MP0 (XI1_I1482_I86_XP_p1 I1_I1482_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I86_XP_MP1 (I1_I1482_P20_19 I1_I1482_pn19 XI1_I1482_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I84_XP_MP0 (XI1_I1482_I84_XP_p1 I1_I1482_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I84_XP_MP1 (I1_I1482_P18_17 I1_I1482_pn17 XI1_I1482_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I82_XP_MP0 (XI1_I1482_I82_XP_p1 I1_I1482_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I82_XP_MP1 (I1_I1482_P16_15 I1_I1482_pn15 XI1_I1482_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I80_XP_MP0 (XI1_I1482_I80_XP_p1 I1_I1482_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I80_XP_MP1 (I1_I1482_P14_13 I1_I1482_pn13 XI1_I1482_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I78_XP_MP0 (XI1_I1482_I78_XP_p1 I1_I1482_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I78_XP_MP1 (I1_I1482_P12_11 I1_I1482_pn11 XI1_I1482_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I76_XP_MP0 (XI1_I1482_I76_XP_p1 I1_I1482_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I76_XP_MP1 (I1_I1482_P10_9 I1_I1482_pn9 XI1_I1482_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I133_XP_MP0 (XI1_I1482_I133_XP_p1 I1_I1482_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I133_XP_MP1 (I1_I1482_P8_1 I1_I1482_P4_1n XI1_I1482_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I74_XP_MP0 (XI1_I1114_I74_XP_p1 I1_I1114_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I74_XP_MP1 (I1_I1114_P8_7 I1_I1114_pn7 XI1_I1114_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I71_XP_MP0 (XI1_I1114_I71_XP_p1 I1_I1114_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I71_XP_MP1 (I1_I1114_P5_4 I1_I1114_pn4 XI1_I1114_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I69_XP_MP0 (XI1_I1114_I69_XP_p1 I1_I1114_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I69_XP_MP1 (I1_I1114_P3_2 I1_I1114_pn2 XI1_I1114_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I68_XP_MP0 (XI1_I1114_I68_XP_p1 I1_I1114_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I68_XP_MP1 (I1_I1114_P2_1 I1_I1114_pn1 XI1_I1114_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I137_XP_MP0 (XI1_I1068_I137_XP_p1 I1_I1068_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I137_XP_MP1 (I1_I1068_P12_5 I1_I1068_P8_5n XI1_I1068_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I135_XP_MP0 (XI1_I1068_I135_XP_p1 I1_I1068_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I135_XP_MP1 (I1_I1068_P10_3 I1_I1068_P6_3n XI1_I1068_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I76_XP_MP0 (XI1_I1068_I76_XP_p1 I1_I1068_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I76_XP_MP1 (I1_I1068_P10_9 I1_I1068_pn9 XI1_I1068_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I134_XP_MP0 (XI1_I1068_I134_XP_p1 I1_I1068_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I134_XP_MP1 (I1_I1068_P9_2 I1_I1068_P5_2n XI1_I1068_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I75_XP_MP0 (XI1_I1068_I75_XP_p1 I1_I1068_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I75_XP_MP1 (I1_I1068_P9_8 I1_I1068_pn8 XI1_I1068_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I77_XP_MP0 (XI1_I1068_I77_XP_p1 I1_I1068_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I77_XP_MP1 (I1_I1068_P11_10 I1_I1068_pn10 XI1_I1068_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I143_XP_MP0 (XI1_I1022_I143_XP_p1 I1_I1022_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I143_XP_MP1 (I1_I1022_P18_11 I1_I1022_P14_11n XI1_I1022_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I149_XP_MP0 (XI1_I1022_I149_XP_p1 I1_I1022_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I149_XP_MP1 (I1_I1022_P24_17 I1_I1022_P20_17n XI1_I1022_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I145_XP_MP0 (XI1_I1022_I145_XP_p1 I1_I1022_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I145_XP_MP1 (I1_I1022_P20_13 I1_I1022_P16_13n XI1_I1022_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I80_XP_MP0 (XI1_I1022_I80_XP_p1 I1_I1022_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I80_XP_MP1 (I1_I1022_P14_13 I1_I1022_pn13 XI1_I1022_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I78_XP_MP0 (XI1_I1022_I78_XP_p1 I1_I1022_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I78_XP_MP1 (I1_I1022_P12_11 I1_I1022_pn11 XI1_I1022_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I150_XP_MP0 (XI1_I1022_I150_XP_p1 I1_I1022_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I150_XP_MP1 (I1_I1022_P25_18 I1_I1022_P21_18n XI1_I1022_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I146_XP_MP0 (XI1_I1022_I146_XP_p1 I1_I1022_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I146_XP_MP1 (I1_I1022_P21_14 I1_I1022_P17_14n XI1_I1022_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I140_XP_MP0 (XI1_I1022_I140_XP_p1 I1_I1022_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I140_XP_MP1 (I1_I1022_P15_8 I1_I1022_P11_8n XI1_I1022_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I79_XP_MP0 (XI1_I1022_I79_XP_p1 I1_I1022_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I79_XP_MP1 (I1_I1022_P13_12 I1_I1022_pn12 XI1_I1022_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I81_XP_MP0 (XI1_I608_I81_XP_p1 I1_I608_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I81_XP_MP1 (I1_I608_P15_14 I1_I608_pn14 XI1_I608_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I85_XP_MP0 (XI1_I608_I85_XP_p1 I1_I608_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I85_XP_MP1 (I1_I608_P19_18 I1_I608_pn18 XI1_I608_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I87_XP_MP0 (XI1_I608_I87_XP_p1 I1_I608_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I87_XP_MP1 (I1_I608_P21_20 I1_I608_pn20 XI1_I608_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I89_XP_MP0 (XI1_I608_I89_XP_p1 I1_I608_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I89_XP_MP1 (I1_I608_P23_22 I1_I608_pn22 XI1_I608_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I93_XP_MP0 (XI1_I1482_I93_XP_p1 I1_I1482_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I93_XP_MP1 (I1_I1482_P27_26 I1_I1482_pn26 XI1_I1482_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I92_XP_MP0 (XI1_I1482_I92_XP_p1 I1_I1482_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I92_XP_MP1 (I1_I1482_P26_25 I1_I1482_pn25 XI1_I1482_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I90_XP_MP0 (XI1_I1482_I90_XP_p1 I1_I1482_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I90_XP_MP1 (I1_I1482_P24_23 I1_I1482_pn23 XI1_I1482_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I149_XP_MP0 (XI1_I1482_I149_XP_p1 I1_I1482_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I149_XP_MP1 (I1_I1482_P24_17 I1_I1482_P20_17n XI1_I1482_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I145_XP_MP0 (XI1_I1482_I145_XP_p1 I1_I1482_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I145_XP_MP1 (I1_I1482_P20_13 I1_I1482_P16_13n XI1_I1482_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I141_XP_MP0 (XI1_I1482_I141_XP_p1 I1_I1482_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I141_XP_MP1 (I1_I1482_P16_9 I1_I1482_P12_9n XI1_I1482_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I137_XP_MP0 (XI1_I1482_I137_XP_p1 I1_I1482_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I137_XP_MP1 (I1_I1482_P12_5 I1_I1482_P8_5n XI1_I1482_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I135_XP_MP0 (XI1_I1482_I135_XP_p1 I1_I1482_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I135_XP_MP1 (I1_I1482_P10_3 I1_I1482_P6_3n XI1_I1482_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I70_XP_MP0 (XI1_I1114_I70_XP_p1 I1_I1114_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I70_XP_MP1 (I1_I1114_P4_3 I1_I1114_pn3 XI1_I1114_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I133_XP_MP0 (XI1_I1068_I133_XP_p1 I1_I1068_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I133_XP_MP1 (I1_I1068_P8_1 I1_I1068_P4_1n XI1_I1068_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I74_XP_MP0 (XI1_I1068_I74_XP_p1 I1_I1068_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I74_XP_MP1 (I1_I1068_P8_7 I1_I1068_pn7 XI1_I1068_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I139_XP_MP0 (XI1_I1022_I139_XP_p1 I1_I1022_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I139_XP_MP1 (I1_I1022_P14_7 I1_I1022_P10_7n XI1_I1022_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I76_XP_MP0 (XI1_I1022_I76_XP_p1 I1_I1022_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I76_XP_MP1 (I1_I1022_P10_9 I1_I1022_pn9 XI1_I1022_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I142_XP_MP0 (XI1_I1022_I142_XP_p1 I1_I1022_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I142_XP_MP1 (I1_I1022_P17_10 I1_I1022_P13_10n XI1_I1022_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I136_XP_MP0 (XI1_I1022_I136_XP_p1 I1_I1022_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I136_XP_MP1 (I1_I1022_P11_4 I1_I1022_P7_4n XI1_I1022_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I75_XP_MP0 (XI1_I1022_I75_XP_p1 I1_I1022_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I75_XP_MP1 (I1_I1022_P9_8 I1_I1022_pn8 XI1_I1022_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I77_XP_MP0 (XI1_I1022_I77_XP_p1 I1_I1022_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I77_XP_MP1 (I1_I1022_P11_10 I1_I1022_pn10 XI1_I1022_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I153_XP_MP0 (XI1_I1482_I153_XP_p1 I1_I1482_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I153_XP_MP1 (I1_I1482_P28_21 I1_I1482_P24_21n XI1_I1482_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I147_XP_MP0 (XI1_I1482_I147_XP_p1 I1_I1482_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I147_XP_MP1 (I1_I1482_P22_15 I1_I1482_P18_15n XI1_I1482_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I76_XP_MP0 (XI1_I1528_I76_XP_p1 I1_I1528_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I76_XP_MP1 (I1_I1528_P10_9 I1_I1528_pn9 XI1_I1528_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I74_XP_MP0 (XI1_I1528_I74_XP_p1 I1_I1528_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I74_XP_MP1 (I1_I1528_P8_7 I1_I1528_pn7 XI1_I1528_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I72_XP_MP0 (XI1_I1068_I72_XP_p1 I1_I1068_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I72_XP_MP1 (I1_I1068_P6_5 I1_I1068_pn5 XI1_I1068_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I71_XP_MP0 (XI1_I1068_I71_XP_p1 I1_I1068_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I71_XP_MP1 (I1_I1068_P5_4 I1_I1068_pn4 XI1_I1068_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I73_XP_MP0 (XI1_I1068_I73_XP_p1 I1_I1068_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I73_XP_MP1 (I1_I1068_P7_6 I1_I1068_pn6 XI1_I1068_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I135_XP_MP0 (XI1_I1022_I135_XP_p1 I1_I1022_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I135_XP_MP1 (I1_I1022_P10_3 I1_I1022_P6_3n XI1_I1022_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I141_XP_MP0 (XI1_I1022_I141_XP_p1 I1_I1022_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I141_XP_MP1 (I1_I1022_P16_9 I1_I1022_P12_9n XI1_I1022_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I137_XP_MP0 (XI1_I1022_I137_XP_p1 I1_I1022_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I137_XP_MP1 (I1_I1022_P12_5 I1_I1022_P8_5n XI1_I1022_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I74_XP_MP0 (XI1_I1022_I74_XP_p1 I1_I1022_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I74_XP_MP1 (I1_I1022_P8_7 I1_I1022_pn7 XI1_I1022_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
