    I_MXI1_I1068_I4_MP0 (VDD I1_p10_3 I1_I1068_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I5_MP1 (I1_I1068_gn5 I1_b11_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I5_MP0 (VDD I1_p10_4 I1_I1068_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I0_MP1 (I1_I1068_gn0 I1_b11_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I0_MP0 (VDD I1_aa20 I1_I1068_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I100_XP_MP1 (I1_I1022_P4_1n I1_I1022_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I100_XP_MP0 (VDD I1_I1022_P4_3 I1_I1022_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I102_XP_MP1 (I1_I1022_P6_3n I1_I1022_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I102_XP_MP0 (VDD I1_I1022_P6_5 I1_I1022_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I101_XP_MP1 (I1_I1022_P5_2n I1_I1022_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I101_XP_MP0 (VDD I1_I1022_P5_4 I1_I1022_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I1_MP1 (I1_I1022_gn1 I1_b10_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I1_MP0 (VDD I1_p9_0 I1_I1022_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I2_MP1 (I1_I1022_gn2 I1_b10_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I2_MP0 (VDD I1_p9_1 I1_I1022_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I0_MP1 (I1_I976_gn0 I1_b9_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I0_MP0 (VDD I1_aa22 I1_I976_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I0_MP1 (I1_I562_gn0 I1_b0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I0_MP0 (VDD I1_aa31 I1_I562_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I2_MP1 (I1_I562_gn2 I1_b0_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I2_MP0 (VDD VSS I1_I562_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I100_XP_MP1 (I1_I562_P4_1n I1_I562_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I100_XP_MP0 (VDD I1_I562_P4_3 I1_I562_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I9_MP1 (I1_I562_gn9 I1_b0_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I9_MP0 (VDD VSS I1_I562_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I11_MP1 (I1_I562_gn11 I1_b0_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I11_MP0 (VDD VSS I1_I562_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I13_MP1 (I1_I562_gn13 I1_b0_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I13_MP0 (VDD VSS I1_I562_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I29_MP1 (I1_I562_gn29 I1_b0_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I29_MP0 (VDD VSS I1_I562_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I30_MP1 (I1_I1482_gn30 I1_b20_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I30_MP0 (VDD I1_p19_29 I1_I1482_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I31_MP1 (I1_I1482_gn31 I1_b20_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I31_MP0 (VDD I1_p19_30 I1_I1482_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I25_MP1 (I1_I1528_gn25 I1_b21_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I25_MP0 (VDD I1_p20_24 I1_I1528_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I24_MP1 (I1_I1528_gn24 I1_b21_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I24_MP0 (VDD I1_p20_23 I1_I1528_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I23_MP1 (I1_I1528_gn23 I1_b21_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I23_MP0 (VDD I1_p20_22 I1_I1528_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I22_MP1 (I1_I1528_gn22 I1_b21_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I22_MP0 (VDD I1_p20_21 I1_I1528_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I21_MP1 (I1_I1528_gn21 I1_b21_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I21_MP0 (VDD I1_p20_20 I1_I1528_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I19_MP1 (I1_I1528_gn19 I1_b21_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I19_MP0 (VDD I1_p20_18 I1_I1528_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I116_XP_MP1 (I1_I1528_P20_17n I1_I1528_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I116_XP_MP0 (VDD I1_I1528_P20_19 I1_I1528_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I114_XP_MP1 (I1_I1528_P18_15n I1_I1528_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I114_XP_MP0 (VDD I1_I1528_P18_17 I1_I1528_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I175_XP_MP1 (I1_I1528_P24_9n I1_I1528_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I175_XP_MP0 (VDD I1_I1528_P24_17 I1_I1528_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I169_XP_MP1 (I1_I1528_P18_3n I1_I1528_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I169_XP_MP0 (VDD I1_I1528_P18_11 I1_I1528_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I167_XP_MP1 (I1_I1528_P16_1n I1_I1528_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I167_XP_MP0 (VDD I1_I1528_P16_9 I1_I1528_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I100_XP_MP1 (I1_I1528_P4_1n I1_I1528_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I100_XP_MP0 (VDD I1_I1528_P4_3 I1_I1528_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I1_MP1 (I1_I1528_gn1 I1_b21_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I1_MP0 (VDD I1_p20_0 I1_I1528_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I1_MP1 (I1_I1068_gn1 I1_b11_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I1_MP0 (VDD I1_p10_0 I1_I1068_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I2_MP1 (I1_I1068_gn2 I1_b11_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I2_MP0 (VDD I1_p10_1 I1_I1068_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I3_MP1 (I1_I1068_gn3 I1_b11_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I3_MP0 (VDD I1_p10_2 I1_I1068_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I167_XP_MP1 (I1_I1022_P16_1n I1_I1022_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I167_XP_MP0 (VDD I1_I1022_P16_9 I1_I1022_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I0_MP1 (I1_I1022_gn0 I1_b10_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I0_MP0 (VDD I1_aa21 I1_I1022_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I3_MP1 (I1_I562_gn3 I1_b0_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I3_MP0 (VDD VSS I1_I562_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I102_XP_MP1 (I1_I562_P6_3n I1_I562_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I102_XP_MP0 (VDD I1_I562_P6_5 I1_I562_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I104_XP_MP1 (I1_I562_P8_5n I1_I562_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I104_XP_MP0 (VDD I1_I562_P8_7 I1_I562_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I167_XP_MP1 (I1_I562_P16_1n I1_I562_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I167_XP_MP0 (VDD I1_I562_P16_9 I1_I562_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I169_XP_MP1 (I1_I562_P18_3n I1_I562_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I169_XP_MP0 (VDD I1_I562_P18_11 I1_I562_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I175_XP_MP1 (I1_I562_P24_9n I1_I562_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I175_XP_MP0 (VDD I1_I562_P24_17 I1_I562_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I171_XP_MP1 (I1_I562_P20_5n I1_I562_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I171_XP_MP0 (VDD I1_I562_P20_13 I1_I562_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I17_MP1 (I1_I562_gn17 I1_b0_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I17_MP0 (VDD VSS I1_I562_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I177_XP_MP1 (I1_I562_P26_11n I1_I562_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I177_XP_MP0 (VDD I1_I562_P26_19 I1_I562_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I173_XP_MP1 (I1_I562_P22_7n I1_I562_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I173_XP_MP0 (VDD I1_I562_P22_15 I1_I562_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I19_MP1 (I1_I562_gn19 I1_b0_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I19_MP0 (VDD VSS I1_I562_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I21_MP1 (I1_I562_gn21 I1_b0_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I21_MP0 (VDD VSS I1_I562_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I31_MP1 (I1_I562_gn31 I1_b0_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I31_MP0 (VDD VSS I1_I562_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I30_MP1 (I1_I1528_gn30 I1_b21_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I30_MP0 (VDD I1_p20_29 I1_I1528_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I29_MP1 (I1_I1528_gn29 I1_b21_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I29_MP0 (VDD I1_p20_28 I1_I1528_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I120_XP_MP1 (I1_I1528_P24_21n I1_I1528_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I120_XP_MP0 (VDD I1_I1528_P24_23 I1_I1528_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I118_XP_MP1 (I1_I1528_P22_19n I1_I1528_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I118_XP_MP0 (VDD I1_I1528_P22_21 I1_I1528_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I173_XP_MP1 (I1_I1528_P22_7n I1_I1528_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I173_XP_MP0 (VDD I1_I1528_P22_15 I1_I1528_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I179_XP_MP1 (I1_I1528_P28_13n I1_I1528_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I179_XP_MP0 (VDD I1_I1528_P28_21 I1_I1528_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I177_XP_MP1 (I1_I1528_P26_11n I1_I1528_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I177_XP_MP0 (VDD I1_I1528_P26_19 I1_I1528_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I171_XP_MP1 (I1_I1528_P20_5n I1_I1528_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I171_XP_MP0 (VDD I1_I1528_P20_13 I1_I1528_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I11_MP1 (I1_I1574_gn11 I1_b22_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I11_MP0 (VDD I1_p21_10 I1_I1574_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I0_MP1 (I1_I1528_gn0 I1_b21_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I0_MP0 (VDD I1_aa10 I1_I1528_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I114_MP1 (I2_I2_nand19 B_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I114_MP0 (VDD A_19 I2_I2_nand19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I317_MP1 (I2_I3_o19_1 I2_I3_n19_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I317_MP0 (VDD I2_I3_n19_2 I2_I3_o19_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I313_MP1 (I2_I3_n19_3 I2_NOT_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I313_MP0 (VDD I2_I3_SEL_NOT_b3_3 I2_I3_n19_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I325_MP1 (I2_I3_n20_3 I2_NOT_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I325_MP0 (VDD I2_I3_SEL_NOT_b3_3 I2_I3_n20_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I329_MP1 (I2_I3_o20_1 I2_I3_n20_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I329_MP0 (VDD I2_I3_n20_2 I2_I3_o20_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I4_MP1 (I1_I562_gn4 I1_b0_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I4_MP0 (VDD VSS I1_I562_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I5_MP1 (I1_I562_gn5 I1_b0_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I5_MP0 (VDD VSS I1_I562_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I6_MP1 (I1_I562_gn6 I1_b0_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I6_MP0 (VDD VSS I1_I562_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I7_MP1 (I1_I562_gn7 I1_b0_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I7_MP0 (VDD VSS I1_I562_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I106_XP_MP1 (I1_I562_P10_7n I1_I562_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I106_XP_MP0 (VDD I1_I562_P10_9 I1_I562_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I108_XP_MP1 (I1_I562_P12_9n I1_I562_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I108_XP_MP0 (VDD I1_I562_P12_11 I1_I562_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I110_XP_MP1 (I1_I562_P14_11n I1_I562_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I110_XP_MP0 (VDD I1_I562_P14_13 I1_I562_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I112_XP_MP1 (I1_I562_P16_13n I1_I562_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I112_XP_MP0 (VDD I1_I562_P16_15 I1_I562_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I179_XP_MP1 (I1_I562_P28_13n I1_I562_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I179_XP_MP0 (VDD I1_I562_P28_21 I1_I562_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I181_XP_MP1 (I1_I562_P30_15n I1_I562_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I181_XP_MP0 (VDD I1_I562_P30_23 I1_I562_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I124_XP_MP1 (I1_I562_P28_25n I1_I562_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I124_XP_MP0 (VDD I1_I562_P28_27 I1_I562_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I126_XP_MP1 (I1_I562_P30_27n I1_I562_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I126_XP_MP0 (VDD I1_I562_P30_29 I1_I562_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I30_MP1 (I1_I562_gn30 I1_b0_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I30_MP0 (VDD VSS I1_I562_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I31_MP1 (I1_I1528_gn31 I1_b21_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I31_MP0 (VDD I1_p20_30 I1_I1528_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I28_MP1 (I1_I1528_gn28 I1_b21_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I28_MP0 (VDD I1_p20_27 I1_I1528_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I27_MP1 (I1_I1528_gn27 I1_b21_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I27_MP0 (VDD I1_p20_26 I1_I1528_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I26_MP1 (I1_I1528_gn26 I1_b21_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I26_MP0 (VDD I1_p20_25 I1_I1528_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I126_XP_MP1 (I1_I1528_P30_27n I1_I1528_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I126_XP_MP0 (VDD I1_I1528_P30_29 I1_I1528_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I124_XP_MP1 (I1_I1528_P28_25n I1_I1528_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I124_XP_MP0 (VDD I1_I1528_P28_27 I1_I1528_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I122_XP_MP1 (I1_I1528_P26_23n I1_I1528_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I122_XP_MP0 (VDD I1_I1528_P26_25 I1_I1528_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I181_XP_MP1 (I1_I1528_P30_15n I1_I1528_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I181_XP_MP0 (VDD I1_I1528_P30_23 I1_I1528_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I105_XP_MP1 (I1_I1528_P9_6n I1_I1528_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I105_XP_MP0 (VDD I1_I1528_P9_8 I1_I1528_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I103_XP_MP1 (I1_I1528_P7_4n I1_I1528_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I103_XP_MP0 (VDD I1_I1528_P7_6 I1_I1528_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I101_XP_MP1 (I1_I1528_P5_2n I1_I1528_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I101_XP_MP0 (VDD I1_I1528_P5_4 I1_I1528_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I12_MP1 (I1_I1574_gn12 I1_b22_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I12_MP0 (VDD I1_p21_11 I1_I1574_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I10_MP1 (I1_I1574_gn10 I1_b22_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I10_MP0 (VDD I1_p21_9 I1_I1574_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I9_MP1 (I1_I1574_gn9 I1_b22_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I9_MP0 (VDD I1_p21_8 I1_I1574_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I8_MP1 (I1_I1574_gn8 I1_b22_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I8_MP0 (VDD I1_p21_7 I1_I1574_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I7_MP1 (I1_I1574_gn7 I1_b22_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I7_MP0 (VDD I1_p21_6 I1_I1574_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I339_MP1 (I2_I3_n21_5 DIVQ_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I339_MP0 (VDD I2_I3_SEL_DIV_b3_3 I2_I3_n21_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I327_MP1 (I2_I3_n20_5 DIVQ_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I327_MP0 (VDD I2_I3_SEL_DIV_b3_3 I2_I3_n20_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I315_MP1 (I2_I3_n19_5 DIVQ_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I315_MP0 (VDD I2_I3_SEL_DIV_b3_3 I2_I3_n19_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I363_MP1 (I2_I3_n23_5 DIVQ_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I363_MP0 (VDD I2_I3_SEL_DIV_b3_3 I2_I3_n23_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I126_MP1 (I2_I2_nand21 B_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I126_MP0 (VDD A_21 I2_I2_nand21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I311_MP1 (I2_I3_n19_1 I2_OR_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I311_MP0 (VDD I2_I3_SEL_OR_b3_3 I2_I3_n19_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I321_MP1 (Y_19 I2_I3_q19_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I321_MP0 (VDD I2_I3_q19_1 Y_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I312_MP1 (I2_I3_n19_2 I2_XOR_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I312_MP0 (VDD I2_I3_SEL_XOR_b3_3 I2_I3_n19_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I300_MP1 (I2_I3_n18_2 I2_XOR_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I300_MP0 (VDD I2_I3_SEL_XOR_b3_3 I2_I3_n18_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I305_MP1 (I2_I3_o18_1 I2_I3_n18_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I305_MP0 (VDD I2_I3_n18_2 I2_I3_o18_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I298_MP1 (I2_I3_n18_0 I2_AND_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I298_MP0 (VDD I2_I3_SEL_AND_b3_3 I2_I3_n18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I333_MP1 (Y_20 I2_I3_q20_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I333_MP0 (VDD I2_I3_q20_1 Y_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I328_MP1 (I2_I3_o20_0 I2_I3_n20_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I328_MP0 (VDD I2_I3_n20_0 I2_I3_o20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I322_MP1 (I2_I3_n20_0 I2_AND_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I322_MP0 (VDD I2_I3_SEL_AND_b3_3 I2_I3_n20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I324_MP1 (I2_I3_n20_2 I2_XOR_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I324_MP0 (VDD I2_I3_SEL_XOR_b3_3 I2_I3_n20_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I120_MP1 (I2_I2_nand20 B_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I120_MP0 (VDD A_20 I2_I2_nand20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I132_MP1 (I2_I2_nand22 B_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I132_MP0 (VDD A_22 I2_I2_nand22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I37_MP1 (I2_I4_z1_5 I2_I4_z0_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I37_MP0 (VDD I2_I4_z0_10 I2_I4_z1_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I8_MP1 (I1_I562_gn8 I1_b0_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I8_MP0 (VDD VSS I1_I562_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I10_MP1 (I1_I562_gn10 I1_b0_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I10_MP0 (VDD VSS I1_I562_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I12_MP1 (I1_I562_gn12 I1_b0_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I12_MP0 (VDD VSS I1_I562_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I14_MP1 (I1_I562_gn14 I1_b0_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I14_MP0 (VDD VSS I1_I562_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I15_MP1 (I1_I562_gn15 I1_b0_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I15_MP0 (VDD VSS I1_I562_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I114_XP_MP1 (I1_I562_P18_15n I1_I562_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I114_XP_MP0 (VDD I1_I562_P18_17 I1_I562_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I116_XP_MP1 (I1_I562_P20_17n I1_I562_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I116_XP_MP0 (VDD I1_I562_P20_19 I1_I562_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I118_XP_MP1 (I1_I562_P22_19n I1_I562_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I118_XP_MP0 (VDD I1_I562_P22_21 I1_I562_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I20_MP1 (I1_I562_gn20 I1_b0_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I20_MP0 (VDD VSS I1_I562_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I120_XP_MP1 (I1_I562_P24_21n I1_I562_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I120_XP_MP0 (VDD I1_I562_P24_23 I1_I562_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I122_XP_MP1 (I1_I562_P26_23n I1_I562_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I122_XP_MP0 (VDD I1_I562_P26_25 I1_I562_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I27_MP1 (I1_I562_gn27 I1_b0_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I27_MP0 (VDD VSS I1_I562_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I28_MP1 (I1_I562_gn28 I1_b0_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I28_MP0 (VDD VSS I1_I562_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I174_XP_MP1 (I1_I1712_P23_8n I1_I1712_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I174_XP_MP0 (VDD I1_I1712_P23_16 I1_I1712_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I127_XP_MP1 (I1_I1528_P31_28n I1_I1528_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I127_XP_MP0 (VDD I1_I1528_P31_30 I1_I1528_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I125_XP_MP1 (I1_I1528_P29_26n I1_I1528_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I125_XP_MP0 (VDD I1_I1528_P29_28 I1_I1528_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I123_XP_MP1 (I1_I1528_P27_24n I1_I1528_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I123_XP_MP0 (VDD I1_I1528_P27_26 I1_I1528_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I121_XP_MP1 (I1_I1528_P25_22n I1_I1528_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I121_XP_MP0 (VDD I1_I1528_P25_24 I1_I1528_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I119_XP_MP1 (I1_I1528_P23_20n I1_I1528_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I119_XP_MP0 (VDD I1_I1528_P23_22 I1_I1528_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I117_XP_MP1 (I1_I1528_P21_18n I1_I1528_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I117_XP_MP0 (VDD I1_I1528_P21_20 I1_I1528_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I115_XP_MP1 (I1_I1528_P19_16n I1_I1528_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I115_XP_MP0 (VDD I1_I1528_P19_18 I1_I1528_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I113_XP_MP1 (I1_I1528_P17_14n I1_I1528_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I113_XP_MP0 (VDD I1_I1528_P17_16 I1_I1528_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I111_XP_MP1 (I1_I1528_P15_12n I1_I1528_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I111_XP_MP0 (VDD I1_I1528_P15_14 I1_I1528_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I109_XP_MP1 (I1_I1528_P13_10n I1_I1528_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I109_XP_MP0 (VDD I1_I1528_P13_12 I1_I1528_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I107_XP_MP1 (I1_I1528_P11_8n I1_I1528_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I107_XP_MP0 (VDD I1_I1528_P11_10 I1_I1528_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I178_XP_MP1 (I1_I1574_P27_12n I1_I1574_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I178_XP_MP0 (VDD I1_I1574_P27_20 I1_I1574_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I170_XP_MP1 (I1_I1574_P19_4n I1_I1574_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I170_XP_MP0 (VDD I1_I1574_P19_12 I1_I1574_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I111_XP_MP1 (I1_I1574_P15_12n I1_I1574_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I111_XP_MP0 (VDD I1_I1574_P15_14 I1_I1574_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I109_XP_MP1 (I1_I1574_P13_10n I1_I1574_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I109_XP_MP0 (VDD I1_I1574_P13_12 I1_I1574_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I107_XP_MP1 (I1_I1574_P11_8n I1_I1574_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I107_XP_MP0 (VDD I1_I1574_P11_10 I1_I1574_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I6_MP1 (I1_I1574_gn6 I1_b22_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I6_MP0 (VDD I1_p21_5 I1_I1574_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I5_MP1 (I1_I1574_gn5 I1_b22_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I5_MP0 (VDD I1_p21_4 I1_I1574_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I128_MP1 (I1_nbkn1 I1_B_0_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I128_MP0 (VDD I1_B_31_b3_0 I1_nbkn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I303_MP1 (I2_I3_n18_5 DIVQ_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I303_MP0 (VDD I2_I3_SEL_DIV_b3_3 I2_I3_n18_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I306_MP1 (I2_I3_o18_2 I2_I3_n18_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I306_MP0 (VDD I2_I3_n18_4 I2_I3_o18_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I318_MP1 (I2_I3_o19_2 I2_I3_n19_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I318_MP0 (VDD I2_I3_n19_4 I2_I3_o19_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I330_MP1 (I2_I3_o20_2 I2_I3_n20_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I330_MP0 (VDD I2_I3_n20_4 I2_I3_o20_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I342_MP1 (I2_I3_o21_2 I2_I3_n21_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I342_MP0 (VDD I2_I3_n21_4 I2_I3_o21_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I334_MP1 (I2_I3_n21_0 I2_AND_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I334_MP0 (VDD I2_I3_SEL_AND_b3_3 I2_I3_n21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I340_MP1 (I2_I3_o21_0 I2_I3_n21_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I340_MP0 (VDD I2_I3_n21_0 I2_I3_o21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I341_MP1 (I2_I3_o21_1 I2_I3_n21_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I341_MP0 (VDD I2_I3_n21_2 I2_I3_o21_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I336_MP1 (I2_I3_n21_2 I2_XOR_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I336_MP0 (VDD I2_I3_SEL_XOR_b3_3 I2_I3_n21_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I309_MP1 (Y_18 I2_I3_q18_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I309_MP0 (VDD I2_I3_q18_1 Y_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I304_MP1 (I2_I3_o18_0 I2_I3_n18_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I304_MP0 (VDD I2_I3_n18_0 I2_I3_o18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I299_MP1 (I2_I3_n18_1 I2_OR_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I299_MP0 (VDD I2_I3_SEL_OR_b3_3 I2_I3_n18_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I277_MP1 (I2_I3_n16_3 I2_NOT_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I277_MP0 (VDD I2_I3_SEL_NOT_b3_3 I2_I3_n16_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I323_MP1 (I2_I3_n20_1 I2_OR_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I323_MP0 (VDD I2_I3_SEL_OR_b3_3 I2_I3_n20_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I138_MP1 (I2_I2_nand23 B_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I138_MP0 (VDD A_23 I2_I2_nand23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I360_MP1 (I2_I3_n23_2 I2_XOR_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I360_MP0 (VDD I2_I3_SEL_XOR_b3_4 I2_I3_n23_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I365_MP1 (I2_I3_o23_1 I2_I3_n23_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I365_MP0 (VDD I2_I3_n23_2 I2_I3_o23_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I361_MP1 (I2_I3_n23_3 I2_NOT_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I361_MP0 (VDD I2_I3_SEL_NOT_b3_4 I2_I3_n23_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I348_MP1 (I2_I3_n22_2 I2_XOR_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I348_MP0 (VDD I2_I3_SEL_XOR_b3_4 I2_I3_n22_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I36_MP1 (I2_I4_z1_4 I2_I4_z0_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I36_MP0 (VDD I2_I4_z0_8 I2_I4_z1_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I101_XP_MP1 (I1_I562_P5_2n I1_I562_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I101_XP_MP0 (VDD I1_I562_P5_4 I1_I562_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I105_XP_MP1 (I1_I562_P9_6n I1_I562_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I105_XP_MP0 (VDD I1_I562_P9_8 I1_I562_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I107_XP_MP1 (I1_I562_P11_8n I1_I562_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I107_XP_MP0 (VDD I1_I562_P11_10 I1_I562_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I16_MP1 (I1_I562_gn16 I1_b0_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I16_MP0 (VDD VSS I1_I562_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I18_MP1 (I1_I562_gn18 I1_b0_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I18_MP0 (VDD VSS I1_I562_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I22_MP1 (I1_I562_gn22 I1_b0_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I22_MP0 (VDD VSS I1_I562_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I23_MP1 (I1_I562_gn23 I1_b0_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I23_MP0 (VDD VSS I1_I562_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I25_MP1 (I1_I562_gn25 I1_b0_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I25_MP0 (VDD VSS I1_I562_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I123_XP_MP1 (I1_I1712_P27_24n I1_I1712_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I123_XP_MP0 (VDD I1_I1712_P27_26 I1_I1712_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I178_XP_MP1 (I1_I1712_P27_12n I1_I1712_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I178_XP_MP0 (VDD I1_I1712_P27_20 I1_I1712_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I182_XP_MP1 (I1_I1712_P31_16n I1_I1712_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I182_XP_MP0 (VDD I1_I1712_P31_24 I1_I1712_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I170_XP_MP1 (I1_I1712_P19_4n I1_I1712_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I170_XP_MP0 (VDD I1_I1712_P19_12 I1_I1712_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I182_XP_MP1 (I1_I1528_P31_16n I1_I1528_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I182_XP_MP0 (VDD I1_I1528_P31_24 I1_I1528_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I174_XP_MP1 (I1_I1528_P23_8n I1_I1528_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I174_XP_MP0 (VDD I1_I1528_P23_16 I1_I1528_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I178_XP_MP1 (I1_I1528_P27_12n I1_I1528_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I178_XP_MP0 (VDD I1_I1528_P27_20 I1_I1528_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I172_XP_MP1 (I1_I1528_P21_6n I1_I1528_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I172_XP_MP0 (VDD I1_I1528_P21_14 I1_I1528_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I176_XP_MP1 (I1_I1528_P25_10n I1_I1528_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I176_XP_MP0 (VDD I1_I1528_P25_18 I1_I1528_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I170_XP_MP1 (I1_I1528_P19_4n I1_I1528_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I170_XP_MP0 (VDD I1_I1528_P19_12 I1_I1528_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I168_XP_MP1 (I1_I1528_P17_2n I1_I1528_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I168_XP_MP0 (VDD I1_I1528_P17_10 I1_I1528_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I174_XP_MP1 (I1_I1574_P23_8n I1_I1574_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I174_XP_MP0 (VDD I1_I1574_P23_16 I1_I1574_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I14_MP1 (I1_I1574_gn14 I1_b22_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I14_MP0 (VDD I1_p21_13 I1_I1574_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I13_MP1 (I1_I1574_gn13 I1_b22_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I13_MP0 (VDD I1_p21_12 I1_I1574_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I105_XP_MP1 (I1_I1574_P9_6n I1_I1574_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I105_XP_MP0 (VDD I1_I1574_P9_8 I1_I1574_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I4_MP1 (I1_I1574_gn4 I1_b22_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I4_MP0 (VDD I1_p21_3 I1_I1574_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I231_MP1 (I2_I3_n12_5 DIVQ_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I231_MP0 (VDD I2_I3_SEL_DIV_b3_2 I2_I3_n12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I243_MP1 (I2_I3_n13_5 DIVQ_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I243_MP0 (VDD I2_I3_SEL_DIV_b3_2 I2_I3_n13_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I15_MP1 (I2_I1_I42_gn15 I2_I1_bx15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I15_MP0 (VDD A_15 I2_I1_I42_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I16_MP1 (I2_I1_I42_gn16 I2_I1_bx16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I16_MP0 (VDD A_16 I2_I1_I42_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I17_MP1 (I2_I1_I42_gn17 I2_I1_bx17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I17_MP0 (VDD A_17 I2_I1_I42_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I18_MP1 (I2_I1_I42_gn18 I2_I1_bx18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I18_MP0 (VDD A_18 I2_I1_I42_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I19_MP1 (I2_I1_I42_gn19 I2_I1_bx19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I19_MP0 (VDD A_19 I2_I1_I42_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I294_MP1 (I2_I3_o17_2 I2_I3_n17_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I294_MP0 (VDD I2_I3_n17_4 I2_I3_o17_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I20_MP1 (I2_I1_I42_gn20 I2_I1_bx20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I20_MP0 (VDD A_20 I2_I1_I42_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I23_MP1 (I2_I1_I42_gn23 I2_I1_bx23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I23_MP0 (VDD A_23 I2_I1_I42_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I354_MP1 (I2_I3_o22_2 I2_I3_n22_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I354_MP0 (VDD I2_I3_n22_4 I2_I3_o22_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2284_MP1 (I1_z1_6 I1_z0_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2284_MP0 (VDD I1_z0_12 I1_z1_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2285_MP1 (I1_z1_7 I1_z0_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2285_MP0 (VDD I1_z0_14 I1_z1_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I286_MP1 (I2_I3_n17_0 I2_AND_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I286_MP0 (VDD I2_I3_SEL_AND_b3_3 I2_I3_n17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I102_MP1 (I2_I2_nand17 B_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I102_MP0 (VDD A_17 I2_I2_nand17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I287_MP1 (I2_I3_n17_1 I2_OR_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I287_MP0 (VDD I2_I3_SEL_OR_b3_3 I2_I3_n17_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I292_MP1 (I2_I3_o17_0 I2_I3_n17_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I292_MP0 (VDD I2_I3_n17_0 I2_I3_o17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I297_MP1 (Y_17 I2_I3_q17_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I297_MP0 (VDD I2_I3_q17_1 Y_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I293_MP1 (I2_I3_o17_1 I2_I3_n17_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I293_MP0 (VDD I2_I3_n17_2 I2_I3_o17_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I337_MP1 (I2_I3_n21_3 I2_NOT_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I337_MP0 (VDD I2_I3_SEL_NOT_b3_3 I2_I3_n21_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I288_MP1 (I2_I3_n17_2 I2_XOR_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I288_MP0 (VDD I2_I3_SEL_XOR_b3_3 I2_I3_n17_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I280_MP1 (I2_I3_o16_0 I2_I3_n16_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I280_MP0 (VDD I2_I3_n16_0 I2_I3_o16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I274_MP1 (I2_I3_n16_0 I2_AND_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I274_MP0 (VDD I2_I3_SEL_AND_b3_3 I2_I3_n16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I285_MP1 (Y_16 I2_I3_q16_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I285_MP0 (VDD I2_I3_q16_1 Y_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I281_MP1 (I2_I3_o16_1 I2_I3_n16_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I281_MP0 (VDD I2_I3_n16_2 I2_I3_o16_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I276_MP1 (I2_I3_n16_2 I2_XOR_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I276_MP0 (VDD I2_I3_SEL_XOR_b3_3 I2_I3_n16_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I358_MP1 (I2_I3_n23_0 I2_AND_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I358_MP0 (VDD I2_I3_SEL_AND_b3_4 I2_I3_n23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I364_MP1 (I2_I3_o23_0 I2_I3_n23_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I364_MP0 (VDD I2_I3_n23_0 I2_I3_o23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I359_MP1 (I2_I3_n23_1 I2_OR_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I359_MP0 (VDD I2_I3_SEL_OR_b3_4 I2_I3_n23_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I385_MP1 (I2_I3_n25_3 I2_NOT_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I385_MP0 (VDD I2_I3_SEL_NOT_b3_4 I2_I3_n25_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I347_MP1 (I2_I3_n22_1 I2_OR_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I347_MP0 (VDD I2_I3_SEL_OR_b3_4 I2_I3_n22_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I357_MP1 (Y_22 I2_I3_q22_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I357_MP0 (VDD I2_I3_q22_1 Y_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I162_MP1 (I2_I2_nand27 B_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I162_MP0 (VDD A_27 I2_I2_nand27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I103_XP_MP1 (I1_I562_P7_4n I1_I562_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I103_XP_MP0 (VDD I1_I562_P7_6 I1_I562_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I174_MP1 (I2_I2_nand29 B_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I174_MP0 (VDD A_29 I2_I2_nand29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I168_XP_MP1 (I1_I562_P17_2n I1_I562_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I168_XP_MP0 (VDD I1_I562_P17_10 I1_I562_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I109_XP_MP1 (I1_I562_P13_10n I1_I562_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I109_XP_MP0 (VDD I1_I562_P13_12 I1_I562_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I176_XP_MP1 (I1_I562_P25_10n I1_I562_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I176_XP_MP0 (VDD I1_I562_P25_18 I1_I562_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I111_XP_MP1 (I1_I562_P15_12n I1_I562_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I111_XP_MP0 (VDD I1_I562_P15_14 I1_I562_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I113_XP_MP1 (I1_I562_P17_14n I1_I562_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I113_XP_MP0 (VDD I1_I562_P17_16 I1_I562_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I180_XP_MP1 (I1_I562_P29_14n I1_I562_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I180_XP_MP0 (VDD I1_I562_P29_22 I1_I562_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I24_MP1 (I1_I562_gn24 I1_b0_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I24_MP0 (VDD VSS I1_I562_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I26_MP1 (I1_I562_gn26 I1_b0_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I26_MP0 (VDD VSS I1_I562_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I127_XP_MP1 (I1_I1712_P31_28n I1_I1712_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I127_XP_MP0 (VDD I1_I1712_P31_30 I1_I1712_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I125_XP_MP1 (I1_I1712_P29_26n I1_I1712_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I125_XP_MP0 (VDD I1_I1712_P29_28 I1_I1712_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I121_XP_MP1 (I1_I1712_P25_22n I1_I1712_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I121_XP_MP0 (VDD I1_I1712_P25_24 I1_I1712_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I119_XP_MP1 (I1_I1712_P23_20n I1_I1712_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I119_XP_MP0 (VDD I1_I1712_P23_22 I1_I1712_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I117_XP_MP1 (I1_I1712_P21_18n I1_I1712_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I117_XP_MP0 (VDD I1_I1712_P21_20 I1_I1712_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I115_XP_MP1 (I1_I1712_P19_16n I1_I1712_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I115_XP_MP0 (VDD I1_I1712_P19_18 I1_I1712_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I113_XP_MP1 (I1_I1712_P17_14n I1_I1712_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I113_XP_MP0 (VDD I1_I1712_P17_16 I1_I1712_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I111_XP_MP1 (I1_I1712_P15_12n I1_I1712_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I111_XP_MP0 (VDD I1_I1712_P15_14 I1_I1712_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I109_XP_MP1 (I1_I1712_P13_10n I1_I1712_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I109_XP_MP0 (VDD I1_I1712_P13_12 I1_I1712_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I168_XP_MP1 (I1_I1712_P17_2n I1_I1712_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I168_XP_MP0 (VDD I1_I1712_P17_10 I1_I1712_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I107_XP_MP1 (I1_I1712_P11_8n I1_I1712_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I107_XP_MP0 (VDD I1_I1712_P11_10 I1_I1712_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I105_XP_MP1 (I1_I1712_P9_6n I1_I1712_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I105_XP_MP0 (VDD I1_I1712_P9_8 I1_I1712_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I103_XP_MP1 (I1_I1712_P7_4n I1_I1712_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I103_XP_MP0 (VDD I1_I1712_P7_6 I1_I1712_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I180_XP_MP1 (I1_I1528_P29_14n I1_I1528_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I180_XP_MP0 (VDD I1_I1528_P29_22 I1_I1528_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I127_XP_MP1 (I1_I1574_P31_28n I1_I1574_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I127_XP_MP0 (VDD I1_I1574_P31_30 I1_I1574_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I182_XP_MP1 (I1_I1574_P31_16n I1_I1574_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I182_XP_MP0 (VDD I1_I1574_P31_24 I1_I1574_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I180_XP_MP1 (I1_I1574_P29_14n I1_I1574_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I180_XP_MP0 (VDD I1_I1574_P29_22 I1_I1574_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I115_XP_MP1 (I1_I1574_P19_16n I1_I1574_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I115_XP_MP0 (VDD I1_I1574_P19_18 I1_I1574_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I113_XP_MP1 (I1_I1574_P17_14n I1_I1574_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I113_XP_MP0 (VDD I1_I1574_P17_16 I1_I1574_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I15_MP1 (I1_I1574_gn15 I1_b22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I15_MP0 (VDD I1_p21_14 I1_I1574_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I172_XP_MP1 (I1_I1574_P21_6n I1_I1574_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I172_XP_MP0 (VDD I1_I1574_P21_14 I1_I1574_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I176_XP_MP1 (I1_I1574_P25_10n I1_I1574_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I176_XP_MP0 (VDD I1_I1574_P25_18 I1_I1574_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I168_XP_MP1 (I1_I1574_P17_2n I1_I1574_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I168_XP_MP0 (VDD I1_I1574_P17_10 I1_I1574_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I103_XP_MP1 (I1_I1574_P7_4n I1_I1574_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I103_XP_MP0 (VDD I1_I1574_P7_6 I1_I1574_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I101_XP_MP1 (I1_I1574_P5_2n I1_I1574_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I101_XP_MP0 (VDD I1_I1574_P5_4 I1_I1574_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I3_MP1 (I1_I1574_gn3 I1_b22_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I3_MP0 (VDD I1_p21_2 I1_I1574_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I240_MP1 (I2_I3_n13_2 I2_XOR_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I240_MP0 (VDD I2_I3_SEL_XOR_b3_2 I2_I3_n13_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I265_MP1 (I2_I3_n15_3 I2_NOT_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I265_MP0 (VDD I2_I3_SEL_NOT_b3_2 I2_I3_n15_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I264_MP1 (I2_I3_n15_2 I2_XOR_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I264_MP0 (VDD I2_I3_SEL_XOR_b3_2 I2_I3_n15_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2280_MP1 (I1_z1_2 I1_z0_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2280_MP0 (VDD I1_z0_4 I1_z1_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2281_MP1 (I1_z1_3 I1_z0_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2281_MP0 (VDD I1_z0_6 I1_z1_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I255_MP1 (I2_I3_n14_5 DIVQ_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I255_MP0 (VDD I2_I3_SEL_DIV_b3_2 I2_I3_n14_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I267_MP1 (I2_I3_n15_5 DIVQ_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I267_MP0 (VDD I2_I3_SEL_DIV_b3_2 I2_I3_n15_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I13_MP1 (I2_I1_I42_gn13 I2_I1_bx13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I13_MP0 (VDD A_13 I2_I1_I42_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I14_MP1 (I2_I1_I42_gn14 I2_I1_bx14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I14_MP0 (VDD A_14 I2_I1_I42_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I116_XP_MP1 (I2_I1_I42_P20_17n I2_I1_I42_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I116_XP_MP0 (VDD I2_I1_I42_P20_19 I2_I1_I42_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I282_MP1 (I2_I3_o16_2 I2_I3_n16_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I282_MP0 (VDD I2_I3_n16_4 I2_I3_o16_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I21_MP1 (I2_I1_I42_gn21 I2_I1_bx21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I21_MP0 (VDD A_21 I2_I1_I42_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I22_MP1 (I2_I1_I42_gn22 I2_I1_bx22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I22_MP0 (VDD A_22 I2_I1_I42_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I375_MP1 (I2_I3_n24_5 DIVQ_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I375_MP0 (VDD I2_I3_SEL_DIV_b3_4 I2_I3_n24_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I387_MP1 (I2_I3_n25_5 DIVQ_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I387_MP0 (VDD I2_I3_SEL_DIV_b3_4 I2_I3_n25_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2291_MP1 (I1_z3_1 I1_z2_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2291_MP0 (VDD I1_z2_2 I1_z3_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I289_MP1 (I2_I3_n17_3 I2_NOT_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I289_MP0 (VDD I2_I3_SEL_NOT_b3_3 I2_I3_n17_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I275_MP1 (I2_I3_n16_1 I2_OR_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I275_MP0 (VDD I2_I3_SEL_OR_b3_3 I2_I3_n16_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I423_MP1 (I2_I3_n28_5 DIVQ_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I423_MP0 (VDD I2_I3_SEL_DIV_b3_4 I2_I3_n28_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I96_MP1 (I2_I2_nand16 B_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I96_MP0 (VDD A_16 I2_I2_nand16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2283_MP1 (I1_z1_5 I1_z0_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2283_MP0 (VDD I1_z0_10 I1_z1_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I150_MP1 (I2_I2_nand25 B_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I150_MP0 (VDD A_25 I2_I2_nand25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I383_MP1 (I2_I3_n25_1 I2_OR_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I383_MP0 (VDD I2_I3_SEL_OR_b3_4 I2_I3_n25_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I373_MP1 (I2_I3_n24_3 I2_NOT_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I373_MP0 (VDD I2_I3_SEL_NOT_b3_4 I2_I3_n24_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I397_MP1 (I2_I3_n26_3 I2_NOT_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I397_MP0 (VDD I2_I3_SEL_NOT_b3_4 I2_I3_n26_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I407_MP1 (I2_I3_n27_1 I2_OR_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I407_MP0 (VDD I2_I3_SEL_OR_b3_5 I2_I3_n27_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I412_MP1 (I2_I3_o27_0 I2_I3_n27_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I412_MP0 (VDD I2_I3_n27_0 I2_I3_o27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I406_MP1 (I2_I3_n27_0 I2_AND_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I406_MP0 (VDD I2_I3_SEL_AND_b3_5 I2_I3_n27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I431_MP1 (I2_I3_n29_1 I2_OR_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I431_MP0 (VDD I2_I3_SEL_OR_b3_5 I2_I3_n29_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I430_MP1 (I2_I3_n29_0 I2_AND_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I430_MP0 (VDD I2_I3_SEL_AND_b3_5 I2_I3_n29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I436_MP1 (I2_I3_o29_0 I2_I3_n29_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I436_MP0 (VDD I2_I3_n29_0 I2_I3_o29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I433_MP1 (I2_I3_n29_3 I2_NOT_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I433_MP0 (VDD I2_I3_SEL_NOT_b3_5 I2_I3_n29_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I437_MP1 (I2_I3_o29_1 I2_I3_n29_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I437_MP0 (VDD I2_I3_n29_2 I2_I3_o29_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I432_MP1 (I2_I3_n29_2 I2_XOR_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I432_MP0 (VDD I2_I3_SEL_XOR_b3_5 I2_I3_n29_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I170_XP_MP1 (I1_I562_P19_4n I1_I562_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I170_XP_MP0 (VDD I1_I562_P19_12 I1_I562_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I172_XP_MP1 (I1_I562_P21_6n I1_I562_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I172_XP_MP0 (VDD I1_I562_P21_14 I1_I562_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I115_XP_MP1 (I1_I562_P19_16n I1_I562_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I115_XP_MP0 (VDD I1_I562_P19_18 I1_I562_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I117_XP_MP1 (I1_I562_P21_18n I1_I562_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I117_XP_MP0 (VDD I1_I562_P21_20 I1_I562_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I119_XP_MP1 (I1_I562_P23_20n I1_I562_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I119_XP_MP0 (VDD I1_I562_P23_22 I1_I562_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I121_XP_MP1 (I1_I562_P25_22n I1_I562_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I121_XP_MP0 (VDD I1_I562_P25_24 I1_I562_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I123_XP_MP1 (I1_I562_P27_24n I1_I562_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I123_XP_MP0 (VDD I1_I562_P27_26 I1_I562_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I125_XP_MP1 (I1_I562_P29_26n I1_I562_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I125_XP_MP0 (VDD I1_I562_P29_28 I1_I562_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I180_XP_MP1 (I1_I1712_P29_14n I1_I1712_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I180_XP_MP0 (VDD I1_I1712_P29_22 I1_I1712_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I176_XP_MP1 (I1_I1712_P25_10n I1_I1712_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I176_XP_MP0 (VDD I1_I1712_P25_18 I1_I1712_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I172_XP_MP1 (I1_I1712_P21_6n I1_I1712_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I172_XP_MP0 (VDD I1_I1712_P21_14 I1_I1712_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I101_XP_MP1 (I1_I1712_P5_2n I1_I1712_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I101_XP_MP0 (VDD I1_I1712_P5_4 I1_I1712_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I3_MP1 (I1_I1712_gn3 I1_b25_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I3_MP0 (VDD I1_p24_2 I1_I1712_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I31_MP1 (I1_I1574_gn31 I1_b22_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I31_MP0 (VDD I1_p21_30 I1_I1574_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I30_MP1 (I1_I1574_gn30 I1_b22_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I30_MP0 (VDD I1_p21_29 I1_I1574_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I29_MP1 (I1_I1574_gn29 I1_b22_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I29_MP0 (VDD I1_p21_28 I1_I1574_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I28_MP1 (I1_I1574_gn28 I1_b22_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I28_MP0 (VDD I1_p21_27 I1_I1574_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I125_XP_MP1 (I1_I1574_P29_26n I1_I1574_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I125_XP_MP0 (VDD I1_I1574_P29_28 I1_I1574_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I123_XP_MP1 (I1_I1574_P27_24n I1_I1574_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I123_XP_MP0 (VDD I1_I1574_P27_26 I1_I1574_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I121_XP_MP1 (I1_I1574_P25_22n I1_I1574_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I121_XP_MP0 (VDD I1_I1574_P25_24 I1_I1574_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I119_XP_MP1 (I1_I1574_P23_20n I1_I1574_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I119_XP_MP0 (VDD I1_I1574_P23_22 I1_I1574_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I117_XP_MP1 (I1_I1574_P21_18n I1_I1574_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I117_XP_MP0 (VDD I1_I1574_P21_20 I1_I1574_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I16_MP1 (I1_I1574_gn16 I1_b22_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I16_MP0 (VDD I1_p21_15 I1_I1574_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I2_MP1 (I1_I1574_gn2 I1_b22_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I2_MP0 (VDD I1_p21_1 I1_I1574_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I249_MP1 (Y_13 I2_I3_q13_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I249_MP0 (VDD I2_I3_q13_1 Y_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I245_MP1 (I2_I3_o13_1 I2_I3_n13_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I245_MP0 (VDD I2_I3_n13_2 I2_I3_o13_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I241_MP1 (I2_I3_n13_3 I2_NOT_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I241_MP0 (VDD I2_I3_SEL_NOT_b3_2 I2_I3_n13_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I90_MP1 (I2_I2_nand15 B_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I90_MP0 (VDD A_15 I2_I2_nand15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I269_MP1 (I2_I3_o15_1 I2_I3_n15_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I269_MP0 (VDD I2_I3_n15_2 I2_I3_o15_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I252_MP1 (I2_I3_n14_2 I2_XOR_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I252_MP0 (VDD I2_I3_SEL_XOR_b3_2 I2_I3_n14_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2290_MP1 (I1_z3_0 I1_z2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2290_MP0 (VDD I1_z2_0 I1_z3_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I246_MP1 (I2_I3_o13_2 I2_I3_n13_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I246_MP0 (VDD I2_I3_n13_4 I2_I3_o13_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I12_MP1 (I2_I1_I42_gn12 I2_I1_bx12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I12_MP0 (VDD A_12 I2_I1_I42_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I171_XP_MP1 (I2_I1_I42_P20_5n I2_I1_I42_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I171_XP_MP0 (VDD I2_I1_I42_P20_13 I2_I1_I42_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I112_XP_MP1 (I2_I1_I42_P16_13n I2_I1_I42_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I112_XP_MP0 (VDD I2_I1_I42_P16_15 I2_I1_I42_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I114_XP_MP1 (I2_I1_I42_P18_15n I2_I1_I42_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I114_XP_MP0 (VDD I2_I1_I42_P18_17 I2_I1_I42_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I179_XP_MP1 (I2_I1_I42_P28_13n I2_I1_I42_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I179_XP_MP0 (VDD I2_I1_I42_P28_21 I2_I1_I42_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I118_XP_MP1 (I2_I1_I42_P22_19n I2_I1_I42_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I118_XP_MP0 (VDD I2_I1_I42_P22_21 I2_I1_I42_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I120_XP_MP1 (I2_I1_I42_P24_21n I2_I1_I42_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I120_XP_MP0 (VDD I2_I1_I42_P24_23 I2_I1_I42_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I122_XP_MP1 (I2_I1_I42_P26_23n I2_I1_I42_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I122_XP_MP0 (VDD I2_I1_I42_P26_25 I2_I1_I42_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I124_XP_MP1 (I2_I1_I42_P28_25n I2_I1_I42_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I124_XP_MP0 (VDD I2_I1_I42_P28_27 I2_I1_I42_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I24_MP1 (I2_I1_I42_gn24 I2_I1_bx24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I24_MP0 (VDD A_24 I2_I1_I42_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I25_MP1 (I2_I1_I42_gn25 I2_I1_bx25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I25_MP0 (VDD A_25 I2_I1_I42_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I26_MP1 (I2_I1_I42_gn26 I2_I1_bx26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I26_MP0 (VDD A_26 I2_I1_I42_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I27_MP1 (I2_I1_I42_gn27 I2_I1_bx27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I27_MP0 (VDD A_27 I2_I1_I42_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I378_MP1 (I2_I3_o24_2 I2_I3_n24_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I378_MP0 (VDD I2_I3_n24_4 I2_I3_o24_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I390_MP1 (I2_I3_o25_2 I2_I3_n25_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I390_MP0 (VDD I2_I3_n25_4 I2_I3_o25_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I399_MP1 (I2_I3_n26_5 DIVQ_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I399_MP0 (VDD I2_I3_SEL_DIV_b3_4 I2_I3_n26_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I411_MP1 (I2_I3_n27_5 DIVQ_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I411_MP0 (VDD I2_I3_SEL_DIV_b3_4 I2_I3_n27_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I438_MP1 (I2_I3_o29_2 I2_I3_n29_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I438_MP0 (VDD I2_I3_n29_4 I2_I3_o29_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I70_MP1 (I2_I4_dzn DIVDZ VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I70_MP0 (VDD I2_SEL_DIV I2_I4_dzn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2282_MP1 (I1_z1_4 I1_z0_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2282_MP0 (VDD I1_z0_8 I1_z1_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I144_MP1 (I2_I2_nand24 B_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I144_MP0 (VDD A_24 I2_I2_nand24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I370_MP1 (I2_I3_n24_0 I2_AND_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I370_MP0 (VDD I2_I3_SEL_AND_b3_4 I2_I3_n24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I376_MP1 (I2_I3_o24_0 I2_I3_n24_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I376_MP0 (VDD I2_I3_n24_0 I2_I3_o24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I393_MP1 (Y_25 I2_I3_q25_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I393_MP0 (VDD I2_I3_q25_1 Y_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I401_MP1 (I2_I3_o26_1 I2_I3_n26_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I401_MP0 (VDD I2_I3_n26_2 I2_I3_o26_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I396_MP1 (I2_I3_n26_2 I2_XOR_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I396_MP0 (VDD I2_I3_SEL_XOR_b3_4 I2_I3_n26_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I445_MP1 (I2_I3_n30_3 I2_NOT_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I445_MP0 (VDD I2_I3_SEL_NOT_b3_5 I2_I3_n30_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I419_MP1 (I2_I3_n28_1 I2_OR_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I419_MP0 (VDD I2_I3_SEL_OR_b3_5 I2_I3_n28_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I408_MP1 (I2_I3_n27_2 I2_XOR_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I408_MP0 (VDD I2_I3_SEL_XOR_b3_5 I2_I3_n27_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I418_MP1 (I2_I3_n28_0 I2_AND_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I418_MP0 (VDD I2_I3_SEL_AND_b3_5 I2_I3_n28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I424_MP1 (I2_I3_o28_0 I2_I3_n28_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I424_MP0 (VDD I2_I3_n28_0 I2_I3_o28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I168_MP1 (I2_I2_nand28 B_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I168_MP0 (VDD A_28 I2_I2_nand28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I441_MP1 (Y_29 I2_I3_q29_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I441_MP0 (VDD I2_I3_q29_1 Y_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I421_MP1 (I2_I3_n28_3 I2_NOT_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I421_MP0 (VDD I2_I3_SEL_NOT_b3_5 I2_I3_n28_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I425_MP1 (I2_I3_o28_1 I2_I3_n28_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I425_MP0 (VDD I2_I3_n28_2 I2_I3_o28_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I420_MP1 (I2_I3_n28_2 I2_XOR_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I420_MP0 (VDD I2_I3_SEL_XOR_b3_5 I2_I3_n28_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I178_XP_MP1 (I1_I562_P27_12n I1_I562_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I178_XP_MP0 (VDD I1_I562_P27_20 I1_I562_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I174_XP_MP1 (I1_I562_P23_8n I1_I562_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I174_XP_MP0 (VDD I1_I562_P23_16 I1_I562_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I182_XP_MP1 (I1_I562_P31_16n I1_I562_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I182_XP_MP0 (VDD I1_I562_P31_24 I1_I562_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I127_XP_MP1 (I1_I562_P31_28n I1_I562_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I127_XP_MP0 (VDD I1_I562_P31_30 I1_I562_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I28_MP1 (I1_I1712_gn28 I1_b25_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I28_MP0 (VDD I1_p24_27 I1_I1712_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I124_XP_MP1 (I1_I1712_P28_25n I1_I1712_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I124_XP_MP0 (VDD I1_I1712_P28_27 I1_I1712_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I179_XP_MP1 (I1_I1712_P28_13n I1_I1712_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I179_XP_MP0 (VDD I1_I1712_P28_21 I1_I1712_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I171_XP_MP1 (I1_I1712_P20_5n I1_I1712_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I171_XP_MP0 (VDD I1_I1712_P20_13 I1_I1712_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I4_MP1 (I1_I1712_gn4 I1_b25_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I4_MP0 (VDD I1_p24_3 I1_I1712_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I27_MP1 (I1_I1574_gn27 I1_b22_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I27_MP0 (VDD I1_p21_26 I1_I1574_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I26_MP1 (I1_I1574_gn26 I1_b22_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I26_MP0 (VDD I1_p21_25 I1_I1574_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I112_XP_MP1 (I1_I1574_P16_13n I1_I1574_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I112_XP_MP0 (VDD I1_I1574_P16_15 I1_I1574_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I110_XP_MP1 (I1_I1574_P14_11n I1_I1574_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I110_XP_MP0 (VDD I1_I1574_P14_13 I1_I1574_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I108_XP_MP1 (I1_I1574_P12_9n I1_I1574_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I108_XP_MP0 (VDD I1_I1574_P12_11 I1_I1574_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I106_XP_MP1 (I1_I1574_P10_7n I1_I1574_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I106_XP_MP0 (VDD I1_I1574_P10_9 I1_I1574_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I104_XP_MP1 (I1_I1574_P8_5n I1_I1574_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I104_XP_MP0 (VDD I1_I1574_P8_7 I1_I1574_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I78_MP1 (I2_I2_nand13 B_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I78_MP0 (VDD A_13 I2_I2_nand13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I239_MP1 (I2_I3_n13_1 I2_OR_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I239_MP0 (VDD I2_I3_SEL_OR_b3_2 I2_I3_n13_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I238_MP1 (I2_I3_n13_0 I2_AND_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I238_MP0 (VDD I2_I3_SEL_AND_b3_2 I2_I3_n13_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I244_MP1 (I2_I3_o13_0 I2_I3_n13_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I244_MP0 (VDD I2_I3_n13_0 I2_I3_o13_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I262_MP1 (I2_I3_n15_0 I2_AND_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I262_MP0 (VDD I2_I3_SEL_AND_b3_2 I2_I3_n15_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I268_MP1 (I2_I3_o15_0 I2_I3_n15_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I268_MP0 (VDD I2_I3_n15_0 I2_I3_o15_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I273_MP1 (Y_15 I2_I3_q15_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I273_MP0 (VDD I2_I3_q15_1 Y_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I217_MP1 (I2_I3_n11_3 I2_NOT_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I217_MP0 (VDD I2_I3_SEL_NOT_b3_2 I2_I3_n11_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I263_MP1 (I2_I3_n15_1 I2_OR_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I263_MP0 (VDD I2_I3_SEL_OR_b3_2 I2_I3_n15_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I258_MP1 (I2_I3_o14_2 I2_I3_n14_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I258_MP0 (VDD I2_I3_n14_4 I2_I3_o14_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I270_MP1 (I2_I3_o15_2 I2_I3_n15_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I270_MP0 (VDD I2_I3_n15_4 I2_I3_o15_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I11_MP1 (I2_I1_I42_gn11 I2_I1_bx11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I11_MP0 (VDD A_11 I2_I1_I42_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I110_XP_MP1 (I2_I1_I42_P14_11n I2_I1_I42_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I110_XP_MP0 (VDD I2_I1_I42_P14_13 I2_I1_I42_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I173_XP_MP1 (I2_I1_I42_P22_7n I2_I1_I42_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I173_XP_MP0 (VDD I2_I1_I42_P22_15 I2_I1_I42_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I177_XP_MP1 (I2_I1_I42_P26_11n I2_I1_I42_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I177_XP_MP0 (VDD I2_I1_I42_P26_19 I2_I1_I42_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I181_XP_MP1 (I2_I1_I42_P30_15n I2_I1_I42_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I181_XP_MP0 (VDD I2_I1_I42_P30_23 I2_I1_I42_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I126_XP_MP1 (I2_I1_I42_P30_27n I2_I1_I42_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I126_XP_MP0 (VDD I2_I1_I42_P30_29 I2_I1_I42_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I28_MP1 (I2_I1_I42_gn28 I2_I1_bx28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I28_MP0 (VDD A_28 I2_I1_I42_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I402_MP1 (I2_I3_o26_2 I2_I3_n26_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I402_MP0 (VDD I2_I3_n26_4 I2_I3_o26_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I414_MP1 (I2_I3_o27_2 I2_I3_n27_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I414_MP0 (VDD I2_I3_n27_4 I2_I3_o27_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I69_MP1 (V I2_I4_v2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I69_MP0 (VDD I2_I4_v1 V VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I395_MP1 (I2_I3_n26_1 I2_OR_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I395_MP0 (VDD I2_I3_SEL_OR_b3_4 I2_I3_n26_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I405_MP1 (Y_26 I2_I3_q26_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I405_MP0 (VDD I2_I3_q26_1 Y_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I443_MP1 (I2_I3_n30_1 I2_OR_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I443_MP0 (VDD I2_I3_SEL_OR_b3_5 I2_I3_n30_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I448_MP1 (I2_I3_o30_0 I2_I3_n30_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I448_MP0 (VDD I2_I3_n30_0 I2_I3_o30_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I417_MP1 (Y_27 I2_I3_q27_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I417_MP0 (VDD I2_I3_q27_1 Y_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I455_MP1 (I2_I3_n31_1 I2_OR_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I455_MP0 (VDD I2_I3_SEL_OR_b3_5 I2_I3_n31_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I429_MP1 (Y_28 I2_I3_q28_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I429_MP0 (VDD I2_I3_q28_1 Y_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I457_MP1 (I2_I3_n31_3 I2_NOT_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I457_MP0 (VDD I2_I3_SEL_NOT_b3_5 I2_I3_n31_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I461_MP1 (I2_I3_o31_1 I2_I3_n31_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I461_MP0 (VDD I2_I3_n31_2 I2_I3_o31_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I456_MP1 (I2_I3_n31_2 I2_XOR_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I456_MP0 (VDD I2_I3_SEL_XOR_b3_5 I2_I3_n31_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I29_MP1 (I1_I1712_gn29 I1_b25_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I29_MP0 (VDD I1_p24_28 I1_I1712_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I27_MP1 (I1_I1712_gn27 I1_b25_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I27_MP0 (VDD I1_p24_26 I1_I1712_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I126_XP_MP1 (I1_I1712_P30_27n I1_I1712_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I126_XP_MP0 (VDD I1_I1712_P30_29 I1_I1712_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I122_XP_MP1 (I1_I1712_P26_23n I1_I1712_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I122_XP_MP0 (VDD I1_I1712_P26_25 I1_I1712_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I120_XP_MP1 (I1_I1712_P24_21n I1_I1712_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I120_XP_MP0 (VDD I1_I1712_P24_23 I1_I1712_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I177_XP_MP1 (I1_I1712_P26_11n I1_I1712_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I177_XP_MP0 (VDD I1_I1712_P26_19 I1_I1712_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I175_XP_MP1 (I1_I1712_P24_9n I1_I1712_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I175_XP_MP0 (VDD I1_I1712_P24_17 I1_I1712_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I169_XP_MP1 (I1_I1712_P18_3n I1_I1712_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I169_XP_MP0 (VDD I1_I1712_P18_11 I1_I1712_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I167_XP_MP1 (I1_I1712_P16_1n I1_I1712_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I167_XP_MP0 (VDD I1_I1712_P16_9 I1_I1712_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I104_XP_MP1 (I1_I1712_P8_5n I1_I1712_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I104_XP_MP0 (VDD I1_I1712_P8_7 I1_I1712_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I102_XP_MP1 (I1_I1712_P6_3n I1_I1712_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I102_XP_MP0 (VDD I1_I1712_P6_5 I1_I1712_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I100_XP_MP1 (I1_I1712_P4_1n I1_I1712_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I100_XP_MP0 (VDD I1_I1712_P4_3 I1_I1712_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I1_MP1 (I1_I1712_gn1 I1_b25_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I1_MP0 (VDD I1_p24_0 I1_I1712_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I2_MP1 (I1_I1712_gn2 I1_b25_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I2_MP0 (VDD I1_p24_1 I1_I1712_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I5_MP1 (I1_I1712_gn5 I1_b25_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I5_MP0 (VDD I1_p24_4 I1_I1712_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I25_MP1 (I1_I1574_gn25 I1_b22_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I25_MP0 (VDD I1_p21_24 I1_I1574_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I24_MP1 (I1_I1574_gn24 I1_b22_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I24_MP0 (VDD I1_p21_23 I1_I1574_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I126_XP_MP1 (I1_I1574_P30_27n I1_I1574_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I126_XP_MP0 (VDD I1_I1574_P30_29 I1_I1574_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I124_XP_MP1 (I1_I1574_P28_25n I1_I1574_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I124_XP_MP0 (VDD I1_I1574_P28_27 I1_I1574_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I18_MP1 (I1_I1574_gn18 I1_b22_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I18_MP0 (VDD I1_p21_17 I1_I1574_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I17_MP1 (I1_I1574_gn17 I1_b22_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I17_MP0 (VDD I1_p21_16 I1_I1574_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I179_XP_MP1 (I1_I1574_P28_13n I1_I1574_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I179_XP_MP0 (VDD I1_I1574_P28_21 I1_I1574_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I171_XP_MP1 (I1_I1574_P20_5n I1_I1574_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I171_XP_MP0 (VDD I1_I1574_P20_13 I1_I1574_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I102_XP_MP1 (I1_I1574_P6_3n I1_I1574_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I102_XP_MP0 (VDD I1_I1574_P6_5 I1_I1574_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I100_XP_MP1 (I1_I1574_P4_1n I1_I1574_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I100_XP_MP0 (VDD I1_I1574_P4_3 I1_I1574_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I1_MP1 (I1_I1574_gn1 I1_b22_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I1_MP0 (VDD I1_p21_0 I1_I1574_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I35_MP1 (I2_I4_z1_3 I2_I4_z0_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I35_MP0 (VDD I2_I4_z0_6 I2_I4_z1_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I228_MP1 (I2_I3_n12_2 I2_XOR_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I228_MP0 (VDD I2_I3_SEL_XOR_b3_2 I2_I3_n12_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I233_MP1 (I2_I3_o12_1 I2_I3_n12_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I233_MP0 (VDD I2_I3_n12_2 I2_I3_o12_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I229_MP1 (I2_I3_n12_3 I2_NOT_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I229_MP0 (VDD I2_I3_SEL_NOT_b3_2 I2_I3_n12_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I216_MP1 (I2_I3_n11_2 I2_XOR_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I216_MP0 (VDD I2_I3_SEL_XOR_b3_2 I2_I3_n11_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I250_MP1 (I2_I3_n14_0 I2_AND_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I250_MP0 (VDD I2_I3_SEL_AND_b3_2 I2_I3_n14_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I261_MP1 (Y_14 I2_I3_q14_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I261_MP0 (VDD I2_I3_q14_1 Y_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I234_MP1 (I2_I3_o12_2 I2_I3_n12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I234_MP0 (VDD I2_I3_n12_4 I2_I3_o12_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I175_XP_MP1 (I2_I1_I42_P24_9n I2_I1_I42_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I175_XP_MP0 (VDD I2_I1_I42_P24_17 I2_I1_I42_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I111_XP_MP1 (I2_I1_I42_P15_12n I2_I1_I42_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I111_XP_MP0 (VDD I2_I1_I42_P15_14 I2_I1_I42_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I113_XP_MP1 (I2_I1_I42_P17_14n I2_I1_I42_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I113_XP_MP0 (VDD I2_I1_I42_P17_16 I2_I1_I42_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I115_XP_MP1 (I2_I1_I42_P19_16n I2_I1_I42_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I115_XP_MP0 (VDD I2_I1_I42_P19_18 I2_I1_I42_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I117_XP_MP1 (I2_I1_I42_P21_18n I2_I1_I42_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I117_XP_MP0 (VDD I2_I1_I42_P21_20 I2_I1_I42_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I178_XP_MP1 (I2_I1_I42_P27_12n I2_I1_I42_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I178_XP_MP0 (VDD I2_I1_I42_P27_20 I2_I1_I42_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I119_XP_MP1 (I2_I1_I42_P23_20n I2_I1_I42_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I119_XP_MP0 (VDD I2_I1_I42_P23_22 I2_I1_I42_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I121_XP_MP1 (I2_I1_I42_P25_22n I2_I1_I42_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I121_XP_MP0 (VDD I2_I1_I42_P25_24 I2_I1_I42_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I123_XP_MP1 (I2_I1_I42_P27_24n I2_I1_I42_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I123_XP_MP0 (VDD I2_I1_I42_P27_26 I2_I1_I42_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I125_XP_MP1 (I2_I1_I42_P29_26n I2_I1_I42_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I125_XP_MP0 (VDD I2_I1_I42_P29_28 I2_I1_I42_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I30_MP1 (I2_I1_I42_gn30 I2_I1_bx30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I30_MP0 (VDD A_30 I2_I1_I42_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I29_MP1 (I2_I1_I42_gn29 I2_I1_bx29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I29_MP0 (VDD A_29 I2_I1_I42_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I64_MP1 (I2_I4_cn I2_SEL_AS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I64_MP0 (VDD I2_CO I2_I4_cn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I67_MP1 (I2_I4_v1 I2_I4_ovf VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I67_MP0 (VDD I2_SEL_AS I2_I4_v1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I450_MP1 (I2_I3_o30_2 I2_I3_n30_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I450_MP0 (VDD I2_I3_n30_4 I2_I3_o30_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I447_MP1 (I2_I3_n30_5 DIVQ_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I447_MP0 (VDD I2_I3_SEL_DIV_b3_5 I2_I3_n30_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I0_I10_MP1 (I2_I0_l11 OP_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I0_I10_MP0 (VDD OP_1 I2_I0_l11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I0_I8_MP1 (I2_I0_l01 OP_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I0_I8_MP0 (VDD I2_I0_opn1 I2_I0_l01 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I0_I7_MP1 (I2_I0_l00 I2_I0_opn0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I0_I7_MP0 (VDD I2_I0_opn1 I2_I0_l00 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I0_I9_MP1 (I2_I0_l10 I2_I0_opn0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I0_I9_MP0 (VDD OP_1 I2_I0_l10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I0_I6_MP1 (I2_I0_h10 I2_I0_opn2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I0_I6_MP0 (VDD OP_3 I2_I0_h10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I156_MP1 (I2_I2_nand26 B_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I156_MP0 (VDD A_26 I2_I2_nand26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I453_MP1 (Y_30 I2_I3_q30_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I453_MP0 (VDD I2_I3_q30_1 Y_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I442_MP1 (I2_I3_n30_0 I2_AND_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I442_MP0 (VDD I2_I3_SEL_AND_b3_5 I2_I3_n30_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I180_MP1 (I2_I2_nand30 B_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I180_MP0 (VDD A_30 I2_I2_nand30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I186_MP1 (I2_I2_nand31 B_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I186_MP0 (VDD A_31 I2_I2_nand31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I465_MP1 (Y_31 I2_I3_q31_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I465_MP0 (VDD I2_I3_q31_1 Y_31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I181_XP_MP1 (I1_I1712_P30_15n I1_I1712_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I181_XP_MP0 (VDD I1_I1712_P30_23 I1_I1712_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I173_XP_MP1 (I1_I1712_P22_7n I1_I1712_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I173_XP_MP0 (VDD I1_I1712_P22_15 I1_I1712_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I108_XP_MP1 (I1_I1712_P12_9n I1_I1712_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I108_XP_MP0 (VDD I1_I1712_P12_11 I1_I1712_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I106_XP_MP1 (I1_I1712_P10_7n I1_I1712_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I106_XP_MP0 (VDD I1_I1712_P10_9 I1_I1712_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I6_MP1 (I1_I1712_gn6 I1_b25_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I6_MP0 (VDD I1_p24_5 I1_I1712_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I0_MP1 (I1_I1666_gn0 I1_b24_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I0_MP0 (VDD I1_aa7 I1_I1666_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I23_MP1 (I1_I1574_gn23 I1_b22_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I23_MP0 (VDD I1_p21_22 I1_I1574_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I22_MP1 (I1_I1574_gn22 I1_b22_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I22_MP0 (VDD I1_p21_21 I1_I1574_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I122_XP_MP1 (I1_I1574_P26_23n I1_I1574_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I122_XP_MP0 (VDD I1_I1574_P26_25 I1_I1574_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I120_XP_MP1 (I1_I1574_P24_21n I1_I1574_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I120_XP_MP0 (VDD I1_I1574_P24_23 I1_I1574_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I116_XP_MP1 (I1_I1574_P20_17n I1_I1574_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I116_XP_MP0 (VDD I1_I1574_P20_19 I1_I1574_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I114_XP_MP1 (I1_I1574_P18_15n I1_I1574_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I114_XP_MP0 (VDD I1_I1574_P18_17 I1_I1574_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I175_XP_MP1 (I1_I1574_P24_9n I1_I1574_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I175_XP_MP0 (VDD I1_I1574_P24_17 I1_I1574_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I167_XP_MP1 (I1_I1574_P16_1n I1_I1574_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I167_XP_MP0 (VDD I1_I1574_P16_9 I1_I1574_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I232_MP1 (I2_I3_o12_0 I2_I3_n12_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I232_MP0 (VDD I2_I3_n12_0 I2_I3_o12_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I227_MP1 (I2_I3_n12_1 I2_OR_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I227_MP0 (VDD I2_I3_SEL_OR_b3_2 I2_I3_n12_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I226_MP1 (I2_I3_n12_0 I2_AND_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I226_MP0 (VDD I2_I3_SEL_AND_b3_2 I2_I3_n12_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I237_MP1 (Y_12 I2_I3_q12_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I237_MP0 (VDD I2_I3_q12_1 Y_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I215_MP1 (I2_I3_n11_1 I2_OR_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I215_MP0 (VDD I2_I3_SEL_OR_b3_2 I2_I3_n11_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I220_MP1 (I2_I3_o11_0 I2_I3_n11_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I220_MP0 (VDD I2_I3_n11_0 I2_I3_o11_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I221_MP1 (I2_I3_o11_1 I2_I3_n11_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I221_MP0 (VDD I2_I3_n11_2 I2_I3_o11_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I225_MP1 (Y_11 I2_I3_q11_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I225_MP0 (VDD I2_I3_q11_1 Y_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I84_MP1 (I2_I2_nand14 B_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I84_MP0 (VDD A_14 I2_I2_nand14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I10_MP1 (I2_I1_I42_gn10 I2_I1_bx10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I10_MP0 (VDD A_10 I2_I1_I42_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I108_XP_MP1 (I2_I1_I42_P12_9n I2_I1_I42_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I108_XP_MP0 (VDD I2_I1_I42_P12_11 I2_I1_I42_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I169_XP_MP1 (I2_I1_I42_P18_3n I2_I1_I42_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I169_XP_MP0 (VDD I2_I1_I42_P18_11 I2_I1_I42_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I172_XP_MP1 (I2_I1_I42_P21_6n I2_I1_I42_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I172_XP_MP0 (VDD I2_I1_I42_P21_14 I2_I1_I42_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I174_XP_MP1 (I2_I1_I42_P23_8n I2_I1_I42_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I174_XP_MP0 (VDD I2_I1_I42_P23_16 I2_I1_I42_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I180_XP_MP1 (I2_I1_I42_P29_14n I2_I1_I42_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I180_XP_MP0 (VDD I2_I1_I42_P29_22 I2_I1_I42_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I182_XP_MP1 (I2_I1_I42_P31_16n I2_I1_I42_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I182_XP_MP0 (VDD I2_I1_I42_P31_24 I2_I1_I42_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I127_XP_MP1 (I2_I1_I42_P31_28n I2_I1_I42_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I127_XP_MP0 (VDD I2_I1_I42_P31_30 I2_I1_I42_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I31_MP1 (I2_I1_I42_gn31 I2_I1_bx31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I31_MP0 (VDD A_31 I2_I1_I42_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I462_MP1 (I2_I3_o31_2 I2_I3_n31_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I462_MP0 (VDD I2_I3_n31_4 I2_I3_o31_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I459_MP1 (I2_I3_n31_5 DIVQ_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I459_MP0 (VDD I2_I3_SEL_DIV_b3_5 I2_I3_n31_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I30_MP1 (I1_I1712_gn30 I1_b25_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I30_MP0 (VDD I1_p24_29 I1_I1712_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I26_MP1 (I1_I1712_gn26 I1_b25_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I26_MP0 (VDD I1_p24_25 I1_I1712_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I24_MP1 (I1_I1712_gn24 I1_b25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I24_MP0 (VDD I1_p24_23 I1_I1712_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I118_XP_MP1 (I1_I1712_P22_19n I1_I1712_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I118_XP_MP0 (VDD I1_I1712_P22_21 I1_I1712_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I116_XP_MP1 (I1_I1712_P20_17n I1_I1712_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I116_XP_MP0 (VDD I1_I1712_P20_19 I1_I1712_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I114_XP_MP1 (I1_I1712_P18_15n I1_I1712_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I114_XP_MP0 (VDD I1_I1712_P18_17 I1_I1712_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I112_XP_MP1 (I1_I1712_P16_13n I1_I1712_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I112_XP_MP0 (VDD I1_I1712_P16_15 I1_I1712_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I110_XP_MP1 (I1_I1712_P14_11n I1_I1712_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I110_XP_MP0 (VDD I1_I1712_P14_13 I1_I1712_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I8_MP1 (I1_I1712_gn8 I1_b25_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I8_MP0 (VDD I1_p24_7 I1_I1712_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I7_MP1 (I1_I1712_gn7 I1_b25_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I7_MP0 (VDD I1_p24_6 I1_I1712_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I0_MP1 (I1_I1712_gn0 I1_b25_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I0_MP0 (VDD I1_aa6 I1_I1712_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I21_MP1 (I1_I1574_gn21 I1_b22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I21_MP0 (VDD I1_p21_20 I1_I1574_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I20_MP1 (I1_I1574_gn20 I1_b22_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I20_MP0 (VDD I1_p21_19 I1_I1574_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I19_MP1 (I1_I1574_gn19 I1_b22_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I19_MP0 (VDD I1_p21_18 I1_I1574_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I118_XP_MP1 (I1_I1574_P22_19n I1_I1574_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I118_XP_MP0 (VDD I1_I1574_P22_21 I1_I1574_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I177_XP_MP1 (I1_I1574_P26_11n I1_I1574_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I177_XP_MP0 (VDD I1_I1574_P26_19 I1_I1574_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I169_XP_MP1 (I1_I1574_P18_3n I1_I1574_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I169_XP_MP0 (VDD I1_I1574_P18_11 I1_I1574_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I72_MP1 (I2_I2_nand12 B_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I72_MP0 (VDD A_12 I2_I2_nand12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I66_MP1 (I2_I2_nand11 B_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I66_MP0 (VDD A_11 I2_I2_nand11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I214_MP1 (I2_I3_n11_0 I2_AND_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I214_MP0 (VDD I2_I3_SEL_AND_b3_2 I2_I3_n11_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2278_MP1 (I1_z1_0 I1_z0_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2278_MP0 (VDD I1_z0_0 I1_z1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2279_MP1 (I1_z1_1 I1_z0_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2279_MP0 (VDD I1_z0_2 I1_z1_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I9_MP1 (I2_I1_I42_gn9 I2_I1_bx9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I9_MP0 (VDD A_9 I2_I1_I42_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I106_XP_MP1 (I2_I1_I42_P10_7n I2_I1_I42_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I106_XP_MP0 (VDD I2_I1_I42_P10_9 I2_I1_I42_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I167_XP_MP1 (I2_I1_I42_P16_1n I2_I1_I42_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I167_XP_MP0 (VDD I2_I1_I42_P16_9 I2_I1_I42_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I107_XP_MP1 (I2_I1_I42_P11_8n I2_I1_I42_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I107_XP_MP0 (VDD I2_I1_I42_P11_10 I2_I1_I42_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I109_XP_MP1 (I2_I1_I42_P13_10n I2_I1_I42_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I109_XP_MP0 (VDD I2_I1_I42_P13_12 I2_I1_I42_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I170_XP_MP1 (I2_I1_I42_P19_4n I2_I1_I42_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I170_XP_MP0 (VDD I2_I1_I42_P19_12 I2_I1_I42_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I176_XP_MP1 (I2_I1_I42_P25_10n I2_I1_I42_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I176_XP_MP0 (VDD I2_I1_I42_P25_18 I2_I1_I42_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I25_MP1 (I1_I1712_gn25 I1_b25_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I25_MP0 (VDD I1_p24_24 I1_I1712_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I11_MP1 (I1_I1712_gn11 I1_b25_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I11_MP0 (VDD I1_p24_10 I1_I1712_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I10_MP1 (I1_I1712_gn10 I1_b25_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I10_MP0 (VDD I1_p24_9 I1_I1712_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I9_MP1 (I1_I1712_gn9 I1_b25_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I9_MP0 (VDD I1_p24_8 I1_I1712_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I1_MP1 (I1_I1666_gn1 I1_b24_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I1_MP0 (VDD I1_p23_0 I1_I1666_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I2_MP1 (I1_I1666_gn2 I1_b24_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I2_MP0 (VDD I1_p23_1 I1_I1666_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I3_MP1 (I1_I1666_gn3 I1_b24_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I3_MP0 (VDD I1_p23_2 I1_I1666_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I181_XP_MP1 (I1_I1574_P30_15n I1_I1574_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I181_XP_MP0 (VDD I1_I1574_P30_23 I1_I1574_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I173_XP_MP1 (I1_I1574_P22_7n I1_I1574_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I173_XP_MP0 (VDD I1_I1574_P22_15 I1_I1574_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I4_MP1 (I1_I1620_gn4 I1_b23_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I4_MP0 (VDD I1_p22_3 I1_I1620_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I0_MP1 (I1_I1574_gn0 I1_b22_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I0_MP0 (VDD I1_aa9 I1_I1574_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I8_MP1 (I2_I1_I42_gn8 I2_I1_bx8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I8_MP0 (VDD A_8 I2_I1_I42_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I104_XP_MP1 (I2_I1_I42_P8_5n I2_I1_I42_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I104_XP_MP0 (VDD I2_I1_I42_P8_7 I2_I1_I42_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I105_XP_MP1 (I2_I1_I42_P9_6n I2_I1_I42_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I105_XP_MP0 (VDD I2_I1_I42_P9_8 I2_I1_I42_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I168_XP_MP1 (I2_I1_I42_P17_2n I2_I1_I42_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I168_XP_MP0 (VDD I2_I1_I42_P17_10 I2_I1_I42_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I31_MP1 (I1_I1712_gn31 I1_b25_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I31_MP0 (VDD I1_p24_30 I1_I1712_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I22_MP1 (I1_I1712_gn22 I1_b25_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I22_MP0 (VDD I1_p24_21 I1_I1712_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I20_MP1 (I1_I1712_gn20 I1_b25_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I20_MP0 (VDD I1_p24_19 I1_I1712_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I18_MP1 (I1_I1712_gn18 I1_b25_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I18_MP0 (VDD I1_p24_17 I1_I1712_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I15_MP1 (I1_I1712_gn15 I1_b25_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I15_MP0 (VDD I1_p24_14 I1_I1712_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I12_MP1 (I1_I1712_gn12 I1_b25_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I12_MP0 (VDD I1_p24_11 I1_I1712_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I167_XP_MP1 (I1_I1666_P16_1n I1_I1666_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I167_XP_MP0 (VDD I1_I1666_P16_9 I1_I1666_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I100_XP_MP1 (I1_I1666_P4_1n I1_I1666_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I100_XP_MP0 (VDD I1_I1666_P4_3 I1_I1666_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I102_XP_MP1 (I1_I1666_P6_3n I1_I1666_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I102_XP_MP0 (VDD I1_I1666_P6_5 I1_I1666_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I101_XP_MP1 (I1_I1666_P5_2n I1_I1666_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I101_XP_MP0 (VDD I1_I1666_P5_4 I1_I1666_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I4_MP1 (I1_I1666_gn4 I1_b24_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I4_MP0 (VDD I1_p23_3 I1_I1666_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I8_MP1 (I1_I1620_gn8 I1_b23_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I8_MP0 (VDD I1_p22_7 I1_I1620_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I3_MP1 (I1_I1620_gn3 I1_b23_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I3_MP0 (VDD I1_p22_2 I1_I1620_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I7_MP1 (I2_I1_I42_gn7 I2_I1_bx7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I7_MP0 (VDD A_7 I2_I1_I42_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I6_MP1 (I2_I1_I42_gn6 I2_I1_bx6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I6_MP0 (VDD A_6 I2_I1_I42_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I102_XP_MP1 (I2_I1_I42_P6_3n I2_I1_I42_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I102_XP_MP0 (VDD I2_I1_I42_P6_5 I2_I1_I42_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I103_XP_MP1 (I2_I1_I42_P7_4n I2_I1_I42_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I103_XP_MP0 (VDD I2_I1_I42_P7_6 I2_I1_I42_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I28_MP1 (I1_I1758_gn28 I1_b26_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I28_MP0 (VDD I1_p25_27 I1_I1758_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I27_MP1 (I1_I1758_gn27 I1_b26_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I27_MP0 (VDD I1_p25_26 I1_I1758_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I23_MP1 (I1_I1712_gn23 I1_b25_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I23_MP0 (VDD I1_p24_22 I1_I1712_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I21_MP1 (I1_I1712_gn21 I1_b25_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I21_MP0 (VDD I1_p24_20 I1_I1712_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I19_MP1 (I1_I1712_gn19 I1_b25_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I19_MP0 (VDD I1_p24_18 I1_I1712_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I17_MP1 (I1_I1712_gn17 I1_b25_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I17_MP0 (VDD I1_p24_16 I1_I1712_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I16_MP1 (I1_I1712_gn16 I1_b25_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I16_MP0 (VDD I1_p24_15 I1_I1712_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I14_MP1 (I1_I1712_gn14 I1_b25_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I14_MP0 (VDD I1_p24_13 I1_I1712_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I169_XP_MP1 (I1_I1666_P18_3n I1_I1666_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I169_XP_MP0 (VDD I1_I1666_P18_11 I1_I1666_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I104_XP_MP1 (I1_I1666_P8_5n I1_I1666_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I104_XP_MP0 (VDD I1_I1666_P8_7 I1_I1666_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I103_XP_MP1 (I1_I1666_P7_4n I1_I1666_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I103_XP_MP0 (VDD I1_I1666_P7_6 I1_I1666_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I5_MP1 (I1_I1666_gn5 I1_b24_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I5_MP0 (VDD I1_p23_4 I1_I1666_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I6_MP1 (I1_I1666_gn6 I1_b24_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I6_MP0 (VDD I1_p23_5 I1_I1666_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I8_MP1 (I1_I1666_gn8 I1_b24_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I8_MP0 (VDD I1_p23_7 I1_I1666_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I13_MP1 (I1_I1620_gn13 I1_b23_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I13_MP0 (VDD I1_p22_12 I1_I1620_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I11_MP1 (I1_I1620_gn11 I1_b23_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I11_MP0 (VDD I1_p22_10 I1_I1620_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I9_MP1 (I1_I1620_gn9 I1_b23_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I9_MP0 (VDD I1_p22_8 I1_I1620_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I6_MP1 (I1_I1620_gn6 I1_b23_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I6_MP0 (VDD I1_p22_5 I1_I1620_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I5_MP1 (I1_I1620_gn5 I1_b23_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I5_MP0 (VDD I1_p22_4 I1_I1620_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I0_MP1 (I1_I1620_gn0 I1_b23_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I0_MP0 (VDD I1_aa8 I1_I1620_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I219_MP1 (I2_I3_n11_5 DIVQ_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I219_MP0 (VDD I2_I3_SEL_DIV_b3_1 I2_I3_n11_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I222_MP1 (I2_I3_o11_2 I2_I3_n11_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I222_MP0 (VDD I2_I3_n11_4 I2_I3_o11_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I5_MP1 (I2_I1_I42_gn5 I2_I1_bx5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I5_MP0 (VDD A_5 I2_I1_I42_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I100_XP_MP1 (I2_I1_I42_P4_1n I2_I1_I42_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I100_XP_MP0 (VDD I2_I1_I42_P4_3 I2_I1_I42_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I101_XP_MP1 (I2_I1_I42_P5_2n I2_I1_I42_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I101_XP_MP0 (VDD I2_I1_I42_P5_4 I2_I1_I42_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I29_MP1 (I1_I1758_gn29 I1_b26_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I29_MP0 (VDD I1_p25_28 I1_I1758_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I25_MP1 (I1_I1758_gn25 I1_b26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I25_MP0 (VDD I1_p25_24 I1_I1758_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I24_MP1 (I1_I1758_gn24 I1_b26_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I24_MP0 (VDD I1_p25_23 I1_I1758_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I13_MP1 (I1_I1712_gn13 I1_b25_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I13_MP0 (VDD I1_p24_12 I1_I1712_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I106_XP_MP1 (I1_I1666_P10_7n I1_I1666_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I106_XP_MP0 (VDD I1_I1666_P10_9 I1_I1666_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I108_XP_MP1 (I1_I1666_P12_9n I1_I1666_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I108_XP_MP0 (VDD I1_I1666_P12_11 I1_I1666_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I168_XP_MP1 (I1_I1666_P17_2n I1_I1666_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I168_XP_MP0 (VDD I1_I1666_P17_10 I1_I1666_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I105_XP_MP1 (I1_I1666_P9_6n I1_I1666_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I105_XP_MP0 (VDD I1_I1666_P9_8 I1_I1666_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I7_MP1 (I1_I1666_gn7 I1_b24_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I7_MP0 (VDD I1_p23_6 I1_I1666_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I9_MP1 (I1_I1666_gn9 I1_b24_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I9_MP0 (VDD I1_p23_8 I1_I1666_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I10_MP1 (I1_I1620_gn10 I1_b23_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I10_MP0 (VDD I1_p22_9 I1_I1620_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I7_MP1 (I1_I1620_gn7 I1_b23_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I7_MP0 (VDD I1_p22_6 I1_I1620_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I2_MP1 (I1_I1620_gn2 I1_b23_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I2_MP0 (VDD I1_p22_1 I1_I1620_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I1_MP1 (I1_I1620_gn1 I1_b23_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I1_MP0 (VDD I1_p22_0 I1_I1620_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I54_MP1 (I2_I2_nand9 B_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I54_MP0 (VDD A_9 I2_I2_nand9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I191_MP1 (I2_I3_n9_1 I2_OR_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I191_MP0 (VDD I2_I3_SEL_OR_b3_1 I2_I3_n9_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I48_MP1 (I2_I2_nand8 B_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I48_MP0 (VDD A_8 I2_I2_nand8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I26_MP1 (I1_I1758_gn26 I1_b26_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I26_MP0 (VDD I1_p25_25 I1_I1758_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I23_MP1 (I1_I1758_gn23 I1_b26_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I23_MP0 (VDD I1_p25_22 I1_I1758_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I20_MP1 (I1_I1758_gn20 I1_b26_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I20_MP0 (VDD I1_p25_19 I1_I1758_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I21_MP1 (I1_I1758_gn21 I1_b26_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I21_MP0 (VDD I1_p25_20 I1_I1758_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I19_MP1 (I1_I1758_gn19 I1_b26_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I19_MP0 (VDD I1_p25_18 I1_I1758_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I18_MP1 (I1_I1758_gn18 I1_b26_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I18_MP0 (VDD I1_p25_17 I1_I1758_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I16_MP1 (I1_I1758_gn16 I1_b26_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I16_MP0 (VDD I1_p25_15 I1_I1758_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I15_MP1 (I1_I1758_gn15 I1_b26_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I15_MP0 (VDD I1_p25_14 I1_I1758_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I14_MP1 (I1_I1758_gn14 I1_b26_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I14_MP0 (VDD I1_p25_13 I1_I1758_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I13_MP1 (I1_I1758_gn13 I1_b26_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I13_MP0 (VDD I1_p25_12 I1_I1758_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I12_MP1 (I1_I1758_gn12 I1_b26_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I12_MP0 (VDD I1_p25_11 I1_I1758_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I171_XP_MP1 (I1_I1666_P20_5n I1_I1666_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I171_XP_MP0 (VDD I1_I1666_P20_13 I1_I1666_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I175_XP_MP1 (I1_I1666_P24_9n I1_I1666_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I175_XP_MP0 (VDD I1_I1666_P24_17 I1_I1666_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I170_XP_MP1 (I1_I1666_P19_4n I1_I1666_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I170_XP_MP0 (VDD I1_I1666_P19_12 I1_I1666_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I109_XP_MP1 (I1_I1666_P13_10n I1_I1666_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I109_XP_MP0 (VDD I1_I1666_P13_12 I1_I1666_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I107_XP_MP1 (I1_I1666_P11_8n I1_I1666_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I107_XP_MP0 (VDD I1_I1666_P11_10 I1_I1666_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I11_MP1 (I1_I1666_gn11 I1_b24_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I11_MP0 (VDD I1_p23_10 I1_I1666_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I10_MP1 (I1_I1666_gn10 I1_b24_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I10_MP0 (VDD I1_p23_9 I1_I1666_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I15_MP1 (I1_I1620_gn15 I1_b23_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I15_MP0 (VDD I1_p22_14 I1_I1620_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I16_MP1 (I1_I1620_gn16 I1_b23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I16_MP0 (VDD I1_p22_15 I1_I1620_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I14_MP1 (I1_I1620_gn14 I1_b23_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I14_MP0 (VDD I1_p22_13 I1_I1620_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I12_MP1 (I1_I1620_gn12 I1_b23_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I12_MP0 (VDD I1_p22_11 I1_I1620_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I60_MP1 (I2_I2_nand10 B_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I60_MP0 (VDD A_10 I2_I2_nand10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I190_MP1 (I2_I3_n9_0 I2_AND_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I190_MP0 (VDD I2_I3_SEL_AND_b3_1 I2_I3_n9_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I202_MP1 (I2_I3_n10_0 I2_AND_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I202_MP0 (VDD I2_I3_SEL_AND_b3_1 I2_I3_n10_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I196_MP1 (I2_I3_o9_0 I2_I3_n9_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I196_MP0 (VDD I2_I3_n9_0 I2_I3_o9_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I178_MP1 (I2_I3_n8_0 I2_AND_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I178_MP0 (VDD I2_I3_SEL_AND_b3_1 I2_I3_n8_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I42_MP1 (I2_I2_nand7 B_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I42_MP0 (VDD A_7 I2_I2_nand7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I184_MP1 (I2_I3_o8_0 I2_I3_n8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I184_MP0 (VDD I2_I3_n8_0 I2_I3_o8_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I179_MP1 (I2_I3_n8_1 I2_OR_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I179_MP0 (VDD I2_I3_SEL_OR_b3_1 I2_I3_n8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I36_MP1 (I2_I2_nand6 B_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I36_MP0 (VDD A_6 I2_I2_nand6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I31_MP1 (I1_I1758_gn31 I1_b26_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I31_MP0 (VDD I1_p25_30 I1_I1758_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I22_MP1 (I1_I1758_gn22 I1_b26_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I22_MP0 (VDD I1_p25_21 I1_I1758_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I17_MP1 (I1_I1758_gn17 I1_b26_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I17_MP0 (VDD I1_p25_16 I1_I1758_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I11_MP1 (I1_I1758_gn11 I1_b26_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I11_MP0 (VDD I1_p25_10 I1_I1758_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I177_XP_MP1 (I1_I1666_P26_11n I1_I1666_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I177_XP_MP0 (VDD I1_I1666_P26_19 I1_I1666_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I112_XP_MP1 (I1_I1666_P16_13n I1_I1666_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I112_XP_MP0 (VDD I1_I1666_P16_15 I1_I1666_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I110_XP_MP1 (I1_I1666_P14_11n I1_I1666_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I110_XP_MP0 (VDD I1_I1666_P14_13 I1_I1666_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I176_XP_MP1 (I1_I1666_P25_10n I1_I1666_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I176_XP_MP0 (VDD I1_I1666_P25_18 I1_I1666_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I12_MP1 (I1_I1666_gn12 I1_b24_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I12_MP0 (VDD I1_p23_11 I1_I1666_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I13_MP1 (I1_I1666_gn13 I1_b24_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I13_MP0 (VDD I1_p23_12 I1_I1666_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I17_MP1 (I1_I1620_gn17 I1_b23_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I17_MP0 (VDD I1_p22_16 I1_I1620_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I106_XP_MP1 (I1_I1620_P10_7n I1_I1620_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I106_XP_MP0 (VDD I1_I1620_P10_9 I1_I1620_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I104_XP_MP1 (I1_I1620_P8_5n I1_I1620_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I104_XP_MP0 (VDD I1_I1620_P8_7 I1_I1620_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I102_XP_MP1 (I1_I1620_P6_3n I1_I1620_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I102_XP_MP0 (VDD I1_I1620_P6_5 I1_I1620_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I100_XP_MP1 (I1_I1620_P4_1n I1_I1620_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I100_XP_MP0 (VDD I1_I1620_P4_3 I1_I1620_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I208_MP1 (I2_I3_o10_0 I2_I3_n10_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I208_MP0 (VDD I2_I3_n10_0 I2_I3_o10_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I203_MP1 (I2_I3_n10_1 I2_OR_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I203_MP0 (VDD I2_I3_SEL_OR_b3_1 I2_I3_n10_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I166_MP1 (I2_I3_n7_0 I2_AND_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I166_MP0 (VDD I2_I3_SEL_AND_b3_1 I2_I3_n7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I167_MP1 (I2_I3_n7_1 I2_OR_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I167_MP0 (VDD I2_I3_SEL_OR_b3_1 I2_I3_n7_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I172_MP1 (I2_I3_o7_0 I2_I3_n7_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I172_MP0 (VDD I2_I3_n7_0 I2_I3_o7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I154_MP1 (I2_I3_n6_0 I2_AND_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I154_MP0 (VDD I2_I3_SEL_AND_b3_1 I2_I3_n6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I160_MP1 (I2_I3_o6_0 I2_I3_n6_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I160_MP0 (VDD I2_I3_n6_0 I2_I3_o6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I155_MP1 (I2_I3_n6_1 I2_OR_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I155_MP0 (VDD I2_I3_SEL_OR_b3_1 I2_I3_n6_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I2_MP1 (I2_I1_I42_gn2 I2_I1_bx2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I2_MP0 (VDD A_2 I2_I1_I42_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I1_MP1 (I2_I1_I42_gn1 I2_I1_bx1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I1_MP0 (VDD A_1 I2_I1_I42_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I30_MP1 (I1_I1758_gn30 I1_b26_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I30_MP0 (VDD I1_p25_29 I1_I1758_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I125_XP_MP1 (I1_I1758_P29_26n I1_I1758_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I125_XP_MP0 (VDD I1_I1758_P29_28 I1_I1758_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I123_XP_MP1 (I1_I1758_P27_24n I1_I1758_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I123_XP_MP0 (VDD I1_I1758_P27_26 I1_I1758_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I121_XP_MP1 (I1_I1758_P25_22n I1_I1758_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I121_XP_MP0 (VDD I1_I1758_P25_24 I1_I1758_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I119_XP_MP1 (I1_I1758_P23_20n I1_I1758_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I119_XP_MP0 (VDD I1_I1758_P23_22 I1_I1758_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I117_XP_MP1 (I1_I1758_P21_18n I1_I1758_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I117_XP_MP0 (VDD I1_I1758_P21_20 I1_I1758_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I10_MP1 (I1_I1758_gn10 I1_b26_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I10_MP0 (VDD I1_p25_9 I1_I1758_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I8_MP1 (I1_I1758_gn8 I1_b26_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I8_MP0 (VDD I1_p25_7 I1_I1758_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I179_XP_MP1 (I1_I1666_P28_13n I1_I1666_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I179_XP_MP0 (VDD I1_I1666_P28_21 I1_I1666_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I114_XP_MP1 (I1_I1666_P18_15n I1_I1666_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I114_XP_MP0 (VDD I1_I1666_P18_17 I1_I1666_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I178_XP_MP1 (I1_I1666_P27_12n I1_I1666_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I178_XP_MP0 (VDD I1_I1666_P27_20 I1_I1666_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I172_XP_MP1 (I1_I1666_P21_6n I1_I1666_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I172_XP_MP0 (VDD I1_I1666_P21_14 I1_I1666_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I111_XP_MP1 (I1_I1666_P15_12n I1_I1666_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I111_XP_MP0 (VDD I1_I1666_P15_14 I1_I1666_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I113_XP_MP1 (I1_I1666_P17_14n I1_I1666_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I113_XP_MP0 (VDD I1_I1666_P17_16 I1_I1666_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I14_MP1 (I1_I1666_gn14 I1_b24_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I14_MP0 (VDD I1_p23_13 I1_I1666_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I16_MP1 (I1_I1666_gn16 I1_b24_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I16_MP0 (VDD I1_p23_15 I1_I1666_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I169_XP_MP1 (I1_I1620_P18_3n I1_I1620_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I169_XP_MP0 (VDD I1_I1620_P18_11 I1_I1620_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I110_XP_MP1 (I1_I1620_P14_11n I1_I1620_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I110_XP_MP0 (VDD I1_I1620_P14_13 I1_I1620_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I108_XP_MP1 (I1_I1620_P12_9n I1_I1620_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I108_XP_MP0 (VDD I1_I1620_P12_11 I1_I1620_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I103_XP_MP1 (I1_I1620_P7_4n I1_I1620_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I103_XP_MP0 (VDD I1_I1620_P7_6 I1_I1620_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I101_XP_MP1 (I1_I1620_P5_2n I1_I1620_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I101_XP_MP0 (VDD I1_I1620_P5_4 I1_I1620_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I205_MP1 (I2_I3_n10_3 I2_NOT_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I205_MP0 (VDD I2_I3_SEL_NOT_b3_1 I2_I3_n10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I209_MP1 (I2_I3_o10_1 I2_I3_n10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I209_MP0 (VDD I2_I3_n10_2 I2_I3_o10_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I173_MP1 (I2_I3_o7_1 I2_I3_n7_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I173_MP0 (VDD I2_I3_n7_2 I2_I3_o7_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I169_MP1 (I2_I3_n7_3 I2_NOT_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I169_MP0 (VDD I2_I3_SEL_NOT_b3_1 I2_I3_n7_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I168_MP1 (I2_I3_n7_2 I2_XOR_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I168_MP0 (VDD I2_I3_SEL_XOR_b3_1 I2_I3_n7_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I157_MP1 (I2_I3_n6_3 I2_NOT_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I157_MP0 (VDD I2_I3_SEL_NOT_b3_1 I2_I3_n6_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I161_MP1 (I2_I3_o6_1 I2_I3_n6_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I161_MP0 (VDD I2_I3_n6_2 I2_I3_o6_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I127_XP_MP1 (I1_I1758_P31_28n I1_I1758_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I127_XP_MP0 (VDD I1_I1758_P31_30 I1_I1758_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I176_XP_MP1 (I1_I1758_P25_10n I1_I1758_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I176_XP_MP0 (VDD I1_I1758_P25_18 I1_I1758_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I115_XP_MP1 (I1_I1758_P19_16n I1_I1758_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I115_XP_MP0 (VDD I1_I1758_P19_18 I1_I1758_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I113_XP_MP1 (I1_I1758_P17_14n I1_I1758_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I113_XP_MP0 (VDD I1_I1758_P17_16 I1_I1758_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I111_XP_MP1 (I1_I1758_P15_12n I1_I1758_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I111_XP_MP0 (VDD I1_I1758_P15_14 I1_I1758_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I9_MP1 (I1_I1758_gn9 I1_b26_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I9_MP0 (VDD I1_p25_8 I1_I1758_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I7_MP1 (I1_I1758_gn7 I1_b26_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I7_MP0 (VDD I1_p25_6 I1_I1758_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I6_MP1 (I1_I1758_gn6 I1_b26_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I6_MP0 (VDD I1_p25_5 I1_I1758_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I173_XP_MP1 (I1_I1666_P22_7n I1_I1666_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I173_XP_MP0 (VDD I1_I1666_P22_15 I1_I1666_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I116_XP_MP1 (I1_I1666_P20_17n I1_I1666_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I116_XP_MP0 (VDD I1_I1666_P20_19 I1_I1666_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I180_XP_MP1 (I1_I1666_P29_14n I1_I1666_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I180_XP_MP0 (VDD I1_I1666_P29_22 I1_I1666_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I117_XP_MP1 (I1_I1666_P21_18n I1_I1666_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I117_XP_MP0 (VDD I1_I1666_P21_20 I1_I1666_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I115_XP_MP1 (I1_I1666_P19_16n I1_I1666_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I115_XP_MP0 (VDD I1_I1666_P19_18 I1_I1666_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I15_MP1 (I1_I1666_gn15 I1_b24_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I15_MP0 (VDD I1_p23_14 I1_I1666_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I18_MP1 (I1_I1666_gn18 I1_b24_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I18_MP0 (VDD I1_p23_17 I1_I1666_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I17_MP1 (I1_I1666_gn17 I1_b24_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I17_MP0 (VDD I1_p23_16 I1_I1666_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I177_XP_MP1 (I1_I1620_P26_11n I1_I1620_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I177_XP_MP0 (VDD I1_I1620_P26_19 I1_I1620_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I114_XP_MP1 (I1_I1620_P18_15n I1_I1620_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I114_XP_MP0 (VDD I1_I1620_P18_17 I1_I1620_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I112_XP_MP1 (I1_I1620_P16_13n I1_I1620_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I112_XP_MP0 (VDD I1_I1620_P16_15 I1_I1620_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I107_XP_MP1 (I1_I1620_P11_8n I1_I1620_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I107_XP_MP0 (VDD I1_I1620_P11_10 I1_I1620_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I105_XP_MP1 (I1_I1620_P9_6n I1_I1620_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I105_XP_MP0 (VDD I1_I1620_P9_8 I1_I1620_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I167_XP_MP1 (I1_I1620_P16_1n I1_I1620_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I167_XP_MP0 (VDD I1_I1620_P16_9 I1_I1620_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I204_MP1 (I2_I3_n10_2 I2_XOR_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I204_MP0 (VDD I2_I3_SEL_XOR_b3_1 I2_I3_n10_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I197_MP1 (I2_I3_o9_1 I2_I3_n9_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I197_MP0 (VDD I2_I3_n9_2 I2_I3_o9_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I193_MP1 (I2_I3_n9_3 I2_NOT_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I193_MP0 (VDD I2_I3_SEL_NOT_b3_1 I2_I3_n9_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I181_MP1 (I2_I3_n8_3 I2_NOT_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I181_MP0 (VDD I2_I3_SEL_NOT_b3_1 I2_I3_n8_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I156_MP1 (I2_I3_n6_2 I2_XOR_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I156_MP0 (VDD I2_I3_SEL_XOR_b3_1 I2_I3_n6_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I177_MP1 (Y_7 I2_I3_q7_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I177_MP0 (VDD I2_I3_q7_1 Y_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I213_MP1 (Y_10 I2_I3_q10_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I213_MP0 (VDD I2_I3_q10_1 Y_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I0_MP1 (I2_I1_I42_gn0 I2_I1_bx0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I0_MP0 (VDD A_0 I2_I1_I42_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I182_XP_MP1 (I1_I1758_P31_16n I1_I1758_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I182_XP_MP0 (VDD I1_I1758_P31_24 I1_I1758_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I180_XP_MP1 (I1_I1758_P29_14n I1_I1758_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I180_XP_MP0 (VDD I1_I1758_P29_22 I1_I1758_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I174_XP_MP1 (I1_I1758_P23_8n I1_I1758_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I174_XP_MP0 (VDD I1_I1758_P23_16 I1_I1758_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I178_XP_MP1 (I1_I1758_P27_12n I1_I1758_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I178_XP_MP0 (VDD I1_I1758_P27_20 I1_I1758_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I172_XP_MP1 (I1_I1758_P21_6n I1_I1758_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I172_XP_MP0 (VDD I1_I1758_P21_14 I1_I1758_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I170_XP_MP1 (I1_I1758_P19_4n I1_I1758_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I170_XP_MP0 (VDD I1_I1758_P19_12 I1_I1758_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I109_XP_MP1 (I1_I1758_P13_10n I1_I1758_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I109_XP_MP0 (VDD I1_I1758_P13_12 I1_I1758_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I107_XP_MP1 (I1_I1758_P11_8n I1_I1758_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I107_XP_MP0 (VDD I1_I1758_P11_10 I1_I1758_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I105_XP_MP1 (I1_I1758_P9_6n I1_I1758_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I105_XP_MP0 (VDD I1_I1758_P9_8 I1_I1758_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I181_XP_MP1 (I1_I1666_P30_15n I1_I1666_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I181_XP_MP0 (VDD I1_I1666_P30_23 I1_I1666_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I118_XP_MP1 (I1_I1666_P22_19n I1_I1666_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I118_XP_MP0 (VDD I1_I1666_P22_21 I1_I1666_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I174_XP_MP1 (I1_I1666_P23_8n I1_I1666_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I174_XP_MP0 (VDD I1_I1666_P23_16 I1_I1666_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I119_XP_MP1 (I1_I1666_P23_20n I1_I1666_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I119_XP_MP0 (VDD I1_I1666_P23_22 I1_I1666_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I19_MP1 (I1_I1666_gn19 I1_b24_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I19_MP0 (VDD I1_p23_18 I1_I1666_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I173_XP_MP1 (I1_I1620_P22_7n I1_I1620_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I173_XP_MP0 (VDD I1_I1620_P22_15 I1_I1620_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I18_MP1 (I1_I1620_gn18 I1_b23_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I18_MP0 (VDD I1_p22_17 I1_I1620_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I171_XP_MP1 (I1_I1620_P20_5n I1_I1620_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I171_XP_MP0 (VDD I1_I1620_P20_13 I1_I1620_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I111_XP_MP1 (I1_I1620_P15_12n I1_I1620_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I111_XP_MP0 (VDD I1_I1620_P15_14 I1_I1620_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I109_XP_MP1 (I1_I1620_P13_10n I1_I1620_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I109_XP_MP0 (VDD I1_I1620_P13_12 I1_I1620_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I185_MP1 (I2_I3_o8_1 I2_I3_n8_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I185_MP0 (VDD I2_I3_n8_2 I2_I3_o8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I180_MP1 (I2_I3_n8_2 I2_XOR_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I180_MP0 (VDD I2_I3_SEL_XOR_b3_1 I2_I3_n8_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I189_MP1 (Y_8 I2_I3_q8_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I189_MP0 (VDD I2_I3_q8_1 Y_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I201_MP1 (Y_9 I2_I3_q9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I201_MP0 (VDD I2_I3_q9_1 Y_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I210_MP1 (I2_I3_o10_2 I2_I3_n10_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I210_MP0 (VDD I2_I3_n10_4 I2_I3_o10_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I168_XP_MP1 (I1_I1758_P17_2n I1_I1758_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I168_XP_MP0 (VDD I1_I1758_P17_10 I1_I1758_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I103_XP_MP1 (I1_I1758_P7_4n I1_I1758_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I103_XP_MP0 (VDD I1_I1758_P7_6 I1_I1758_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I120_XP_MP1 (I1_I1666_P24_21n I1_I1666_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I120_XP_MP0 (VDD I1_I1666_P24_23 I1_I1666_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I182_XP_MP1 (I1_I1666_P31_16n I1_I1666_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I182_XP_MP0 (VDD I1_I1666_P31_24 I1_I1666_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I121_XP_MP1 (I1_I1666_P25_22n I1_I1666_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I121_XP_MP0 (VDD I1_I1666_P25_24 I1_I1666_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I20_MP1 (I1_I1666_gn20 I1_b24_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I20_MP0 (VDD I1_p23_19 I1_I1666_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I20_MP1 (I1_I1620_gn20 I1_b23_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I20_MP0 (VDD I1_p22_19 I1_I1620_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I19_MP1 (I1_I1620_gn19 I1_b23_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I19_MP0 (VDD I1_p22_18 I1_I1620_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I118_XP_MP1 (I1_I1620_P22_19n I1_I1620_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I118_XP_MP0 (VDD I1_I1620_P22_21 I1_I1620_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I116_XP_MP1 (I1_I1620_P20_17n I1_I1620_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I116_XP_MP0 (VDD I1_I1620_P20_19 I1_I1620_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I175_XP_MP1 (I1_I1620_P24_9n I1_I1620_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I175_XP_MP0 (VDD I1_I1620_P24_17 I1_I1620_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I113_XP_MP1 (I1_I1620_P17_14n I1_I1620_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I113_XP_MP0 (VDD I1_I1620_P17_16 I1_I1620_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I168_XP_MP1 (I1_I1620_P17_2n I1_I1620_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I168_XP_MP0 (VDD I1_I1620_P17_10 I1_I1620_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I171_MP1 (I2_I3_n7_5 DIVQ_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I171_MP0 (VDD I2_I3_SEL_DIV_b3_1 I2_I3_n7_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I195_MP1 (I2_I3_n9_5 DIVQ_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I195_MP0 (VDD I2_I3_SEL_DIV_b3_1 I2_I3_n9_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I30_MP1 (I2_I2_nand5 B_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I30_MP0 (VDD A_5 I2_I2_nand5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I34_MP1 (I2_I4_z1_2 I2_I4_z0_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I34_MP0 (VDD I2_I4_z0_4 I2_I4_z1_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I198_MP1 (I2_I3_o9_2 I2_I3_n9_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I198_MP0 (VDD I2_I3_n9_4 I2_I3_o9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I165_MP1 (Y_6 I2_I3_q6_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I165_MP0 (VDD I2_I3_q6_1 Y_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I174_MP1 (I2_I3_o7_2 I2_I3_n7_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I174_MP0 (VDD I2_I3_n7_4 I2_I3_o7_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I126_XP_MP1 (I1_I1758_P30_27n I1_I1758_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I126_XP_MP0 (VDD I1_I1758_P30_29 I1_I1758_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I124_XP_MP1 (I1_I1758_P28_25n I1_I1758_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I124_XP_MP0 (VDD I1_I1758_P28_27 I1_I1758_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I122_XP_MP1 (I1_I1758_P26_23n I1_I1758_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I122_XP_MP0 (VDD I1_I1758_P26_25 I1_I1758_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I120_XP_MP1 (I1_I1758_P24_21n I1_I1758_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I120_XP_MP0 (VDD I1_I1758_P24_23 I1_I1758_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I118_XP_MP1 (I1_I1758_P22_19n I1_I1758_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I118_XP_MP0 (VDD I1_I1758_P22_21 I1_I1758_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I116_XP_MP1 (I1_I1758_P20_17n I1_I1758_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I116_XP_MP0 (VDD I1_I1758_P20_19 I1_I1758_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I114_XP_MP1 (I1_I1758_P18_15n I1_I1758_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I114_XP_MP0 (VDD I1_I1758_P18_17 I1_I1758_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I112_XP_MP1 (I1_I1758_P16_13n I1_I1758_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I112_XP_MP0 (VDD I1_I1758_P16_15 I1_I1758_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I110_XP_MP1 (I1_I1758_P14_11n I1_I1758_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I110_XP_MP0 (VDD I1_I1758_P14_13 I1_I1758_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I101_XP_MP1 (I1_I1758_P5_2n I1_I1758_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I101_XP_MP0 (VDD I1_I1758_P5_4 I1_I1758_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I5_MP1 (I1_I1758_gn5 I1_b26_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I5_MP0 (VDD I1_p25_4 I1_I1758_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I4_MP1 (I1_I1758_gn4 I1_b26_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I4_MP0 (VDD I1_p25_3 I1_I1758_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I122_XP_MP1 (I1_I1666_P26_23n I1_I1666_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I122_XP_MP0 (VDD I1_I1666_P26_25 I1_I1666_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I124_XP_MP1 (I1_I1666_P28_25n I1_I1666_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I124_XP_MP0 (VDD I1_I1666_P28_27 I1_I1666_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I125_XP_MP1 (I1_I1666_P29_26n I1_I1666_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I125_XP_MP0 (VDD I1_I1666_P29_28 I1_I1666_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I123_XP_MP1 (I1_I1666_P27_24n I1_I1666_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I123_XP_MP0 (VDD I1_I1666_P27_26 I1_I1666_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I22_MP1 (I1_I1666_gn22 I1_b24_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I22_MP0 (VDD I1_p23_21 I1_I1666_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I21_MP1 (I1_I1666_gn21 I1_b24_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I21_MP0 (VDD I1_p23_20 I1_I1666_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I181_XP_MP1 (I1_I1620_P30_15n I1_I1620_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I181_XP_MP0 (VDD I1_I1620_P30_23 I1_I1620_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I179_XP_MP1 (I1_I1620_P28_13n I1_I1620_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I179_XP_MP0 (VDD I1_I1620_P28_21 I1_I1620_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I117_XP_MP1 (I1_I1620_P21_18n I1_I1620_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I117_XP_MP0 (VDD I1_I1620_P21_20 I1_I1620_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I115_XP_MP1 (I1_I1620_P19_16n I1_I1620_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I115_XP_MP0 (VDD I1_I1620_P19_18 I1_I1620_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I170_XP_MP1 (I1_I1620_P19_4n I1_I1620_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I170_XP_MP0 (VDD I1_I1620_P19_12 I1_I1620_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I172_XP_MP1 (I1_I1620_P21_6n I1_I1620_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I172_XP_MP0 (VDD I1_I1620_P21_14 I1_I1620_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I159_MP1 (I2_I3_n6_5 DIVQ_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I159_MP0 (VDD I2_I3_SEL_DIV_b3_1 I2_I3_n6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I183_MP1 (I2_I3_n8_5 DIVQ_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I183_MP0 (VDD I2_I3_SEL_DIV_b3_1 I2_I3_n8_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I143_MP1 (I2_I3_n5_1 I2_OR_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I143_MP0 (VDD I2_I3_SEL_OR_b3_0 I2_I3_n5_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I144_MP1 (I2_I3_n5_2 I2_XOR_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I144_MP0 (VDD I2_I3_SEL_XOR_b3_0 I2_I3_n5_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I148_MP1 (I2_I3_o5_0 I2_I3_n5_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I148_MP0 (VDD I2_I3_n5_0 I2_I3_o5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I142_MP1 (I2_I3_n5_0 I2_AND_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I142_MP0 (VDD I2_I3_SEL_AND_b3_0 I2_I3_n5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I85_MP1 (I2_I3_n0_3 I2_NOT_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I85_MP0 (VDD I2_I3_SEL_NOT_b3_0 I2_I3_n0_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I89_MP1 (I2_I3_o0_1 I2_I3_n0_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I89_MP0 (VDD I2_I3_n0_2 I2_I3_o0_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I84_MP1 (I2_I3_n0_2 I2_XOR_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I84_MP0 (VDD I2_I3_SEL_XOR_b3_0 I2_I3_n0_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I162_MP1 (I2_I3_o6_2 I2_I3_n6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I162_MP0 (VDD I2_I3_n6_4 I2_I3_o6_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I186_MP1 (I2_I3_o8_2 I2_I3_n8_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I186_MP0 (VDD I2_I3_n8_4 I2_I3_o8_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I181_XP_MP1 (I1_I1758_P30_15n I1_I1758_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I181_XP_MP0 (VDD I1_I1758_P30_23 I1_I1758_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I179_XP_MP1 (I1_I1758_P28_13n I1_I1758_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I179_XP_MP0 (VDD I1_I1758_P28_21 I1_I1758_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I177_XP_MP1 (I1_I1758_P26_11n I1_I1758_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I177_XP_MP0 (VDD I1_I1758_P26_19 I1_I1758_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I173_XP_MP1 (I1_I1758_P22_7n I1_I1758_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I173_XP_MP0 (VDD I1_I1758_P22_15 I1_I1758_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I108_XP_MP1 (I1_I1758_P12_9n I1_I1758_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I108_XP_MP0 (VDD I1_I1758_P12_11 I1_I1758_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I106_XP_MP1 (I1_I1758_P10_7n I1_I1758_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I106_XP_MP0 (VDD I1_I1758_P10_9 I1_I1758_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I3_MP1 (I1_I1758_gn3 I1_b26_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I3_MP0 (VDD I1_p25_2 I1_I1758_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I126_XP_MP1 (I1_I1666_P30_27n I1_I1666_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I126_XP_MP0 (VDD I1_I1666_P30_29 I1_I1666_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I127_XP_MP1 (I1_I1666_P31_28n I1_I1666_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I127_XP_MP0 (VDD I1_I1666_P31_30 I1_I1666_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I23_MP1 (I1_I1666_gn23 I1_b24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I23_MP0 (VDD I1_p23_22 I1_I1666_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I21_MP1 (I1_I1620_gn21 I1_b23_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I21_MP0 (VDD I1_p22_20 I1_I1620_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I22_MP1 (I1_I1620_gn22 I1_b23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I22_MP0 (VDD I1_p22_21 I1_I1620_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I120_XP_MP1 (I1_I1620_P24_21n I1_I1620_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I120_XP_MP0 (VDD I1_I1620_P24_23 I1_I1620_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I119_XP_MP1 (I1_I1620_P23_20n I1_I1620_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I119_XP_MP0 (VDD I1_I1620_P23_22 I1_I1620_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I174_XP_MP1 (I1_I1620_P23_8n I1_I1620_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I174_XP_MP0 (VDD I1_I1620_P23_16 I1_I1620_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I176_XP_MP1 (I1_I1620_P25_10n I1_I1620_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I176_XP_MP0 (VDD I1_I1620_P25_18 I1_I1620_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I6_MP1 (I2_I2_nand1 B_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I6_MP0 (VDD A_1 I2_I2_nand1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I94_MP1 (I2_I3_n1_0 I2_AND_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I94_MP0 (VDD I2_I3_SEL_AND_b3_0 I2_I3_n1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I18_MP1 (I2_I2_nand3 B_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I18_MP0 (VDD A_3 I2_I2_nand3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I106_MP1 (I2_I3_n2_0 I2_AND_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I106_MP0 (VDD I2_I3_SEL_AND_b3_0 I2_I3_n2_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I83_MP1 (I2_I3_n0_1 I2_OR_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I83_MP0 (VDD I2_I3_SEL_OR_b3_0 I2_I3_n0_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I12_MP1 (I2_I2_nand2 B_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I12_MP0 (VDD A_2 I2_I2_nand2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I88_MP1 (I2_I3_o0_0 I2_I3_n0_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I88_MP0 (VDD I2_I3_n0_0 I2_I3_o0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I130_MP1 (I2_I3_n4_0 I2_AND_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I130_MP0 (VDD I2_I3_SEL_AND_b3_0 I2_I3_n4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I82_MP1 (I2_I3_n0_0 I2_AND_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I82_MP0 (VDD I2_I3_SEL_AND_b3_0 I2_I3_n0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I24_MP1 (I2_I2_nand4 B_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I24_MP0 (VDD A_4 I2_I2_nand4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I0_MP1 (I2_I2_nand0 B_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I0_MP0 (VDD A_0 I2_I2_nand0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I175_XP_MP1 (I1_I1758_P24_9n I1_I1758_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I175_XP_MP0 (VDD I1_I1758_P24_17 I1_I1758_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I171_XP_MP1 (I1_I1758_P20_5n I1_I1758_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I171_XP_MP0 (VDD I1_I1758_P20_13 I1_I1758_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I169_XP_MP1 (I1_I1758_P18_3n I1_I1758_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I169_XP_MP0 (VDD I1_I1758_P18_11 I1_I1758_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I167_XP_MP1 (I1_I1758_P16_1n I1_I1758_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I167_XP_MP0 (VDD I1_I1758_P16_9 I1_I1758_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I104_XP_MP1 (I1_I1758_P8_5n I1_I1758_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I104_XP_MP0 (VDD I1_I1758_P8_7 I1_I1758_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I102_XP_MP1 (I1_I1758_P6_3n I1_I1758_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I102_XP_MP0 (VDD I1_I1758_P6_5 I1_I1758_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I100_XP_MP1 (I1_I1758_P4_1n I1_I1758_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I100_XP_MP0 (VDD I1_I1758_P4_3 I1_I1758_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I1_MP1 (I1_I1758_gn1 I1_b26_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I1_MP0 (VDD I1_p25_0 I1_I1758_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I2_MP1 (I1_I1758_gn2 I1_b26_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I2_MP0 (VDD I1_p25_1 I1_I1758_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I30_MP1 (I1_I1666_gn30 I1_b24_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I30_MP0 (VDD I1_p23_29 I1_I1666_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I25_MP1 (I1_I1666_gn25 I1_b24_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I25_MP0 (VDD I1_p23_24 I1_I1666_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I24_MP1 (I1_I1666_gn24 I1_b24_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I24_MP0 (VDD I1_p23_23 I1_I1666_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I31_MP1 (I1_I1620_gn31 I1_b23_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I31_MP0 (VDD I1_p22_30 I1_I1620_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I23_MP1 (I1_I1620_gn23 I1_b23_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I23_MP0 (VDD I1_p22_22 I1_I1620_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I122_XP_MP1 (I1_I1620_P26_23n I1_I1620_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I122_XP_MP0 (VDD I1_I1620_P26_25 I1_I1620_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I121_XP_MP1 (I1_I1620_P25_22n I1_I1620_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I121_XP_MP0 (VDD I1_I1620_P25_24 I1_I1620_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I182_XP_MP1 (I1_I1620_P31_16n I1_I1620_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I182_XP_MP0 (VDD I1_I1620_P31_24 I1_I1620_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I100_MP1 (I2_I3_o1_0 I2_I3_n1_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I100_MP0 (VDD I2_I3_n1_0 I2_I3_o1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I95_MP1 (I2_I3_n1_1 I2_OR_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I95_MP0 (VDD I2_I3_SEL_OR_b3_0 I2_I3_n1_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I119_MP1 (I2_I3_n3_1 I2_OR_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I119_MP0 (VDD I2_I3_SEL_OR_b3_0 I2_I3_n3_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I107_MP1 (I2_I3_n2_1 I2_OR_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I107_MP0 (VDD I2_I3_SEL_OR_b3_0 I2_I3_n2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I112_MP1 (I2_I3_o2_0 I2_I3_n2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I112_MP0 (VDD I2_I3_n2_0 I2_I3_o2_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I131_MP1 (I2_I3_n4_1 I2_OR_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I131_MP0 (VDD I2_I3_SEL_OR_b3_0 I2_I3_n4_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I136_MP1 (I2_I3_o4_0 I2_I3_n4_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I136_MP0 (VDD I2_I3_n4_0 I2_I3_o4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I93_MP1 (Y_0 I2_I3_q0_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I93_MP0 (VDD I2_I3_q0_1 Y_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I153_MP1 (Y_5 I2_I3_q5_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I153_MP0 (VDD I2_I3_q5_1 Y_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I30_MP1 (I1_I1804_gn30 I1_b27_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I30_MP0 (VDD I1_p26_29 I1_I1804_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I15_MP1 (I1_I1804_gn15 I1_b27_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I15_MP0 (VDD I1_p26_14 I1_I1804_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I13_MP1 (I1_I1804_gn13 I1_b27_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I13_MP0 (VDD I1_p26_12 I1_I1804_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I12_MP1 (I1_I1804_gn12 I1_b27_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I12_MP0 (VDD I1_p26_11 I1_I1804_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I10_MP1 (I1_I1804_gn10 I1_b27_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I10_MP0 (VDD I1_p26_9 I1_I1804_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I0_MP1 (I1_I1758_gn0 I1_b26_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I0_MP0 (VDD I1_aa5 I1_I1758_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I31_MP1 (I1_I1666_gn31 I1_b24_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I31_MP0 (VDD I1_p23_30 I1_I1666_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I28_MP1 (I1_I1666_gn28 I1_b24_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I28_MP0 (VDD I1_p23_27 I1_I1666_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I26_MP1 (I1_I1666_gn26 I1_b24_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I26_MP0 (VDD I1_p23_25 I1_I1666_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I30_MP1 (I1_I1620_gn30 I1_b23_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I30_MP0 (VDD I1_p22_29 I1_I1620_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I25_MP1 (I1_I1620_gn25 I1_b23_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I25_MP0 (VDD I1_p22_24 I1_I1620_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I126_XP_MP1 (I1_I1620_P30_27n I1_I1620_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I126_XP_MP0 (VDD I1_I1620_P30_29 I1_I1620_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I124_XP_MP1 (I1_I1620_P28_25n I1_I1620_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I124_XP_MP0 (VDD I1_I1620_P28_27 I1_I1620_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I24_MP1 (I1_I1620_gn24 I1_b23_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I24_MP0 (VDD I1_p22_23 I1_I1620_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I123_XP_MP1 (I1_I1620_P27_24n I1_I1620_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I123_XP_MP0 (VDD I1_I1620_P27_26 I1_I1620_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I178_XP_MP1 (I1_I1620_P27_12n I1_I1620_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I178_XP_MP0 (VDD I1_I1620_P27_20 I1_I1620_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I180_XP_MP1 (I1_I1620_P29_14n I1_I1620_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I180_XP_MP0 (VDD I1_I1620_P29_22 I1_I1620_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I101_MP1 (I2_I3_o1_1 I2_I3_n1_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I101_MP0 (VDD I2_I3_n1_2 I2_I3_o1_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I96_MP1 (I2_I3_n1_2 I2_XOR_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I96_MP0 (VDD I2_I3_SEL_XOR_b3_0 I2_I3_n1_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I109_MP1 (I2_I3_n2_3 I2_NOT_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I109_MP0 (VDD I2_I3_SEL_NOT_b3_0 I2_I3_n2_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I133_MP1 (I2_I3_n4_3 I2_NOT_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I133_MP0 (VDD I2_I3_SEL_NOT_b3_0 I2_I3_n4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I132_MP1 (I2_I3_n4_2 I2_XOR_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I132_MP0 (VDD I2_I3_SEL_XOR_b3_0 I2_I3_n4_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I137_MP1 (I2_I3_o4_1 I2_I3_n4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I137_MP0 (VDD I2_I3_n4_2 I2_I3_o4_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I141_MP1 (Y_4 I2_I3_q4_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I141_MP0 (VDD I2_I3_q4_1 Y_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I0_MP1 (I0_I1660_gn0 I0_B_1_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I0_MP0 (VDD I0_pp0_0 I0_I1660_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I26_MP1 (I1_I1804_gn26 I1_b27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I26_MP0 (VDD I1_p26_25 I1_I1804_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I24_MP1 (I1_I1804_gn24 I1_b27_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I24_MP0 (VDD I1_p26_23 I1_I1804_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I23_MP1 (I1_I1804_gn23 I1_b27_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I23_MP0 (VDD I1_p26_22 I1_I1804_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I22_MP1 (I1_I1804_gn22 I1_b27_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I22_MP0 (VDD I1_p26_21 I1_I1804_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I21_MP1 (I1_I1804_gn21 I1_b27_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I21_MP0 (VDD I1_p26_20 I1_I1804_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I19_MP1 (I1_I1804_gn19 I1_b27_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I19_MP0 (VDD I1_p26_18 I1_I1804_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I18_MP1 (I1_I1804_gn18 I1_b27_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I18_MP0 (VDD I1_p26_17 I1_I1804_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I17_MP1 (I1_I1804_gn17 I1_b27_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I17_MP0 (VDD I1_p26_16 I1_I1804_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I16_MP1 (I1_I1804_gn16 I1_b27_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I16_MP0 (VDD I1_p26_15 I1_I1804_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I14_MP1 (I1_I1804_gn14 I1_b27_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I14_MP0 (VDD I1_p26_13 I1_I1804_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I9_MP1 (I1_I1804_gn9 I1_b27_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I9_MP0 (VDD I1_p26_8 I1_I1804_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I8_MP1 (I1_I1804_gn8 I1_b27_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I8_MP0 (VDD I1_p26_7 I1_I1804_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I6_MP1 (I1_I1804_gn6 I1_b27_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I6_MP0 (VDD I1_p26_5 I1_I1804_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I7_MP1 (I1_I1804_gn7 I1_b27_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I7_MP0 (VDD I1_p26_6 I1_I1804_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I5_MP1 (I1_I1804_gn5 I1_b27_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I5_MP0 (VDD I1_p26_4 I1_I1804_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I4_MP1 (I1_I1804_gn4 I1_b27_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I4_MP0 (VDD I1_p26_3 I1_I1804_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I29_MP1 (I1_I1666_gn29 I1_b24_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I29_MP0 (VDD I1_p23_28 I1_I1666_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I27_MP1 (I1_I1666_gn27 I1_b24_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I27_MP0 (VDD I1_p23_26 I1_I1666_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I28_MP1 (I1_I1620_gn28 I1_b23_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I28_MP0 (VDD I1_p22_27 I1_I1620_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I26_MP1 (I1_I1620_gn26 I1_b23_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I26_MP0 (VDD I1_p22_25 I1_I1620_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I127_XP_MP1 (I1_I1620_P31_28n I1_I1620_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I127_XP_MP0 (VDD I1_I1620_P31_30 I1_I1620_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I125_XP_MP1 (I1_I1620_P29_26n I1_I1620_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I125_XP_MP0 (VDD I1_I1620_P29_28 I1_I1620_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I36_MP1 (I1_nakn1 A_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I36_MP0 (VDD I1_A_31_b3_0 I1_nakn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I97_MP1 (I2_I3_n1_3 I2_NOT_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I97_MP0 (VDD I2_I3_SEL_NOT_b3_0 I2_I3_n1_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I121_MP1 (I2_I3_n3_3 I2_NOT_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I121_MP0 (VDD I2_I3_SEL_NOT_b3_0 I2_I3_n3_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I113_MP1 (I2_I3_o2_1 I2_I3_n2_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I113_MP0 (VDD I2_I3_n2_2 I2_I3_o2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I108_MP1 (I2_I3_n2_2 I2_XOR_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I108_MP0 (VDD I2_I3_SEL_XOR_b3_0 I2_I3_n2_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I147_MP1 (I2_I3_n5_5 DIVQ_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I147_MP0 (VDD I2_I3_SEL_DIV_b3_0 I2_I3_n5_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I117_MP1 (Y_2 I2_I3_q2_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I117_MP0 (VDD I2_I3_q2_1 Y_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I129_MP1 (Y_3 I2_I3_q3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I129_MP0 (VDD I2_I3_q3_1 Y_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I105_MP1 (Y_1 I2_I3_q1_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I105_MP0 (VDD I2_I3_q1_1 Y_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I150_MP1 (I2_I3_o5_2 I2_I3_n5_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I150_MP0 (VDD I2_I3_n5_4 I2_I3_o5_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I27_MP1 (I1_I1804_gn27 I1_b27_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I27_MP0 (VDD I1_p26_26 I1_I1804_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I25_MP1 (I1_I1804_gn25 I1_b27_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I25_MP0 (VDD I1_p26_24 I1_I1804_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I20_MP1 (I1_I1804_gn20 I1_b27_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I20_MP0 (VDD I1_p26_19 I1_I1804_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I11_MP1 (I1_I1804_gn11 I1_b27_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I11_MP0 (VDD I1_p26_10 I1_I1804_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I3_MP1 (I1_I1804_gn3 I1_b27_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I3_MP0 (VDD I1_p26_2 I1_I1804_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I2_MP1 (I1_I1804_gn2 I1_b27_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I2_MP0 (VDD I1_p26_1 I1_I1804_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I1_MP1 (I1_I1804_gn1 I1_b27_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I1_MP0 (VDD I1_p26_0 I1_I1804_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I0_MP1 (I1_I1804_gn0 I1_b27_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I0_MP0 (VDD I1_aa4 I1_I1804_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I0_MP1 (I1_I1850_gn0 I1_b28_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I0_MP0 (VDD I1_aa3 I1_I1850_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I29_MP1 (I1_I1620_gn29 I1_b23_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I29_MP0 (VDD I1_p22_28 I1_I1620_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I27_MP1 (I1_I1620_gn27 I1_b23_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I27_MP0 (VDD I1_p22_26 I1_I1620_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I0_MP1 (I1_I1896_gn0 I1_b29_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I0_MP0 (VDD I1_aa2 I1_I1896_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I0_MP1 (I1_I1942_gn0 I1_b30_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I0_MP0 (VDD I1_aa1 I1_I1942_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2078_MP1 (I1_nqkn1 DIVQ_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2078_MP0 (VDD I1_sq_b3_0 I1_nqkn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I87_MP1 (I2_I3_n0_5 DIVQ_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I87_MP0 (VDD I2_I3_SEL_DIV_b3_0 I2_I3_n0_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I111_MP1 (I2_I3_n2_5 DIVQ_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I111_MP0 (VDD I2_I3_SEL_DIV_b3_0 I2_I3_n2_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I56_MP1 (I2_I4_z3_0 I2_I4_z2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I56_MP0 (VDD I2_I4_z2_0 I2_I4_z3_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I114_MP1 (I2_I3_o2_2 I2_I3_n2_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I114_MP0 (VDD I2_I3_n2_4 I2_I3_o2_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I90_MP1 (I2_I3_o0_2 I2_I3_n0_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I90_MP0 (VDD I2_I3_n0_4 I2_I3_o0_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I86_MP1 (I2_I3_n0_4 MULP_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I86_MP0 (VDD I2_I3_SEL_MUL_b3_0 I2_I3_n0_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I230_MP1 (I2_I3_n12_4 MULP_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I230_MP0 (VDD I2_I3_SEL_MUL_b3_2 I2_I3_n12_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I11_MP1 (I0_I1660_gn11 I0_ha255_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I11_MP0 (VDD I0_ha254_1 I0_I1660_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I242_MP1 (I2_I3_n13_4 MULP_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I242_MP0 (VDD I2_I3_SEL_MUL_b3_2 I2_I3_n13_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I12_MP1 (I0_I1660_gn12 I0_ha256_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I12_MP0 (VDD I0_ha255_1 I0_I1660_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I266_MP1 (I2_I3_n15_4 MULP_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I266_MP0 (VDD I2_I3_SEL_MUL_b3_2 I2_I3_n15_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I290_MP1 (I2_I3_n17_4 MULP_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I290_MP0 (VDD I2_I3_SEL_MUL_b3_2 I2_I3_n17_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I278_MP1 (I2_I3_n16_4 MULP_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I278_MP0 (VDD I2_I3_SEL_MUL_b3_2 I2_I3_n16_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I16_MP1 (I0_I1660_gn16 I0_ha260_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I16_MP0 (VDD I0_ha259_1 I0_I1660_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I302_MP1 (I2_I3_n18_4 MULP_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I302_MP0 (VDD I2_I3_SEL_MUL_b3_3 I2_I3_n18_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I314_MP1 (I2_I3_n19_4 MULP_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I314_MP0 (VDD I2_I3_SEL_MUL_b3_3 I2_I3_n19_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I326_MP1 (I2_I3_n20_4 MULP_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I326_MP0 (VDD I2_I3_SEL_MUL_b3_3 I2_I3_n20_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I338_MP1 (I2_I3_n21_4 MULP_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I338_MP0 (VDD I2_I3_SEL_MUL_b3_3 I2_I3_n21_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I362_MP1 (I2_I3_n23_4 MULP_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I362_MP0 (VDD I2_I3_SEL_MUL_b3_3 I2_I3_n23_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I350_MP1 (I2_I3_n22_4 MULP_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I350_MP0 (VDD I2_I3_SEL_MUL_b3_3 I2_I3_n22_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I31_MP1 (I1_I1804_gn31 I1_b27_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I31_MP0 (VDD I1_p26_30 I1_I1804_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I28_MP1 (I1_I1804_gn28 I1_b27_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I28_MP0 (VDD I1_p26_27 I1_I1804_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I120_XP_MP1 (I1_I1804_P24_21n I1_I1804_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I120_XP_MP0 (VDD I1_I1804_P24_23 I1_I1804_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I118_XP_MP1 (I1_I1804_P22_19n I1_I1804_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I118_XP_MP0 (VDD I1_I1804_P22_21 I1_I1804_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I116_XP_MP1 (I1_I1804_P20_17n I1_I1804_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I116_XP_MP0 (VDD I1_I1804_P20_19 I1_I1804_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I114_XP_MP1 (I1_I1804_P18_15n I1_I1804_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I114_XP_MP0 (VDD I1_I1804_P18_17 I1_I1804_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I112_XP_MP1 (I1_I1804_P16_13n I1_I1804_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I112_XP_MP0 (VDD I1_I1804_P16_15 I1_I1804_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I110_XP_MP1 (I1_I1804_P14_11n I1_I1804_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I110_XP_MP0 (VDD I1_I1804_P14_13 I1_I1804_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I108_XP_MP1 (I1_I1804_P12_9n I1_I1804_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I108_XP_MP0 (VDD I1_I1804_P12_11 I1_I1804_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I106_XP_MP1 (I1_I1804_P10_7n I1_I1804_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I106_XP_MP0 (VDD I1_I1804_P10_9 I1_I1804_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I1_MP1 (I1_I1850_gn1 I1_b28_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I1_MP0 (VDD I1_p27_0 I1_I1850_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I1_MP1 (I1_I1896_gn1 I1_b29_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I1_MP0 (VDD I1_p28_0 I1_I1896_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I2_MP1 (I1_I1942_gn2 I1_b30_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I2_MP0 (VDD I1_p29_1 I1_I1942_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I1_MP1 (I1_I1942_gn1 I1_b30_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I1_MP0 (VDD I1_p29_0 I1_I1942_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2006_MP1 (I1_dmn2 I1_p31_32_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2006_MP0 (VDD I1_dd2_b3_5 I1_dmn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2002_MP1 (I1_dmn0 I1_p31_32_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2002_MP0 (VDD I1_B_0_b3_5 I1_dmn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I123_MP1 (I2_I3_n3_5 DIVQ_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I123_MP0 (VDD I2_I3_SEL_DIV_b3_0 I2_I3_n3_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I99_MP1 (I2_I3_n1_5 DIVQ_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I99_MP0 (VDD I2_I3_SEL_DIV_b3_0 I2_I3_n1_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I135_MP1 (I2_I3_n4_5 DIVQ_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I135_MP0 (VDD I2_I3_SEL_DIV_b3_0 I2_I3_n4_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I32_MP1 (I2_I4_z1_0 I2_I4_z0_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I32_MP0 (VDD I2_I4_z0_0 I2_I4_z1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I33_MP1 (I2_I4_z1_1 I2_I4_z0_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I33_MP0 (VDD I2_I4_z0_2 I2_I4_z1_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I126_MP1 (I2_I3_o3_2 I2_I3_n3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I126_MP0 (VDD I2_I3_n3_4 I2_I3_o3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I134_MP1 (I2_I3_n4_4 MULP_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I134_MP0 (VDD I2_I3_SEL_MUL_b3_0 I2_I3_n4_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I110_MP1 (I2_I3_n2_4 MULP_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I110_MP0 (VDD I2_I3_SEL_MUL_b3_0 I2_I3_n2_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I218_MP1 (I2_I3_n11_4 MULP_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I218_MP0 (VDD I2_I3_SEL_MUL_b3_1 I2_I3_n11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I158_MP1 (I2_I3_n6_4 MULP_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I158_MP0 (VDD I2_I3_SEL_MUL_b3_1 I2_I3_n6_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I182_MP1 (I2_I3_n8_4 MULP_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I182_MP0 (VDD I2_I3_SEL_MUL_b3_1 I2_I3_n8_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I194_MP1 (I2_I3_n9_4 MULP_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I194_MP0 (VDD I2_I3_SEL_MUL_b3_1 I2_I3_n9_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I6_MP1 (I0_I1660_gn6 I0_ha250_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I6_MP0 (VDD I0_fa249_1 I0_I1660_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I7_MP1 (I0_I1660_gn7 I0_ha251_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I7_MP0 (VDD I0_ha250_1 I0_I1660_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I8_MP1 (I0_I1660_gn8 I0_ha252_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I8_MP0 (VDD I0_ha251_1 I0_I1660_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I9_MP1 (I0_I1660_gn9 I0_ha253_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I9_MP0 (VDD I0_ha252_1 I0_I1660_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I10_MP1 (I0_I1660_gn10 I0_ha254_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I10_MP0 (VDD I0_ha253_1 I0_I1660_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I13_MP1 (I0_I1660_gn13 I0_ha257_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I13_MP0 (VDD I0_ha256_1 I0_I1660_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I14_MP1 (I0_I1660_gn14 I0_ha258_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I14_MP0 (VDD I0_ha257_1 I0_I1660_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I254_MP1 (I2_I3_n14_4 MULP_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I254_MP0 (VDD I2_I3_SEL_MUL_b3_2 I2_I3_n14_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I15_MP1 (I0_I1660_gn15 I0_ha259_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I15_MP0 (VDD I0_ha258_1 I0_I1660_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I17_MP1 (I0_I1660_gn17 I0_ha261_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I17_MP0 (VDD I0_ha260_1 I0_I1660_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I19_MP1 (I0_I1660_gn19 I0_ha263_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I19_MP0 (VDD I0_ha262_1 I0_I1660_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I20_MP1 (I0_I1660_gn20 I0_ha264_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I20_MP0 (VDD I0_ha263_1 I0_I1660_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I22_MP1 (I0_I1660_gn22 I0_ha266_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I22_MP0 (VDD I0_ha265_1 I0_I1660_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I23_MP1 (I0_I1660_gn23 I0_ha267_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I23_MP0 (VDD I0_ha266_1 I0_I1660_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I398_MP1 (I2_I3_n26_4 MULP_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I398_MP0 (VDD I2_I3_SEL_MUL_b3_4 I2_I3_n26_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I29_MP1 (I1_I1804_gn29 I1_b27_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I29_MP0 (VDD I1_p26_28 I1_I1804_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I124_XP_MP1 (I1_I1804_P28_25n I1_I1804_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I124_XP_MP0 (VDD I1_I1804_P28_27 I1_I1804_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I122_XP_MP1 (I1_I1804_P26_23n I1_I1804_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I122_XP_MP0 (VDD I1_I1804_P26_25 I1_I1804_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I177_XP_MP1 (I1_I1804_P26_11n I1_I1804_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I177_XP_MP0 (VDD I1_I1804_P26_19 I1_I1804_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I171_XP_MP1 (I1_I1804_P20_5n I1_I1804_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I171_XP_MP0 (VDD I1_I1804_P20_13 I1_I1804_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I175_XP_MP1 (I1_I1804_P24_9n I1_I1804_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I175_XP_MP0 (VDD I1_I1804_P24_17 I1_I1804_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I167_XP_MP1 (I1_I1804_P16_1n I1_I1804_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I167_XP_MP0 (VDD I1_I1804_P16_9 I1_I1804_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I104_XP_MP1 (I1_I1804_P8_5n I1_I1804_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I104_XP_MP0 (VDD I1_I1804_P8_7 I1_I1804_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I102_XP_MP1 (I1_I1804_P6_3n I1_I1804_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I102_XP_MP0 (VDD I1_I1804_P6_5 I1_I1804_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I100_XP_MP1 (I1_I1804_P4_1n I1_I1804_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I100_XP_MP0 (VDD I1_I1804_P4_3 I1_I1804_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I2_MP1 (I1_I1850_gn2 I1_b28_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I2_MP0 (VDD I1_p27_1 I1_I1850_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I3_MP1 (I1_I1896_gn3 I1_b29_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I3_MP0 (VDD I1_p28_2 I1_I1896_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I2_MP1 (I1_I1896_gn2 I1_b29_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I2_MP0 (VDD I1_p28_1 I1_I1896_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I4_MP1 (I1_I1942_gn4 I1_b30_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I4_MP0 (VDD I1_p29_3 I1_I1942_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I3_MP1 (I1_I1942_gn3 I1_b30_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I3_MP0 (VDD I1_p29_2 I1_I1942_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I4_MP1 (I1_I1988_gn4 I1_b31_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I4_MP0 (VDD I1_p30_3 I1_I1988_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I3_MP1 (I1_I1988_gn3 I1_b31_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I3_MP0 (VDD I1_p30_2 I1_I1988_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I2_MP1 (I1_I1988_gn2 I1_b31_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I2_MP0 (VDD I1_p30_1 I1_I1988_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2008_MP1 (I1_dmn3 I1_p31_32_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2008_MP0 (VDD I1_dd3_b3_5 I1_dmn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I1_MP1 (I1_I1988_gn1 I1_b31_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I1_MP0 (VDD I1_p30_0 I1_I1988_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2004_MP1 (I1_dmn1 I1_p31_32_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2004_MP0 (VDD I1_dd1_b3_5 I1_dmn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I0_MP1 (I1_I1988_gn0 I1_b31_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I0_MP0 (VDD A_0 I1_I1988_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I0_MP1 (I1_I2066_gn0 I1_dm0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I0_MP0 (VDD I1_p31_0 I1_I2066_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I122_MP1 (I2_I3_n3_4 MULP_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I122_MP0 (VDD I2_I3_SEL_MUL_b3_0 I2_I3_n3_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I206_MP1 (I2_I3_n10_4 MULP_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I206_MP0 (VDD I2_I3_SEL_MUL_b3_1 I2_I3_n10_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I170_MP1 (I2_I3_n7_4 MULP_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I170_MP0 (VDD I2_I3_SEL_MUL_b3_1 I2_I3_n7_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I5_MP1 (I0_I1660_gn5 VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I5_MP0 (VDD I0_fa249_0 I0_I1660_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I18_MP1 (I0_I1660_gn18 I0_ha262_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I18_MP0 (VDD I0_ha261_1 I0_I1660_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I21_MP1 (I0_I1660_gn21 I0_ha265_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I21_MP0 (VDD I0_ha264_1 I0_I1660_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I374_MP1 (I2_I3_n24_4 MULP_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I374_MP0 (VDD I2_I3_SEL_MUL_b3_4 I2_I3_n24_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I386_MP1 (I2_I3_n25_4 MULP_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I386_MP0 (VDD I2_I3_SEL_MUL_b3_4 I2_I3_n25_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I24_MP1 (I0_I1660_gn24 I0_ha268_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I24_MP0 (VDD I0_ha267_1 I0_I1660_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I25_MP1 (I0_I1660_gn25 I0_ha269_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I25_MP0 (VDD I0_ha268_1 I0_I1660_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I410_MP1 (I2_I3_n27_4 MULP_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I410_MP0 (VDD I2_I3_SEL_MUL_b3_4 I2_I3_n27_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I422_MP1 (I2_I3_n28_4 MULP_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I422_MP0 (VDD I2_I3_SEL_MUL_b3_4 I2_I3_n28_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I434_MP1 (I2_I3_n29_4 MULP_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I434_MP0 (VDD I2_I3_SEL_MUL_b3_4 I2_I3_n29_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I26_MP1 (I0_I1660_gn26 I0_ha270_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I26_MP0 (VDD I0_ha269_1 I0_I1660_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I27_MP1 (I0_I1660_gn27 I0_ha271_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I27_MP0 (VDD I0_ha270_1 I0_I1660_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I28_MP1 (I0_I1660_gn28 I0_ha272_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I28_MP0 (VDD I0_ha271_1 I0_I1660_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I126_XP_MP1 (I1_I1804_P30_27n I1_I1804_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I126_XP_MP0 (VDD I1_I1804_P30_29 I1_I1804_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I181_XP_MP1 (I1_I1804_P30_15n I1_I1804_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I181_XP_MP0 (VDD I1_I1804_P30_23 I1_I1804_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I179_XP_MP1 (I1_I1804_P28_13n I1_I1804_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I179_XP_MP0 (VDD I1_I1804_P28_21 I1_I1804_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I173_XP_MP1 (I1_I1804_P22_7n I1_I1804_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I173_XP_MP0 (VDD I1_I1804_P22_15 I1_I1804_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I169_XP_MP1 (I1_I1804_P18_3n I1_I1804_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I169_XP_MP0 (VDD I1_I1804_P18_11 I1_I1804_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I4_MP1 (I1_I1850_gn4 I1_b28_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I4_MP0 (VDD I1_p27_3 I1_I1850_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I3_MP1 (I1_I1850_gn3 I1_b28_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I3_MP0 (VDD I1_p27_2 I1_I1850_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I4_MP1 (I1_I1896_gn4 I1_b29_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I4_MP0 (VDD I1_p28_3 I1_I1896_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I5_MP1 (I1_I1942_gn5 I1_b30_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I5_MP0 (VDD I1_p29_4 I1_I1942_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I6_MP1 (I1_I1942_gn6 I1_b30_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I6_MP0 (VDD I1_p29_5 I1_I1942_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I101_XP_MP1 (I1_I1942_P5_2n I1_I1942_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I101_XP_MP0 (VDD I1_I1942_P5_4 I1_I1942_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I102_XP_MP1 (I1_I1942_P6_3n I1_I1942_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I102_XP_MP0 (VDD I1_I1942_P6_5 I1_I1942_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I100_XP_MP1 (I1_I1942_P4_1n I1_I1942_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I100_XP_MP0 (VDD I1_I1942_P4_3 I1_I1942_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I7_MP1 (I1_I1988_gn7 I1_b31_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I7_MP0 (VDD I1_p30_6 I1_I1988_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I5_MP1 (I1_I1988_gn5 I1_b31_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I5_MP0 (VDD I1_p30_4 I1_I1988_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I6_MP1 (I1_I1988_gn6 I1_b31_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I6_MP0 (VDD I1_p30_5 I1_I1988_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2010_MP1 (I1_dmn4 I1_p31_32_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2010_MP0 (VDD I1_dd4_b3_5 I1_dmn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I100_XP_MP1 (I1_I1988_P4_1n I1_I1988_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I100_XP_MP0 (VDD I1_I1988_P4_3 I1_I1988_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I2_MP1 (I1_I2066_gn2 I1_dm2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I2_MP0 (VDD I1_p31_2 I1_I2066_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I1_MP1 (I1_I2066_gn1 I1_dm1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I1_MP0 (VDD I1_p31_1 I1_I2066_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I1_MP1 (I0_I1660_gn1 VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I1_MP0 (VDD I0_pp0_1 I0_I1660_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I4_MP1 (I0_I1660_gn4 VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I4_MP0 (VDD I0_fa209_0 I0_I1660_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I203_XP_MP1 (I0_I1660_P11_8n I0_I1660_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I203_XP_MP0 (VDD I0_I1660_P11_10 I0_I1660_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I205_XP_MP1 (I0_I1660_P13_10n I0_I1660_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I205_XP_MP0 (VDD I0_I1660_P13_12 I0_I1660_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I211_XP_MP1 (I0_I1660_P19_16n I0_I1660_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I211_XP_MP0 (VDD I0_I1660_P19_18 I0_I1660_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I213_XP_MP1 (I0_I1660_P21_18n I0_I1660_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I213_XP_MP0 (VDD I0_I1660_P21_20 I0_I1660_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I215_XP_MP1 (I0_I1660_P23_20n I0_I1660_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I215_XP_MP0 (VDD I0_I1660_P23_22 I0_I1660_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I217_XP_MP1 (I0_I1660_P25_22n I0_I1660_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I217_XP_MP0 (VDD I0_I1660_P25_24 I0_I1660_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I219_XP_MP1 (I0_I1660_P27_24n I0_I1660_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I219_XP_MP0 (VDD I0_I1660_P27_26 I0_I1660_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I103_XP_MP1 (I1_I1804_P7_4n I1_I1804_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I103_XP_MP0 (VDD I1_I1804_P7_6 I1_I1804_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I101_XP_MP1 (I1_I1804_P5_2n I1_I1804_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I101_XP_MP0 (VDD I1_I1804_P5_4 I1_I1804_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I5_MP1 (I1_I1850_gn5 I1_b28_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I5_MP0 (VDD I1_p27_4 I1_I1850_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I5_MP1 (I1_I1896_gn5 I1_b29_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I5_MP0 (VDD I1_p28_4 I1_I1896_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I101_XP_MP1 (I1_I1896_P5_2n I1_I1896_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I101_XP_MP0 (VDD I1_I1896_P5_4 I1_I1896_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I100_XP_MP1 (I1_I1896_P4_1n I1_I1896_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I100_XP_MP0 (VDD I1_I1896_P4_3 I1_I1896_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I7_MP1 (I1_I1942_gn7 I1_b30_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I7_MP0 (VDD I1_p29_6 I1_I1942_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I103_XP_MP1 (I1_I1942_P7_4n I1_I1942_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I103_XP_MP0 (VDD I1_I1942_P7_6 I1_I1942_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I104_XP_MP1 (I1_I1942_P8_5n I1_I1942_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I104_XP_MP0 (VDD I1_I1942_P8_7 I1_I1942_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I167_XP_MP1 (I1_I1942_P16_1n I1_I1942_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I167_XP_MP0 (VDD I1_I1942_P16_9 I1_I1942_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2014_MP1 (I1_dmn6 I1_p31_32_b3_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2014_MP0 (VDD I1_dd6_b3_5 I1_dmn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2012_MP1 (I1_dmn5 I1_p31_32_b3_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2012_MP0 (VDD I1_dd5_b3_5 I1_dmn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I105_XP_MP1 (I1_I1988_P9_6n I1_I1988_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I105_XP_MP0 (VDD I1_I1988_P9_8 I1_I1988_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I103_XP_MP1 (I1_I1988_P7_4n I1_I1988_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I103_XP_MP0 (VDD I1_I1988_P7_6 I1_I1988_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I101_XP_MP1 (I1_I1988_P5_2n I1_I1988_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I101_XP_MP0 (VDD I1_I1988_P5_4 I1_I1988_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I102_XP_MP1 (I1_I1988_P6_3n I1_I1988_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I102_XP_MP0 (VDD I1_I1988_P6_5 I1_I1988_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I104_XP_MP1 (I1_I1988_P8_5n I1_I1988_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I104_XP_MP0 (VDD I1_I1988_P8_7 I1_I1988_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I4_MP1 (I1_I2066_gn4 I1_dm4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I4_MP0 (VDD I1_p31_4 I1_I2066_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I3_MP1 (I1_I2066_gn3 I1_dm3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I3_MP0 (VDD I1_p31_3 I1_I2066_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I2_MP1 (I0_I1660_gn2 VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I2_MP0 (VDD I0_fa1_0 I0_I1660_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I3_MP1 (I0_I1660_gn3 VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I3_MP0 (VDD I0_fa137_0 I0_I1660_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I199_XP_MP1 (I0_I1660_P7_4n I0_I1660_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I199_XP_MP0 (VDD I0_I1660_P7_6 I0_I1660_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I197_XP_MP1 (I0_I1660_P5_2n I0_I1660_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I197_XP_MP0 (VDD I0_I1660_P5_4 I0_I1660_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I201_XP_MP1 (I0_I1660_P9_6n I0_I1660_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I201_XP_MP0 (VDD I0_I1660_P9_8 I0_I1660_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I207_XP_MP1 (I0_I1660_P15_12n I0_I1660_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I207_XP_MP0 (VDD I0_I1660_P15_14 I0_I1660_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I209_XP_MP1 (I0_I1660_P17_14n I0_I1660_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I209_XP_MP0 (VDD I0_I1660_P17_16 I0_I1660_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I330_XP_MP1 (I0_I1660_P19_4n I0_I1660_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I330_XP_MP0 (VDD I0_I1660_P19_12 I0_I1660_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I334_XP_MP1 (I0_I1660_P23_8n I0_I1660_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I334_XP_MP0 (VDD I0_I1660_P23_16 I0_I1660_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I446_MP1 (I2_I3_n30_4 MULP_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I446_MP0 (VDD I2_I3_SEL_MUL_b3_5 I2_I3_n30_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I221_XP_MP1 (I0_I1660_P29_26n I0_I1660_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I221_XP_MP0 (VDD I0_I1660_P29_28 I0_I1660_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I223_XP_MP1 (I0_I1660_P31_28n I0_I1660_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I223_XP_MP0 (VDD I0_I1660_P31_30 I0_I1660_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I29_MP1 (I0_I1660_gn29 I0_ha273_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I29_MP0 (VDD I0_ha272_1 I0_I1660_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I30_MP1 (I0_I1660_gn30 I0_ha274_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I30_MP0 (VDD I0_ha273_1 I0_I1660_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I127_XP_MP1 (I1_I1804_P31_28n I1_I1804_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I127_XP_MP0 (VDD I1_I1804_P31_30 I1_I1804_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I125_XP_MP1 (I1_I1804_P29_26n I1_I1804_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I125_XP_MP0 (VDD I1_I1804_P29_28 I1_I1804_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I123_XP_MP1 (I1_I1804_P27_24n I1_I1804_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I123_XP_MP0 (VDD I1_I1804_P27_26 I1_I1804_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I121_XP_MP1 (I1_I1804_P25_22n I1_I1804_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I121_XP_MP0 (VDD I1_I1804_P25_24 I1_I1804_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I119_XP_MP1 (I1_I1804_P23_20n I1_I1804_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I119_XP_MP0 (VDD I1_I1804_P23_22 I1_I1804_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I117_XP_MP1 (I1_I1804_P21_18n I1_I1804_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I117_XP_MP0 (VDD I1_I1804_P21_20 I1_I1804_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I176_XP_MP1 (I1_I1804_P25_10n I1_I1804_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I176_XP_MP0 (VDD I1_I1804_P25_18 I1_I1804_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I115_XP_MP1 (I1_I1804_P19_16n I1_I1804_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I115_XP_MP0 (VDD I1_I1804_P19_18 I1_I1804_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I113_XP_MP1 (I1_I1804_P17_14n I1_I1804_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I113_XP_MP0 (VDD I1_I1804_P17_16 I1_I1804_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I111_XP_MP1 (I1_I1804_P15_12n I1_I1804_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I111_XP_MP0 (VDD I1_I1804_P15_14 I1_I1804_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I109_XP_MP1 (I1_I1804_P13_10n I1_I1804_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I109_XP_MP0 (VDD I1_I1804_P13_12 I1_I1804_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I107_XP_MP1 (I1_I1804_P11_8n I1_I1804_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I107_XP_MP0 (VDD I1_I1804_P11_10 I1_I1804_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I168_XP_MP1 (I1_I1804_P17_2n I1_I1804_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I168_XP_MP0 (VDD I1_I1804_P17_10 I1_I1804_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I105_XP_MP1 (I1_I1804_P9_6n I1_I1804_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I105_XP_MP0 (VDD I1_I1804_P9_8 I1_I1804_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I7_MP1 (I1_I1850_gn7 I1_b28_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I7_MP0 (VDD I1_p27_6 I1_I1850_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I6_MP1 (I1_I1850_gn6 I1_b28_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I6_MP0 (VDD I1_p27_5 I1_I1850_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I6_MP1 (I1_I1896_gn6 I1_b29_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I6_MP0 (VDD I1_p28_5 I1_I1896_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I103_XP_MP1 (I1_I1896_P7_4n I1_I1896_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I103_XP_MP0 (VDD I1_I1896_P7_6 I1_I1896_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I102_XP_MP1 (I1_I1896_P6_3n I1_I1896_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I102_XP_MP0 (VDD I1_I1896_P6_5 I1_I1896_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I8_MP1 (I1_I1942_gn8 I1_b30_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I8_MP0 (VDD I1_p29_7 I1_I1942_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I105_XP_MP1 (I1_I1942_P9_6n I1_I1942_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I105_XP_MP0 (VDD I1_I1942_P9_8 I1_I1942_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I106_XP_MP1 (I1_I1942_P10_7n I1_I1942_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I106_XP_MP0 (VDD I1_I1942_P10_9 I1_I1942_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I9_MP1 (I1_I1988_gn9 I1_b31_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I9_MP0 (VDD I1_p30_8 I1_I1988_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I10_MP1 (I1_I1988_gn10 I1_b31_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I10_MP0 (VDD I1_p30_9 I1_I1988_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2018_MP1 (I1_dmn8 I1_p31_32_b3_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2018_MP0 (VDD I1_dd8_b3_5 I1_dmn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I168_XP_MP1 (I1_I1988_P17_2n I1_I1988_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I168_XP_MP0 (VDD I1_I1988_P17_10 I1_I1988_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I106_XP_MP1 (I1_I1988_P10_7n I1_I1988_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I106_XP_MP0 (VDD I1_I1988_P10_9 I1_I1988_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I167_XP_MP1 (I1_I1988_P16_1n I1_I1988_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I167_XP_MP0 (VDD I1_I1988_P16_9 I1_I1988_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I7_MP1 (I1_I2066_gn7 I1_dm7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I7_MP0 (VDD I1_p31_7 I1_I2066_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I6_MP1 (I1_I2066_gn6 I1_dm6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I6_MP0 (VDD I1_p31_6 I1_I2066_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I5_MP1 (I1_I2066_gn5 I1_dm5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I5_MP0 (VDD I1_p31_5 I1_I2066_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2170_MP1 (I1_nrkn1 DIVR_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2170_MP0 (VDD I1_A_31_b3_5 I1_nrkn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I202_XP_MP1 (I0_I1660_P10_7n I0_I1660_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I202_XP_MP0 (VDD I0_I1660_P10_9 I0_I1660_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I204_XP_MP1 (I0_I1660_P12_9n I0_I1660_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I204_XP_MP0 (VDD I0_I1660_P12_11 I0_I1660_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I206_XP_MP1 (I0_I1660_P14_11n I0_I1660_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I206_XP_MP0 (VDD I0_I1660_P14_13 I0_I1660_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I208_XP_MP1 (I0_I1660_P16_13n I0_I1660_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I208_XP_MP0 (VDD I0_I1660_P16_15 I0_I1660_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I210_XP_MP1 (I0_I1660_P18_15n I0_I1660_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I210_XP_MP0 (VDD I0_I1660_P18_17 I0_I1660_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I328_XP_MP1 (I0_I1660_P17_2n I0_I1660_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I328_XP_MP0 (VDD I0_I1660_P17_10 I0_I1660_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I212_XP_MP1 (I0_I1660_P20_17n I0_I1660_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I212_XP_MP0 (VDD I0_I1660_P20_19 I0_I1660_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I214_XP_MP1 (I0_I1660_P22_19n I0_I1660_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I214_XP_MP0 (VDD I0_I1660_P22_21 I0_I1660_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I332_XP_MP1 (I0_I1660_P21_6n I0_I1660_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I332_XP_MP0 (VDD I0_I1660_P21_14 I0_I1660_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I216_XP_MP1 (I0_I1660_P24_21n I0_I1660_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I216_XP_MP0 (VDD I0_I1660_P24_23 I0_I1660_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I222_XP_MP1 (I0_I1660_P30_27n I0_I1660_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I222_XP_MP0 (VDD I0_I1660_P30_29 I0_I1660_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I336_XP_MP1 (I0_I1660_P25_10n I0_I1660_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I336_XP_MP0 (VDD I0_I1660_P25_18 I0_I1660_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I344_XP_MP1 (I0_I1660_P33_18n I0_I1660_P25_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I344_XP_MP0 (VDD I0_I1660_P33_26 I0_I1660_P33_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I340_XP_MP1 (I0_I1660_P29_14n I0_I1660_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I340_XP_MP0 (VDD I0_I1660_P29_22 I0_I1660_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I338_XP_MP1 (I0_I1660_P27_12n I0_I1660_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I338_XP_MP0 (VDD I0_I1660_P27_20 I0_I1660_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I458_MP1 (I2_I3_n31_4 MULP_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I458_MP0 (VDD I2_I3_SEL_MUL_b3_5 I2_I3_n31_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I342_XP_MP1 (I0_I1660_P31_16n I0_I1660_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I342_XP_MP0 (VDD I0_I1660_P31_24 I0_I1660_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I225_XP_MP1 (I0_I1660_P33_30n I0_I1660_P31_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I225_XP_MP0 (VDD I0_I1660_P33_32 I0_I1660_P33_30n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I31_MP1 (I0_I1660_gn31 I0_ha275_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I31_MP0 (VDD I0_ha274_1 I0_I1660_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I33_MP1 (I0_I1660_gn33 I0_ha277_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I33_MP0 (VDD I0_ha276_1 I0_I1660_gn33 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I180_XP_MP1 (I1_I1804_P29_14n I1_I1804_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I180_XP_MP0 (VDD I1_I1804_P29_22 I1_I1804_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I172_XP_MP1 (I1_I1804_P21_6n I1_I1804_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I172_XP_MP0 (VDD I1_I1804_P21_14 I1_I1804_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I101_XP_MP1 (I1_I1850_P5_2n I1_I1850_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I101_XP_MP0 (VDD I1_I1850_P5_4 I1_I1850_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I8_MP1 (I1_I1850_gn8 I1_b28_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I8_MP0 (VDD I1_p27_7 I1_I1850_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I100_XP_MP1 (I1_I1850_P4_1n I1_I1850_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I100_XP_MP0 (VDD I1_I1850_P4_3 I1_I1850_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I8_MP1 (I1_I1896_gn8 I1_b29_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I8_MP0 (VDD I1_p28_7 I1_I1896_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I7_MP1 (I1_I1896_gn7 I1_b29_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I7_MP0 (VDD I1_p28_6 I1_I1896_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I105_XP_MP1 (I1_I1896_P9_6n I1_I1896_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I105_XP_MP0 (VDD I1_I1896_P9_8 I1_I1896_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I104_XP_MP1 (I1_I1896_P8_5n I1_I1896_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I104_XP_MP0 (VDD I1_I1896_P8_7 I1_I1896_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I167_XP_MP1 (I1_I1896_P16_1n I1_I1896_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I167_XP_MP0 (VDD I1_I1896_P16_9 I1_I1896_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I10_MP1 (I1_I1942_gn10 I1_b30_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I10_MP0 (VDD I1_p29_9 I1_I1942_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I9_MP1 (I1_I1942_gn9 I1_b30_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I9_MP0 (VDD I1_p29_8 I1_I1942_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I107_XP_MP1 (I1_I1942_P11_8n I1_I1942_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I107_XP_MP0 (VDD I1_I1942_P11_10 I1_I1942_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I168_XP_MP1 (I1_I1942_P17_2n I1_I1942_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I168_XP_MP0 (VDD I1_I1942_P17_10 I1_I1942_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I169_XP_MP1 (I1_I1942_P18_3n I1_I1942_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I169_XP_MP0 (VDD I1_I1942_P18_11 I1_I1942_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I11_MP1 (I1_I1988_gn11 I1_b31_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I11_MP0 (VDD I1_p30_10 I1_I1988_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2022_MP1 (I1_dmn10 I1_p31_32_b3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2022_MP0 (VDD I1_dd10_b3_5 I1_dmn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2020_MP1 (I1_dmn9 I1_p31_32_b3_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2020_MP0 (VDD I1_dd9_b3_5 I1_dmn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I107_XP_MP1 (I1_I1988_P11_8n I1_I1988_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I107_XP_MP0 (VDD I1_I1988_P11_10 I1_I1988_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I108_XP_MP1 (I1_I1988_P12_9n I1_I1988_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I108_XP_MP0 (VDD I1_I1988_P12_11 I1_I1988_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I9_MP1 (I1_I2066_gn9 I1_dm9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I9_MP0 (VDD I1_p31_9 I1_I2066_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I8_MP1 (I1_I2066_gn8 I1_dm8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I8_MP0 (VDD I1_p31_8 I1_I2066_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I196_XP_MP1 (I0_I1660_P4_1n I0_I1660_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I196_XP_MP0 (VDD I0_I1660_P4_3 I0_I1660_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I198_XP_MP1 (I0_I1660_P6_3n I0_I1660_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I198_XP_MP0 (VDD I0_I1660_P6_5 I0_I1660_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I200_XP_MP1 (I0_I1660_P8_5n I0_I1660_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I200_XP_MP0 (VDD I0_I1660_P8_7 I0_I1660_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I467_MP1 (I2_I3_hd32 DIVR_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I467_MP0 (VDD I2_I3_SEL_DIV_b3_5 I2_I3_hd32 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I468_MP1 (Y_32 I2_I3_hd32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I468_MP0 (VDD I2_I3_hm32 Y_32 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I472_MP1 (I2_I3_hm34 MULP_34 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I472_MP0 (VDD I2_I3_SEL_MUL_b3_5 I2_I3_hm34 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I469_MP1 (I2_I3_hm33 MULP_33 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I469_MP0 (VDD I2_I3_SEL_MUL_b3_5 I2_I3_hm33 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I466_MP1 (I2_I3_hm32 MULP_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I466_MP0 (VDD I2_I3_SEL_MUL_b3_5 I2_I3_hm32 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I218_XP_MP1 (I0_I1660_P26_23n I0_I1660_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I218_XP_MP0 (VDD I0_I1660_P26_25 I0_I1660_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I220_XP_MP1 (I0_I1660_P28_25n I0_I1660_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I220_XP_MP0 (VDD I0_I1660_P28_27 I0_I1660_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I224_XP_MP1 (I0_I1660_P32_29n I0_I1660_P30_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I224_XP_MP0 (VDD I0_I1660_P32_31 I0_I1660_P32_29n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I346_XP_MP1 (I0_I1660_P35_20n I0_I1660_P27_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I346_XP_MP0 (VDD I0_I1660_P35_28 I0_I1660_P35_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I350_XP_MP1 (I0_I1660_P39_24n I0_I1660_P31_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I350_XP_MP0 (VDD I0_I1660_P39_32 I0_I1660_P39_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I227_XP_MP1 (I0_I1660_P35_32n I0_I1660_P33_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I227_XP_MP0 (VDD I0_I1660_P35_34 I0_I1660_P35_32n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I32_MP1 (I0_I1660_gn32 I0_ha276_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I32_MP0 (VDD I0_ha275_1 I0_I1660_gn32 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I34_MP1 (I0_I1660_gn34 I0_ha278_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I34_MP0 (VDD I0_ha277_1 I0_I1660_gn34 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I36_MP1 (I0_I1660_gn36 I0_fa280_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I36_MP0 (VDD I0_ha279_1 I0_I1660_gn36 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I37_MP1 (I0_I1660_gn37 I0_fa281_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I37_MP0 (VDD I0_fa280_1 I0_I1660_gn37 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I182_XP_MP1 (I1_I1804_P31_16n I1_I1804_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I182_XP_MP0 (VDD I1_I1804_P31_24 I1_I1804_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I178_XP_MP1 (I1_I1804_P27_12n I1_I1804_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I178_XP_MP0 (VDD I1_I1804_P27_20 I1_I1804_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I174_XP_MP1 (I1_I1804_P23_8n I1_I1804_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I174_XP_MP0 (VDD I1_I1804_P23_16 I1_I1804_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I170_XP_MP1 (I1_I1804_P19_4n I1_I1804_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I170_XP_MP0 (VDD I1_I1804_P19_12 I1_I1804_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I11_MP1 (I1_I1850_gn11 I1_b28_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I11_MP0 (VDD I1_p27_10 I1_I1850_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I10_MP1 (I1_I1850_gn10 I1_b28_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I10_MP0 (VDD I1_p27_9 I1_I1850_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I9_MP1 (I1_I1850_gn9 I1_b28_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I9_MP0 (VDD I1_p27_8 I1_I1850_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I168_XP_MP1 (I1_I1896_P17_2n I1_I1896_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I168_XP_MP0 (VDD I1_I1896_P17_10 I1_I1896_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I106_XP_MP1 (I1_I1896_P10_7n I1_I1896_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I106_XP_MP0 (VDD I1_I1896_P10_9 I1_I1896_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I11_MP1 (I1_I1942_gn11 I1_b30_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I11_MP0 (VDD I1_p29_10 I1_I1942_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I12_MP1 (I1_I1942_gn12 I1_b30_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I12_MP0 (VDD I1_p29_11 I1_I1942_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I109_XP_MP1 (I1_I1942_P13_10n I1_I1942_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I109_XP_MP0 (VDD I1_I1942_P13_12 I1_I1942_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I170_XP_MP1 (I1_I1942_P19_4n I1_I1942_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I170_XP_MP0 (VDD I1_I1942_P19_12 I1_I1942_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I108_XP_MP1 (I1_I1942_P12_9n I1_I1942_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I108_XP_MP0 (VDD I1_I1942_P12_11 I1_I1942_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I175_XP_MP1 (I1_I1942_P24_9n I1_I1942_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I175_XP_MP0 (VDD I1_I1942_P24_17 I1_I1942_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2024_MP1 (I1_dmn11 I1_p31_32_b3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2024_MP0 (VDD I1_dd11_b3_5 I1_dmn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2026_MP1 (I1_dmn12 I1_p31_32_b3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2026_MP0 (VDD I1_dd12_b3_5 I1_dmn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I12_MP1 (I1_I1988_gn12 I1_b31_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I12_MP0 (VDD I1_p30_11 I1_I1988_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I109_XP_MP1 (I1_I1988_P13_10n I1_I1988_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I109_XP_MP0 (VDD I1_I1988_P13_12 I1_I1988_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I175_XP_MP1 (I1_I1988_P24_9n I1_I1988_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I175_XP_MP0 (VDD I1_I1988_P24_17 I1_I1988_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I169_XP_MP1 (I1_I1988_P18_3n I1_I1988_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I169_XP_MP0 (VDD I1_I1988_P18_11 I1_I1988_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I10_MP1 (I1_I2066_gn10 I1_dm10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I10_MP0 (VDD I1_p31_10 I1_I2066_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I104_XP_MP1 (I1_I2066_P8_5n I1_I2066_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I104_XP_MP0 (VDD I1_I2066_P8_7 I1_I2066_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I102_XP_MP1 (I1_I2066_P6_3n I1_I2066_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I102_XP_MP0 (VDD I1_I2066_P6_5 I1_I2066_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I100_XP_MP1 (I1_I2066_P4_1n I1_I2066_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I100_XP_MP0 (VDD I1_I2066_P4_3 I1_I2066_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I327_XP_MP1 (I0_I1660_P16_1n I0_I1660_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I327_XP_MP0 (VDD I0_I1660_P16_9 I0_I1660_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I473_MP1 (I2_I3_hd34 DIVR_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I473_MP0 (VDD I2_I3_SEL_DIV_b3_5 I2_I3_hd34 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I470_MP1 (I2_I3_hd33 DIVR_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I470_MP0 (VDD I2_I3_SEL_DIV_b3_5 I2_I3_hd33 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I474_MP1 (Y_34 I2_I3_hd34 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I474_MP0 (VDD I2_I3_hm34 Y_34 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I471_MP1 (Y_33 I2_I3_hd33 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I471_MP0 (VDD I2_I3_hm33 Y_33 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I331_XP_MP1 (I0_I1660_P20_5n I0_I1660_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I331_XP_MP0 (VDD I0_I1660_P20_13 I0_I1660_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I335_XP_MP1 (I0_I1660_P24_9n I0_I1660_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I335_XP_MP0 (VDD I0_I1660_P24_17 I0_I1660_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I343_XP_MP1 (I0_I1660_P32_17n I0_I1660_P24_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I343_XP_MP0 (VDD I0_I1660_P32_25 I0_I1660_P32_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I339_XP_MP1 (I0_I1660_P28_13n I0_I1660_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I339_XP_MP0 (VDD I0_I1660_P28_21 I0_I1660_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I226_XP_MP1 (I0_I1660_P34_31n I0_I1660_P32_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I226_XP_MP0 (VDD I0_I1660_P34_33 I0_I1660_P34_31n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I228_XP_MP1 (I0_I1660_P36_33n I0_I1660_P34_33 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I228_XP_MP0 (VDD I0_I1660_P36_35 I0_I1660_P36_33n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I348_XP_MP1 (I0_I1660_P37_22n I0_I1660_P29_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I348_XP_MP0 (VDD I0_I1660_P37_30 I0_I1660_P37_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I354_XP_MP1 (I0_I1660_P43_28n I0_I1660_P35_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I354_XP_MP0 (VDD I0_I1660_P43_36 I0_I1660_P43_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I362_XP_MP1 (I0_I1660_P51_36n I0_I1660_P43_36 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I362_XP_MP0 (VDD I0_I1660_P51_44 I0_I1660_P51_36n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I229_XP_MP1 (I0_I1660_P37_34n I0_I1660_P35_34 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I229_XP_MP0 (VDD I0_I1660_P37_36 I0_I1660_P37_34n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I231_XP_MP1 (I0_I1660_P39_36n I0_I1660_P37_36 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I231_XP_MP0 (VDD I0_I1660_P39_38 I0_I1660_P39_36n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I35_MP1 (I0_I1660_gn35 I0_ha279_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I35_MP0 (VDD I0_ha278_1 I0_I1660_gn35 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I107_XP_MP1 (I1_I1850_P11_8n I1_I1850_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I107_XP_MP0 (VDD I1_I1850_P11_10 I1_I1850_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I105_XP_MP1 (I1_I1850_P9_6n I1_I1850_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I105_XP_MP0 (VDD I1_I1850_P9_8 I1_I1850_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I103_XP_MP1 (I1_I1850_P7_4n I1_I1850_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I103_XP_MP0 (VDD I1_I1850_P7_6 I1_I1850_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I13_MP1 (I1_I1850_gn13 I1_b28_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I13_MP0 (VDD I1_p27_12 I1_I1850_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I102_XP_MP1 (I1_I1850_P6_3n I1_I1850_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I102_XP_MP0 (VDD I1_I1850_P6_5 I1_I1850_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I10_MP1 (I1_I1896_gn10 I1_b29_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I10_MP0 (VDD I1_p28_9 I1_I1896_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I11_MP1 (I1_I1896_gn11 I1_b29_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I11_MP0 (VDD I1_p28_10 I1_I1896_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I9_MP1 (I1_I1896_gn9 I1_b29_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I9_MP0 (VDD I1_p28_8 I1_I1896_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I107_XP_MP1 (I1_I1896_P11_8n I1_I1896_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I107_XP_MP0 (VDD I1_I1896_P11_10 I1_I1896_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I169_XP_MP1 (I1_I1896_P18_3n I1_I1896_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I169_XP_MP0 (VDD I1_I1896_P18_11 I1_I1896_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I13_MP1 (I1_I1942_gn13 I1_b30_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I13_MP0 (VDD I1_p29_12 I1_I1942_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I176_XP_MP1 (I1_I1942_P25_10n I1_I1942_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I176_XP_MP0 (VDD I1_I1942_P25_18 I1_I1942_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I110_XP_MP1 (I1_I1942_P14_11n I1_I1942_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I110_XP_MP0 (VDD I1_I1942_P14_13 I1_I1942_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I13_MP1 (I1_I1988_gn13 I1_b31_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I13_MP0 (VDD I1_p30_12 I1_I1988_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2028_MP1 (I1_dmn13 I1_p31_32_b3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2028_MP0 (VDD I1_dd13_b3_5 I1_dmn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I14_MP1 (I1_I1988_gn14 I1_b31_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I14_MP0 (VDD I1_p30_13 I1_I1988_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I176_XP_MP1 (I1_I1988_P25_10n I1_I1988_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I176_XP_MP0 (VDD I1_I1988_P25_18 I1_I1988_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I110_XP_MP1 (I1_I1988_P14_11n I1_I1988_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I110_XP_MP0 (VDD I1_I1988_P14_13 I1_I1988_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I112_XP_MP1 (I1_I1988_P16_13n I1_I1988_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I112_XP_MP0 (VDD I1_I1988_P16_15 I1_I1988_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I12_MP1 (I1_I2066_gn12 I1_dm12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I12_MP0 (VDD I1_p31_12 I1_I2066_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I11_MP1 (I1_I2066_gn11 I1_dm11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I11_MP0 (VDD I1_p31_11 I1_I2066_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I108_XP_MP1 (I1_I2066_P12_9n I1_I2066_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I108_XP_MP0 (VDD I1_I2066_P12_11 I1_I2066_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I106_XP_MP1 (I1_I2066_P10_7n I1_I2066_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I106_XP_MP0 (VDD I1_I2066_P10_9 I1_I2066_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I167_XP_MP1 (I1_I2066_P16_1n I1_I2066_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I167_XP_MP0 (VDD I1_I2066_P16_9 I1_I2066_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I105_XP_MP1 (I1_I2066_P9_6n I1_I2066_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I105_XP_MP0 (VDD I1_I2066_P9_8 I1_I2066_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I101_XP_MP1 (I1_I2066_P5_2n I1_I2066_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I101_XP_MP0 (VDD I1_I2066_P5_4 I1_I2066_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I103_XP_MP1 (I1_I2066_P7_4n I1_I2066_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I103_XP_MP0 (VDD I1_I2066_P7_6 I1_I2066_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I329_XP_MP1 (I0_I1660_P18_3n I0_I1660_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I329_XP_MP0 (VDD I0_I1660_P18_11 I0_I1660_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I347_XP_MP1 (I0_I1660_P36_21n I0_I1660_P28_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I347_XP_MP0 (VDD I0_I1660_P36_29 I0_I1660_P36_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I351_XP_MP1 (I0_I1660_P40_25n I0_I1660_P32_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I351_XP_MP0 (VDD I0_I1660_P40_33 I0_I1660_P40_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I230_XP_MP1 (I0_I1660_P38_35n I0_I1660_P36_35 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I230_XP_MP0 (VDD I0_I1660_P38_37 I0_I1660_P38_35n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I352_XP_MP1 (I0_I1660_P41_26n I0_I1660_P33_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I352_XP_MP0 (VDD I0_I1660_P41_34 I0_I1660_P41_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I360_XP_MP1 (I0_I1660_P49_34n I0_I1660_P41_34 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I360_XP_MP0 (VDD I0_I1660_P49_42 I0_I1660_P49_34n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I358_XP_MP1 (I0_I1660_P47_32n I0_I1660_P39_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I358_XP_MP0 (VDD I0_I1660_P47_40 I0_I1660_P47_32n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I233_XP_MP1 (I0_I1660_P41_38n I0_I1660_P39_38 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I233_XP_MP0 (VDD I0_I1660_P41_40 I0_I1660_P41_38n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I38_MP1 (I0_I1660_gn38 I0_ha282_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I38_MP0 (VDD I0_fa281_1 I0_I1660_gn38 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I40_MP1 (I0_I1660_gn40 I0_ha284_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I40_MP0 (VDD I0_fa283_1 I0_I1660_gn40 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I39_MP1 (I0_I1660_gn39 I0_fa283_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I39_MP0 (VDD I0_ha282_1 I0_I1660_gn39 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I41_MP1 (I0_I1660_gn41 I0_fa285_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I41_MP0 (VDD I0_ha284_1 I0_I1660_gn41 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I42_MP1 (I0_I1660_gn42 I0_ha286_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I42_MP0 (VDD I0_fa285_1 I0_I1660_gn42 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I170_XP_MP1 (I1_I1850_P19_4n I1_I1850_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I170_XP_MP0 (VDD I1_I1850_P19_12 I1_I1850_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I111_XP_MP1 (I1_I1850_P15_12n I1_I1850_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I111_XP_MP0 (VDD I1_I1850_P15_14 I1_I1850_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I109_XP_MP1 (I1_I1850_P13_10n I1_I1850_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I109_XP_MP0 (VDD I1_I1850_P13_12 I1_I1850_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I15_MP1 (I1_I1850_gn15 I1_b28_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I15_MP0 (VDD I1_p27_14 I1_I1850_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I14_MP1 (I1_I1850_gn14 I1_b28_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I14_MP0 (VDD I1_p27_13 I1_I1850_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I12_MP1 (I1_I1850_gn12 I1_b28_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I12_MP0 (VDD I1_p27_11 I1_I1850_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I104_XP_MP1 (I1_I1850_P8_5n I1_I1850_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I104_XP_MP0 (VDD I1_I1850_P8_7 I1_I1850_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I12_MP1 (I1_I1896_gn12 I1_b29_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I12_MP0 (VDD I1_p28_11 I1_I1896_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I13_MP1 (I1_I1896_gn13 I1_b29_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I13_MP0 (VDD I1_p28_12 I1_I1896_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I109_XP_MP1 (I1_I1896_P13_10n I1_I1896_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I109_XP_MP0 (VDD I1_I1896_P13_12 I1_I1896_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I108_XP_MP1 (I1_I1896_P12_9n I1_I1896_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I108_XP_MP0 (VDD I1_I1896_P12_11 I1_I1896_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I14_MP1 (I1_I1942_gn14 I1_b30_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I14_MP0 (VDD I1_p29_13 I1_I1942_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I111_XP_MP1 (I1_I1942_P15_12n I1_I1942_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I111_XP_MP0 (VDD I1_I1942_P15_14 I1_I1942_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I113_XP_MP1 (I1_I1942_P17_14n I1_I1942_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I113_XP_MP0 (VDD I1_I1942_P17_16 I1_I1942_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I172_XP_MP1 (I1_I1942_P21_6n I1_I1942_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I172_XP_MP0 (VDD I1_I1942_P21_14 I1_I1942_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I112_XP_MP1 (I1_I1942_P16_13n I1_I1942_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I112_XP_MP0 (VDD I1_I1942_P16_15 I1_I1942_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I171_XP_MP1 (I1_I1942_P20_5n I1_I1942_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I171_XP_MP0 (VDD I1_I1942_P20_13 I1_I1942_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I15_MP1 (I1_I1988_gn15 I1_b31_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I15_MP0 (VDD I1_p30_14 I1_I1988_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I111_XP_MP1 (I1_I1988_P15_12n I1_I1988_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I111_XP_MP0 (VDD I1_I1988_P15_14 I1_I1988_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I113_XP_MP1 (I1_I1988_P17_14n I1_I1988_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I113_XP_MP0 (VDD I1_I1988_P17_16 I1_I1988_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I170_XP_MP1 (I1_I1988_P19_4n I1_I1988_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I170_XP_MP0 (VDD I1_I1988_P19_12 I1_I1988_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I114_XP_MP1 (I1_I1988_P18_15n I1_I1988_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I114_XP_MP0 (VDD I1_I1988_P18_17 I1_I1988_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I171_XP_MP1 (I1_I1988_P20_5n I1_I1988_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I171_XP_MP0 (VDD I1_I1988_P20_13 I1_I1988_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I13_MP1 (I1_I2066_gn13 I1_dm13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I13_MP0 (VDD I1_p31_13 I1_I2066_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I14_MP1 (I1_I2066_gn14 I1_dm14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I14_MP0 (VDD I1_p31_14 I1_I2066_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I175_XP_MP1 (I1_I2066_P24_9n I1_I2066_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I175_XP_MP0 (VDD I1_I2066_P24_17 I1_I2066_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I107_XP_MP1 (I1_I2066_P11_8n I1_I2066_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I107_XP_MP0 (VDD I1_I2066_P11_10 I1_I2066_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I482_MP1 (I2_I3_hd37 DIVR_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I482_MP0 (VDD I2_I3_SEL_DIV_b3_6 I2_I3_hd37 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I476_MP1 (I2_I3_hd35 DIVR_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I476_MP0 (VDD I2_I3_SEL_DIV_b3_6 I2_I3_hd35 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I477_MP1 (Y_35 I2_I3_hd35 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I477_MP0 (VDD I2_I3_hm35 Y_35 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I483_MP1 (Y_37 I2_I3_hd37 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I483_MP0 (VDD I2_I3_hm37 Y_37 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I481_MP1 (I2_I3_hm37 MULP_37 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I481_MP0 (VDD I2_I3_SEL_MUL_b3_6 I2_I3_hm37 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I359_XP_MP1 (I0_I1660_P48_33n I0_I1660_P40_33 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I359_XP_MP0 (VDD I0_I1660_P48_41 I0_I1660_P48_33n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I355_XP_MP1 (I0_I1660_P44_29n I0_I1660_P36_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I355_XP_MP0 (VDD I0_I1660_P44_37 I0_I1660_P44_29n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I232_XP_MP1 (I0_I1660_P40_37n I0_I1660_P38_37 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I232_XP_MP0 (VDD I0_I1660_P40_39 I0_I1660_P40_37n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I364_XP_MP1 (I0_I1660_P53_38n I0_I1660_P45_38 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I364_XP_MP0 (VDD I0_I1660_P53_46 I0_I1660_P53_38n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I366_XP_MP1 (I0_I1660_P55_40n I0_I1660_P47_40 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I366_XP_MP0 (VDD I0_I1660_P55_48 I0_I1660_P55_40n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I235_XP_MP1 (I0_I1660_P43_40n I0_I1660_P41_40 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I235_XP_MP0 (VDD I0_I1660_P43_42 I0_I1660_P43_40n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I45_MP1 (I0_I1660_gn45 I0_fa289_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I45_MP0 (VDD I0_ha288_1 I0_I1660_gn45 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I43_MP1 (I0_I1660_gn43 I0_fa287_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I43_MP0 (VDD I0_ha286_1 I0_I1660_gn43 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I113_XP_MP1 (I1_I1850_P17_14n I1_I1850_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I113_XP_MP0 (VDD I1_I1850_P17_16 I1_I1850_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I168_XP_MP1 (I1_I1850_P17_2n I1_I1850_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I168_XP_MP0 (VDD I1_I1850_P17_10 I1_I1850_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I17_MP1 (I1_I1850_gn17 I1_b28_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I17_MP0 (VDD I1_p27_16 I1_I1850_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I16_MP1 (I1_I1850_gn16 I1_b28_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I16_MP0 (VDD I1_p27_15 I1_I1850_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I108_XP_MP1 (I1_I1850_P12_9n I1_I1850_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I108_XP_MP0 (VDD I1_I1850_P12_11 I1_I1850_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I106_XP_MP1 (I1_I1850_P10_7n I1_I1850_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I106_XP_MP0 (VDD I1_I1850_P10_9 I1_I1850_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I15_MP1 (I1_I1896_gn15 I1_b29_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I15_MP0 (VDD I1_p28_14 I1_I1896_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I14_MP1 (I1_I1896_gn14 I1_b29_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I14_MP0 (VDD I1_p28_13 I1_I1896_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I170_XP_MP1 (I1_I1896_P19_4n I1_I1896_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I170_XP_MP0 (VDD I1_I1896_P19_12 I1_I1896_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I110_XP_MP1 (I1_I1896_P14_11n I1_I1896_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I110_XP_MP0 (VDD I1_I1896_P14_13 I1_I1896_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I15_MP1 (I1_I1942_gn15 I1_b30_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I15_MP0 (VDD I1_p29_14 I1_I1942_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I16_MP1 (I1_I1942_gn16 I1_b30_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I16_MP0 (VDD I1_p29_15 I1_I1942_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I114_XP_MP1 (I1_I1942_P18_15n I1_I1942_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I114_XP_MP0 (VDD I1_I1942_P18_17 I1_I1942_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I17_MP1 (I1_I1988_gn17 I1_b31_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I17_MP0 (VDD I1_p30_16 I1_I1988_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I16_MP1 (I1_I1988_gn16 I1_b31_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I16_MP0 (VDD I1_p30_15 I1_I1988_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2036_MP1 (I1_dmn17 I1_p31_32_b3_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2036_MP0 (VDD I1_dd17_b3_5 I1_dmn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2034_MP1 (I1_dmn16 I1_p31_32_b3_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2034_MP0 (VDD I1_dd16_b3_5 I1_dmn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I115_XP_MP1 (I1_I1988_P19_16n I1_I1988_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I115_XP_MP0 (VDD I1_I1988_P19_18 I1_I1988_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I172_XP_MP1 (I1_I1988_P21_6n I1_I1988_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I172_XP_MP0 (VDD I1_I1988_P21_14 I1_I1988_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I116_XP_MP1 (I1_I1988_P20_17n I1_I1988_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I116_XP_MP0 (VDD I1_I1988_P20_19 I1_I1988_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I15_MP1 (I1_I2066_gn15 I1_dm15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I15_MP0 (VDD I1_p31_15 I1_I2066_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I112_XP_MP1 (I1_I2066_P16_13n I1_I2066_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I112_XP_MP0 (VDD I1_I2066_P16_15 I1_I2066_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I110_XP_MP1 (I1_I2066_P14_11n I1_I2066_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I110_XP_MP0 (VDD I1_I2066_P14_13 I1_I2066_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I109_XP_MP1 (I1_I2066_P13_10n I1_I2066_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I109_XP_MP0 (VDD I1_I2066_P13_12 I1_I2066_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I168_XP_MP1 (I1_I2066_P17_2n I1_I2066_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I168_XP_MP0 (VDD I1_I2066_P17_10 I1_I2066_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I485_MP1 (I2_I3_hd38 DIVR_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I485_MP0 (VDD I2_I3_SEL_DIV_b3_6 I2_I3_hd38 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I479_MP1 (I2_I3_hd36 DIVR_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I479_MP0 (VDD I2_I3_SEL_DIV_b3_6 I2_I3_hd36 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I488_MP1 (I2_I3_hd39 DIVR_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I488_MP0 (VDD I2_I3_SEL_DIV_b3_6 I2_I3_hd39 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I491_MP1 (I2_I3_hd40 DIVR_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I491_MP0 (VDD I2_I3_SEL_DIV_b3_6 I2_I3_hd40 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I486_MP1 (Y_38 I2_I3_hd38 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I486_MP0 (VDD I2_I3_hm38 Y_38 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I480_MP1 (Y_36 I2_I3_hd36 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I480_MP0 (VDD I2_I3_hm36 Y_36 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I492_MP1 (Y_40 I2_I3_hd40 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I492_MP0 (VDD I2_I3_hm40 Y_40 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I475_MP1 (I2_I3_hm35 MULP_35 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I475_MP0 (VDD I2_I3_SEL_MUL_b3_6 I2_I3_hm35 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I484_MP1 (I2_I3_hm38 MULP_38 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I484_MP0 (VDD I2_I3_SEL_MUL_b3_6 I2_I3_hm38 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I333_XP_MP1 (I0_I1660_P22_7n I0_I1660_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I333_XP_MP0 (VDD I0_I1660_P22_15 I0_I1660_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I337_XP_MP1 (I0_I1660_P26_11n I0_I1660_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I337_XP_MP0 (VDD I0_I1660_P26_19 I0_I1660_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I345_XP_MP1 (I0_I1660_P34_19n I0_I1660_P26_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I345_XP_MP0 (VDD I0_I1660_P34_27 I0_I1660_P34_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I363_XP_MP1 (I0_I1660_P52_37n I0_I1660_P44_37 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I363_XP_MP0 (VDD I0_I1660_P52_45 I0_I1660_P52_37n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I234_XP_MP1 (I0_I1660_P42_39n I0_I1660_P40_39 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I234_XP_MP0 (VDD I0_I1660_P42_41 I0_I1660_P42_39n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I356_XP_MP1 (I0_I1660_P45_30n I0_I1660_P37_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I356_XP_MP0 (VDD I0_I1660_P45_38 I0_I1660_P45_30n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I370_XP_MP1 (I0_I1660_P59_44n I0_I1660_P51_44 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I370_XP_MP0 (VDD I0_I1660_P59_52 I0_I1660_P59_44n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I239_XP_MP1 (I0_I1660_P47_44n I0_I1660_P45_44 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I239_XP_MP0 (VDD I0_I1660_P47_46 I0_I1660_P47_44n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I237_XP_MP1 (I0_I1660_P45_42n I0_I1660_P43_42 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I237_XP_MP0 (VDD I0_I1660_P45_44 I0_I1660_P45_42n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I44_MP1 (I0_I1660_gn44 I0_ha288_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I44_MP0 (VDD I0_fa287_1 I0_I1660_gn44 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I174_XP_MP1 (I1_I1850_P23_8n I1_I1850_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I174_XP_MP0 (VDD I1_I1850_P23_16 I1_I1850_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I115_XP_MP1 (I1_I1850_P19_16n I1_I1850_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I115_XP_MP0 (VDD I1_I1850_P19_18 I1_I1850_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I172_XP_MP1 (I1_I1850_P21_6n I1_I1850_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I172_XP_MP0 (VDD I1_I1850_P21_14 I1_I1850_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I112_XP_MP1 (I1_I1850_P16_13n I1_I1850_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I112_XP_MP0 (VDD I1_I1850_P16_15 I1_I1850_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I110_XP_MP1 (I1_I1850_P14_11n I1_I1850_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I110_XP_MP0 (VDD I1_I1850_P14_13 I1_I1850_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I167_XP_MP1 (I1_I1850_P16_1n I1_I1850_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I167_XP_MP0 (VDD I1_I1850_P16_9 I1_I1850_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I17_MP1 (I1_I1896_gn17 I1_b29_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I17_MP0 (VDD I1_p28_16 I1_I1896_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I113_XP_MP1 (I1_I1896_P17_14n I1_I1896_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I113_XP_MP0 (VDD I1_I1896_P17_16 I1_I1896_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I111_XP_MP1 (I1_I1896_P15_12n I1_I1896_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I111_XP_MP0 (VDD I1_I1896_P15_14 I1_I1896_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I114_XP_MP1 (I1_I1896_P18_15n I1_I1896_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I114_XP_MP0 (VDD I1_I1896_P18_17 I1_I1896_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I112_XP_MP1 (I1_I1896_P16_13n I1_I1896_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I112_XP_MP0 (VDD I1_I1896_P16_15 I1_I1896_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I171_XP_MP1 (I1_I1896_P20_5n I1_I1896_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I171_XP_MP0 (VDD I1_I1896_P20_13 I1_I1896_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I17_MP1 (I1_I1942_gn17 I1_b30_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I17_MP0 (VDD I1_p29_16 I1_I1942_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I18_MP1 (I1_I1942_gn18 I1_b30_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I18_MP0 (VDD I1_p29_17 I1_I1942_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I117_XP_MP1 (I1_I1942_P21_18n I1_I1942_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I117_XP_MP0 (VDD I1_I1942_P21_20 I1_I1942_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I115_XP_MP1 (I1_I1942_P19_16n I1_I1942_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I115_XP_MP0 (VDD I1_I1942_P19_18 I1_I1942_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I178_XP_MP1 (I1_I1942_P27_12n I1_I1942_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I178_XP_MP0 (VDD I1_I1942_P27_20 I1_I1942_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I116_XP_MP1 (I1_I1942_P20_17n I1_I1942_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I116_XP_MP0 (VDD I1_I1942_P20_19 I1_I1942_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I177_XP_MP1 (I1_I1942_P26_11n I1_I1942_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I177_XP_MP0 (VDD I1_I1942_P26_19 I1_I1942_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I18_MP1 (I1_I1988_gn18 I1_b31_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I18_MP0 (VDD I1_p30_17 I1_I1988_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I19_MP1 (I1_I1988_gn19 I1_b31_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I19_MP0 (VDD I1_p30_18 I1_I1988_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I117_XP_MP1 (I1_I1988_P21_18n I1_I1988_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I117_XP_MP0 (VDD I1_I1988_P21_20 I1_I1988_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I178_XP_MP1 (I1_I1988_P27_12n I1_I1988_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I178_XP_MP0 (VDD I1_I1988_P27_20 I1_I1988_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I177_XP_MP1 (I1_I1988_P26_11n I1_I1988_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I177_XP_MP0 (VDD I1_I1988_P26_19 I1_I1988_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I17_MP1 (I1_I2066_gn17 I1_dm17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I17_MP0 (VDD I1_p31_17 I1_I2066_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I16_MP1 (I1_I2066_gn16 I1_dm16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I16_MP0 (VDD I1_p31_16 I1_I2066_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I114_XP_MP1 (I1_I2066_P18_15n I1_I2066_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I114_XP_MP0 (VDD I1_I2066_P18_17 I1_I2066_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I169_XP_MP1 (I1_I2066_P18_3n I1_I2066_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I169_XP_MP0 (VDD I1_I2066_P18_11 I1_I2066_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I111_XP_MP1 (I1_I2066_P15_12n I1_I2066_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I111_XP_MP0 (VDD I1_I2066_P15_14 I1_I2066_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I176_XP_MP1 (I1_I2066_P25_10n I1_I2066_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I176_XP_MP0 (VDD I1_I2066_P25_18 I1_I2066_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I494_MP1 (I2_I3_hd41 DIVR_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I494_MP0 (VDD I2_I3_SEL_DIV_b3_7 I2_I3_hd41 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I489_MP1 (Y_39 I2_I3_hd39 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I489_MP0 (VDD I2_I3_hm39 Y_39 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I495_MP1 (Y_41 I2_I3_hd41 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I495_MP0 (VDD I2_I3_hm41 Y_41 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I487_MP1 (I2_I3_hm39 MULP_39 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I487_MP0 (VDD I2_I3_SEL_MUL_b3_6 I2_I3_hm39 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I502_MP1 (I2_I3_hm44 MULP_44 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I502_MP0 (VDD I2_I3_SEL_MUL_b3_7 I2_I3_hm44 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I493_MP1 (I2_I3_hm41 MULP_41 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I493_MP0 (VDD I2_I3_SEL_MUL_b3_7 I2_I3_hm41 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I353_XP_MP1 (I0_I1660_P42_27n I0_I1660_P34_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I353_XP_MP0 (VDD I0_I1660_P42_35 I0_I1660_P42_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I367_XP_MP1 (I0_I1660_P56_41n I0_I1660_P48_41 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I367_XP_MP0 (VDD I0_I1660_P56_49 I0_I1660_P56_41n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I236_XP_MP1 (I0_I1660_P44_41n I0_I1660_P42_41 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I236_XP_MP0 (VDD I0_I1660_P44_43 I0_I1660_P44_41n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I368_XP_MP1 (I0_I1660_P57_42n I0_I1660_P49_42 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I368_XP_MP0 (VDD I0_I1660_P57_50 I0_I1660_P57_42n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I374_XP_MP1 (I0_I1660_P63_48n I0_I1660_P55_48 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I374_XP_MP0 (VDD I0_I1660_P63_56 I0_I1660_P63_48n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I241_XP_MP1 (I0_I1660_P49_46n I0_I1660_P47_46 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I241_XP_MP0 (VDD I0_I1660_P49_48 I0_I1660_P49_46n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I46_MP1 (I0_I1660_gn46 I0_ha290_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I46_MP0 (VDD I0_fa289_1 I0_I1660_gn46 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I47_MP1 (I0_I1660_gn47 I0_fa291_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I47_MP0 (VDD I0_ha290_1 I0_I1660_gn47 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I182_XP_MP1 (I1_I1850_P31_16n I1_I1850_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I182_XP_MP0 (VDD I1_I1850_P31_24 I1_I1850_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I117_XP_MP1 (I1_I1850_P21_18n I1_I1850_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I117_XP_MP0 (VDD I1_I1850_P21_20 I1_I1850_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I176_XP_MP1 (I1_I1850_P25_10n I1_I1850_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I176_XP_MP0 (VDD I1_I1850_P25_18 I1_I1850_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I18_MP1 (I1_I1850_gn18 I1_b28_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I18_MP0 (VDD I1_p27_17 I1_I1850_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I114_XP_MP1 (I1_I1850_P18_15n I1_I1850_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I114_XP_MP0 (VDD I1_I1850_P18_17 I1_I1850_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I19_MP1 (I1_I1850_gn19 I1_b28_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I19_MP0 (VDD I1_p27_18 I1_I1850_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I169_XP_MP1 (I1_I1850_P18_3n I1_I1850_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I169_XP_MP0 (VDD I1_I1850_P18_11 I1_I1850_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I18_MP1 (I1_I1896_gn18 I1_b29_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I18_MP0 (VDD I1_p28_17 I1_I1896_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I16_MP1 (I1_I1896_gn16 I1_b29_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I16_MP0 (VDD I1_p28_15 I1_I1896_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I115_XP_MP1 (I1_I1896_P19_16n I1_I1896_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I115_XP_MP0 (VDD I1_I1896_P19_18 I1_I1896_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I172_XP_MP1 (I1_I1896_P21_6n I1_I1896_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I172_XP_MP0 (VDD I1_I1896_P21_14 I1_I1896_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I19_MP1 (I1_I1942_gn19 I1_b30_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I19_MP0 (VDD I1_p29_18 I1_I1942_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I118_XP_MP1 (I1_I1942_P22_19n I1_I1942_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I118_XP_MP0 (VDD I1_I1942_P22_21 I1_I1942_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I173_XP_MP1 (I1_I1942_P22_7n I1_I1942_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I173_XP_MP0 (VDD I1_I1942_P22_15 I1_I1942_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2040_MP1 (I1_dmn19 I1_p31_32_b3_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2040_MP0 (VDD I1_dd19_b3_5 I1_dmn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2038_MP1 (I1_dmn18 I1_p31_32_b3_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2038_MP0 (VDD I1_dd18_b3_5 I1_dmn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I20_MP1 (I1_I1988_gn20 I1_b31_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I20_MP0 (VDD I1_p30_19 I1_I1988_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I119_XP_MP1 (I1_I1988_P23_20n I1_I1988_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I119_XP_MP0 (VDD I1_I1988_P23_22 I1_I1988_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I174_XP_MP1 (I1_I1988_P23_8n I1_I1988_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I174_XP_MP0 (VDD I1_I1988_P23_16 I1_I1988_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I118_XP_MP1 (I1_I1988_P22_19n I1_I1988_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I118_XP_MP0 (VDD I1_I1988_P22_21 I1_I1988_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I173_XP_MP1 (I1_I1988_P22_7n I1_I1988_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I173_XP_MP0 (VDD I1_I1988_P22_15 I1_I1988_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I18_MP1 (I1_I2066_gn18 I1_dm18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I18_MP0 (VDD I1_p31_18 I1_I2066_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I171_XP_MP1 (I1_I2066_P20_5n I1_I2066_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I171_XP_MP0 (VDD I1_I2066_P20_13 I1_I2066_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I115_XP_MP1 (I1_I2066_P19_16n I1_I2066_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I115_XP_MP0 (VDD I1_I2066_P19_18 I1_I2066_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I113_XP_MP1 (I1_I2066_P17_14n I1_I2066_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I113_XP_MP0 (VDD I1_I2066_P17_16 I1_I2066_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I503_MP1 (I2_I3_hd44 DIVR_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I503_MP0 (VDD I2_I3_SEL_DIV_b3_7 I2_I3_hd44 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I497_MP1 (I2_I3_hd42 DIVR_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I497_MP0 (VDD I2_I3_SEL_DIV_b3_7 I2_I3_hd42 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I500_MP1 (I2_I3_hd43 DIVR_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I500_MP0 (VDD I2_I3_SEL_DIV_b3_7 I2_I3_hd43 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I498_MP1 (Y_42 I2_I3_hd42 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I498_MP0 (VDD I2_I3_hm42 Y_42 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I504_MP1 (Y_44 I2_I3_hd44 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I504_MP0 (VDD I2_I3_hm44 Y_44 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I499_MP1 (I2_I3_hm43 MULP_43 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I499_MP0 (VDD I2_I3_SEL_MUL_b3_7 I2_I3_hm43 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I496_MP1 (I2_I3_hm42 MULP_42 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I496_MP0 (VDD I2_I3_SEL_MUL_b3_7 I2_I3_hm42 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I341_XP_MP1 (I0_I1660_P30_15n I0_I1660_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I341_XP_MP0 (VDD I0_I1660_P30_23 I0_I1660_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I349_XP_MP1 (I0_I1660_P38_23n I0_I1660_P30_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I349_XP_MP0 (VDD I0_I1660_P38_31 I0_I1660_P38_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I361_XP_MP1 (I0_I1660_P50_35n I0_I1660_P42_35 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
