    I_MXI1_I884_I45_MN2 (XI1_I884_I45_n1 I1_p6_12 I1_I884_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I45_MN3 (VSS XI1_I884_I45_Bn XI1_I884_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I45_MN0 (XI1_I884_I45_An I1_p6_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I43_MN1 (XI1_I884_I43_Bn I1_b7_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I43_MN5 (XI1_I884_I43_n2 I1_b7_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I43_MN4 (I1_I884_pn11 XI1_I884_I43_An XI1_I884_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I43_MN2 (XI1_I884_I43_n1 I1_p6_10 I1_I884_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I43_MN3 (VSS XI1_I884_I43_Bn XI1_I884_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I43_MN0 (XI1_I884_I43_An I1_p6_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I36_MN1 (XI1_I838_I36_Bn I1_b6_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I36_MN5 (XI1_I838_I36_n2 I1_b6_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I36_MN4 (I1_I838_pn4 XI1_I838_I36_An XI1_I838_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I36_MN2 (XI1_I838_I36_n1 I1_p5_3 I1_I838_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I36_MN3 (VSS XI1_I838_I36_Bn XI1_I838_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I36_MN0 (XI1_I838_I36_An I1_p5_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I38_MN1 (XI1_I792_I38_Bn I1_b5_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I38_MN5 (XI1_I792_I38_n2 I1_b5_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I38_MN4 (I1_I792_pn6 XI1_I792_I38_An XI1_I792_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I38_MN2 (XI1_I792_I38_n1 I1_p4_5 I1_I792_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I38_MN3 (VSS XI1_I792_I38_Bn XI1_I792_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I38_MN0 (XI1_I792_I38_An I1_p4_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I40_MN1 (XI1_I792_I40_Bn I1_b5_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I40_MN5 (XI1_I792_I40_n2 I1_b5_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I40_MN4 (I1_I792_pn8 XI1_I792_I40_An XI1_I792_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I40_MN2 (XI1_I792_I40_n1 I1_p4_7 I1_I792_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I40_MN3 (VSS XI1_I792_I40_Bn XI1_I792_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I40_MN0 (XI1_I792_I40_An I1_p4_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I43_MN1 (XI1_I792_I43_Bn I1_b5_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I43_MN5 (XI1_I792_I43_n2 I1_b5_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I43_MN4 (I1_I792_pn11 XI1_I792_I43_An XI1_I792_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I43_MN2 (XI1_I792_I43_n1 I1_p4_10 I1_I792_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I43_MN3 (VSS XI1_I792_I43_Bn XI1_I792_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I43_MN0 (XI1_I792_I43_An I1_p4_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I210_MN1 (XI1_I746_I210_Bn I1_I746_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I210_MN5 (XI1_I746_I210_n2 I1_I746_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I210_MN4 (I1_p4_7 XI1_I746_I210_An XI1_I746_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I210_MN2 (XI1_I746_I210_n1 I1_I746_pn7 I1_p4_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I210_MN3 (VSS XI1_I746_I210_Bn XI1_I746_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I210_MN0 (XI1_I746_I210_An I1_I746_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I60_MN1 (XI1_I1390_I60_Bn I1_b18_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I60_MN5 (XI1_I1390_I60_n2 I1_b18_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I60_MN4 (I1_I1390_pn28 XI1_I1390_I60_An XI1_I1390_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I60_MN2 (XI1_I1390_I60_n1 I1_p17_27 I1_I1390_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I60_MN3 (VSS XI1_I1390_I60_Bn XI1_I1390_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I60_MN0 (XI1_I1390_I60_An I1_p17_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I226_MN1 (XI1_I1344_I226_Bn I1_I1344_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I226_MN5 (XI1_I1344_I226_n2 I1_I1344_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I226_MN4 (I1_p17_23 XI1_I1344_I226_An XI1_I1344_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I226_MN2 (XI1_I1344_I226_n1 I1_I1344_pn23 I1_p17_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I226_MN3 (VSS XI1_I1344_I226_Bn XI1_I1344_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I226_MN0 (XI1_I1344_I226_An I1_I1344_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I43_MN1 (XI1_I1344_I43_Bn I1_b17_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I43_MN5 (XI1_I1344_I43_n2 I1_b17_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I43_MN4 (I1_I1344_pn11 XI1_I1344_I43_An XI1_I1344_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I43_MN2 (XI1_I1344_I43_n1 I1_p16_10 I1_I1344_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I43_MN3 (VSS XI1_I1344_I43_Bn XI1_I1344_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I43_MN0 (XI1_I1344_I43_An I1_p16_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I211_MN1 (XI1_I1298_I211_Bn I1_I1298_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I211_MN5 (XI1_I1298_I211_n2 I1_I1298_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I211_MN4 (I1_p16_8 XI1_I1298_I211_An XI1_I1298_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I211_MN2 (XI1_I1298_I211_n1 I1_I1298_pn8 I1_p16_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I211_MN3 (VSS XI1_I1298_I211_Bn XI1_I1298_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I211_MN0 (XI1_I1298_I211_An I1_I1298_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I44_MN1 (XI1_I1298_I44_Bn I1_b16_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I44_MN5 (XI1_I1298_I44_n2 I1_b16_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I44_MN4 (I1_I1298_pn12 XI1_I1298_I44_An XI1_I1298_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I44_MN2 (XI1_I1298_I44_n1 I1_p15_11 I1_I1298_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I44_MN3 (VSS XI1_I1298_I44_Bn XI1_I1298_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I44_MN0 (XI1_I1298_I44_An I1_p15_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I43_MN1 (XI1_I1298_I43_Bn I1_b16_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I43_MN5 (XI1_I1298_I43_n2 I1_b16_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I43_MN4 (I1_I1298_pn11 XI1_I1298_I43_An XI1_I1298_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I43_MN2 (XI1_I1298_I43_n1 I1_p15_10 I1_I1298_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I43_MN3 (VSS XI1_I1298_I43_Bn XI1_I1298_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I43_MN0 (XI1_I1298_I43_An I1_p15_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I43_MN1 (XI1_I1252_I43_Bn I1_b15_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I43_MN5 (XI1_I1252_I43_n2 I1_b15_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I43_MN4 (I1_I1252_pn11 XI1_I1252_I43_An XI1_I1252_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I43_MN2 (XI1_I1252_I43_n1 I1_p14_10 I1_I1252_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I43_MN3 (VSS XI1_I1252_I43_Bn XI1_I1252_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I43_MN0 (XI1_I1252_I43_An I1_p14_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I44_MN1 (XI1_I1252_I44_Bn I1_b15_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I44_MN5 (XI1_I1252_I44_n2 I1_b15_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I44_MN4 (I1_I1252_pn12 XI1_I1252_I44_An XI1_I1252_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I44_MN2 (XI1_I1252_I44_n1 I1_p14_11 I1_I1252_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I44_MN3 (VSS XI1_I1252_I44_Bn XI1_I1252_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I44_MN0 (XI1_I1252_I44_An I1_p14_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I46_MN1 (XI1_I1206_I46_Bn I1_b14_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I46_MN5 (XI1_I1206_I46_n2 I1_b14_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I46_MN4 (I1_I1206_pn14 XI1_I1206_I46_An XI1_I1206_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I46_MN2 (XI1_I1206_I46_n1 I1_p13_13 I1_I1206_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I46_MN3 (VSS XI1_I1206_I46_Bn XI1_I1206_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I46_MN0 (XI1_I1206_I46_An I1_p13_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I44_MN1 (XI1_I884_I44_Bn I1_b7_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I44_MN5 (XI1_I884_I44_n2 I1_b7_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I44_MN4 (I1_I884_pn12 XI1_I884_I44_An XI1_I884_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I44_MN2 (XI1_I884_I44_n1 I1_p6_11 I1_I884_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I44_MN3 (VSS XI1_I884_I44_Bn XI1_I884_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I44_MN0 (XI1_I884_I44_An I1_p6_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I42_MN1 (XI1_I884_I42_Bn I1_b7_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I42_MN5 (XI1_I884_I42_n2 I1_b7_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I42_MN4 (I1_I884_pn10 XI1_I884_I42_An XI1_I884_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I42_MN2 (XI1_I884_I42_n1 I1_p6_9 I1_I884_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I42_MN3 (VSS XI1_I884_I42_Bn XI1_I884_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I42_MN0 (XI1_I884_I42_An I1_p6_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I41_MN1 (XI1_I884_I41_Bn I1_b7_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I41_MN5 (XI1_I884_I41_n2 I1_b7_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I41_MN4 (I1_I884_pn9 XI1_I884_I41_An XI1_I884_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I41_MN2 (XI1_I884_I41_n1 I1_p6_8 I1_I884_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I41_MN3 (VSS XI1_I884_I41_Bn XI1_I884_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I41_MN0 (XI1_I884_I41_An I1_p6_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I35_MN1 (XI1_I838_I35_Bn I1_b6_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I35_MN5 (XI1_I838_I35_n2 I1_b6_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I35_MN4 (I1_I838_pn3 XI1_I838_I35_An XI1_I838_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I35_MN2 (XI1_I838_I35_n1 I1_p5_2 I1_I838_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I35_MN3 (VSS XI1_I838_I35_Bn XI1_I838_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I35_MN0 (XI1_I838_I35_An I1_p5_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I205_MN1 (XI1_I792_I205_Bn I1_I792_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I205_MN5 (XI1_I792_I205_n2 I1_I792_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I205_MN4 (I1_p5_2 XI1_I792_I205_An XI1_I792_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I205_MN2 (XI1_I792_I205_n1 I1_I792_pn2 I1_p5_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I205_MN3 (VSS XI1_I792_I205_Bn XI1_I792_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I205_MN0 (XI1_I792_I205_An I1_I792_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I37_MN1 (XI1_I792_I37_Bn I1_b5_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I37_MN5 (XI1_I792_I37_n2 I1_b5_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I37_MN4 (I1_I792_pn5 XI1_I792_I37_An XI1_I792_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I37_MN2 (XI1_I792_I37_n1 I1_p4_4 I1_I792_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I37_MN3 (VSS XI1_I792_I37_Bn XI1_I792_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I37_MN0 (XI1_I792_I37_An I1_p4_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I39_MN1 (XI1_I792_I39_Bn I1_b5_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I39_MN5 (XI1_I792_I39_n2 I1_b5_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I39_MN4 (I1_I792_pn7 XI1_I792_I39_An XI1_I792_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I39_MN2 (XI1_I792_I39_n1 I1_p4_6 I1_I792_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I39_MN3 (VSS XI1_I792_I39_Bn XI1_I792_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I39_MN0 (XI1_I792_I39_An I1_p4_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I41_MN1 (XI1_I792_I41_Bn I1_b5_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I41_MN5 (XI1_I792_I41_n2 I1_b5_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I41_MN4 (I1_I792_pn9 XI1_I792_I41_An XI1_I792_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I41_MN2 (XI1_I792_I41_n1 I1_p4_8 I1_I792_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I41_MN3 (VSS XI1_I792_I41_Bn XI1_I792_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I41_MN0 (XI1_I792_I41_An I1_p4_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I208_MN1 (XI1_I746_I208_Bn I1_I746_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I208_MN5 (XI1_I746_I208_n2 I1_I746_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I208_MN4 (I1_p4_5 XI1_I746_I208_An XI1_I746_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I208_MN2 (XI1_I746_I208_n1 I1_I746_pn5 I1_p4_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I208_MN3 (VSS XI1_I746_I208_Bn XI1_I746_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I208_MN0 (XI1_I746_I208_An I1_I746_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I209_MN1 (XI1_I746_I209_Bn I1_I746_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I209_MN5 (XI1_I746_I209_n2 I1_I746_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I209_MN4 (I1_p4_6 XI1_I746_I209_An XI1_I746_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I209_MN2 (XI1_I746_I209_n1 I1_I746_pn6 I1_p4_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I209_MN3 (VSS XI1_I746_I209_Bn XI1_I746_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I209_MN0 (XI1_I746_I209_An I1_I746_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I211_MN1 (XI1_I746_I211_Bn I1_I746_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I211_MN5 (XI1_I746_I211_n2 I1_I746_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I211_MN4 (I1_p4_8 XI1_I746_I211_An XI1_I746_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I211_MN2 (XI1_I746_I211_n1 I1_I746_pn8 I1_p4_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I211_MN3 (VSS XI1_I746_I211_Bn XI1_I746_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I211_MN0 (XI1_I746_I211_An I1_I746_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I53_MN1 (XI1_I746_I53_Bn I1_b4_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I53_MN5 (XI1_I746_I53_n2 I1_b4_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I53_MN4 (I1_I746_pn21 XI1_I746_I53_An XI1_I746_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I53_MN2 (XI1_I746_I53_n1 I1_p3_20 I1_I746_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I53_MN3 (VSS XI1_I746_I53_Bn XI1_I746_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I53_MN0 (XI1_I746_I53_An I1_p3_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I55_MN1 (XI1_I746_I55_Bn I1_b4_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I55_MN5 (XI1_I746_I55_n2 I1_b4_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I55_MN4 (I1_I746_pn23 XI1_I746_I55_An XI1_I746_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I55_MN2 (XI1_I746_I55_n1 I1_p3_22 I1_I746_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I55_MN3 (VSS XI1_I746_I55_Bn XI1_I746_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I55_MN0 (XI1_I746_I55_An I1_p3_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I63_MN1 (XI1_I1390_I63_Bn I1_b18_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I63_MN5 (XI1_I1390_I63_n2 I1_b18_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I63_MN4 (I1_I1390_pn31 XI1_I1390_I63_An XI1_I1390_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I63_MN2 (XI1_I1390_I63_n1 I1_p17_30 I1_I1390_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I63_MN3 (VSS XI1_I1390_I63_Bn XI1_I1390_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I63_MN0 (XI1_I1390_I63_An I1_p17_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I58_MN1 (XI1_I1390_I58_Bn I1_b18_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I58_MN5 (XI1_I1390_I58_n2 I1_b18_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I58_MN4 (I1_I1390_pn26 XI1_I1390_I58_An XI1_I1390_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I58_MN2 (XI1_I1390_I58_n1 I1_p17_25 I1_I1390_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I58_MN3 (VSS XI1_I1390_I58_Bn XI1_I1390_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I58_MN0 (XI1_I1390_I58_An I1_p17_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I56_MN1 (XI1_I1390_I56_Bn I1_b18_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I56_MN5 (XI1_I1390_I56_n2 I1_b18_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I56_MN4 (I1_I1390_pn24 XI1_I1390_I56_An XI1_I1390_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I56_MN2 (XI1_I1390_I56_n1 I1_p17_23 I1_I1390_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I56_MN3 (VSS XI1_I1390_I56_Bn XI1_I1390_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I56_MN0 (XI1_I1390_I56_An I1_p17_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I54_MN1 (XI1_I1390_I54_Bn I1_b18_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I54_MN5 (XI1_I1390_I54_n2 I1_b18_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I54_MN4 (I1_I1390_pn22 XI1_I1390_I54_An XI1_I1390_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I54_MN2 (XI1_I1390_I54_n1 I1_p17_21 I1_I1390_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I54_MN3 (VSS XI1_I1390_I54_Bn XI1_I1390_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I54_MN0 (XI1_I1390_I54_An I1_p17_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I52_MN1 (XI1_I1390_I52_Bn I1_b18_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I52_MN5 (XI1_I1390_I52_n2 I1_b18_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I52_MN4 (I1_I1390_pn20 XI1_I1390_I52_An XI1_I1390_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I52_MN2 (XI1_I1390_I52_n1 I1_p17_19 I1_I1390_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I52_MN3 (VSS XI1_I1390_I52_Bn XI1_I1390_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I52_MN0 (XI1_I1390_I52_An I1_p17_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I222_MN1 (XI1_I1344_I222_Bn I1_I1344_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I222_MN5 (XI1_I1344_I222_n2 I1_I1344_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I222_MN4 (I1_p17_19 XI1_I1344_I222_An XI1_I1344_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I222_MN2 (XI1_I1344_I222_n1 I1_I1344_pn19 I1_p17_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I222_MN3 (VSS XI1_I1344_I222_Bn XI1_I1344_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I222_MN0 (XI1_I1344_I222_An I1_I1344_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I220_MN1 (XI1_I1344_I220_Bn I1_I1344_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I220_MN5 (XI1_I1344_I220_n2 I1_I1344_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I220_MN4 (I1_p17_17 XI1_I1344_I220_An XI1_I1344_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I220_MN2 (XI1_I1344_I220_n1 I1_I1344_pn17 I1_p17_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I220_MN3 (VSS XI1_I1344_I220_Bn XI1_I1344_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I220_MN0 (XI1_I1344_I220_An I1_I1344_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I211_MN1 (XI1_I1344_I211_Bn I1_I1344_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I211_MN5 (XI1_I1344_I211_n2 I1_I1344_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I211_MN4 (I1_p17_8 XI1_I1344_I211_An XI1_I1344_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I211_MN2 (XI1_I1344_I211_n1 I1_I1344_pn8 I1_p17_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I211_MN3 (VSS XI1_I1344_I211_Bn XI1_I1344_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I211_MN0 (XI1_I1344_I211_An I1_I1344_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I42_MN1 (XI1_I1344_I42_Bn I1_b17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I42_MN5 (XI1_I1344_I42_n2 I1_b17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I42_MN4 (I1_I1344_pn10 XI1_I1344_I42_An XI1_I1344_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I42_MN2 (XI1_I1344_I42_n1 I1_p16_9 I1_I1344_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I42_MN3 (VSS XI1_I1344_I42_Bn XI1_I1344_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I42_MN0 (XI1_I1344_I42_An I1_p16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I41_MN1 (XI1_I1344_I41_Bn I1_b17_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I41_MN5 (XI1_I1344_I41_n2 I1_b17_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I41_MN4 (I1_I1344_pn9 XI1_I1344_I41_An XI1_I1344_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I41_MN2 (XI1_I1344_I41_n1 I1_p16_8 I1_I1344_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I41_MN3 (VSS XI1_I1344_I41_Bn XI1_I1344_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I41_MN0 (XI1_I1344_I41_An I1_p16_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I40_MN1 (XI1_I1344_I40_Bn I1_b17_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I40_MN5 (XI1_I1344_I40_n2 I1_b17_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I40_MN4 (I1_I1344_pn8 XI1_I1344_I40_An XI1_I1344_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I40_MN2 (XI1_I1344_I40_n1 I1_p16_7 I1_I1344_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I40_MN3 (VSS XI1_I1344_I40_Bn XI1_I1344_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I40_MN0 (XI1_I1344_I40_An I1_p16_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I210_MN1 (XI1_I1298_I210_Bn I1_I1298_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I210_MN5 (XI1_I1298_I210_n2 I1_I1298_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I210_MN4 (I1_p16_7 XI1_I1298_I210_An XI1_I1298_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I210_MN2 (XI1_I1298_I210_n1 I1_I1298_pn7 I1_p16_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I210_MN3 (VSS XI1_I1298_I210_Bn XI1_I1298_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I210_MN0 (XI1_I1298_I210_An I1_I1298_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I42_MN1 (XI1_I1298_I42_Bn I1_b16_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I42_MN5 (XI1_I1298_I42_n2 I1_b16_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I42_MN4 (I1_I1298_pn10 XI1_I1298_I42_An XI1_I1298_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I42_MN2 (XI1_I1298_I42_n1 I1_p15_9 I1_I1298_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I42_MN3 (VSS XI1_I1298_I42_Bn XI1_I1298_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I42_MN0 (XI1_I1298_I42_An I1_p15_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I41_MN1 (XI1_I1298_I41_Bn I1_b16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I41_MN5 (XI1_I1298_I41_n2 I1_b16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I41_MN4 (I1_I1298_pn9 XI1_I1298_I41_An XI1_I1298_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I41_MN2 (XI1_I1298_I41_n1 I1_p15_8 I1_I1298_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I41_MN3 (VSS XI1_I1298_I41_Bn XI1_I1298_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I41_MN0 (XI1_I1298_I41_An I1_p15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I210_MN1 (XI1_I1252_I210_Bn I1_I1252_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I210_MN5 (XI1_I1252_I210_n2 I1_I1252_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I210_MN4 (I1_p15_7 XI1_I1252_I210_An XI1_I1252_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I210_MN2 (XI1_I1252_I210_n1 I1_I1252_pn7 I1_p15_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I210_MN3 (VSS XI1_I1252_I210_Bn XI1_I1252_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I210_MN0 (XI1_I1252_I210_An I1_I1252_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I211_MN1 (XI1_I1252_I211_Bn I1_I1252_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I211_MN5 (XI1_I1252_I211_n2 I1_I1252_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I211_MN4 (I1_p15_8 XI1_I1252_I211_An XI1_I1252_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I211_MN2 (XI1_I1252_I211_n1 I1_I1252_pn8 I1_p15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I211_MN3 (VSS XI1_I1252_I211_Bn XI1_I1252_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I211_MN0 (XI1_I1252_I211_An I1_I1252_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I41_MN1 (XI1_I1252_I41_Bn I1_b15_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I41_MN5 (XI1_I1252_I41_n2 I1_b15_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I41_MN4 (I1_I1252_pn9 XI1_I1252_I41_An XI1_I1252_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I41_MN2 (XI1_I1252_I41_n1 I1_p14_8 I1_I1252_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I41_MN3 (VSS XI1_I1252_I41_Bn XI1_I1252_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I41_MN0 (XI1_I1252_I41_An I1_p14_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I45_MN1 (XI1_I1206_I45_Bn I1_b14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I45_MN5 (XI1_I1206_I45_n2 I1_b14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I45_MN4 (I1_I1206_pn13 XI1_I1206_I45_An XI1_I1206_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I45_MN2 (XI1_I1206_I45_n1 I1_p13_12 I1_I1206_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I45_MN3 (VSS XI1_I1206_I45_Bn XI1_I1206_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I45_MN0 (XI1_I1206_I45_An I1_p13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I211_MN1 (XI1_I1206_I211_Bn I1_I1206_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I211_MN5 (XI1_I1206_I211_n2 I1_I1206_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I211_MN4 (I1_p14_8 XI1_I1206_I211_An XI1_I1206_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I211_MN2 (XI1_I1206_I211_n1 I1_I1206_pn8 I1_p14_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I211_MN3 (VSS XI1_I1206_I211_Bn XI1_I1206_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I211_MN0 (XI1_I1206_I211_An I1_I1206_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I210_MN1 (XI1_I1206_I210_Bn I1_I1206_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I210_MN5 (XI1_I1206_I210_n2 I1_I1206_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I210_MN4 (I1_p14_7 XI1_I1206_I210_An XI1_I1206_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I210_MN2 (XI1_I1206_I210_n1 I1_I1206_pn7 I1_p14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I210_MN3 (VSS XI1_I1206_I210_Bn XI1_I1206_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I210_MN0 (XI1_I1206_I210_An I1_I1206_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I62_MN1 (XI1_I884_I62_Bn I1_b7_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I62_MN5 (XI1_I884_I62_n2 I1_b7_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I62_MN4 (I1_I884_pn30 XI1_I884_I62_An XI1_I884_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I62_MN2 (XI1_I884_I62_n1 I1_p6_29 I1_I884_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I62_MN3 (VSS XI1_I884_I62_Bn XI1_I884_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I62_MN0 (XI1_I884_I62_An I1_p6_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I231_MN1 (XI1_I884_I231_Bn I1_I884_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I231_MN5 (XI1_I884_I231_n2 I1_I884_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I231_MN4 (I1_p7_28 XI1_I884_I231_An XI1_I884_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I231_MN2 (XI1_I884_I231_n1 I1_I884_pn28 I1_p7_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I231_MN3 (VSS XI1_I884_I231_Bn XI1_I884_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I231_MN0 (XI1_I884_I231_An I1_I884_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I40_MN1 (XI1_I884_I40_Bn I1_b7_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I40_MN5 (XI1_I884_I40_n2 I1_b7_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I40_MN4 (I1_I884_pn8 XI1_I884_I40_An XI1_I884_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I40_MN2 (XI1_I884_I40_n1 I1_p6_7 I1_I884_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I40_MN3 (VSS XI1_I884_I40_Bn XI1_I884_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I40_MN0 (XI1_I884_I40_An I1_p6_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I39_MN1 (XI1_I884_I39_Bn I1_b7_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I39_MN5 (XI1_I884_I39_n2 I1_b7_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I39_MN4 (I1_I884_pn7 XI1_I884_I39_An XI1_I884_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I39_MN2 (XI1_I884_I39_n1 I1_p6_6 I1_I884_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I39_MN3 (VSS XI1_I884_I39_Bn XI1_I884_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I39_MN0 (XI1_I884_I39_An I1_p6_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I205_MN1 (XI1_I838_I205_Bn I1_I838_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I205_MN5 (XI1_I838_I205_n2 I1_I838_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I205_MN4 (I1_p6_2 XI1_I838_I205_An XI1_I838_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I205_MN2 (XI1_I838_I205_n1 I1_I838_pn2 I1_p6_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I205_MN3 (VSS XI1_I838_I205_Bn XI1_I838_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I205_MN0 (XI1_I838_I205_An I1_I838_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I34_MN1 (XI1_I838_I34_Bn I1_b6_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I34_MN5 (XI1_I838_I34_n2 I1_b6_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I34_MN4 (I1_I838_pn2 XI1_I838_I34_An XI1_I838_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I34_MN2 (XI1_I838_I34_n1 I1_p5_1 I1_I838_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I34_MN3 (VSS XI1_I838_I34_Bn XI1_I838_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I34_MN0 (XI1_I838_I34_An I1_p5_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I36_MN1 (XI1_I792_I36_Bn I1_b5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I36_MN5 (XI1_I792_I36_n2 I1_b5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I36_MN4 (I1_I792_pn4 XI1_I792_I36_An XI1_I792_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I36_MN2 (XI1_I792_I36_n1 I1_p4_3 I1_I792_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I36_MN3 (VSS XI1_I792_I36_Bn XI1_I792_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I36_MN0 (XI1_I792_I36_An I1_p4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I44_MN1 (XI1_I746_I44_Bn I1_b4_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I44_MN5 (XI1_I746_I44_n2 I1_b4_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I44_MN4 (I1_I746_pn12 XI1_I746_I44_An XI1_I746_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I44_MN2 (XI1_I746_I44_n1 I1_p3_11 I1_I746_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I44_MN3 (VSS XI1_I746_I44_Bn XI1_I746_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I44_MN0 (XI1_I746_I44_An I1_p3_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I46_MN1 (XI1_I746_I46_Bn I1_b4_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I46_MN5 (XI1_I746_I46_n2 I1_b4_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I46_MN4 (I1_I746_pn14 XI1_I746_I46_An XI1_I746_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I46_MN2 (XI1_I746_I46_n1 I1_p3_13 I1_I746_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I46_MN3 (VSS XI1_I746_I46_Bn XI1_I746_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I46_MN0 (XI1_I746_I46_An I1_p3_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I48_MN1 (XI1_I746_I48_Bn I1_b4_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I48_MN5 (XI1_I746_I48_n2 I1_b4_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I48_MN4 (I1_I746_pn16 XI1_I746_I48_An XI1_I746_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I48_MN2 (XI1_I746_I48_n1 I1_p3_15 I1_I746_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I48_MN3 (VSS XI1_I746_I48_Bn XI1_I746_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I48_MN0 (XI1_I746_I48_An I1_p3_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I50_MN1 (XI1_I746_I50_Bn I1_b4_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I50_MN5 (XI1_I746_I50_n2 I1_b4_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I50_MN4 (I1_I746_pn18 XI1_I746_I50_An XI1_I746_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I50_MN2 (XI1_I746_I50_n1 I1_p3_17 I1_I746_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I50_MN3 (VSS XI1_I746_I50_Bn XI1_I746_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I50_MN0 (XI1_I746_I50_An I1_p3_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I52_MN1 (XI1_I746_I52_Bn I1_b4_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I52_MN5 (XI1_I746_I52_n2 I1_b4_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I52_MN4 (I1_I746_pn20 XI1_I746_I52_An XI1_I746_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I52_MN2 (XI1_I746_I52_n1 I1_p3_19 I1_I746_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I52_MN3 (VSS XI1_I746_I52_Bn XI1_I746_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I52_MN0 (XI1_I746_I52_An I1_p3_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I54_MN1 (XI1_I746_I54_Bn I1_b4_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I54_MN5 (XI1_I746_I54_n2 I1_b4_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I54_MN4 (I1_I746_pn22 XI1_I746_I54_An XI1_I746_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I54_MN2 (XI1_I746_I54_n1 I1_p3_21 I1_I746_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I54_MN3 (VSS XI1_I746_I54_Bn XI1_I746_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I54_MN0 (XI1_I746_I54_An I1_p3_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I62_MN1 (XI1_I1390_I62_Bn I1_b18_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I62_MN5 (XI1_I1390_I62_n2 I1_b18_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I62_MN4 (I1_I1390_pn30 XI1_I1390_I62_An XI1_I1390_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I62_MN2 (XI1_I1390_I62_n1 I1_p17_29 I1_I1390_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I62_MN3 (VSS XI1_I1390_I62_Bn XI1_I1390_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I62_MN0 (XI1_I1390_I62_An I1_p17_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I55_MN1 (XI1_I1390_I55_Bn I1_b18_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I55_MN5 (XI1_I1390_I55_n2 I1_b18_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I55_MN4 (I1_I1390_pn23 XI1_I1390_I55_An XI1_I1390_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I55_MN2 (XI1_I1390_I55_n1 I1_p17_22 I1_I1390_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I55_MN3 (VSS XI1_I1390_I55_Bn XI1_I1390_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I55_MN0 (XI1_I1390_I55_An I1_p17_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I50_MN1 (XI1_I1390_I50_Bn I1_b18_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I50_MN5 (XI1_I1390_I50_n2 I1_b18_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I50_MN4 (I1_I1390_pn18 XI1_I1390_I50_An XI1_I1390_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I50_MN2 (XI1_I1390_I50_n1 I1_p17_17 I1_I1390_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I50_MN3 (VSS XI1_I1390_I50_Bn XI1_I1390_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I50_MN0 (XI1_I1390_I50_An I1_p17_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I49_MN1 (XI1_I1390_I49_Bn I1_b18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I49_MN5 (XI1_I1390_I49_n2 I1_b18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I49_MN4 (I1_I1390_pn17 XI1_I1390_I49_An XI1_I1390_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I49_MN2 (XI1_I1390_I49_n1 I1_p17_16 I1_I1390_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I49_MN3 (VSS XI1_I1390_I49_Bn XI1_I1390_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I49_MN0 (XI1_I1390_I49_An I1_p17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I210_MN1 (XI1_I1344_I210_Bn I1_I1344_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I210_MN5 (XI1_I1344_I210_n2 I1_I1344_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I210_MN4 (I1_p17_7 XI1_I1344_I210_An XI1_I1344_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I210_MN2 (XI1_I1344_I210_n1 I1_I1344_pn7 I1_p17_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I210_MN3 (VSS XI1_I1344_I210_Bn XI1_I1344_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I210_MN0 (XI1_I1344_I210_An I1_I1344_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I39_MN1 (XI1_I1344_I39_Bn I1_b17_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I39_MN5 (XI1_I1344_I39_n2 I1_b17_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I39_MN4 (I1_I1344_pn7 XI1_I1344_I39_An XI1_I1344_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I39_MN2 (XI1_I1344_I39_n1 I1_p16_6 I1_I1344_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I39_MN3 (VSS XI1_I1344_I39_Bn XI1_I1344_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I39_MN0 (XI1_I1344_I39_An I1_p16_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I209_MN1 (XI1_I1298_I209_Bn I1_I1298_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I209_MN5 (XI1_I1298_I209_n2 I1_I1298_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I209_MN4 (I1_p16_6 XI1_I1298_I209_An XI1_I1298_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I209_MN2 (XI1_I1298_I209_n1 I1_I1298_pn6 I1_p16_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I209_MN3 (VSS XI1_I1298_I209_Bn XI1_I1298_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I209_MN0 (XI1_I1298_I209_An I1_I1298_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I40_MN1 (XI1_I1298_I40_Bn I1_b16_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I40_MN5 (XI1_I1298_I40_n2 I1_b16_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I40_MN4 (I1_I1298_pn8 XI1_I1298_I40_An XI1_I1298_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I40_MN2 (XI1_I1298_I40_n1 I1_p15_7 I1_I1298_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I40_MN3 (VSS XI1_I1298_I40_Bn XI1_I1298_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I40_MN0 (XI1_I1298_I40_An I1_p15_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I209_MN1 (XI1_I1252_I209_Bn I1_I1252_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I209_MN5 (XI1_I1252_I209_n2 I1_I1252_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I209_MN4 (I1_p15_6 XI1_I1252_I209_An XI1_I1252_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I209_MN2 (XI1_I1252_I209_n1 I1_I1252_pn6 I1_p15_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I209_MN3 (VSS XI1_I1252_I209_Bn XI1_I1252_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I209_MN0 (XI1_I1252_I209_An I1_I1252_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I39_MN1 (XI1_I1252_I39_Bn I1_b15_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I39_MN5 (XI1_I1252_I39_n2 I1_b15_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I39_MN4 (I1_I1252_pn7 XI1_I1252_I39_An XI1_I1252_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I39_MN2 (XI1_I1252_I39_n1 I1_p14_6 I1_I1252_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I39_MN3 (VSS XI1_I1252_I39_Bn XI1_I1252_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I39_MN0 (XI1_I1252_I39_An I1_p14_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I40_MN1 (XI1_I1252_I40_Bn I1_b15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I40_MN5 (XI1_I1252_I40_n2 I1_b15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I40_MN4 (I1_I1252_pn8 XI1_I1252_I40_An XI1_I1252_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I40_MN2 (XI1_I1252_I40_n1 I1_p14_7 I1_I1252_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I40_MN3 (VSS XI1_I1252_I40_Bn XI1_I1252_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I40_MN0 (XI1_I1252_I40_An I1_p14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I42_MN1 (XI1_I1252_I42_Bn I1_b15_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I42_MN5 (XI1_I1252_I42_n2 I1_b15_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I42_MN4 (I1_I1252_pn10 XI1_I1252_I42_An XI1_I1252_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I42_MN2 (XI1_I1252_I42_n1 I1_p14_9 I1_I1252_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I42_MN3 (VSS XI1_I1252_I42_Bn XI1_I1252_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I42_MN0 (XI1_I1252_I42_An I1_p14_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I44_MN1 (XI1_I1206_I44_Bn I1_b14_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I44_MN5 (XI1_I1206_I44_n2 I1_b14_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I44_MN4 (I1_I1206_pn12 XI1_I1206_I44_An XI1_I1206_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I44_MN2 (XI1_I1206_I44_n1 I1_p13_11 I1_I1206_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I44_MN3 (VSS XI1_I1206_I44_Bn XI1_I1206_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I44_MN0 (XI1_I1206_I44_An I1_p13_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I42_MN1 (XI1_I1206_I42_Bn I1_b14_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I42_MN5 (XI1_I1206_I42_n2 I1_b14_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I42_MN4 (I1_I1206_pn10 XI1_I1206_I42_An XI1_I1206_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I42_MN2 (XI1_I1206_I42_n1 I1_p13_9 I1_I1206_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I42_MN3 (VSS XI1_I1206_I42_Bn XI1_I1206_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I42_MN0 (XI1_I1206_I42_An I1_p13_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I43_MN1 (XI1_I1206_I43_Bn I1_b14_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I43_MN5 (XI1_I1206_I43_n2 I1_b14_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I43_MN4 (I1_I1206_pn11 XI1_I1206_I43_An XI1_I1206_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I43_MN2 (XI1_I1206_I43_n1 I1_p13_10 I1_I1206_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I43_MN3 (VSS XI1_I1206_I43_Bn XI1_I1206_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I43_MN0 (XI1_I1206_I43_An I1_p13_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I41_MN1 (XI1_I1206_I41_Bn I1_b14_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I41_MN5 (XI1_I1206_I41_n2 I1_b14_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I41_MN4 (I1_I1206_pn9 XI1_I1206_I41_An XI1_I1206_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I41_MN2 (XI1_I1206_I41_n1 I1_p13_8 I1_I1206_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I41_MN3 (VSS XI1_I1206_I41_Bn XI1_I1206_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I41_MN0 (XI1_I1206_I41_An I1_p13_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I209_MN1 (XI1_I1206_I209_Bn I1_I1206_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I209_MN5 (XI1_I1206_I209_n2 I1_I1206_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I209_MN4 (I1_p14_6 XI1_I1206_I209_An XI1_I1206_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I209_MN2 (XI1_I1206_I209_n1 I1_I1206_pn6 I1_p14_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I209_MN3 (VSS XI1_I1206_I209_Bn XI1_I1206_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I209_MN0 (XI1_I1206_I209_An I1_I1206_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I229_MN1 (XI1_I884_I229_Bn I1_I884_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I229_MN5 (XI1_I884_I229_n2 I1_I884_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I229_MN4 (I1_p7_26 XI1_I884_I229_An XI1_I884_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I229_MN2 (XI1_I884_I229_n1 I1_I884_pn26 I1_p7_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I229_MN3 (VSS XI1_I884_I229_Bn XI1_I884_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I229_MN0 (XI1_I884_I229_An I1_I884_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I227_MN1 (XI1_I884_I227_Bn I1_I884_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I227_MN5 (XI1_I884_I227_n2 I1_I884_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I227_MN4 (I1_p7_24 XI1_I884_I227_An XI1_I884_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I227_MN2 (XI1_I884_I227_n1 I1_I884_pn24 I1_p7_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I227_MN3 (VSS XI1_I884_I227_Bn XI1_I884_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I227_MN0 (XI1_I884_I227_An I1_I884_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I225_MN1 (XI1_I884_I225_Bn I1_I884_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I225_MN5 (XI1_I884_I225_n2 I1_I884_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I225_MN4 (I1_p7_22 XI1_I884_I225_An XI1_I884_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I225_MN2 (XI1_I884_I225_n1 I1_I884_pn22 I1_p7_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I225_MN3 (VSS XI1_I884_I225_Bn XI1_I884_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I225_MN0 (XI1_I884_I225_An I1_I884_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I223_MN1 (XI1_I884_I223_Bn I1_I884_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I223_MN5 (XI1_I884_I223_n2 I1_I884_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I223_MN4 (I1_p7_20 XI1_I884_I223_An XI1_I884_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I223_MN2 (XI1_I884_I223_n1 I1_I884_pn20 I1_p7_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I223_MN3 (VSS XI1_I884_I223_Bn XI1_I884_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I223_MN0 (XI1_I884_I223_An I1_I884_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I221_MN1 (XI1_I884_I221_Bn I1_I884_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I221_MN5 (XI1_I884_I221_n2 I1_I884_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I221_MN4 (I1_p7_18 XI1_I884_I221_An XI1_I884_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I221_MN2 (XI1_I884_I221_n1 I1_I884_pn18 I1_p7_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I221_MN3 (VSS XI1_I884_I221_Bn XI1_I884_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I221_MN0 (XI1_I884_I221_An I1_I884_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I38_MN1 (XI1_I884_I38_Bn I1_b7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I38_MN5 (XI1_I884_I38_n2 I1_b7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I38_MN4 (I1_I884_pn6 XI1_I884_I38_An XI1_I884_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I38_MN2 (XI1_I884_I38_n1 I1_p6_5 I1_I884_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I38_MN3 (VSS XI1_I884_I38_Bn XI1_I884_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I38_MN0 (XI1_I884_I38_An I1_p6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I37_MN1 (XI1_I884_I37_Bn I1_b7_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I37_MN5 (XI1_I884_I37_n2 I1_b7_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I37_MN4 (I1_I884_pn5 XI1_I884_I37_An XI1_I884_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I37_MN2 (XI1_I884_I37_n1 I1_p6_4 I1_I884_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I37_MN3 (VSS XI1_I884_I37_Bn XI1_I884_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I37_MN0 (XI1_I884_I37_An I1_p6_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I35_MN1 (XI1_I792_I35_Bn I1_b5_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I35_MN5 (XI1_I792_I35_n2 I1_b5_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I35_MN4 (I1_I792_pn3 XI1_I792_I35_An XI1_I792_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I35_MN2 (XI1_I792_I35_n1 I1_p4_2 I1_I792_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I35_MN3 (VSS XI1_I792_I35_Bn XI1_I792_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I35_MN0 (XI1_I792_I35_An I1_p4_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I204_MN1 (XI1_I792_I204_Bn I1_I792_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I204_MN5 (XI1_I792_I204_n2 I1_I792_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I204_MN4 (I1_p5_1 XI1_I792_I204_An XI1_I792_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I204_MN2 (XI1_I792_I204_n1 I1_I792_pn1 I1_p5_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I204_MN3 (VSS XI1_I792_I204_Bn XI1_I792_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I204_MN0 (XI1_I792_I204_An I1_I792_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I205_MN1 (XI1_I746_I205_Bn I1_I746_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I205_MN5 (XI1_I746_I205_n2 I1_I746_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I205_MN4 (I1_p4_2 XI1_I746_I205_An XI1_I746_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I205_MN2 (XI1_I746_I205_n1 I1_I746_pn2 I1_p4_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I205_MN3 (VSS XI1_I746_I205_Bn XI1_I746_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I205_MN0 (XI1_I746_I205_An I1_I746_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I38_MN1 (XI1_I746_I38_Bn I1_b4_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I38_MN5 (XI1_I746_I38_n2 I1_b4_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I38_MN4 (I1_I746_pn6 XI1_I746_I38_An XI1_I746_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I38_MN2 (XI1_I746_I38_n1 I1_p3_5 I1_I746_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I38_MN3 (VSS XI1_I746_I38_Bn XI1_I746_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I38_MN0 (XI1_I746_I38_An I1_p3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I40_MN1 (XI1_I746_I40_Bn I1_b4_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I40_MN5 (XI1_I746_I40_n2 I1_b4_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I40_MN4 (I1_I746_pn8 XI1_I746_I40_An XI1_I746_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I40_MN2 (XI1_I746_I40_n1 I1_p3_7 I1_I746_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I40_MN3 (VSS XI1_I746_I40_Bn XI1_I746_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I40_MN0 (XI1_I746_I40_An I1_p3_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I42_MN1 (XI1_I746_I42_Bn I1_b4_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I42_MN5 (XI1_I746_I42_n2 I1_b4_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I42_MN4 (I1_I746_pn10 XI1_I746_I42_An XI1_I746_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I42_MN2 (XI1_I746_I42_n1 I1_p3_9 I1_I746_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I42_MN3 (VSS XI1_I746_I42_Bn XI1_I746_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I42_MN0 (XI1_I746_I42_An I1_p3_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I45_MN1 (XI1_I746_I45_Bn I1_b4_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I45_MN5 (XI1_I746_I45_n2 I1_b4_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I45_MN4 (I1_I746_pn13 XI1_I746_I45_An XI1_I746_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I45_MN2 (XI1_I746_I45_n1 I1_p3_12 I1_I746_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I45_MN3 (VSS XI1_I746_I45_Bn XI1_I746_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I45_MN0 (XI1_I746_I45_An I1_p3_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I47_MN1 (XI1_I746_I47_Bn I1_b4_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I47_MN5 (XI1_I746_I47_n2 I1_b4_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I47_MN4 (I1_I746_pn15 XI1_I746_I47_An XI1_I746_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I47_MN2 (XI1_I746_I47_n1 I1_p3_14 I1_I746_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I47_MN3 (VSS XI1_I746_I47_Bn XI1_I746_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I47_MN0 (XI1_I746_I47_An I1_p3_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I49_MN1 (XI1_I746_I49_Bn I1_b4_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I49_MN5 (XI1_I746_I49_n2 I1_b4_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I49_MN4 (I1_I746_pn17 XI1_I746_I49_An XI1_I746_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I49_MN2 (XI1_I746_I49_n1 I1_p3_16 I1_I746_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I49_MN3 (VSS XI1_I746_I49_Bn XI1_I746_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I49_MN0 (XI1_I746_I49_An I1_p3_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I51_MN1 (XI1_I746_I51_Bn I1_b4_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I51_MN5 (XI1_I746_I51_n2 I1_b4_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I51_MN4 (I1_I746_pn19 XI1_I746_I51_An XI1_I746_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I51_MN2 (XI1_I746_I51_n1 I1_p3_18 I1_I746_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I51_MN3 (VSS XI1_I746_I51_Bn XI1_I746_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I51_MN0 (XI1_I746_I51_An I1_p3_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I223_MN1 (XI1_I700_I223_Bn I1_I700_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I223_MN5 (XI1_I700_I223_n2 I1_I700_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I223_MN4 (I1_p3_20 XI1_I700_I223_An XI1_I700_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I223_MN2 (XI1_I700_I223_n1 I1_I700_pn20 I1_p3_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I223_MN3 (VSS XI1_I700_I223_Bn XI1_I700_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I223_MN0 (XI1_I700_I223_An I1_I700_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I225_MN1 (XI1_I700_I225_Bn I1_I700_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I225_MN5 (XI1_I700_I225_n2 I1_I700_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I225_MN4 (I1_p3_22 XI1_I700_I225_An XI1_I700_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I225_MN2 (XI1_I700_I225_n1 I1_I700_pn22 I1_p3_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I225_MN3 (VSS XI1_I700_I225_Bn XI1_I700_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I225_MN0 (XI1_I700_I225_An I1_I700_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I227_MN1 (XI1_I700_I227_Bn I1_I700_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I227_MN5 (XI1_I700_I227_n2 I1_I700_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I227_MN4 (I1_p3_24 XI1_I700_I227_An XI1_I700_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I227_MN2 (XI1_I700_I227_n1 I1_I700_pn24 I1_p3_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I227_MN3 (VSS XI1_I700_I227_Bn XI1_I700_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I227_MN0 (XI1_I700_I227_An I1_I700_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I229_MN1 (XI1_I700_I229_Bn I1_I700_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I229_MN5 (XI1_I700_I229_n2 I1_I700_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I229_MN4 (I1_p3_26 XI1_I700_I229_An XI1_I700_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I229_MN2 (XI1_I700_I229_n1 I1_I700_pn26 I1_p3_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I229_MN3 (VSS XI1_I700_I229_Bn XI1_I700_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I229_MN0 (XI1_I700_I229_An I1_I700_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I53_MN1 (XI1_I1390_I53_Bn I1_b18_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I53_MN5 (XI1_I1390_I53_n2 I1_b18_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I53_MN4 (I1_I1390_pn21 XI1_I1390_I53_An XI1_I1390_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I53_MN2 (XI1_I1390_I53_n1 I1_p17_20 I1_I1390_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I53_MN3 (VSS XI1_I1390_I53_Bn XI1_I1390_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I53_MN0 (XI1_I1390_I53_An I1_p17_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I51_MN1 (XI1_I1390_I51_Bn I1_b18_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I51_MN5 (XI1_I1390_I51_n2 I1_b18_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I51_MN4 (I1_I1390_pn19 XI1_I1390_I51_An XI1_I1390_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I51_MN2 (XI1_I1390_I51_n1 I1_p17_18 I1_I1390_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I51_MN3 (VSS XI1_I1390_I51_Bn XI1_I1390_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I51_MN0 (XI1_I1390_I51_An I1_p17_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I48_MN1 (XI1_I1390_I48_Bn I1_b18_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I48_MN5 (XI1_I1390_I48_n2 I1_b18_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I48_MN4 (I1_I1390_pn16 XI1_I1390_I48_An XI1_I1390_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I48_MN2 (XI1_I1390_I48_n1 I1_p17_15 I1_I1390_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I48_MN3 (VSS XI1_I1390_I48_Bn XI1_I1390_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I48_MN0 (XI1_I1390_I48_An I1_p17_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I47_MN1 (XI1_I1390_I47_Bn I1_b18_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I47_MN5 (XI1_I1390_I47_n2 I1_b18_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I47_MN4 (I1_I1390_pn15 XI1_I1390_I47_An XI1_I1390_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I47_MN2 (XI1_I1390_I47_n1 I1_p17_14 I1_I1390_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I47_MN3 (VSS XI1_I1390_I47_Bn XI1_I1390_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I47_MN0 (XI1_I1390_I47_An I1_p17_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I45_MN1 (XI1_I1390_I45_Bn I1_b18_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I45_MN5 (XI1_I1390_I45_n2 I1_b18_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I45_MN4 (I1_I1390_pn13 XI1_I1390_I45_An XI1_I1390_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I45_MN2 (XI1_I1390_I45_n1 I1_p17_12 I1_I1390_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I45_MN3 (VSS XI1_I1390_I45_Bn XI1_I1390_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I45_MN0 (XI1_I1390_I45_An I1_p17_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I209_MN1 (XI1_I1344_I209_Bn I1_I1344_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I209_MN5 (XI1_I1344_I209_n2 I1_I1344_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I209_MN4 (I1_p17_6 XI1_I1344_I209_An XI1_I1344_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I209_MN2 (XI1_I1344_I209_n1 I1_I1344_pn6 I1_p17_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I209_MN3 (VSS XI1_I1344_I209_Bn XI1_I1344_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I209_MN0 (XI1_I1344_I209_An I1_I1344_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I208_MN1 (XI1_I1344_I208_Bn I1_I1344_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I208_MN5 (XI1_I1344_I208_n2 I1_I1344_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I208_MN4 (I1_p17_5 XI1_I1344_I208_An XI1_I1344_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I208_MN2 (XI1_I1344_I208_n1 I1_I1344_pn5 I1_p17_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I208_MN3 (VSS XI1_I1344_I208_Bn XI1_I1344_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I208_MN0 (XI1_I1344_I208_An I1_I1344_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I38_MN1 (XI1_I1344_I38_Bn I1_b17_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I38_MN5 (XI1_I1344_I38_n2 I1_b17_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I38_MN4 (I1_I1344_pn6 XI1_I1344_I38_An XI1_I1344_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I38_MN2 (XI1_I1344_I38_n1 I1_p16_5 I1_I1344_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I38_MN3 (VSS XI1_I1344_I38_Bn XI1_I1344_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I38_MN0 (XI1_I1344_I38_An I1_p16_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I37_MN1 (XI1_I1344_I37_Bn I1_b17_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I37_MN5 (XI1_I1344_I37_n2 I1_b17_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I37_MN4 (I1_I1344_pn5 XI1_I1344_I37_An XI1_I1344_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I37_MN2 (XI1_I1344_I37_n1 I1_p16_4 I1_I1344_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I37_MN3 (VSS XI1_I1344_I37_Bn XI1_I1344_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I37_MN0 (XI1_I1344_I37_An I1_p16_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I208_MN1 (XI1_I1298_I208_Bn I1_I1298_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I208_MN5 (XI1_I1298_I208_n2 I1_I1298_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I208_MN4 (I1_p16_5 XI1_I1298_I208_An XI1_I1298_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I208_MN2 (XI1_I1298_I208_n1 I1_I1298_pn5 I1_p16_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I208_MN3 (VSS XI1_I1298_I208_Bn XI1_I1298_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I208_MN0 (XI1_I1298_I208_An I1_I1298_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I38_MN1 (XI1_I1298_I38_Bn I1_b16_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I38_MN5 (XI1_I1298_I38_n2 I1_b16_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I38_MN4 (I1_I1298_pn6 XI1_I1298_I38_An XI1_I1298_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I38_MN2 (XI1_I1298_I38_n1 I1_p15_5 I1_I1298_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I38_MN3 (VSS XI1_I1298_I38_Bn XI1_I1298_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I38_MN0 (XI1_I1298_I38_An I1_p15_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I39_MN1 (XI1_I1298_I39_Bn I1_b16_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I39_MN5 (XI1_I1298_I39_n2 I1_b16_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I39_MN4 (I1_I1298_pn7 XI1_I1298_I39_An XI1_I1298_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I39_MN2 (XI1_I1298_I39_n1 I1_p15_6 I1_I1298_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I39_MN3 (VSS XI1_I1298_I39_Bn XI1_I1298_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I39_MN0 (XI1_I1298_I39_An I1_p15_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I37_MN1 (XI1_I1298_I37_Bn I1_b16_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I37_MN5 (XI1_I1298_I37_n2 I1_b16_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I37_MN4 (I1_I1298_pn5 XI1_I1298_I37_An XI1_I1298_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I37_MN2 (XI1_I1298_I37_n1 I1_p15_4 I1_I1298_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I37_MN3 (VSS XI1_I1298_I37_Bn XI1_I1298_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I37_MN0 (XI1_I1298_I37_An I1_p15_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I208_MN1 (XI1_I1252_I208_Bn I1_I1252_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I208_MN5 (XI1_I1252_I208_n2 I1_I1252_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I208_MN4 (I1_p15_5 XI1_I1252_I208_An XI1_I1252_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I208_MN2 (XI1_I1252_I208_n1 I1_I1252_pn5 I1_p15_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I208_MN3 (VSS XI1_I1252_I208_Bn XI1_I1252_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I208_MN0 (XI1_I1252_I208_An I1_I1252_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I38_MN1 (XI1_I1252_I38_Bn I1_b15_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I38_MN5 (XI1_I1252_I38_n2 I1_b15_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I38_MN4 (I1_I1252_pn6 XI1_I1252_I38_An XI1_I1252_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I38_MN2 (XI1_I1252_I38_n1 I1_p14_5 I1_I1252_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I38_MN3 (VSS XI1_I1252_I38_Bn XI1_I1252_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I38_MN0 (XI1_I1252_I38_An I1_p14_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I227_MN1 (XI1_I1160_I227_Bn I1_I1160_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I227_MN5 (XI1_I1160_I227_n2 I1_I1160_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I227_MN4 (I1_p13_24 XI1_I1160_I227_An XI1_I1160_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I227_MN2 (XI1_I1160_I227_n1 I1_I1160_pn24 I1_p13_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I227_MN3 (VSS XI1_I1160_I227_Bn XI1_I1160_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I227_MN0 (XI1_I1160_I227_An I1_I1160_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I231_MN1 (XI1_I1160_I231_Bn I1_I1160_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I231_MN5 (XI1_I1160_I231_n2 I1_I1160_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I231_MN4 (I1_p13_28 XI1_I1160_I231_An XI1_I1160_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I231_MN2 (XI1_I1160_I231_n1 I1_I1160_pn28 I1_p13_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I231_MN3 (VSS XI1_I1160_I231_Bn XI1_I1160_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I231_MN0 (XI1_I1160_I231_An I1_I1160_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I233_MN1 (XI1_I1160_I233_Bn I1_I1160_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I233_MN5 (XI1_I1160_I233_n2 I1_I1160_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I233_MN4 (I1_p13_30 XI1_I1160_I233_An XI1_I1160_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I233_MN2 (XI1_I1160_I233_n1 I1_I1160_pn30 I1_p13_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I233_MN3 (VSS XI1_I1160_I233_Bn XI1_I1160_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I233_MN0 (XI1_I1160_I233_An I1_I1160_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I225_MN1 (XI1_I1160_I225_Bn I1_I1160_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I225_MN5 (XI1_I1160_I225_n2 I1_I1160_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I225_MN4 (I1_p13_22 XI1_I1160_I225_An XI1_I1160_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I225_MN2 (XI1_I1160_I225_n1 I1_I1160_pn22 I1_p13_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I225_MN3 (VSS XI1_I1160_I225_Bn XI1_I1160_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I225_MN0 (XI1_I1160_I225_An I1_I1160_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I223_MN1 (XI1_I1160_I223_Bn I1_I1160_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I223_MN5 (XI1_I1160_I223_n2 I1_I1160_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I223_MN4 (I1_p13_20 XI1_I1160_I223_An XI1_I1160_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I223_MN2 (XI1_I1160_I223_n1 I1_I1160_pn20 I1_p13_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I223_MN3 (VSS XI1_I1160_I223_Bn XI1_I1160_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I223_MN0 (XI1_I1160_I223_An I1_I1160_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I40_MN1 (XI1_I1206_I40_Bn I1_b14_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I40_MN5 (XI1_I1206_I40_n2 I1_b14_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I40_MN4 (I1_I1206_pn8 XI1_I1206_I40_An XI1_I1206_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I40_MN2 (XI1_I1206_I40_n1 I1_p13_7 I1_I1206_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I40_MN3 (VSS XI1_I1206_I40_Bn XI1_I1206_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I40_MN0 (XI1_I1206_I40_An I1_p13_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I38_MN1 (XI1_I1206_I38_Bn I1_b14_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I38_MN5 (XI1_I1206_I38_n2 I1_b14_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I38_MN4 (I1_I1206_pn6 XI1_I1206_I38_An XI1_I1206_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I38_MN2 (XI1_I1206_I38_n1 I1_p13_5 I1_I1206_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I38_MN3 (VSS XI1_I1206_I38_Bn XI1_I1206_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I38_MN0 (XI1_I1206_I38_An I1_p13_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I208_MN1 (XI1_I1206_I208_Bn I1_I1206_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I208_MN5 (XI1_I1206_I208_n2 I1_I1206_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I208_MN4 (I1_p14_5 XI1_I1206_I208_An XI1_I1206_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I208_MN2 (XI1_I1206_I208_n1 I1_I1206_pn5 I1_p14_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I208_MN3 (VSS XI1_I1206_I208_Bn XI1_I1206_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I208_MN0 (XI1_I1206_I208_An I1_I1206_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I234_MN1 (XI1_I884_I234_Bn I1_c7_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I234_MN5 (XI1_I884_I234_n2 I1_c7_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I234_MN4 (I1_p7_31 XI1_I884_I234_An XI1_I884_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I234_MN2 (XI1_I884_I234_n1 I1_I884_pn31 I1_p7_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I234_MN3 (VSS XI1_I884_I234_Bn XI1_I884_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I234_MN0 (XI1_I884_I234_An I1_I884_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I233_MN1 (XI1_I884_I233_Bn I1_I884_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I233_MN5 (XI1_I884_I233_n2 I1_I884_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I233_MN4 (I1_p7_30 XI1_I884_I233_An XI1_I884_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I233_MN2 (XI1_I884_I233_n1 I1_I884_pn30 I1_p7_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I233_MN3 (VSS XI1_I884_I233_Bn XI1_I884_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I233_MN0 (XI1_I884_I233_An I1_I884_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I211_MN1 (XI1_I884_I211_Bn I1_I884_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I211_MN5 (XI1_I884_I211_n2 I1_I884_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I211_MN4 (I1_p7_8 XI1_I884_I211_An XI1_I884_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I211_MN2 (XI1_I884_I211_n1 I1_I884_pn8 I1_p7_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I211_MN3 (VSS XI1_I884_I211_Bn XI1_I884_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I211_MN0 (XI1_I884_I211_An I1_I884_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I209_MN1 (XI1_I884_I209_Bn I1_I884_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I209_MN5 (XI1_I884_I209_n2 I1_I884_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I209_MN4 (I1_p7_6 XI1_I884_I209_An XI1_I884_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I209_MN2 (XI1_I884_I209_n1 I1_I884_pn6 I1_p7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I209_MN3 (VSS XI1_I884_I209_Bn XI1_I884_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I209_MN0 (XI1_I884_I209_An I1_I884_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I204_MN1 (XI1_I838_I204_Bn I1_I838_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I204_MN5 (XI1_I838_I204_n2 I1_I838_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I204_MN4 (I1_p6_1 XI1_I838_I204_An XI1_I838_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I204_MN2 (XI1_I838_I204_n1 I1_I838_pn1 I1_p6_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I204_MN3 (VSS XI1_I838_I204_Bn XI1_I838_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I204_MN0 (XI1_I838_I204_An I1_I838_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I36_MN1 (XI1_I884_I36_Bn I1_b7_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I36_MN5 (XI1_I884_I36_n2 I1_b7_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I36_MN4 (I1_I884_pn4 XI1_I884_I36_An XI1_I884_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I36_MN2 (XI1_I884_I36_n1 I1_p6_3 I1_I884_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I36_MN3 (VSS XI1_I884_I36_Bn XI1_I884_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I36_MN0 (XI1_I884_I36_An I1_p6_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I34_MN1 (XI1_I792_I34_Bn I1_b5_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I34_MN5 (XI1_I792_I34_n2 I1_b5_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I34_MN4 (I1_I792_pn2 XI1_I792_I34_An XI1_I792_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I34_MN2 (XI1_I792_I34_n1 I1_p4_1 I1_I792_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I34_MN3 (VSS XI1_I792_I34_Bn XI1_I792_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I34_MN0 (XI1_I792_I34_An I1_p4_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I204_MN1 (XI1_I746_I204_Bn I1_I746_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I204_MN5 (XI1_I746_I204_n2 I1_I746_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I204_MN4 (I1_p4_1 XI1_I746_I204_An XI1_I746_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I204_MN2 (XI1_I746_I204_n1 I1_I746_pn1 I1_p4_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I204_MN3 (VSS XI1_I746_I204_Bn XI1_I746_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I204_MN0 (XI1_I746_I204_An I1_I746_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I33_MN1 (XI1_I792_I33_Bn I1_b5_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I33_MN5 (XI1_I792_I33_n2 I1_b5_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I33_MN4 (I1_I792_pn1 XI1_I792_I33_An XI1_I792_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I33_MN2 (XI1_I792_I33_n1 I1_p4_0 I1_I792_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I33_MN3 (VSS XI1_I792_I33_Bn XI1_I792_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I33_MN0 (XI1_I792_I33_An I1_p4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I35_MN1 (XI1_I746_I35_Bn I1_b4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I35_MN5 (XI1_I746_I35_n2 I1_b4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I35_MN4 (I1_I746_pn3 XI1_I746_I35_An XI1_I746_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I35_MN2 (XI1_I746_I35_n1 I1_p3_2 I1_I746_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I35_MN3 (VSS XI1_I746_I35_Bn XI1_I746_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I35_MN0 (XI1_I746_I35_An I1_p3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I41_MN1 (XI1_I746_I41_Bn I1_b4_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I41_MN5 (XI1_I746_I41_n2 I1_b4_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I41_MN4 (I1_I746_pn9 XI1_I746_I41_An XI1_I746_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I41_MN2 (XI1_I746_I41_n1 I1_p3_8 I1_I746_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I41_MN3 (VSS XI1_I746_I41_Bn XI1_I746_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I41_MN0 (XI1_I746_I41_An I1_p3_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I43_MN1 (XI1_I746_I43_Bn I1_b4_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I43_MN5 (XI1_I746_I43_n2 I1_b4_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I43_MN4 (I1_I746_pn11 XI1_I746_I43_An XI1_I746_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I43_MN2 (XI1_I746_I43_n1 I1_p3_10 I1_I746_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I43_MN3 (VSS XI1_I746_I43_Bn XI1_I746_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I43_MN0 (XI1_I746_I43_An I1_p3_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I211_MN1 (XI1_I700_I211_Bn I1_I700_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I211_MN5 (XI1_I700_I211_n2 I1_I700_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I211_MN4 (I1_p3_8 XI1_I700_I211_An XI1_I700_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I211_MN2 (XI1_I700_I211_n1 I1_I700_pn8 I1_p3_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I211_MN3 (VSS XI1_I700_I211_Bn XI1_I700_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I211_MN0 (XI1_I700_I211_An I1_I700_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I231_MN1 (XI1_I700_I231_Bn I1_I700_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I231_MN5 (XI1_I700_I231_n2 I1_I700_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I231_MN4 (I1_p3_28 XI1_I700_I231_An XI1_I700_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I231_MN2 (XI1_I700_I231_n1 I1_I700_pn28 I1_p3_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I231_MN3 (VSS XI1_I700_I231_Bn XI1_I700_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I231_MN0 (XI1_I700_I231_An I1_I700_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I233_MN1 (XI1_I700_I233_Bn I1_I700_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I233_MN5 (XI1_I700_I233_n2 I1_I700_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I233_MN4 (I1_p3_30 XI1_I700_I233_An XI1_I700_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I233_MN2 (XI1_I700_I233_n1 I1_I700_pn30 I1_p3_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I233_MN3 (VSS XI1_I700_I233_Bn XI1_I700_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I233_MN0 (XI1_I700_I233_An I1_I700_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I46_MN1 (XI1_I1390_I46_Bn I1_b18_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I46_MN5 (XI1_I1390_I46_n2 I1_b18_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I46_MN4 (I1_I1390_pn14 XI1_I1390_I46_An XI1_I1390_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I46_MN2 (XI1_I1390_I46_n1 I1_p17_13 I1_I1390_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I46_MN3 (VSS XI1_I1390_I46_Bn XI1_I1390_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I46_MN0 (XI1_I1390_I46_An I1_p17_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I42_MN1 (XI1_I1390_I42_Bn I1_b18_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I42_MN5 (XI1_I1390_I42_n2 I1_b18_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I42_MN4 (I1_I1390_pn10 XI1_I1390_I42_An XI1_I1390_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I42_MN2 (XI1_I1390_I42_n1 I1_p17_9 I1_I1390_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I42_MN3 (VSS XI1_I1390_I42_Bn XI1_I1390_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I42_MN0 (XI1_I1390_I42_An I1_p17_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I36_MN1 (XI1_I1344_I36_Bn I1_b17_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I36_MN5 (XI1_I1344_I36_n2 I1_b17_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I36_MN4 (I1_I1344_pn4 XI1_I1344_I36_An XI1_I1344_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I36_MN2 (XI1_I1344_I36_n1 I1_p16_3 I1_I1344_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I36_MN3 (VSS XI1_I1344_I36_Bn XI1_I1344_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I36_MN0 (XI1_I1344_I36_An I1_p16_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I36_MN1 (XI1_I1298_I36_Bn I1_b16_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I36_MN5 (XI1_I1298_I36_n2 I1_b16_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I36_MN4 (I1_I1298_pn4 XI1_I1298_I36_An XI1_I1298_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I36_MN2 (XI1_I1298_I36_n1 I1_p15_3 I1_I1298_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I36_MN3 (VSS XI1_I1298_I36_Bn XI1_I1298_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I36_MN0 (XI1_I1298_I36_An I1_p15_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I36_MN1 (XI1_I1252_I36_Bn I1_b15_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I36_MN5 (XI1_I1252_I36_n2 I1_b15_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I36_MN4 (I1_I1252_pn4 XI1_I1252_I36_An XI1_I1252_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I36_MN2 (XI1_I1252_I36_n1 I1_p14_3 I1_I1252_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I36_MN3 (VSS XI1_I1252_I36_Bn XI1_I1252_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I36_MN0 (XI1_I1252_I36_An I1_p14_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I37_MN1 (XI1_I1252_I37_Bn I1_b15_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I37_MN5 (XI1_I1252_I37_n2 I1_b15_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I37_MN4 (I1_I1252_pn5 XI1_I1252_I37_An XI1_I1252_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I37_MN2 (XI1_I1252_I37_n1 I1_p14_4 I1_I1252_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I37_MN3 (VSS XI1_I1252_I37_Bn XI1_I1252_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I37_MN0 (XI1_I1252_I37_An I1_p14_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I229_MN1 (XI1_I1160_I229_Bn I1_I1160_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I229_MN5 (XI1_I1160_I229_n2 I1_I1160_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I229_MN4 (I1_p13_26 XI1_I1160_I229_An XI1_I1160_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I229_MN2 (XI1_I1160_I229_n1 I1_I1160_pn26 I1_p13_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I229_MN3 (VSS XI1_I1160_I229_Bn XI1_I1160_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I229_MN0 (XI1_I1160_I229_An I1_I1160_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I211_MN1 (XI1_I1160_I211_Bn I1_I1160_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I211_MN5 (XI1_I1160_I211_n2 I1_I1160_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I211_MN4 (I1_p13_8 XI1_I1160_I211_An XI1_I1160_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I211_MN2 (XI1_I1160_I211_n1 I1_I1160_pn8 I1_p13_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I211_MN3 (VSS XI1_I1160_I211_Bn XI1_I1160_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I211_MN0 (XI1_I1160_I211_An I1_I1160_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I39_MN1 (XI1_I1206_I39_Bn I1_b14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I39_MN5 (XI1_I1206_I39_n2 I1_b14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I39_MN4 (I1_I1206_pn7 XI1_I1206_I39_An XI1_I1206_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I39_MN2 (XI1_I1206_I39_n1 I1_p13_6 I1_I1206_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I39_MN3 (VSS XI1_I1206_I39_Bn XI1_I1206_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I39_MN0 (XI1_I1206_I39_An I1_p13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I36_MN1 (XI1_I1206_I36_Bn I1_b14_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I36_MN5 (XI1_I1206_I36_n2 I1_b14_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I36_MN4 (I1_I1206_pn4 XI1_I1206_I36_An XI1_I1206_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I36_MN2 (XI1_I1206_I36_n1 I1_p13_3 I1_I1206_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I36_MN3 (VSS XI1_I1206_I36_Bn XI1_I1206_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I36_MN0 (XI1_I1206_I36_An I1_p13_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I205_MN1 (XI1_I1206_I205_Bn I1_I1206_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I205_MN5 (XI1_I1206_I205_n2 I1_I1206_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I205_MN4 (I1_p14_2 XI1_I1206_I205_An XI1_I1206_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I205_MN2 (XI1_I1206_I205_n1 I1_I1206_pn2 I1_p14_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I205_MN3 (VSS XI1_I1206_I205_Bn XI1_I1206_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I205_MN0 (XI1_I1206_I205_An I1_I1206_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I232_MN1 (XI1_I884_I232_Bn I1_I884_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I232_MN5 (XI1_I884_I232_n2 I1_I884_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I232_MN4 (I1_p7_29 XI1_I884_I232_An XI1_I884_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I232_MN2 (XI1_I884_I232_n1 I1_I884_pn29 I1_p7_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I232_MN3 (VSS XI1_I884_I232_Bn XI1_I884_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I232_MN0 (XI1_I884_I232_An I1_I884_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I230_MN1 (XI1_I884_I230_Bn I1_I884_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I230_MN5 (XI1_I884_I230_n2 I1_I884_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I230_MN4 (I1_p7_27 XI1_I884_I230_An XI1_I884_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I230_MN2 (XI1_I884_I230_n1 I1_I884_pn27 I1_p7_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I230_MN3 (VSS XI1_I884_I230_Bn XI1_I884_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I230_MN0 (XI1_I884_I230_An I1_I884_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I226_MN1 (XI1_I884_I226_Bn I1_I884_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I226_MN5 (XI1_I884_I226_n2 I1_I884_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I226_MN4 (I1_p7_23 XI1_I884_I226_An XI1_I884_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I226_MN2 (XI1_I884_I226_n1 I1_I884_pn23 I1_p7_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I226_MN3 (VSS XI1_I884_I226_Bn XI1_I884_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I226_MN0 (XI1_I884_I226_An I1_I884_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I224_MN1 (XI1_I884_I224_Bn I1_I884_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I224_MN5 (XI1_I884_I224_n2 I1_I884_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I224_MN4 (I1_p7_21 XI1_I884_I224_An XI1_I884_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I224_MN2 (XI1_I884_I224_n1 I1_I884_pn21 I1_p7_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I224_MN3 (VSS XI1_I884_I224_Bn XI1_I884_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I224_MN0 (XI1_I884_I224_An I1_I884_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I220_MN1 (XI1_I884_I220_Bn I1_I884_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I220_MN5 (XI1_I884_I220_n2 I1_I884_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I220_MN4 (I1_p7_17 XI1_I884_I220_An XI1_I884_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I220_MN2 (XI1_I884_I220_n1 I1_I884_pn17 I1_p7_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I220_MN3 (VSS XI1_I884_I220_Bn XI1_I884_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I220_MN0 (XI1_I884_I220_An I1_I884_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I210_MN1 (XI1_I884_I210_Bn I1_I884_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I210_MN5 (XI1_I884_I210_n2 I1_I884_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I210_MN4 (I1_p7_7 XI1_I884_I210_An XI1_I884_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I210_MN2 (XI1_I884_I210_n1 I1_I884_pn7 I1_p7_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I210_MN3 (VSS XI1_I884_I210_Bn XI1_I884_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I210_MN0 (XI1_I884_I210_An I1_I884_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I208_MN1 (XI1_I884_I208_Bn I1_I884_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I208_MN5 (XI1_I884_I208_n2 I1_I884_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I208_MN4 (I1_p7_5 XI1_I884_I208_An XI1_I884_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I208_MN2 (XI1_I884_I208_n1 I1_I884_pn5 I1_p7_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I208_MN3 (VSS XI1_I884_I208_Bn XI1_I884_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I208_MN0 (XI1_I884_I208_An I1_I884_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I34_MN1 (XI1_I884_I34_Bn I1_b7_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I34_MN5 (XI1_I884_I34_n2 I1_b7_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I34_MN4 (I1_I884_pn2 XI1_I884_I34_An XI1_I884_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I34_MN2 (XI1_I884_I34_n1 I1_p6_1 I1_I884_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I34_MN3 (VSS XI1_I884_I34_Bn XI1_I884_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I34_MN0 (XI1_I884_I34_An I1_p6_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I33_MN1 (XI1_I838_I33_Bn I1_b6_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I33_MN5 (XI1_I838_I33_n2 I1_b6_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I33_MN4 (I1_I838_pn1 XI1_I838_I33_An XI1_I838_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I33_MN2 (XI1_I838_I33_n1 I1_p5_0 I1_I838_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I33_MN3 (VSS XI1_I838_I33_Bn XI1_I838_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I33_MN0 (XI1_I838_I33_An I1_p5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I35_MN1 (XI1_I884_I35_Bn I1_b7_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I35_MN5 (XI1_I884_I35_n2 I1_b7_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I35_MN4 (I1_I884_pn3 XI1_I884_I35_An XI1_I884_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I35_MN2 (XI1_I884_I35_n1 I1_p6_2 I1_I884_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I35_MN3 (VSS XI1_I884_I35_Bn XI1_I884_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I35_MN0 (XI1_I884_I35_An I1_p6_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I34_MN1 (XI1_I746_I34_Bn I1_b4_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I34_MN5 (XI1_I746_I34_n2 I1_b4_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I34_MN4 (I1_I746_pn2 XI1_I746_I34_An XI1_I746_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I34_MN2 (XI1_I746_I34_n1 I1_p3_1 I1_I746_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I34_MN3 (VSS XI1_I746_I34_Bn XI1_I746_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I34_MN0 (XI1_I746_I34_An I1_p3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I36_MN1 (XI1_I746_I36_Bn I1_b4_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I36_MN5 (XI1_I746_I36_n2 I1_b4_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I36_MN4 (I1_I746_pn4 XI1_I746_I36_An XI1_I746_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I36_MN2 (XI1_I746_I36_n1 I1_p3_3 I1_I746_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I36_MN3 (VSS XI1_I746_I36_Bn XI1_I746_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I36_MN0 (XI1_I746_I36_An I1_p3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I37_MN1 (XI1_I746_I37_Bn I1_b4_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I37_MN5 (XI1_I746_I37_n2 I1_b4_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I37_MN4 (I1_I746_pn5 XI1_I746_I37_An XI1_I746_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I37_MN2 (XI1_I746_I37_n1 I1_p3_4 I1_I746_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I37_MN3 (VSS XI1_I746_I37_Bn XI1_I746_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I37_MN0 (XI1_I746_I37_An I1_p3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I39_MN1 (XI1_I746_I39_Bn I1_b4_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I39_MN5 (XI1_I746_I39_n2 I1_b4_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I39_MN4 (I1_I746_pn7 XI1_I746_I39_An XI1_I746_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I39_MN2 (XI1_I746_I39_n1 I1_p3_6 I1_I746_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I39_MN3 (VSS XI1_I746_I39_Bn XI1_I746_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I39_MN0 (XI1_I746_I39_An I1_p3_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I209_MN1 (XI1_I700_I209_Bn I1_I700_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I209_MN5 (XI1_I700_I209_n2 I1_I700_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I209_MN4 (I1_p3_6 XI1_I700_I209_An XI1_I700_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I209_MN2 (XI1_I700_I209_n1 I1_I700_pn6 I1_p3_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I209_MN3 (VSS XI1_I700_I209_Bn XI1_I700_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I209_MN0 (XI1_I700_I209_An I1_I700_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I221_MN1 (XI1_I700_I221_Bn I1_I700_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I221_MN5 (XI1_I700_I221_n2 I1_I700_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I221_MN4 (I1_p3_18 XI1_I700_I221_An XI1_I700_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I221_MN2 (XI1_I700_I221_n1 I1_I700_pn18 I1_p3_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I221_MN3 (VSS XI1_I700_I221_Bn XI1_I700_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I221_MN0 (XI1_I700_I221_An I1_I700_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I44_MN1 (XI1_I1390_I44_Bn I1_b18_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I44_MN5 (XI1_I1390_I44_n2 I1_b18_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I44_MN4 (I1_I1390_pn12 XI1_I1390_I44_An XI1_I1390_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I44_MN2 (XI1_I1390_I44_n1 I1_p17_11 I1_I1390_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I44_MN3 (VSS XI1_I1390_I44_Bn XI1_I1390_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I44_MN0 (XI1_I1390_I44_An I1_p17_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I43_MN1 (XI1_I1390_I43_Bn I1_b18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I43_MN5 (XI1_I1390_I43_n2 I1_b18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I43_MN4 (I1_I1390_pn11 XI1_I1390_I43_An XI1_I1390_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I43_MN2 (XI1_I1390_I43_n1 I1_p17_10 I1_I1390_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I43_MN3 (VSS XI1_I1390_I43_Bn XI1_I1390_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I43_MN0 (XI1_I1390_I43_An I1_p17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I41_MN1 (XI1_I1390_I41_Bn I1_b18_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I41_MN5 (XI1_I1390_I41_n2 I1_b18_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I41_MN4 (I1_I1390_pn9 XI1_I1390_I41_An XI1_I1390_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I41_MN2 (XI1_I1390_I41_n1 I1_p17_8 I1_I1390_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I41_MN3 (VSS XI1_I1390_I41_Bn XI1_I1390_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I41_MN0 (XI1_I1390_I41_An I1_p17_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I40_MN1 (XI1_I1390_I40_Bn I1_b18_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I40_MN5 (XI1_I1390_I40_n2 I1_b18_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I40_MN4 (I1_I1390_pn8 XI1_I1390_I40_An XI1_I1390_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I40_MN2 (XI1_I1390_I40_n1 I1_p17_7 I1_I1390_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I40_MN3 (VSS XI1_I1390_I40_Bn XI1_I1390_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I40_MN0 (XI1_I1390_I40_An I1_p17_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I205_MN1 (XI1_I1298_I205_Bn I1_I1298_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I205_MN5 (XI1_I1298_I205_n2 I1_I1298_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I205_MN4 (I1_p16_2 XI1_I1298_I205_An XI1_I1298_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I205_MN2 (XI1_I1298_I205_n1 I1_I1298_pn2 I1_p16_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I205_MN3 (VSS XI1_I1298_I205_Bn XI1_I1298_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I205_MN0 (XI1_I1298_I205_An I1_I1298_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I34_MN1 (XI1_I1298_I34_Bn I1_b16_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I34_MN5 (XI1_I1298_I34_n2 I1_b16_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I34_MN4 (I1_I1298_pn2 XI1_I1298_I34_An XI1_I1298_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I34_MN2 (XI1_I1298_I34_n1 I1_p15_1 I1_I1298_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I34_MN3 (VSS XI1_I1298_I34_Bn XI1_I1298_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I34_MN0 (XI1_I1298_I34_An I1_p15_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I35_MN1 (XI1_I1298_I35_Bn I1_b16_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I35_MN5 (XI1_I1298_I35_n2 I1_b16_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I35_MN4 (I1_I1298_pn3 XI1_I1298_I35_An XI1_I1298_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I35_MN2 (XI1_I1298_I35_n1 I1_p15_2 I1_I1298_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I35_MN3 (VSS XI1_I1298_I35_Bn XI1_I1298_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I35_MN0 (XI1_I1298_I35_An I1_p15_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I204_MN1 (XI1_I1252_I204_Bn I1_I1252_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I204_MN5 (XI1_I1252_I204_n2 I1_I1252_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I204_MN4 (I1_p15_1 XI1_I1252_I204_An XI1_I1252_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I204_MN2 (XI1_I1252_I204_n1 I1_I1252_pn1 I1_p15_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I204_MN3 (VSS XI1_I1252_I204_Bn XI1_I1252_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I204_MN0 (XI1_I1252_I204_An I1_I1252_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I205_MN1 (XI1_I1252_I205_Bn I1_I1252_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I205_MN5 (XI1_I1252_I205_n2 I1_I1252_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I205_MN4 (I1_p15_2 XI1_I1252_I205_An XI1_I1252_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I205_MN2 (XI1_I1252_I205_n1 I1_I1252_pn2 I1_p15_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I205_MN3 (VSS XI1_I1252_I205_Bn XI1_I1252_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I205_MN0 (XI1_I1252_I205_An I1_I1252_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I35_MN1 (XI1_I1252_I35_Bn I1_b15_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I35_MN5 (XI1_I1252_I35_n2 I1_b15_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I35_MN4 (I1_I1252_pn3 XI1_I1252_I35_An XI1_I1252_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I35_MN2 (XI1_I1252_I35_n1 I1_p14_2 I1_I1252_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I35_MN3 (VSS XI1_I1252_I35_Bn XI1_I1252_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I35_MN0 (XI1_I1252_I35_An I1_p14_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I34_MN1 (XI1_I1252_I34_Bn I1_b15_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I34_MN5 (XI1_I1252_I34_n2 I1_b15_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I34_MN4 (I1_I1252_pn2 XI1_I1252_I34_An XI1_I1252_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I34_MN2 (XI1_I1252_I34_n1 I1_p14_1 I1_I1252_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I34_MN3 (VSS XI1_I1252_I34_Bn XI1_I1252_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I34_MN0 (XI1_I1252_I34_An I1_p14_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I221_MN1 (XI1_I1160_I221_Bn I1_I1160_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I221_MN5 (XI1_I1160_I221_n2 I1_I1160_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I221_MN4 (I1_p13_18 XI1_I1160_I221_An XI1_I1160_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I221_MN2 (XI1_I1160_I221_n1 I1_I1160_pn18 I1_p13_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I221_MN3 (VSS XI1_I1160_I221_Bn XI1_I1160_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I221_MN0 (XI1_I1160_I221_An I1_I1160_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I209_MN1 (XI1_I1160_I209_Bn I1_I1160_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I209_MN5 (XI1_I1160_I209_n2 I1_I1160_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I209_MN4 (I1_p13_6 XI1_I1160_I209_An XI1_I1160_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I209_MN2 (XI1_I1160_I209_n1 I1_I1160_pn6 I1_p13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I209_MN3 (VSS XI1_I1160_I209_Bn XI1_I1160_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I209_MN0 (XI1_I1160_I209_An I1_I1160_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I37_MN1 (XI1_I1206_I37_Bn I1_b14_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I37_MN5 (XI1_I1206_I37_n2 I1_b14_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I37_MN4 (I1_I1206_pn5 XI1_I1206_I37_An XI1_I1206_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I37_MN2 (XI1_I1206_I37_n1 I1_p13_4 I1_I1206_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I37_MN3 (VSS XI1_I1206_I37_Bn XI1_I1206_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I37_MN0 (XI1_I1206_I37_An I1_p13_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I35_MN1 (XI1_I1206_I35_Bn I1_b14_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I35_MN5 (XI1_I1206_I35_n2 I1_b14_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I35_MN4 (I1_I1206_pn3 XI1_I1206_I35_An XI1_I1206_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I35_MN2 (XI1_I1206_I35_n1 I1_p13_2 I1_I1206_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I35_MN3 (VSS XI1_I1206_I35_Bn XI1_I1206_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I35_MN0 (XI1_I1206_I35_An I1_p13_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I34_MN1 (XI1_I1206_I34_Bn I1_b14_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I34_MN5 (XI1_I1206_I34_n2 I1_b14_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I34_MN4 (I1_I1206_pn2 XI1_I1206_I34_An XI1_I1206_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I34_MN2 (XI1_I1206_I34_n1 I1_p13_1 I1_I1206_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I34_MN3 (VSS XI1_I1206_I34_Bn XI1_I1206_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I34_MN0 (XI1_I1206_I34_An I1_p13_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I204_MN1 (XI1_I1206_I204_Bn I1_I1206_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I204_MN5 (XI1_I1206_I204_n2 I1_I1206_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I204_MN4 (I1_p14_1 XI1_I1206_I204_An XI1_I1206_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I204_MN2 (XI1_I1206_I204_n1 I1_I1206_pn1 I1_p14_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I204_MN3 (VSS XI1_I1206_I204_Bn XI1_I1206_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I204_MN0 (XI1_I1206_I204_An I1_I1206_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I59_MN1 (XI1_I930_I59_Bn I1_b8_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I59_MN5 (XI1_I930_I59_n2 I1_b8_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I59_MN4 (I1_I930_pn27 XI1_I930_I59_An XI1_I930_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I59_MN2 (XI1_I930_I59_n1 I1_p7_26 I1_I930_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I59_MN3 (VSS XI1_I930_I59_Bn XI1_I930_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I59_MN0 (XI1_I930_I59_An I1_p7_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I228_MN1 (XI1_I884_I228_Bn I1_I884_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I228_MN5 (XI1_I884_I228_n2 I1_I884_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I228_MN4 (I1_p7_25 XI1_I884_I228_An XI1_I884_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I228_MN2 (XI1_I884_I228_n1 I1_I884_pn25 I1_p7_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I228_MN3 (VSS XI1_I884_I228_Bn XI1_I884_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I228_MN0 (XI1_I884_I228_An I1_I884_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I55_MN1 (XI1_I930_I55_Bn I1_b8_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I55_MN5 (XI1_I930_I55_n2 I1_b8_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I55_MN4 (I1_I930_pn23 XI1_I930_I55_An XI1_I930_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I55_MN2 (XI1_I930_I55_n1 I1_p7_22 I1_I930_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I55_MN3 (VSS XI1_I930_I55_Bn XI1_I930_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I55_MN0 (XI1_I930_I55_An I1_p7_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I53_MN1 (XI1_I930_I53_Bn I1_b8_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I53_MN5 (XI1_I930_I53_n2 I1_b8_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I53_MN4 (I1_I930_pn21 XI1_I930_I53_An XI1_I930_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I53_MN2 (XI1_I930_I53_n1 I1_p7_20 I1_I930_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I53_MN3 (VSS XI1_I930_I53_Bn XI1_I930_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I53_MN0 (XI1_I930_I53_An I1_p7_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I222_MN1 (XI1_I884_I222_Bn I1_I884_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I222_MN5 (XI1_I884_I222_n2 I1_I884_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I222_MN4 (I1_p7_19 XI1_I884_I222_An XI1_I884_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I222_MN2 (XI1_I884_I222_n1 I1_I884_pn19 I1_p7_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I222_MN3 (VSS XI1_I884_I222_Bn XI1_I884_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I222_MN0 (XI1_I884_I222_An I1_I884_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I50_MN1 (XI1_I930_I50_Bn I1_b8_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I50_MN5 (XI1_I930_I50_n2 I1_b8_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I50_MN4 (I1_I930_pn18 XI1_I930_I50_An XI1_I930_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I50_MN2 (XI1_I930_I50_n1 I1_p7_17 I1_I930_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I50_MN3 (VSS XI1_I930_I50_Bn XI1_I930_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I50_MN0 (XI1_I930_I50_An I1_p7_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I49_MN1 (XI1_I930_I49_Bn I1_b8_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I49_MN5 (XI1_I930_I49_n2 I1_b8_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I49_MN4 (I1_I930_pn17 XI1_I930_I49_An XI1_I930_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I49_MN2 (XI1_I930_I49_n1 I1_p7_16 I1_I930_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I49_MN3 (VSS XI1_I930_I49_Bn XI1_I930_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I49_MN0 (XI1_I930_I49_An I1_p7_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I46_MN1 (XI1_I930_I46_Bn I1_b8_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I46_MN5 (XI1_I930_I46_n2 I1_b8_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I46_MN4 (I1_I930_pn14 XI1_I930_I46_An XI1_I930_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I46_MN2 (XI1_I930_I46_n1 I1_p7_13 I1_I930_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I46_MN3 (VSS XI1_I930_I46_Bn XI1_I930_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I46_MN0 (XI1_I930_I46_An I1_p7_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I42_MN1 (XI1_I930_I42_Bn I1_b8_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I42_MN5 (XI1_I930_I42_n2 I1_b8_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I42_MN4 (I1_I930_pn10 XI1_I930_I42_An XI1_I930_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I42_MN2 (XI1_I930_I42_n1 I1_p7_9 I1_I930_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I42_MN3 (VSS XI1_I930_I42_Bn XI1_I930_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I42_MN0 (XI1_I930_I42_An I1_p7_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I205_MN1 (XI1_I884_I205_Bn I1_I884_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I205_MN5 (XI1_I884_I205_n2 I1_I884_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I205_MN4 (I1_p7_2 XI1_I884_I205_An XI1_I884_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I205_MN2 (XI1_I884_I205_n1 I1_I884_pn2 I1_p7_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I205_MN3 (VSS XI1_I884_I205_Bn XI1_I884_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I205_MN0 (XI1_I884_I205_An I1_I884_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I203_MN1 (XI1_I792_I203_Bn I1_qu27_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I203_MN5 (XI1_I792_I203_n2 I1_qu27_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I203_MN4 (I1_p5_0 XI1_I792_I203_An XI1_I792_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I203_MN2 (XI1_I792_I203_n1 I1_I792_pn0 I1_p5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I203_MN3 (VSS XI1_I792_I203_Bn XI1_I792_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I203_MN0 (XI1_I792_I203_An I1_I792_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I33_MN1 (XI1_I746_I33_Bn I1_b4_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I33_MN5 (XI1_I746_I33_n2 I1_b4_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I33_MN4 (I1_I746_pn1 XI1_I746_I33_An XI1_I746_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I33_MN2 (XI1_I746_I33_n1 I1_p3_0 I1_I746_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I33_MN3 (VSS XI1_I746_I33_Bn XI1_I746_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I33_MN0 (XI1_I746_I33_An I1_p3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I205_MN1 (XI1_I700_I205_Bn I1_I700_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I205_MN5 (XI1_I700_I205_n2 I1_I700_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I205_MN4 (I1_p3_2 XI1_I700_I205_An XI1_I700_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I205_MN2 (XI1_I700_I205_n1 I1_I700_pn2 I1_p3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I205_MN3 (VSS XI1_I700_I205_Bn XI1_I700_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I205_MN0 (XI1_I700_I205_An I1_I700_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I208_MN1 (XI1_I700_I208_Bn I1_I700_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I208_MN5 (XI1_I700_I208_n2 I1_I700_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I208_MN4 (I1_p3_5 XI1_I700_I208_An XI1_I700_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I208_MN2 (XI1_I700_I208_n1 I1_I700_pn5 I1_p3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I208_MN3 (VSS XI1_I700_I208_Bn XI1_I700_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I208_MN0 (XI1_I700_I208_An I1_I700_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I210_MN1 (XI1_I700_I210_Bn I1_I700_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I210_MN5 (XI1_I700_I210_n2 I1_I700_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I210_MN4 (I1_p3_7 XI1_I700_I210_An XI1_I700_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I210_MN2 (XI1_I700_I210_n1 I1_I700_pn7 I1_p3_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I210_MN3 (VSS XI1_I700_I210_Bn XI1_I700_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I210_MN0 (XI1_I700_I210_An I1_I700_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I220_MN1 (XI1_I700_I220_Bn I1_I700_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I220_MN5 (XI1_I700_I220_n2 I1_I700_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I220_MN4 (I1_p3_17 XI1_I700_I220_An XI1_I700_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I220_MN2 (XI1_I700_I220_n1 I1_I700_pn17 I1_p3_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I220_MN3 (VSS XI1_I700_I220_Bn XI1_I700_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I220_MN0 (XI1_I700_I220_An I1_I700_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I222_MN1 (XI1_I700_I222_Bn I1_I700_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I222_MN5 (XI1_I700_I222_n2 I1_I700_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I222_MN4 (I1_p3_19 XI1_I700_I222_An XI1_I700_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I222_MN2 (XI1_I700_I222_n1 I1_I700_pn19 I1_p3_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I222_MN3 (VSS XI1_I700_I222_Bn XI1_I700_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I222_MN0 (XI1_I700_I222_An I1_I700_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I224_MN1 (XI1_I700_I224_Bn I1_I700_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I224_MN5 (XI1_I700_I224_n2 I1_I700_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I224_MN4 (I1_p3_21 XI1_I700_I224_An XI1_I700_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I224_MN2 (XI1_I700_I224_n1 I1_I700_pn21 I1_p3_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I224_MN3 (VSS XI1_I700_I224_Bn XI1_I700_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I224_MN0 (XI1_I700_I224_An I1_I700_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I226_MN1 (XI1_I700_I226_Bn I1_I700_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I226_MN5 (XI1_I700_I226_n2 I1_I700_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I226_MN4 (I1_p3_23 XI1_I700_I226_An XI1_I700_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I226_MN2 (XI1_I700_I226_n1 I1_I700_pn23 I1_p3_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I226_MN3 (VSS XI1_I700_I226_Bn XI1_I700_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I226_MN0 (XI1_I700_I226_An I1_I700_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I228_MN1 (XI1_I700_I228_Bn I1_I700_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I228_MN5 (XI1_I700_I228_n2 I1_I700_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I228_MN4 (I1_p3_25 XI1_I700_I228_An XI1_I700_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I228_MN2 (XI1_I700_I228_n1 I1_I700_pn25 I1_p3_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I228_MN3 (VSS XI1_I700_I228_Bn XI1_I700_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I228_MN0 (XI1_I700_I228_An I1_I700_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I234_MN1 (XI1_I700_I234_Bn I1_c3_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I234_MN5 (XI1_I700_I234_n2 I1_c3_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I234_MN4 (I1_p3_31 XI1_I700_I234_An XI1_I700_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I234_MN2 (XI1_I700_I234_n1 I1_I700_pn31 I1_p3_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I234_MN3 (VSS XI1_I700_I234_Bn XI1_I700_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I234_MN0 (XI1_I700_I234_An I1_I700_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I233_MN1 (XI1_I1390_I233_Bn I1_I1390_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I233_MN5 (XI1_I1390_I233_n2 I1_I1390_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I233_MN4 (I1_p18_30 XI1_I1390_I233_An XI1_I1390_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I233_MN2 (XI1_I1390_I233_n1 I1_I1390_pn30 I1_p18_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I233_MN3 (VSS XI1_I1390_I233_Bn XI1_I1390_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I233_MN0 (XI1_I1390_I233_An I1_I1390_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I227_MN1 (XI1_I1390_I227_Bn I1_I1390_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I227_MN5 (XI1_I1390_I227_n2 I1_I1390_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I227_MN4 (I1_p18_24 XI1_I1390_I227_An XI1_I1390_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I227_MN2 (XI1_I1390_I227_n1 I1_I1390_pn24 I1_p18_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I227_MN3 (VSS XI1_I1390_I227_Bn XI1_I1390_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I227_MN0 (XI1_I1390_I227_An I1_I1390_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I225_MN1 (XI1_I1390_I225_Bn I1_I1390_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I225_MN5 (XI1_I1390_I225_n2 I1_I1390_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I225_MN4 (I1_p18_22 XI1_I1390_I225_An XI1_I1390_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I225_MN2 (XI1_I1390_I225_n1 I1_I1390_pn22 I1_p18_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I225_MN3 (VSS XI1_I1390_I225_Bn XI1_I1390_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I225_MN0 (XI1_I1390_I225_An I1_I1390_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I39_MN1 (XI1_I1390_I39_Bn I1_b18_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I39_MN5 (XI1_I1390_I39_n2 I1_b18_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I39_MN4 (I1_I1390_pn7 XI1_I1390_I39_An XI1_I1390_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I39_MN2 (XI1_I1390_I39_n1 I1_p17_6 I1_I1390_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I39_MN3 (VSS XI1_I1390_I39_Bn XI1_I1390_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I39_MN0 (XI1_I1390_I39_An I1_p17_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I205_MN1 (XI1_I1344_I205_Bn I1_I1344_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I205_MN5 (XI1_I1344_I205_n2 I1_I1344_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I205_MN4 (I1_p17_2 XI1_I1344_I205_An XI1_I1344_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I205_MN2 (XI1_I1344_I205_n1 I1_I1344_pn2 I1_p17_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I205_MN3 (VSS XI1_I1344_I205_Bn XI1_I1344_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I205_MN0 (XI1_I1344_I205_An I1_I1344_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I35_MN1 (XI1_I1344_I35_Bn I1_b17_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I35_MN5 (XI1_I1344_I35_n2 I1_b17_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I35_MN4 (I1_I1344_pn3 XI1_I1344_I35_An XI1_I1344_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I35_MN2 (XI1_I1344_I35_n1 I1_p16_2 I1_I1344_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I35_MN3 (VSS XI1_I1344_I35_Bn XI1_I1344_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I35_MN0 (XI1_I1344_I35_An I1_p16_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I34_MN1 (XI1_I1344_I34_Bn I1_b17_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I34_MN5 (XI1_I1344_I34_n2 I1_b17_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I34_MN4 (I1_I1344_pn2 XI1_I1344_I34_An XI1_I1344_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I34_MN2 (XI1_I1344_I34_n1 I1_p16_1 I1_I1344_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I34_MN3 (VSS XI1_I1344_I34_Bn XI1_I1344_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I34_MN0 (XI1_I1344_I34_An I1_p16_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I204_MN1 (XI1_I1298_I204_Bn I1_I1298_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I204_MN5 (XI1_I1298_I204_n2 I1_I1298_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I204_MN4 (I1_p16_1 XI1_I1298_I204_An XI1_I1298_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I204_MN2 (XI1_I1298_I204_n1 I1_I1298_pn1 I1_p16_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I204_MN3 (VSS XI1_I1298_I204_Bn XI1_I1298_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I204_MN0 (XI1_I1298_I204_An I1_I1298_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I33_MN1 (XI1_I1298_I33_Bn I1_b16_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I33_MN5 (XI1_I1298_I33_n2 I1_b16_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I33_MN4 (I1_I1298_pn1 XI1_I1298_I33_An XI1_I1298_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I33_MN2 (XI1_I1298_I33_n1 I1_p15_0 I1_I1298_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I33_MN3 (VSS XI1_I1298_I33_Bn XI1_I1298_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I33_MN0 (XI1_I1298_I33_An I1_p15_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I203_MN1 (XI1_I1252_I203_Bn I1_qu17_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I203_MN5 (XI1_I1252_I203_n2 I1_qu17_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I203_MN4 (I1_p15_0 XI1_I1252_I203_An XI1_I1252_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I203_MN2 (XI1_I1252_I203_n1 I1_I1252_pn0 I1_p15_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I203_MN3 (VSS XI1_I1252_I203_Bn XI1_I1252_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I203_MN0 (XI1_I1252_I203_An I1_I1252_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I33_MN1 (XI1_I1252_I33_Bn I1_b15_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I33_MN5 (XI1_I1252_I33_n2 I1_b15_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I33_MN4 (I1_I1252_pn1 XI1_I1252_I33_An XI1_I1252_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I33_MN2 (XI1_I1252_I33_n1 I1_p14_0 I1_I1252_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I33_MN3 (VSS XI1_I1252_I33_Bn XI1_I1252_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I33_MN0 (XI1_I1252_I33_An I1_p14_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I63_MN1 (XI1_I1160_I63_Bn I1_b13_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I63_MN5 (XI1_I1160_I63_n2 I1_b13_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I63_MN4 (I1_I1160_pn31 XI1_I1160_I63_An XI1_I1160_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I63_MN2 (XI1_I1160_I63_n1 I1_p12_30 I1_I1160_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I63_MN3 (VSS XI1_I1160_I63_Bn XI1_I1160_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I63_MN0 (XI1_I1160_I63_An I1_p12_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I232_MN1 (XI1_I1160_I232_Bn I1_I1160_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I232_MN5 (XI1_I1160_I232_n2 I1_I1160_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I232_MN4 (I1_p13_29 XI1_I1160_I232_An XI1_I1160_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I232_MN2 (XI1_I1160_I232_n1 I1_I1160_pn29 I1_p13_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I232_MN3 (VSS XI1_I1160_I232_Bn XI1_I1160_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I232_MN0 (XI1_I1160_I232_An I1_I1160_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I224_MN1 (XI1_I1160_I224_Bn I1_I1160_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I224_MN5 (XI1_I1160_I224_n2 I1_I1160_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I224_MN4 (I1_p13_21 XI1_I1160_I224_An XI1_I1160_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I224_MN2 (XI1_I1160_I224_n1 I1_I1160_pn21 I1_p13_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I224_MN3 (VSS XI1_I1160_I224_Bn XI1_I1160_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I224_MN0 (XI1_I1160_I224_An I1_I1160_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I210_MN1 (XI1_I1160_I210_Bn I1_I1160_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I210_MN5 (XI1_I1160_I210_n2 I1_I1160_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I210_MN4 (I1_p13_7 XI1_I1160_I210_An XI1_I1160_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I210_MN2 (XI1_I1160_I210_n1 I1_I1160_pn7 I1_p13_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I210_MN3 (VSS XI1_I1160_I210_Bn XI1_I1160_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I210_MN0 (XI1_I1160_I210_An I1_I1160_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I203_MN1 (XI1_I1206_I203_Bn I1_qu18_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I203_MN5 (XI1_I1206_I203_n2 I1_qu18_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I203_MN4 (I1_p14_0 XI1_I1206_I203_An XI1_I1206_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I203_MN2 (XI1_I1206_I203_n1 I1_I1206_pn0 I1_p14_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I203_MN3 (VSS XI1_I1206_I203_Bn XI1_I1206_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I203_MN0 (XI1_I1206_I203_An I1_I1206_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I33_MN1 (XI1_I1206_I33_Bn I1_b14_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I33_MN5 (XI1_I1206_I33_n2 I1_b14_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I33_MN4 (I1_I1206_pn1 XI1_I1206_I33_An XI1_I1206_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I33_MN2 (XI1_I1206_I33_n1 I1_p13_0 I1_I1206_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I33_MN3 (VSS XI1_I1206_I33_Bn XI1_I1206_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I33_MN0 (XI1_I1206_I33_An I1_p13_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I61_MN1 (XI1_I930_I61_Bn I1_b8_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I61_MN5 (XI1_I930_I61_n2 I1_b8_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I61_MN4 (I1_I930_pn29 XI1_I930_I61_An XI1_I930_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I61_MN2 (XI1_I930_I61_n1 I1_p7_28 I1_I930_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I61_MN3 (VSS XI1_I930_I61_Bn XI1_I930_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I61_MN0 (XI1_I930_I61_An I1_p7_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I58_MN1 (XI1_I930_I58_Bn I1_b8_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I58_MN5 (XI1_I930_I58_n2 I1_b8_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I58_MN4 (I1_I930_pn26 XI1_I930_I58_An XI1_I930_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I58_MN2 (XI1_I930_I58_n1 I1_p7_25 I1_I930_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I58_MN3 (VSS XI1_I930_I58_Bn XI1_I930_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I58_MN0 (XI1_I930_I58_An I1_p7_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I60_MN1 (XI1_I930_I60_Bn I1_b8_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I60_MN5 (XI1_I930_I60_n2 I1_b8_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I60_MN4 (I1_I930_pn28 XI1_I930_I60_An XI1_I930_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I60_MN2 (XI1_I930_I60_n1 I1_p7_27 I1_I930_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I60_MN3 (VSS XI1_I930_I60_Bn XI1_I930_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I60_MN0 (XI1_I930_I60_An I1_p7_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I57_MN1 (XI1_I930_I57_Bn I1_b8_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I57_MN5 (XI1_I930_I57_n2 I1_b8_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I57_MN4 (I1_I930_pn25 XI1_I930_I57_An XI1_I930_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I57_MN2 (XI1_I930_I57_n1 I1_p7_24 I1_I930_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I57_MN3 (VSS XI1_I930_I57_Bn XI1_I930_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I57_MN0 (XI1_I930_I57_An I1_p7_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I56_MN1 (XI1_I930_I56_Bn I1_b8_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I56_MN5 (XI1_I930_I56_n2 I1_b8_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I56_MN4 (I1_I930_pn24 XI1_I930_I56_An XI1_I930_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I56_MN2 (XI1_I930_I56_n1 I1_p7_23 I1_I930_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I56_MN3 (VSS XI1_I930_I56_Bn XI1_I930_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I56_MN0 (XI1_I930_I56_An I1_p7_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I54_MN1 (XI1_I930_I54_Bn I1_b8_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I54_MN5 (XI1_I930_I54_n2 I1_b8_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I54_MN4 (I1_I930_pn22 XI1_I930_I54_An XI1_I930_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I54_MN2 (XI1_I930_I54_n1 I1_p7_21 I1_I930_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I54_MN3 (VSS XI1_I930_I54_Bn XI1_I930_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I54_MN0 (XI1_I930_I54_An I1_p7_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I52_MN1 (XI1_I930_I52_Bn I1_b8_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I52_MN5 (XI1_I930_I52_n2 I1_b8_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I52_MN4 (I1_I930_pn20 XI1_I930_I52_An XI1_I930_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I52_MN2 (XI1_I930_I52_n1 I1_p7_19 I1_I930_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I52_MN3 (VSS XI1_I930_I52_Bn XI1_I930_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I52_MN0 (XI1_I930_I52_An I1_p7_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I51_MN1 (XI1_I930_I51_Bn I1_b8_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I51_MN5 (XI1_I930_I51_n2 I1_b8_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I51_MN4 (I1_I930_pn19 XI1_I930_I51_An XI1_I930_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I51_MN2 (XI1_I930_I51_n1 I1_p7_18 I1_I930_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I51_MN3 (VSS XI1_I930_I51_Bn XI1_I930_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I51_MN0 (XI1_I930_I51_An I1_p7_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I48_MN1 (XI1_I930_I48_Bn I1_b8_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I48_MN5 (XI1_I930_I48_n2 I1_b8_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I48_MN4 (I1_I930_pn16 XI1_I930_I48_An XI1_I930_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I48_MN2 (XI1_I930_I48_n1 I1_p7_15 I1_I930_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I48_MN3 (VSS XI1_I930_I48_Bn XI1_I930_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I48_MN0 (XI1_I930_I48_An I1_p7_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I47_MN1 (XI1_I930_I47_Bn I1_b8_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I47_MN5 (XI1_I930_I47_n2 I1_b8_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I47_MN4 (I1_I930_pn15 XI1_I930_I47_An XI1_I930_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I47_MN2 (XI1_I930_I47_n1 I1_p7_14 I1_I930_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I47_MN3 (VSS XI1_I930_I47_Bn XI1_I930_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I47_MN0 (XI1_I930_I47_An I1_p7_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I44_MN1 (XI1_I930_I44_Bn I1_b8_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I44_MN5 (XI1_I930_I44_n2 I1_b8_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I44_MN4 (I1_I930_pn12 XI1_I930_I44_An XI1_I930_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I44_MN2 (XI1_I930_I44_n1 I1_p7_11 I1_I930_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I44_MN3 (VSS XI1_I930_I44_Bn XI1_I930_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I44_MN0 (XI1_I930_I44_An I1_p7_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I45_MN1 (XI1_I930_I45_Bn I1_b8_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I45_MN5 (XI1_I930_I45_n2 I1_b8_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I45_MN4 (I1_I930_pn13 XI1_I930_I45_An XI1_I930_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I45_MN2 (XI1_I930_I45_n1 I1_p7_12 I1_I930_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I45_MN3 (VSS XI1_I930_I45_Bn XI1_I930_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I45_MN0 (XI1_I930_I45_An I1_p7_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I43_MN1 (XI1_I930_I43_Bn I1_b8_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I43_MN5 (XI1_I930_I43_n2 I1_b8_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I43_MN4 (I1_I930_pn11 XI1_I930_I43_An XI1_I930_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I43_MN2 (XI1_I930_I43_n1 I1_p7_10 I1_I930_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I43_MN3 (VSS XI1_I930_I43_Bn XI1_I930_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I43_MN0 (XI1_I930_I43_An I1_p7_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I39_MN1 (XI1_I930_I39_Bn I1_b8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I39_MN5 (XI1_I930_I39_n2 I1_b8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I39_MN4 (I1_I930_pn7 XI1_I930_I39_An XI1_I930_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I39_MN2 (XI1_I930_I39_n1 I1_p7_6 I1_I930_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I39_MN3 (VSS XI1_I930_I39_Bn XI1_I930_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I39_MN0 (XI1_I930_I39_An I1_p7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I203_MN1 (XI1_I838_I203_Bn I1_qu26_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I203_MN5 (XI1_I838_I203_n2 I1_qu26_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I203_MN4 (I1_p6_0 XI1_I838_I203_An XI1_I838_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I203_MN2 (XI1_I838_I203_n1 I1_I838_pn0 I1_p6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I203_MN3 (VSS XI1_I838_I203_Bn XI1_I838_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I203_MN0 (XI1_I838_I203_An I1_I838_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I33_MN1 (XI1_I884_I33_Bn I1_b7_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I33_MN5 (XI1_I884_I33_n2 I1_b7_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I33_MN4 (I1_I884_pn1 XI1_I884_I33_An XI1_I884_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I33_MN2 (XI1_I884_I33_n1 I1_p6_0 I1_I884_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I33_MN3 (VSS XI1_I884_I33_Bn XI1_I884_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I33_MN0 (XI1_I884_I33_An I1_p6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I32_MN1 (XI1_I838_I32_Bn I1_b6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I32_MN5 (XI1_I838_I32_n2 I1_b6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I32_MN4 (I1_I838_pn0 XI1_I838_I32_An XI1_I838_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I32_MN2 (XI1_I838_I32_n1 I1_aa25 I1_I838_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I32_MN3 (VSS XI1_I838_I32_Bn XI1_I838_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I32_MN0 (XI1_I838_I32_An I1_aa25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I32_MN1 (XI1_I792_I32_Bn I1_b5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I32_MN5 (XI1_I792_I32_n2 I1_b5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I32_MN4 (I1_I792_pn0 XI1_I792_I32_An XI1_I792_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I32_MN2 (XI1_I792_I32_n1 I1_aa26 I1_I792_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I32_MN3 (VSS XI1_I792_I32_Bn XI1_I792_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I32_MN0 (XI1_I792_I32_An I1_aa26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I33_MN1 (XI1_I700_I33_Bn I1_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I33_MN5 (XI1_I700_I33_n2 I1_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I33_MN4 (I1_I700_pn1 XI1_I700_I33_An XI1_I700_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I33_MN2 (XI1_I700_I33_n1 I1_p2_0 I1_I700_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I33_MN3 (VSS XI1_I700_I33_Bn XI1_I700_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I33_MN0 (XI1_I700_I33_An I1_p2_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I204_MN1 (XI1_I700_I204_Bn I1_I700_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I204_MN5 (XI1_I700_I204_n2 I1_I700_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I204_MN4 (I1_p3_1 XI1_I700_I204_An XI1_I700_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I204_MN2 (XI1_I700_I204_n1 I1_I700_pn1 I1_p3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I204_MN3 (VSS XI1_I700_I204_Bn XI1_I700_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I204_MN0 (XI1_I700_I204_An I1_I700_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I230_MN1 (XI1_I700_I230_Bn I1_I700_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I230_MN5 (XI1_I700_I230_n2 I1_I700_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I230_MN4 (I1_p3_27 XI1_I700_I230_An XI1_I700_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I230_MN2 (XI1_I700_I230_n1 I1_I700_pn27 I1_p3_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I230_MN3 (VSS XI1_I700_I230_Bn XI1_I700_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I230_MN0 (XI1_I700_I230_An I1_I700_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I232_MN1 (XI1_I700_I232_Bn I1_I700_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I232_MN5 (XI1_I700_I232_n2 I1_I700_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I232_MN4 (I1_p3_29 XI1_I700_I232_An XI1_I700_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I232_MN2 (XI1_I700_I232_n1 I1_I700_pn29 I1_p3_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I232_MN3 (VSS XI1_I700_I232_Bn XI1_I700_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I232_MN0 (XI1_I700_I232_An I1_I700_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I231_MN1 (XI1_I1390_I231_Bn I1_I1390_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I231_MN5 (XI1_I1390_I231_n2 I1_I1390_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I231_MN4 (I1_p18_28 XI1_I1390_I231_An XI1_I1390_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I231_MN2 (XI1_I1390_I231_n1 I1_I1390_pn28 I1_p18_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I231_MN3 (VSS XI1_I1390_I231_Bn XI1_I1390_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I231_MN0 (XI1_I1390_I231_An I1_I1390_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I229_MN1 (XI1_I1390_I229_Bn I1_I1390_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I229_MN5 (XI1_I1390_I229_n2 I1_I1390_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I229_MN4 (I1_p18_26 XI1_I1390_I229_An XI1_I1390_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I229_MN2 (XI1_I1390_I229_n1 I1_I1390_pn26 I1_p18_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I229_MN3 (VSS XI1_I1390_I229_Bn XI1_I1390_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I229_MN0 (XI1_I1390_I229_An I1_I1390_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I223_MN1 (XI1_I1390_I223_Bn I1_I1390_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I223_MN5 (XI1_I1390_I223_n2 I1_I1390_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I223_MN4 (I1_p18_20 XI1_I1390_I223_An XI1_I1390_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I223_MN2 (XI1_I1390_I223_n1 I1_I1390_pn20 I1_p18_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I223_MN3 (VSS XI1_I1390_I223_Bn XI1_I1390_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I223_MN0 (XI1_I1390_I223_An I1_I1390_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I221_MN1 (XI1_I1390_I221_Bn I1_I1390_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I221_MN5 (XI1_I1390_I221_n2 I1_I1390_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I221_MN4 (I1_p18_18 XI1_I1390_I221_An XI1_I1390_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I221_MN2 (XI1_I1390_I221_n1 I1_I1390_pn18 I1_p18_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I221_MN3 (VSS XI1_I1390_I221_Bn XI1_I1390_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I221_MN0 (XI1_I1390_I221_An I1_I1390_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I38_MN1 (XI1_I1390_I38_Bn I1_b18_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I38_MN5 (XI1_I1390_I38_n2 I1_b18_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I38_MN4 (I1_I1390_pn6 XI1_I1390_I38_An XI1_I1390_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I38_MN2 (XI1_I1390_I38_n1 I1_p17_5 I1_I1390_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I38_MN3 (VSS XI1_I1390_I38_Bn XI1_I1390_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I38_MN0 (XI1_I1390_I38_An I1_p17_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I37_MN1 (XI1_I1390_I37_Bn I1_b18_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I37_MN5 (XI1_I1390_I37_n2 I1_b18_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I37_MN4 (I1_I1390_pn5 XI1_I1390_I37_An XI1_I1390_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I37_MN2 (XI1_I1390_I37_n1 I1_p17_4 I1_I1390_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I37_MN3 (VSS XI1_I1390_I37_Bn XI1_I1390_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I37_MN0 (XI1_I1390_I37_An I1_p17_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I33_MN1 (XI1_I1344_I33_Bn I1_b17_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I33_MN5 (XI1_I1344_I33_n2 I1_b17_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I33_MN4 (I1_I1344_pn1 XI1_I1344_I33_An XI1_I1344_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I33_MN2 (XI1_I1344_I33_n1 I1_p16_0 I1_I1344_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I33_MN3 (VSS XI1_I1344_I33_Bn XI1_I1344_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I33_MN0 (XI1_I1344_I33_An I1_p16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I59_MN1 (XI1_I1160_I59_Bn I1_b13_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I59_MN5 (XI1_I1160_I59_n2 I1_b13_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I59_MN4 (I1_I1160_pn27 XI1_I1160_I59_An XI1_I1160_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I59_MN2 (XI1_I1160_I59_n1 I1_p12_26 I1_I1160_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I59_MN3 (VSS XI1_I1160_I59_Bn XI1_I1160_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I59_MN0 (XI1_I1160_I59_An I1_p12_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I32_MN1 (XI1_I1252_I32_Bn I1_b15_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I32_MN5 (XI1_I1252_I32_n2 I1_b15_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I32_MN4 (I1_I1252_pn0 XI1_I1252_I32_An XI1_I1252_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I32_MN2 (XI1_I1252_I32_n1 I1_aa16 I1_I1252_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I32_MN3 (VSS XI1_I1252_I32_Bn XI1_I1252_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I32_MN0 (XI1_I1252_I32_An I1_aa16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I61_MN1 (XI1_I1160_I61_Bn I1_b13_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I61_MN5 (XI1_I1160_I61_n2 I1_b13_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I61_MN4 (I1_I1160_pn29 XI1_I1160_I61_An XI1_I1160_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I61_MN2 (XI1_I1160_I61_n1 I1_p12_28 I1_I1160_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I61_MN3 (VSS XI1_I1160_I61_Bn XI1_I1160_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I61_MN0 (XI1_I1160_I61_An I1_p12_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I234_MN1 (XI1_I1160_I234_Bn I1_c13_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I234_MN5 (XI1_I1160_I234_n2 I1_c13_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I234_MN4 (I1_p13_31 XI1_I1160_I234_An XI1_I1160_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I234_MN2 (XI1_I1160_I234_n1 I1_I1160_pn31 I1_p13_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I234_MN3 (VSS XI1_I1160_I234_Bn XI1_I1160_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I234_MN0 (XI1_I1160_I234_An I1_I1160_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I226_MN1 (XI1_I1160_I226_Bn I1_I1160_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I226_MN5 (XI1_I1160_I226_n2 I1_I1160_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I226_MN4 (I1_p13_23 XI1_I1160_I226_An XI1_I1160_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I226_MN2 (XI1_I1160_I226_n1 I1_I1160_pn23 I1_p13_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I226_MN3 (VSS XI1_I1160_I226_Bn XI1_I1160_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I226_MN0 (XI1_I1160_I226_An I1_I1160_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I220_MN1 (XI1_I1160_I220_Bn I1_I1160_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I220_MN5 (XI1_I1160_I220_n2 I1_I1160_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I220_MN4 (I1_p13_17 XI1_I1160_I220_An XI1_I1160_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I220_MN2 (XI1_I1160_I220_n1 I1_I1160_pn17 I1_p13_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I220_MN3 (VSS XI1_I1160_I220_Bn XI1_I1160_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I220_MN0 (XI1_I1160_I220_An I1_I1160_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I230_MN1 (XI1_I1160_I230_Bn I1_I1160_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I230_MN5 (XI1_I1160_I230_n2 I1_I1160_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I230_MN4 (I1_p13_27 XI1_I1160_I230_An XI1_I1160_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I230_MN2 (XI1_I1160_I230_n1 I1_I1160_pn27 I1_p13_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I230_MN3 (VSS XI1_I1160_I230_Bn XI1_I1160_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I230_MN0 (XI1_I1160_I230_An I1_I1160_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I222_MN1 (XI1_I1160_I222_Bn I1_I1160_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I222_MN5 (XI1_I1160_I222_n2 I1_I1160_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I222_MN4 (I1_p13_19 XI1_I1160_I222_An XI1_I1160_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I222_MN2 (XI1_I1160_I222_n1 I1_I1160_pn19 I1_p13_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I222_MN3 (VSS XI1_I1160_I222_Bn XI1_I1160_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I222_MN0 (XI1_I1160_I222_An I1_I1160_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I228_MN1 (XI1_I1160_I228_Bn I1_I1160_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I228_MN5 (XI1_I1160_I228_n2 I1_I1160_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I228_MN4 (I1_p13_25 XI1_I1160_I228_An XI1_I1160_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I228_MN2 (XI1_I1160_I228_n1 I1_I1160_pn25 I1_p13_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I228_MN3 (VSS XI1_I1160_I228_Bn XI1_I1160_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I228_MN0 (XI1_I1160_I228_An I1_I1160_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I208_MN1 (XI1_I1160_I208_Bn I1_I1160_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I208_MN5 (XI1_I1160_I208_n2 I1_I1160_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I208_MN4 (I1_p13_5 XI1_I1160_I208_An XI1_I1160_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I208_MN2 (XI1_I1160_I208_n1 I1_I1160_pn5 I1_p13_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I208_MN3 (VSS XI1_I1160_I208_Bn XI1_I1160_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I208_MN0 (XI1_I1160_I208_An I1_I1160_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I205_MN1 (XI1_I1160_I205_Bn I1_I1160_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I205_MN5 (XI1_I1160_I205_n2 I1_I1160_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I205_MN4 (I1_p13_2 XI1_I1160_I205_An XI1_I1160_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I205_MN2 (XI1_I1160_I205_n1 I1_I1160_pn2 I1_p13_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I205_MN3 (VSS XI1_I1160_I205_Bn XI1_I1160_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I205_MN0 (XI1_I1160_I205_An I1_I1160_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I204_MN1 (XI1_I1160_I204_Bn I1_I1160_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I204_MN5 (XI1_I1160_I204_n2 I1_I1160_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I204_MN4 (I1_p13_1 XI1_I1160_I204_An XI1_I1160_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I204_MN2 (XI1_I1160_I204_n1 I1_I1160_pn1 I1_p13_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I204_MN3 (VSS XI1_I1160_I204_Bn XI1_I1160_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I204_MN0 (XI1_I1160_I204_An I1_I1160_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I32_MN1 (XI1_I1206_I32_Bn I1_b14_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I32_MN5 (XI1_I1206_I32_n2 I1_b14_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I32_MN4 (I1_I1206_pn0 XI1_I1206_I32_An XI1_I1206_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I32_MN2 (XI1_I1206_I32_n1 I1_aa17 I1_I1206_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I32_MN3 (VSS XI1_I1206_I32_Bn XI1_I1206_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I32_MN0 (XI1_I1206_I32_An I1_aa17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I63_MN1 (XI1_I930_I63_Bn I1_b8_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I63_MN5 (XI1_I930_I63_n2 I1_b8_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I63_MN4 (I1_I930_pn31 XI1_I930_I63_An XI1_I930_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I63_MN2 (XI1_I930_I63_n1 I1_p7_30 I1_I930_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I63_MN3 (VSS XI1_I930_I63_Bn XI1_I930_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I63_MN0 (XI1_I930_I63_An I1_p7_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I41_MN1 (XI1_I930_I41_Bn I1_b8_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I41_MN5 (XI1_I930_I41_n2 I1_b8_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I41_MN4 (I1_I930_pn9 XI1_I930_I41_An XI1_I930_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I41_MN2 (XI1_I930_I41_n1 I1_p7_8 I1_I930_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I41_MN3 (VSS XI1_I930_I41_Bn XI1_I930_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I41_MN0 (XI1_I930_I41_An I1_p7_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I40_MN1 (XI1_I930_I40_Bn I1_b8_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I40_MN5 (XI1_I930_I40_n2 I1_b8_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I40_MN4 (I1_I930_pn8 XI1_I930_I40_An XI1_I930_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I40_MN2 (XI1_I930_I40_n1 I1_p7_7 I1_I930_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I40_MN3 (VSS XI1_I930_I40_Bn XI1_I930_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I40_MN0 (XI1_I930_I40_An I1_p7_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I38_MN1 (XI1_I930_I38_Bn I1_b8_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I38_MN5 (XI1_I930_I38_n2 I1_b8_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I38_MN4 (I1_I930_pn6 XI1_I930_I38_An XI1_I930_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I38_MN2 (XI1_I930_I38_n1 I1_p7_5 I1_I930_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I38_MN3 (VSS XI1_I930_I38_Bn XI1_I930_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I38_MN0 (XI1_I930_I38_An I1_p7_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I204_MN1 (XI1_I884_I204_Bn I1_I884_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I204_MN5 (XI1_I884_I204_n2 I1_I884_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I204_MN4 (I1_p7_1 XI1_I884_I204_An XI1_I884_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I204_MN2 (XI1_I884_I204_n1 I1_I884_pn1 I1_p7_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I204_MN3 (VSS XI1_I884_I204_Bn XI1_I884_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I204_MN0 (XI1_I884_I204_An I1_I884_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I203_MN1 (XI1_I746_I203_Bn I1_qu28_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I203_MN5 (XI1_I746_I203_n2 I1_qu28_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I203_MN4 (I1_p4_0 XI1_I746_I203_An XI1_I746_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I203_MN2 (XI1_I746_I203_n1 I1_I746_pn0 I1_p4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I203_MN3 (VSS XI1_I746_I203_Bn XI1_I746_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I203_MN0 (XI1_I746_I203_An I1_I746_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I34_MN1 (XI1_I700_I34_Bn I1_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I34_MN5 (XI1_I700_I34_n2 I1_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I34_MN4 (I1_I700_pn2 XI1_I700_I34_An XI1_I700_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I34_MN2 (XI1_I700_I34_n1 I1_p2_1 I1_I700_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I34_MN3 (VSS XI1_I700_I34_Bn XI1_I700_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I34_MN0 (XI1_I700_I34_An I1_p2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I60_MN1 (XI1_I700_I60_Bn I1_b3_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I60_MN5 (XI1_I700_I60_n2 I1_b3_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I60_MN4 (I1_I700_pn28 XI1_I700_I60_An XI1_I700_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I60_MN2 (XI1_I700_I60_n1 I1_p2_27 I1_I700_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I60_MN3 (VSS XI1_I700_I60_Bn XI1_I700_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I60_MN0 (XI1_I700_I60_An I1_p2_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I234_MN1 (XI1_I1390_I234_Bn I1_c18_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I234_MN5 (XI1_I1390_I234_n2 I1_c18_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I234_MN4 (I1_p18_31 XI1_I1390_I234_An XI1_I1390_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I234_MN2 (XI1_I1390_I234_n1 I1_I1390_pn31 I1_p18_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I234_MN3 (VSS XI1_I1390_I234_Bn XI1_I1390_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I234_MN0 (XI1_I1390_I234_An I1_I1390_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I211_MN1 (XI1_I1390_I211_Bn I1_I1390_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I211_MN5 (XI1_I1390_I211_n2 I1_I1390_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I211_MN4 (I1_p18_8 XI1_I1390_I211_An XI1_I1390_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I211_MN2 (XI1_I1390_I211_n1 I1_I1390_pn8 I1_p18_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I211_MN3 (VSS XI1_I1390_I211_Bn XI1_I1390_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I211_MN0 (XI1_I1390_I211_An I1_I1390_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I209_MN1 (XI1_I1390_I209_Bn I1_I1390_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I209_MN5 (XI1_I1390_I209_n2 I1_I1390_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I209_MN4 (I1_p18_6 XI1_I1390_I209_An XI1_I1390_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I209_MN2 (XI1_I1390_I209_n1 I1_I1390_pn6 I1_p18_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I209_MN3 (VSS XI1_I1390_I209_Bn XI1_I1390_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I209_MN0 (XI1_I1390_I209_An I1_I1390_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I36_MN1 (XI1_I1390_I36_Bn I1_b18_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I36_MN5 (XI1_I1390_I36_n2 I1_b18_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I36_MN4 (I1_I1390_pn4 XI1_I1390_I36_An XI1_I1390_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I36_MN2 (XI1_I1390_I36_n1 I1_p17_3 I1_I1390_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I36_MN3 (VSS XI1_I1390_I36_Bn XI1_I1390_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I36_MN0 (XI1_I1390_I36_An I1_p17_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I35_MN1 (XI1_I1390_I35_Bn I1_b18_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I35_MN5 (XI1_I1390_I35_n2 I1_b18_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I35_MN4 (I1_I1390_pn3 XI1_I1390_I35_An XI1_I1390_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I35_MN2 (XI1_I1390_I35_n1 I1_p17_2 I1_I1390_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I35_MN3 (VSS XI1_I1390_I35_Bn XI1_I1390_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I35_MN0 (XI1_I1390_I35_An I1_p17_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I204_MN1 (XI1_I1344_I204_Bn I1_I1344_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I204_MN5 (XI1_I1344_I204_n2 I1_I1344_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I204_MN4 (I1_p17_1 XI1_I1344_I204_An XI1_I1344_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I204_MN2 (XI1_I1344_I204_n1 I1_I1344_pn1 I1_p17_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I204_MN3 (VSS XI1_I1344_I204_Bn XI1_I1344_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I204_MN0 (XI1_I1344_I204_An I1_I1344_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I203_MN1 (XI1_I1298_I203_Bn I1_qu16_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I203_MN5 (XI1_I1298_I203_n2 I1_qu16_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I203_MN4 (I1_p16_0 XI1_I1298_I203_An XI1_I1298_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I203_MN2 (XI1_I1298_I203_n1 I1_I1298_pn0 I1_p16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I203_MN3 (VSS XI1_I1298_I203_Bn XI1_I1298_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I203_MN0 (XI1_I1298_I203_An I1_I1298_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I32_MN1 (XI1_I1298_I32_Bn I1_b16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I32_MN5 (XI1_I1298_I32_n2 I1_b16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I32_MN4 (I1_I1298_pn0 XI1_I1298_I32_An XI1_I1298_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I32_MN2 (XI1_I1298_I32_n1 I1_aa15 I1_I1298_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I32_MN3 (VSS XI1_I1298_I32_Bn XI1_I1298_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I32_MN0 (XI1_I1298_I32_An I1_aa15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I62_MN1 (XI1_I1160_I62_Bn I1_b13_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I62_MN5 (XI1_I1160_I62_n2 I1_b13_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I62_MN4 (I1_I1160_pn30 XI1_I1160_I62_An XI1_I1160_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I62_MN2 (XI1_I1160_I62_n1 I1_p12_29 I1_I1160_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I62_MN3 (VSS XI1_I1160_I62_Bn XI1_I1160_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I62_MN0 (XI1_I1160_I62_An I1_p12_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I33_MN1 (XI1_I1160_I33_Bn I1_b13_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I33_MN5 (XI1_I1160_I33_n2 I1_b13_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I33_MN4 (I1_I1160_pn1 XI1_I1160_I33_An XI1_I1160_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I33_MN2 (XI1_I1160_I33_n1 I1_p12_0 I1_I1160_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I33_MN3 (VSS XI1_I1160_I33_Bn XI1_I1160_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I33_MN0 (XI1_I1160_I33_An I1_p12_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I203_MN1 (XI1_I1160_I203_Bn I1_qu19_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I203_MN5 (XI1_I1160_I203_n2 I1_qu19_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I203_MN4 (I1_p13_0 XI1_I1160_I203_An XI1_I1160_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I203_MN2 (XI1_I1160_I203_n1 I1_I1160_pn0 I1_p13_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I203_MN3 (VSS XI1_I1160_I203_Bn XI1_I1160_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I203_MN0 (XI1_I1160_I203_An I1_I1160_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I62_MN1 (XI1_I930_I62_Bn I1_b8_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I62_MN5 (XI1_I930_I62_n2 I1_b8_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I62_MN4 (I1_I930_pn30 XI1_I930_I62_An XI1_I930_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I62_MN2 (XI1_I930_I62_n1 I1_p7_29 I1_I930_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I62_MN3 (VSS XI1_I930_I62_Bn XI1_I930_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I62_MN0 (XI1_I930_I62_An I1_p7_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I37_MN1 (XI1_I930_I37_Bn I1_b8_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I37_MN5 (XI1_I930_I37_n2 I1_b8_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I37_MN4 (I1_I930_pn5 XI1_I930_I37_An XI1_I930_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I37_MN2 (XI1_I930_I37_n1 I1_p7_4 I1_I930_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I37_MN3 (VSS XI1_I930_I37_Bn XI1_I930_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I37_MN0 (XI1_I930_I37_An I1_p7_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I35_MN1 (XI1_I700_I35_Bn I1_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I35_MN5 (XI1_I700_I35_n2 I1_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I35_MN4 (I1_I700_pn3 XI1_I700_I35_An XI1_I700_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I35_MN2 (XI1_I700_I35_n1 I1_p2_2 I1_I700_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I35_MN3 (VSS XI1_I700_I35_Bn XI1_I700_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I35_MN0 (XI1_I700_I35_An I1_p2_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I37_MN1 (XI1_I700_I37_Bn I1_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I37_MN5 (XI1_I700_I37_n2 I1_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I37_MN4 (I1_I700_pn5 XI1_I700_I37_An XI1_I700_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I37_MN2 (XI1_I700_I37_n1 I1_p2_4 I1_I700_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I37_MN3 (VSS XI1_I700_I37_Bn XI1_I700_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I37_MN0 (XI1_I700_I37_An I1_p2_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I38_MN1 (XI1_I700_I38_Bn I1_b3_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I38_MN5 (XI1_I700_I38_n2 I1_b3_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I38_MN4 (I1_I700_pn6 XI1_I700_I38_An XI1_I700_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I38_MN2 (XI1_I700_I38_n1 I1_p2_5 I1_I700_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I38_MN3 (VSS XI1_I700_I38_Bn XI1_I700_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I38_MN0 (XI1_I700_I38_An I1_p2_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I40_MN1 (XI1_I700_I40_Bn I1_b3_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I40_MN5 (XI1_I700_I40_n2 I1_b3_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I40_MN4 (I1_I700_pn8 XI1_I700_I40_An XI1_I700_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I40_MN2 (XI1_I700_I40_n1 I1_p2_7 I1_I700_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I40_MN3 (VSS XI1_I700_I40_Bn XI1_I700_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I40_MN0 (XI1_I700_I40_An I1_p2_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I39_MN1 (XI1_I700_I39_Bn I1_b3_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I39_MN5 (XI1_I700_I39_n2 I1_b3_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I39_MN4 (I1_I700_pn7 XI1_I700_I39_An XI1_I700_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I39_MN2 (XI1_I700_I39_n1 I1_p2_6 I1_I700_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I39_MN3 (VSS XI1_I700_I39_Bn XI1_I700_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I39_MN0 (XI1_I700_I39_An I1_p2_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I41_MN1 (XI1_I700_I41_Bn I1_b3_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I41_MN5 (XI1_I700_I41_n2 I1_b3_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I41_MN4 (I1_I700_pn9 XI1_I700_I41_An XI1_I700_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I41_MN2 (XI1_I700_I41_n1 I1_p2_8 I1_I700_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I41_MN3 (VSS XI1_I700_I41_Bn XI1_I700_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I41_MN0 (XI1_I700_I41_An I1_p2_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I43_MN1 (XI1_I700_I43_Bn I1_b3_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I43_MN5 (XI1_I700_I43_n2 I1_b3_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I43_MN4 (I1_I700_pn11 XI1_I700_I43_An XI1_I700_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I43_MN2 (XI1_I700_I43_n1 I1_p2_10 I1_I700_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I43_MN3 (VSS XI1_I700_I43_Bn XI1_I700_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I43_MN0 (XI1_I700_I43_An I1_p2_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I45_MN1 (XI1_I700_I45_Bn I1_b3_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I45_MN5 (XI1_I700_I45_n2 I1_b3_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I45_MN4 (I1_I700_pn13 XI1_I700_I45_An XI1_I700_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I45_MN2 (XI1_I700_I45_n1 I1_p2_12 I1_I700_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I45_MN3 (VSS XI1_I700_I45_Bn XI1_I700_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I45_MN0 (XI1_I700_I45_An I1_p2_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I46_MN1 (XI1_I700_I46_Bn I1_b3_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I46_MN5 (XI1_I700_I46_n2 I1_b3_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I46_MN4 (I1_I700_pn14 XI1_I700_I46_An XI1_I700_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I46_MN2 (XI1_I700_I46_n1 I1_p2_13 I1_I700_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I46_MN3 (VSS XI1_I700_I46_Bn XI1_I700_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I46_MN0 (XI1_I700_I46_An I1_p2_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I51_MN1 (XI1_I700_I51_Bn I1_b3_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I51_MN5 (XI1_I700_I51_n2 I1_b3_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I51_MN4 (I1_I700_pn19 XI1_I700_I51_An XI1_I700_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I51_MN2 (XI1_I700_I51_n1 I1_p2_18 I1_I700_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I51_MN3 (VSS XI1_I700_I51_Bn XI1_I700_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I51_MN0 (XI1_I700_I51_An I1_p2_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I52_MN1 (XI1_I700_I52_Bn I1_b3_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I52_MN5 (XI1_I700_I52_n2 I1_b3_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I52_MN4 (I1_I700_pn20 XI1_I700_I52_An XI1_I700_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I52_MN2 (XI1_I700_I52_n1 I1_p2_19 I1_I700_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I52_MN3 (VSS XI1_I700_I52_Bn XI1_I700_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I52_MN0 (XI1_I700_I52_An I1_p2_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I54_MN1 (XI1_I700_I54_Bn I1_b3_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I54_MN5 (XI1_I700_I54_n2 I1_b3_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I54_MN4 (I1_I700_pn22 XI1_I700_I54_An XI1_I700_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I54_MN2 (XI1_I700_I54_n1 I1_p2_21 I1_I700_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I54_MN3 (VSS XI1_I700_I54_Bn XI1_I700_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I54_MN0 (XI1_I700_I54_An I1_p2_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I56_MN1 (XI1_I700_I56_Bn I1_b3_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I56_MN5 (XI1_I700_I56_n2 I1_b3_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I56_MN4 (I1_I700_pn24 XI1_I700_I56_An XI1_I700_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I56_MN2 (XI1_I700_I56_n1 I1_p2_23 I1_I700_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I56_MN3 (VSS XI1_I700_I56_Bn XI1_I700_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I56_MN0 (XI1_I700_I56_An I1_p2_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I59_MN1 (XI1_I700_I59_Bn I1_b3_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I59_MN5 (XI1_I700_I59_n2 I1_b3_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I59_MN4 (I1_I700_pn27 XI1_I700_I59_An XI1_I700_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I59_MN2 (XI1_I700_I59_n1 I1_p2_26 I1_I700_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I59_MN3 (VSS XI1_I700_I59_Bn XI1_I700_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I59_MN0 (XI1_I700_I59_An I1_p2_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I232_MN1 (XI1_I1390_I232_Bn I1_I1390_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I232_MN5 (XI1_I1390_I232_n2 I1_I1390_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I232_MN4 (I1_p18_29 XI1_I1390_I232_An XI1_I1390_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I232_MN2 (XI1_I1390_I232_n1 I1_I1390_pn29 I1_p18_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I232_MN3 (VSS XI1_I1390_I232_Bn XI1_I1390_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I232_MN0 (XI1_I1390_I232_An I1_I1390_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I230_MN1 (XI1_I1390_I230_Bn I1_I1390_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I230_MN5 (XI1_I1390_I230_n2 I1_I1390_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I230_MN4 (I1_p18_27 XI1_I1390_I230_An XI1_I1390_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I230_MN2 (XI1_I1390_I230_n1 I1_I1390_pn27 I1_p18_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I230_MN3 (VSS XI1_I1390_I230_Bn XI1_I1390_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I230_MN0 (XI1_I1390_I230_An I1_I1390_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I228_MN1 (XI1_I1390_I228_Bn I1_I1390_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I228_MN5 (XI1_I1390_I228_n2 I1_I1390_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I228_MN4 (I1_p18_25 XI1_I1390_I228_An XI1_I1390_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I228_MN2 (XI1_I1390_I228_n1 I1_I1390_pn25 I1_p18_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I228_MN3 (VSS XI1_I1390_I228_Bn XI1_I1390_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I228_MN0 (XI1_I1390_I228_An I1_I1390_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I208_MN1 (XI1_I1390_I208_Bn I1_I1390_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I208_MN5 (XI1_I1390_I208_n2 I1_I1390_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I208_MN4 (I1_p18_5 XI1_I1390_I208_An XI1_I1390_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I208_MN2 (XI1_I1390_I208_n1 I1_I1390_pn5 I1_p18_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I208_MN3 (VSS XI1_I1390_I208_Bn XI1_I1390_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I208_MN0 (XI1_I1390_I208_An I1_I1390_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I34_MN1 (XI1_I1390_I34_Bn I1_b18_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I34_MN5 (XI1_I1390_I34_n2 I1_b18_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I34_MN4 (I1_I1390_pn2 XI1_I1390_I34_An XI1_I1390_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I34_MN2 (XI1_I1390_I34_n1 I1_p17_1 I1_I1390_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I34_MN3 (VSS XI1_I1390_I34_Bn XI1_I1390_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I34_MN0 (XI1_I1390_I34_An I1_p17_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I57_MN1 (XI1_I1160_I57_Bn I1_b13_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I57_MN5 (XI1_I1160_I57_n2 I1_b13_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I57_MN4 (I1_I1160_pn25 XI1_I1160_I57_An XI1_I1160_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I57_MN2 (XI1_I1160_I57_n1 I1_p12_24 I1_I1160_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I57_MN3 (VSS XI1_I1160_I57_Bn XI1_I1160_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I57_MN0 (XI1_I1160_I57_An I1_p12_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I60_MN1 (XI1_I1160_I60_Bn I1_b13_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I60_MN5 (XI1_I1160_I60_n2 I1_b13_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I60_MN4 (I1_I1160_pn28 XI1_I1160_I60_An XI1_I1160_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I60_MN2 (XI1_I1160_I60_n1 I1_p12_27 I1_I1160_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I60_MN3 (VSS XI1_I1160_I60_Bn XI1_I1160_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I60_MN0 (XI1_I1160_I60_An I1_p12_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I58_MN1 (XI1_I1160_I58_Bn I1_b13_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I58_MN5 (XI1_I1160_I58_n2 I1_b13_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I58_MN4 (I1_I1160_pn26 XI1_I1160_I58_An XI1_I1160_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I58_MN2 (XI1_I1160_I58_n1 I1_p12_25 I1_I1160_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I58_MN3 (VSS XI1_I1160_I58_Bn XI1_I1160_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I58_MN0 (XI1_I1160_I58_An I1_p12_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I56_MN1 (XI1_I1160_I56_Bn I1_b13_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I56_MN5 (XI1_I1160_I56_n2 I1_b13_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I56_MN4 (I1_I1160_pn24 XI1_I1160_I56_An XI1_I1160_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I56_MN2 (XI1_I1160_I56_n1 I1_p12_23 I1_I1160_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I56_MN3 (VSS XI1_I1160_I56_Bn XI1_I1160_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I56_MN0 (XI1_I1160_I56_An I1_p12_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I55_MN1 (XI1_I1160_I55_Bn I1_b13_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I55_MN5 (XI1_I1160_I55_n2 I1_b13_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I55_MN4 (I1_I1160_pn23 XI1_I1160_I55_An XI1_I1160_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I55_MN2 (XI1_I1160_I55_n1 I1_p12_22 I1_I1160_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I55_MN3 (VSS XI1_I1160_I55_Bn XI1_I1160_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I55_MN0 (XI1_I1160_I55_An I1_p12_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I35_MN1 (XI1_I1160_I35_Bn I1_b13_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I35_MN5 (XI1_I1160_I35_n2 I1_b13_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I35_MN4 (I1_I1160_pn3 XI1_I1160_I35_An XI1_I1160_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I35_MN2 (XI1_I1160_I35_n1 I1_p12_2 I1_I1160_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I35_MN3 (VSS XI1_I1160_I35_Bn XI1_I1160_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I35_MN0 (XI1_I1160_I35_An I1_p12_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I34_MN1 (XI1_I1160_I34_Bn I1_b13_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I34_MN5 (XI1_I1160_I34_n2 I1_b13_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I34_MN4 (I1_I1160_pn2 XI1_I1160_I34_An XI1_I1160_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I34_MN2 (XI1_I1160_I34_n1 I1_p12_1 I1_I1160_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I34_MN3 (VSS XI1_I1160_I34_Bn XI1_I1160_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I34_MN0 (XI1_I1160_I34_An I1_p12_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I32_MN1 (XI1_I1160_I32_Bn I1_b13_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I32_MN5 (XI1_I1160_I32_n2 I1_b13_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I32_MN4 (I1_I1160_pn0 XI1_I1160_I32_An XI1_I1160_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I32_MN2 (XI1_I1160_I32_n1 I1_aa18 I1_I1160_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I32_MN3 (VSS XI1_I1160_I32_Bn XI1_I1160_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I32_MN0 (XI1_I1160_I32_An I1_aa18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I233_MN1 (XI1_I930_I233_Bn I1_I930_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I233_MN5 (XI1_I930_I233_n2 I1_I930_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I233_MN4 (I1_p8_30 XI1_I930_I233_An XI1_I930_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I233_MN2 (XI1_I930_I233_n1 I1_I930_pn30 I1_p8_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I233_MN3 (VSS XI1_I930_I233_Bn XI1_I930_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I233_MN0 (XI1_I930_I233_An I1_I930_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I231_MN1 (XI1_I930_I231_Bn I1_I930_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I231_MN5 (XI1_I930_I231_n2 I1_I930_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I231_MN4 (I1_p8_28 XI1_I930_I231_An XI1_I930_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I231_MN2 (XI1_I930_I231_n1 I1_I930_pn28 I1_p8_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I231_MN3 (VSS XI1_I930_I231_Bn XI1_I930_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I231_MN0 (XI1_I930_I231_An I1_I930_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I229_MN1 (XI1_I930_I229_Bn I1_I930_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I229_MN5 (XI1_I930_I229_n2 I1_I930_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I229_MN4 (I1_p8_26 XI1_I930_I229_An XI1_I930_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I229_MN2 (XI1_I930_I229_n1 I1_I930_pn26 I1_p8_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I229_MN3 (VSS XI1_I930_I229_Bn XI1_I930_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I229_MN0 (XI1_I930_I229_An I1_I930_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I227_MN1 (XI1_I930_I227_Bn I1_I930_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I227_MN5 (XI1_I930_I227_n2 I1_I930_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I227_MN4 (I1_p8_24 XI1_I930_I227_An XI1_I930_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I227_MN2 (XI1_I930_I227_n1 I1_I930_pn24 I1_p8_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I227_MN3 (VSS XI1_I930_I227_Bn XI1_I930_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I227_MN0 (XI1_I930_I227_An I1_I930_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I225_MN1 (XI1_I930_I225_Bn I1_I930_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I225_MN5 (XI1_I930_I225_n2 I1_I930_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I225_MN4 (I1_p8_22 XI1_I930_I225_An XI1_I930_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I225_MN2 (XI1_I930_I225_n1 I1_I930_pn22 I1_p8_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I225_MN3 (VSS XI1_I930_I225_Bn XI1_I930_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I225_MN0 (XI1_I930_I225_An I1_I930_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I223_MN1 (XI1_I930_I223_Bn I1_I930_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I223_MN5 (XI1_I930_I223_n2 I1_I930_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I223_MN4 (I1_p8_20 XI1_I930_I223_An XI1_I930_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I223_MN2 (XI1_I930_I223_n1 I1_I930_pn20 I1_p8_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I223_MN3 (VSS XI1_I930_I223_Bn XI1_I930_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I223_MN0 (XI1_I930_I223_An I1_I930_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I221_MN1 (XI1_I930_I221_Bn I1_I930_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I221_MN5 (XI1_I930_I221_n2 I1_I930_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I221_MN4 (I1_p8_18 XI1_I930_I221_An XI1_I930_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I221_MN2 (XI1_I930_I221_n1 I1_I930_pn18 I1_p8_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I221_MN3 (VSS XI1_I930_I221_Bn XI1_I930_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I221_MN0 (XI1_I930_I221_An I1_I930_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I211_MN1 (XI1_I930_I211_Bn I1_I930_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I211_MN5 (XI1_I930_I211_n2 I1_I930_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I211_MN4 (I1_p8_8 XI1_I930_I211_An XI1_I930_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I211_MN2 (XI1_I930_I211_n1 I1_I930_pn8 I1_p8_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I211_MN3 (VSS XI1_I930_I211_Bn XI1_I930_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I211_MN0 (XI1_I930_I211_An I1_I930_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I36_MN1 (XI1_I930_I36_Bn I1_b8_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I36_MN5 (XI1_I930_I36_n2 I1_b8_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I36_MN4 (I1_I930_pn4 XI1_I930_I36_An XI1_I930_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I36_MN2 (XI1_I930_I36_n1 I1_p7_3 I1_I930_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I36_MN3 (VSS XI1_I930_I36_Bn XI1_I930_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I36_MN0 (XI1_I930_I36_An I1_p7_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I32_MN1 (XI1_I746_I32_Bn I1_b4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I32_MN5 (XI1_I746_I32_n2 I1_b4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I32_MN4 (I1_I746_pn0 XI1_I746_I32_An XI1_I746_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I32_MN2 (XI1_I746_I32_n1 I1_aa27 I1_I746_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I32_MN3 (VSS XI1_I746_I32_Bn XI1_I746_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I32_MN0 (XI1_I746_I32_An I1_aa27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I203_MN1 (XI1_I700_I203_Bn I1_qu29_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I203_MN5 (XI1_I700_I203_n2 I1_qu29_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I203_MN4 (I1_p3_0 XI1_I700_I203_An XI1_I700_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I203_MN2 (XI1_I700_I203_n1 I1_I700_pn0 I1_p3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I203_MN3 (VSS XI1_I700_I203_Bn XI1_I700_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I203_MN0 (XI1_I700_I203_An I1_I700_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I36_MN1 (XI1_I700_I36_Bn I1_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I36_MN5 (XI1_I700_I36_n2 I1_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I36_MN4 (I1_I700_pn4 XI1_I700_I36_An XI1_I700_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I36_MN2 (XI1_I700_I36_n1 I1_p2_3 I1_I700_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I36_MN3 (VSS XI1_I700_I36_Bn XI1_I700_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I36_MN0 (XI1_I700_I36_An I1_p2_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I44_MN1 (XI1_I700_I44_Bn I1_b3_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I44_MN5 (XI1_I700_I44_n2 I1_b3_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I44_MN4 (I1_I700_pn12 XI1_I700_I44_An XI1_I700_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I44_MN2 (XI1_I700_I44_n1 I1_p2_11 I1_I700_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I44_MN3 (VSS XI1_I700_I44_Bn XI1_I700_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I44_MN0 (XI1_I700_I44_An I1_p2_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I47_MN1 (XI1_I700_I47_Bn I1_b3_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I47_MN5 (XI1_I700_I47_n2 I1_b3_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I47_MN4 (I1_I700_pn15 XI1_I700_I47_An XI1_I700_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I47_MN2 (XI1_I700_I47_n1 I1_p2_14 I1_I700_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I47_MN3 (VSS XI1_I700_I47_Bn XI1_I700_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I47_MN0 (XI1_I700_I47_An I1_p2_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I49_MN1 (XI1_I700_I49_Bn I1_b3_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I49_MN5 (XI1_I700_I49_n2 I1_b3_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I49_MN4 (I1_I700_pn17 XI1_I700_I49_An XI1_I700_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I49_MN2 (XI1_I700_I49_n1 I1_p2_16 I1_I700_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I49_MN3 (VSS XI1_I700_I49_Bn XI1_I700_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I49_MN0 (XI1_I700_I49_An I1_p2_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I50_MN1 (XI1_I700_I50_Bn I1_b3_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I50_MN5 (XI1_I700_I50_n2 I1_b3_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I50_MN4 (I1_I700_pn18 XI1_I700_I50_An XI1_I700_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I50_MN2 (XI1_I700_I50_n1 I1_p2_17 I1_I700_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I50_MN3 (VSS XI1_I700_I50_Bn XI1_I700_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I50_MN0 (XI1_I700_I50_An I1_p2_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I55_MN1 (XI1_I700_I55_Bn I1_b3_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I55_MN5 (XI1_I700_I55_n2 I1_b3_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I55_MN4 (I1_I700_pn23 XI1_I700_I55_An XI1_I700_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I55_MN2 (XI1_I700_I55_n1 I1_p2_22 I1_I700_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I55_MN3 (VSS XI1_I700_I55_Bn XI1_I700_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I55_MN0 (XI1_I700_I55_An I1_p2_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I58_MN1 (XI1_I700_I58_Bn I1_b3_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I58_MN5 (XI1_I700_I58_n2 I1_b3_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I58_MN4 (I1_I700_pn26 XI1_I700_I58_An XI1_I700_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I58_MN2 (XI1_I700_I58_n1 I1_p2_25 I1_I700_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I58_MN3 (VSS XI1_I700_I58_Bn XI1_I700_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I58_MN0 (XI1_I700_I58_An I1_p2_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I61_MN1 (XI1_I700_I61_Bn I1_b3_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I61_MN5 (XI1_I700_I61_n2 I1_b3_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I61_MN4 (I1_I700_pn29 XI1_I700_I61_An XI1_I700_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I61_MN2 (XI1_I700_I61_n1 I1_p2_28 I1_I700_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I61_MN3 (VSS XI1_I700_I61_Bn XI1_I700_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I61_MN0 (XI1_I700_I61_An I1_p2_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I59_MN1 (XI1_I1436_I59_Bn I1_b19_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I59_MN5 (XI1_I1436_I59_n2 I1_b19_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I59_MN4 (I1_I1436_pn27 XI1_I1436_I59_An XI1_I1436_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I59_MN2 (XI1_I1436_I59_n1 I1_p18_26 I1_I1436_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I59_MN3 (VSS XI1_I1436_I59_Bn XI1_I1436_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I59_MN0 (XI1_I1436_I59_An I1_p18_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I226_MN1 (XI1_I1390_I226_Bn I1_I1390_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I226_MN5 (XI1_I1390_I226_n2 I1_I1390_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I226_MN4 (I1_p18_23 XI1_I1390_I226_An XI1_I1390_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I226_MN2 (XI1_I1390_I226_n1 I1_I1390_pn23 I1_p18_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I226_MN3 (VSS XI1_I1390_I226_Bn XI1_I1390_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I226_MN0 (XI1_I1390_I226_An I1_I1390_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I55_MN1 (XI1_I1436_I55_Bn I1_b19_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I55_MN5 (XI1_I1436_I55_n2 I1_b19_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I55_MN4 (I1_I1436_pn23 XI1_I1436_I55_An XI1_I1436_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I55_MN2 (XI1_I1436_I55_n1 I1_p18_22 I1_I1436_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I55_MN3 (VSS XI1_I1436_I55_Bn XI1_I1436_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I55_MN0 (XI1_I1436_I55_An I1_p18_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I224_MN1 (XI1_I1390_I224_Bn I1_I1390_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I224_MN5 (XI1_I1390_I224_n2 I1_I1390_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I224_MN4 (I1_p18_21 XI1_I1390_I224_An XI1_I1390_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I224_MN2 (XI1_I1390_I224_n1 I1_I1390_pn21 I1_p18_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I224_MN3 (VSS XI1_I1390_I224_Bn XI1_I1390_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I224_MN0 (XI1_I1390_I224_An I1_I1390_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I51_MN1 (XI1_I1436_I51_Bn I1_b19_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I51_MN5 (XI1_I1436_I51_n2 I1_b19_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I51_MN4 (I1_I1436_pn19 XI1_I1436_I51_An XI1_I1436_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I51_MN2 (XI1_I1436_I51_n1 I1_p18_18 I1_I1436_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I51_MN3 (VSS XI1_I1436_I51_Bn XI1_I1436_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I51_MN0 (XI1_I1436_I51_An I1_p18_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I222_MN1 (XI1_I1390_I222_Bn I1_I1390_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I222_MN5 (XI1_I1390_I222_n2 I1_I1390_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I222_MN4 (I1_p18_19 XI1_I1390_I222_An XI1_I1390_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I222_MN2 (XI1_I1390_I222_n1 I1_I1390_pn19 I1_p18_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I222_MN3 (VSS XI1_I1390_I222_Bn XI1_I1390_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I222_MN0 (XI1_I1390_I222_An I1_I1390_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I220_MN1 (XI1_I1390_I220_Bn I1_I1390_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I220_MN5 (XI1_I1390_I220_n2 I1_I1390_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I220_MN4 (I1_p18_17 XI1_I1390_I220_An XI1_I1390_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I220_MN2 (XI1_I1390_I220_n1 I1_I1390_pn17 I1_p18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I220_MN3 (VSS XI1_I1390_I220_Bn XI1_I1390_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I220_MN0 (XI1_I1390_I220_An I1_I1390_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I48_MN1 (XI1_I1436_I48_Bn I1_b19_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I48_MN5 (XI1_I1436_I48_n2 I1_b19_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I48_MN4 (I1_I1436_pn16 XI1_I1436_I48_An XI1_I1436_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I48_MN2 (XI1_I1436_I48_n1 I1_p18_15 I1_I1436_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I48_MN3 (VSS XI1_I1436_I48_Bn XI1_I1436_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I48_MN0 (XI1_I1436_I48_An I1_p18_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I43_MN1 (XI1_I1436_I43_Bn I1_b19_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I43_MN5 (XI1_I1436_I43_n2 I1_b19_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I43_MN4 (I1_I1436_pn11 XI1_I1436_I43_An XI1_I1436_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I43_MN2 (XI1_I1436_I43_n1 I1_p18_10 I1_I1436_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I43_MN3 (VSS XI1_I1436_I43_Bn XI1_I1436_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I43_MN0 (XI1_I1436_I43_An I1_p18_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I210_MN1 (XI1_I1390_I210_Bn I1_I1390_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I210_MN5 (XI1_I1390_I210_n2 I1_I1390_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I210_MN4 (I1_p18_7 XI1_I1390_I210_An XI1_I1390_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I210_MN2 (XI1_I1390_I210_n1 I1_I1390_pn7 I1_p18_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I210_MN3 (VSS XI1_I1390_I210_Bn XI1_I1390_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I210_MN0 (XI1_I1390_I210_An I1_I1390_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I33_MN1 (XI1_I1390_I33_Bn I1_b18_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I33_MN5 (XI1_I1390_I33_n2 I1_b18_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I33_MN4 (I1_I1390_pn1 XI1_I1390_I33_An XI1_I1390_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I33_MN2 (XI1_I1390_I33_n1 I1_p17_0 I1_I1390_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I33_MN3 (VSS XI1_I1390_I33_Bn XI1_I1390_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I33_MN0 (XI1_I1390_I33_An I1_p17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I203_MN1 (XI1_I1344_I203_Bn I1_qu15_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I203_MN5 (XI1_I1344_I203_n2 I1_qu15_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I203_MN4 (I1_p17_0 XI1_I1344_I203_An XI1_I1344_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I203_MN2 (XI1_I1344_I203_n1 I1_I1344_pn0 I1_p17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I203_MN3 (VSS XI1_I1344_I203_Bn XI1_I1344_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I203_MN0 (XI1_I1344_I203_An I1_I1344_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I32_MN1 (XI1_I1344_I32_Bn I1_b17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I32_MN5 (XI1_I1344_I32_n2 I1_b17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I32_MN4 (I1_I1344_pn0 XI1_I1344_I32_An XI1_I1344_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I32_MN2 (XI1_I1344_I32_n1 I1_aa14 I1_I1344_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I32_MN3 (VSS XI1_I1344_I32_Bn XI1_I1344_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I32_MN0 (XI1_I1344_I32_An I1_aa14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I231_MN1 (XI1_I1114_I231_Bn I1_I1114_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I231_MN5 (XI1_I1114_I231_n2 I1_I1114_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I231_MN4 (I1_p12_28 XI1_I1114_I231_An XI1_I1114_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I231_MN2 (XI1_I1114_I231_n1 I1_I1114_pn28 I1_p12_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I231_MN3 (VSS XI1_I1114_I231_Bn XI1_I1114_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I231_MN0 (XI1_I1114_I231_An I1_I1114_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I60_MN1 (XI1_I1114_I60_Bn I1_b12_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I60_MN5 (XI1_I1114_I60_n2 I1_b12_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I60_MN4 (I1_I1114_pn28 XI1_I1114_I60_An XI1_I1114_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I60_MN2 (XI1_I1114_I60_n1 I1_p11_27 I1_I1114_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I60_MN3 (VSS XI1_I1114_I60_Bn XI1_I1114_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I60_MN0 (XI1_I1114_I60_An I1_p11_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I59_MN1 (XI1_I1114_I59_Bn I1_b12_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I59_MN5 (XI1_I1114_I59_n2 I1_b12_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I59_MN4 (I1_I1114_pn27 XI1_I1114_I59_An XI1_I1114_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I59_MN2 (XI1_I1114_I59_n1 I1_p11_26 I1_I1114_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I59_MN3 (VSS XI1_I1114_I59_Bn XI1_I1114_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I59_MN0 (XI1_I1114_I59_An I1_p11_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I230_MN1 (XI1_I1114_I230_Bn I1_I1114_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I230_MN5 (XI1_I1114_I230_n2 I1_I1114_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I230_MN4 (I1_p12_27 XI1_I1114_I230_An XI1_I1114_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I230_MN2 (XI1_I1114_I230_n1 I1_I1114_pn27 I1_p12_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I230_MN3 (VSS XI1_I1114_I230_Bn XI1_I1114_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I230_MN0 (XI1_I1114_I230_An I1_I1114_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I232_MN1 (XI1_I1114_I232_Bn I1_I1114_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I232_MN5 (XI1_I1114_I232_n2 I1_I1114_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I232_MN4 (I1_p12_29 XI1_I1114_I232_An XI1_I1114_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I232_MN2 (XI1_I1114_I232_n1 I1_I1114_pn29 I1_p12_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I232_MN3 (VSS XI1_I1114_I232_Bn XI1_I1114_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I232_MN0 (XI1_I1114_I232_An I1_I1114_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I54_MN1 (XI1_I1160_I54_Bn I1_b13_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I54_MN5 (XI1_I1160_I54_n2 I1_b13_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I54_MN4 (I1_I1160_pn22 XI1_I1160_I54_An XI1_I1160_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I54_MN2 (XI1_I1160_I54_n1 I1_p12_21 I1_I1160_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I54_MN3 (VSS XI1_I1160_I54_Bn XI1_I1160_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I54_MN0 (XI1_I1160_I54_An I1_p12_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I53_MN1 (XI1_I1160_I53_Bn I1_b13_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I53_MN5 (XI1_I1160_I53_n2 I1_b13_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I53_MN4 (I1_I1160_pn21 XI1_I1160_I53_An XI1_I1160_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I53_MN2 (XI1_I1160_I53_n1 I1_p12_20 I1_I1160_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I53_MN3 (VSS XI1_I1160_I53_Bn XI1_I1160_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I53_MN0 (XI1_I1160_I53_An I1_p12_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I52_MN1 (XI1_I1160_I52_Bn I1_b13_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I52_MN5 (XI1_I1160_I52_n2 I1_b13_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I52_MN4 (I1_I1160_pn20 XI1_I1160_I52_An XI1_I1160_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I52_MN2 (XI1_I1160_I52_n1 I1_p12_19 I1_I1160_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I52_MN3 (VSS XI1_I1160_I52_Bn XI1_I1160_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I52_MN0 (XI1_I1160_I52_An I1_p12_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I38_MN1 (XI1_I1160_I38_Bn I1_b13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I38_MN5 (XI1_I1160_I38_n2 I1_b13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I38_MN4 (I1_I1160_pn6 XI1_I1160_I38_An XI1_I1160_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I38_MN2 (XI1_I1160_I38_n1 I1_p12_5 I1_I1160_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I38_MN3 (VSS XI1_I1160_I38_Bn XI1_I1160_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I38_MN0 (XI1_I1160_I38_An I1_p12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I36_MN1 (XI1_I1160_I36_Bn I1_b13_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I36_MN5 (XI1_I1160_I36_n2 I1_b13_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I36_MN4 (I1_I1160_pn4 XI1_I1160_I36_An XI1_I1160_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I36_MN2 (XI1_I1160_I36_n1 I1_p12_3 I1_I1160_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I36_MN3 (VSS XI1_I1160_I36_Bn XI1_I1160_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I36_MN0 (XI1_I1160_I36_An I1_p12_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I61_MN1 (XI1_I976_I61_Bn I1_b9_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I61_MN5 (XI1_I976_I61_n2 I1_b9_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I61_MN4 (I1_I976_pn29 XI1_I976_I61_An XI1_I976_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I61_MN2 (XI1_I976_I61_n1 I1_p8_28 I1_I976_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I61_MN3 (VSS XI1_I976_I61_Bn XI1_I976_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I61_MN0 (XI1_I976_I61_An I1_p8_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I230_MN1 (XI1_I930_I230_Bn I1_I930_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I230_MN5 (XI1_I930_I230_n2 I1_I930_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I230_MN4 (I1_p8_27 XI1_I930_I230_An XI1_I930_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I230_MN2 (XI1_I930_I230_n1 I1_I930_pn27 I1_p8_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I230_MN3 (VSS XI1_I930_I230_Bn XI1_I930_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I230_MN0 (XI1_I930_I230_An I1_I930_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I59_MN1 (XI1_I976_I59_Bn I1_b9_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I59_MN5 (XI1_I976_I59_n2 I1_b9_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I59_MN4 (I1_I976_pn27 XI1_I976_I59_An XI1_I976_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I59_MN2 (XI1_I976_I59_n1 I1_p8_26 I1_I976_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I59_MN3 (VSS XI1_I976_I59_Bn XI1_I976_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I59_MN0 (XI1_I976_I59_An I1_p8_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I234_MN1 (XI1_I930_I234_Bn I1_c8_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I234_MN5 (XI1_I930_I234_n2 I1_c8_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I234_MN4 (I1_p8_31 XI1_I930_I234_An XI1_I930_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I234_MN2 (XI1_I930_I234_n1 I1_I930_pn31 I1_p8_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I234_MN3 (VSS XI1_I930_I234_Bn XI1_I930_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I234_MN0 (XI1_I930_I234_An I1_I930_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I209_MN1 (XI1_I930_I209_Bn I1_I930_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I209_MN5 (XI1_I930_I209_n2 I1_I930_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I209_MN4 (I1_p8_6 XI1_I930_I209_An XI1_I930_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I209_MN2 (XI1_I930_I209_n1 I1_I930_pn6 I1_p8_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I209_MN3 (VSS XI1_I930_I209_Bn XI1_I930_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I209_MN0 (XI1_I930_I209_An I1_I930_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I35_MN1 (XI1_I930_I35_Bn I1_b8_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I35_MN5 (XI1_I930_I35_n2 I1_b8_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I35_MN4 (I1_I930_pn3 XI1_I930_I35_An XI1_I930_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I35_MN2 (XI1_I930_I35_n1 I1_p7_2 I1_I930_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I35_MN3 (VSS XI1_I930_I35_Bn XI1_I930_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I35_MN0 (XI1_I930_I35_An I1_p7_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I205_MN1 (XI1_I654_I205_Bn I1_I654_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I205_MN5 (XI1_I654_I205_n2 I1_I654_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I205_MN4 (I1_p2_2 XI1_I654_I205_An XI1_I654_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I205_MN2 (XI1_I654_I205_n1 I1_I654_pn2 I1_p2_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I205_MN3 (VSS XI1_I654_I205_Bn XI1_I654_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I205_MN0 (XI1_I654_I205_An I1_I654_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I209_MN1 (XI1_I654_I209_Bn I1_I654_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I209_MN5 (XI1_I654_I209_n2 I1_I654_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I209_MN4 (I1_p2_6 XI1_I654_I209_An XI1_I654_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I209_MN2 (XI1_I654_I209_n1 I1_I654_pn6 I1_p2_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I209_MN3 (VSS XI1_I654_I209_Bn XI1_I654_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I209_MN0 (XI1_I654_I209_An I1_I654_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I211_MN1 (XI1_I654_I211_Bn I1_I654_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I211_MN5 (XI1_I654_I211_n2 I1_I654_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I211_MN4 (I1_p2_8 XI1_I654_I211_An XI1_I654_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I211_MN2 (XI1_I654_I211_n1 I1_I654_pn8 I1_p2_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I211_MN3 (VSS XI1_I654_I211_Bn XI1_I654_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I211_MN0 (XI1_I654_I211_An I1_I654_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I42_MN1 (XI1_I700_I42_Bn I1_b3_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I42_MN5 (XI1_I700_I42_n2 I1_b3_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I42_MN4 (I1_I700_pn10 XI1_I700_I42_An XI1_I700_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I42_MN2 (XI1_I700_I42_n1 I1_p2_9 I1_I700_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I42_MN3 (VSS XI1_I700_I42_Bn XI1_I700_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I42_MN0 (XI1_I700_I42_An I1_p2_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I48_MN1 (XI1_I700_I48_Bn I1_b3_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I48_MN5 (XI1_I700_I48_n2 I1_b3_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I48_MN4 (I1_I700_pn16 XI1_I700_I48_An XI1_I700_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I48_MN2 (XI1_I700_I48_n1 I1_p2_15 I1_I700_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I48_MN3 (VSS XI1_I700_I48_Bn XI1_I700_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I48_MN0 (XI1_I700_I48_An I1_p2_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I221_MN1 (XI1_I654_I221_Bn I1_I654_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I221_MN5 (XI1_I654_I221_n2 I1_I654_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I221_MN4 (I1_p2_18 XI1_I654_I221_An XI1_I654_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I221_MN2 (XI1_I654_I221_n1 I1_I654_pn18 I1_p2_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I221_MN3 (VSS XI1_I654_I221_Bn XI1_I654_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I221_MN0 (XI1_I654_I221_An I1_I654_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I223_MN1 (XI1_I654_I223_Bn I1_I654_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I223_MN5 (XI1_I654_I223_n2 I1_I654_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I223_MN4 (I1_p2_20 XI1_I654_I223_An XI1_I654_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I223_MN2 (XI1_I654_I223_n1 I1_I654_pn20 I1_p2_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I223_MN3 (VSS XI1_I654_I223_Bn XI1_I654_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I223_MN0 (XI1_I654_I223_An I1_I654_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I225_MN1 (XI1_I654_I225_Bn I1_I654_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I225_MN5 (XI1_I654_I225_n2 I1_I654_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I225_MN4 (I1_p2_22 XI1_I654_I225_An XI1_I654_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I225_MN2 (XI1_I654_I225_n1 I1_I654_pn22 I1_p2_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I225_MN3 (VSS XI1_I654_I225_Bn XI1_I654_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I225_MN0 (XI1_I654_I225_An I1_I654_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I53_MN1 (XI1_I700_I53_Bn I1_b3_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I53_MN5 (XI1_I700_I53_n2 I1_b3_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I53_MN4 (I1_I700_pn21 XI1_I700_I53_An XI1_I700_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I53_MN2 (XI1_I700_I53_n1 I1_p2_20 I1_I700_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I53_MN3 (VSS XI1_I700_I53_Bn XI1_I700_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I53_MN0 (XI1_I700_I53_An I1_p2_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I227_MN1 (XI1_I654_I227_Bn I1_I654_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I227_MN5 (XI1_I654_I227_n2 I1_I654_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I227_MN4 (I1_p2_24 XI1_I654_I227_An XI1_I654_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I227_MN2 (XI1_I654_I227_n1 I1_I654_pn24 I1_p2_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I227_MN3 (VSS XI1_I654_I227_Bn XI1_I654_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I227_MN0 (XI1_I654_I227_An I1_I654_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I57_MN1 (XI1_I700_I57_Bn I1_b3_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I57_MN5 (XI1_I700_I57_n2 I1_b3_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I57_MN4 (I1_I700_pn25 XI1_I700_I57_An XI1_I700_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I57_MN2 (XI1_I700_I57_n1 I1_p2_24 I1_I700_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I57_MN3 (VSS XI1_I700_I57_Bn XI1_I700_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I57_MN0 (XI1_I700_I57_An I1_p2_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I62_MN1 (XI1_I700_I62_Bn I1_b3_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I62_MN5 (XI1_I700_I62_n2 I1_b3_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I62_MN4 (I1_I700_pn30 XI1_I700_I62_An XI1_I700_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I62_MN2 (XI1_I700_I62_n1 I1_p2_29 I1_I700_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I62_MN3 (VSS XI1_I700_I62_Bn XI1_I700_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I62_MN0 (XI1_I700_I62_An I1_p2_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I63_MN1 (XI1_I700_I63_Bn I1_b3_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I63_MN5 (XI1_I700_I63_n2 I1_b3_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I63_MN4 (I1_I700_pn31 XI1_I700_I63_An XI1_I700_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I63_MN2 (XI1_I700_I63_n1 I1_p2_30 I1_I700_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I63_MN3 (VSS XI1_I700_I63_Bn XI1_I700_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I63_MN0 (XI1_I700_I63_An I1_p2_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I57_MN1 (XI1_I1436_I57_Bn I1_b19_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I57_MN5 (XI1_I1436_I57_n2 I1_b19_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I57_MN4 (I1_I1436_pn25 XI1_I1436_I57_An XI1_I1436_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I57_MN2 (XI1_I1436_I57_n1 I1_p18_24 I1_I1436_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I57_MN3 (VSS XI1_I1436_I57_Bn XI1_I1436_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I57_MN0 (XI1_I1436_I57_An I1_p18_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I53_MN1 (XI1_I1436_I53_Bn I1_b19_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I53_MN5 (XI1_I1436_I53_n2 I1_b19_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I53_MN4 (I1_I1436_pn21 XI1_I1436_I53_An XI1_I1436_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I53_MN2 (XI1_I1436_I53_n1 I1_p18_20 I1_I1436_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I53_MN3 (VSS XI1_I1436_I53_Bn XI1_I1436_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I53_MN0 (XI1_I1436_I53_An I1_p18_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I50_MN1 (XI1_I1436_I50_Bn I1_b19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I50_MN5 (XI1_I1436_I50_n2 I1_b19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I50_MN4 (I1_I1436_pn18 XI1_I1436_I50_An XI1_I1436_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I50_MN2 (XI1_I1436_I50_n1 I1_p18_17 I1_I1436_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I50_MN3 (VSS XI1_I1436_I50_Bn XI1_I1436_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I50_MN0 (XI1_I1436_I50_An I1_p18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I49_MN1 (XI1_I1436_I49_Bn I1_b19_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I49_MN5 (XI1_I1436_I49_n2 I1_b19_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I49_MN4 (I1_I1436_pn17 XI1_I1436_I49_An XI1_I1436_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I49_MN2 (XI1_I1436_I49_n1 I1_p18_16 I1_I1436_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I49_MN3 (VSS XI1_I1436_I49_Bn XI1_I1436_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I49_MN0 (XI1_I1436_I49_An I1_p18_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I47_MN1 (XI1_I1436_I47_Bn I1_b19_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I47_MN5 (XI1_I1436_I47_n2 I1_b19_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I47_MN4 (I1_I1436_pn15 XI1_I1436_I47_An XI1_I1436_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I47_MN2 (XI1_I1436_I47_n1 I1_p18_14 I1_I1436_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I47_MN3 (VSS XI1_I1436_I47_Bn XI1_I1436_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I47_MN0 (XI1_I1436_I47_An I1_p18_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I45_MN1 (XI1_I1436_I45_Bn I1_b19_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I45_MN5 (XI1_I1436_I45_n2 I1_b19_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I45_MN4 (I1_I1436_pn13 XI1_I1436_I45_An XI1_I1436_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I45_MN2 (XI1_I1436_I45_n1 I1_p18_12 I1_I1436_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I45_MN3 (VSS XI1_I1436_I45_Bn XI1_I1436_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I45_MN0 (XI1_I1436_I45_An I1_p18_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I40_MN1 (XI1_I1436_I40_Bn I1_b19_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I40_MN5 (XI1_I1436_I40_n2 I1_b19_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I40_MN4 (I1_I1436_pn8 XI1_I1436_I40_An XI1_I1436_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I40_MN2 (XI1_I1436_I40_n1 I1_p18_7 I1_I1436_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I40_MN3 (VSS XI1_I1436_I40_Bn XI1_I1436_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I40_MN0 (XI1_I1436_I40_An I1_p18_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I38_MN1 (XI1_I1436_I38_Bn I1_b19_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I38_MN5 (XI1_I1436_I38_n2 I1_b19_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I38_MN4 (I1_I1436_pn6 XI1_I1436_I38_An XI1_I1436_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I38_MN2 (XI1_I1436_I38_n1 I1_p18_5 I1_I1436_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I38_MN3 (VSS XI1_I1436_I38_Bn XI1_I1436_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I38_MN0 (XI1_I1436_I38_An I1_p18_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I205_MN1 (XI1_I1390_I205_Bn I1_I1390_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I205_MN5 (XI1_I1390_I205_n2 I1_I1390_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I205_MN4 (I1_p18_2 XI1_I1390_I205_An XI1_I1390_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I205_MN2 (XI1_I1390_I205_n1 I1_I1390_pn2 I1_p18_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I205_MN3 (VSS XI1_I1390_I205_Bn XI1_I1390_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I205_MN0 (XI1_I1390_I205_An I1_I1390_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I204_MN1 (XI1_I1390_I204_Bn I1_I1390_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I204_MN5 (XI1_I1390_I204_n2 I1_I1390_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I204_MN4 (I1_p18_1 XI1_I1390_I204_An XI1_I1390_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I204_MN2 (XI1_I1390_I204_n1 I1_I1390_pn1 I1_p18_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I204_MN3 (VSS XI1_I1390_I204_Bn XI1_I1390_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I204_MN0 (XI1_I1390_I204_An I1_I1390_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I61_MN1 (XI1_I1114_I61_Bn I1_b12_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I61_MN5 (XI1_I1114_I61_n2 I1_b12_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I61_MN4 (I1_I1114_pn29 XI1_I1114_I61_An XI1_I1114_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I61_MN2 (XI1_I1114_I61_n1 I1_p11_28 I1_I1114_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I61_MN3 (VSS XI1_I1114_I61_Bn XI1_I1114_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I61_MN0 (XI1_I1114_I61_An I1_p11_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I234_MN1 (XI1_I1114_I234_Bn I1_c12_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I234_MN5 (XI1_I1114_I234_n2 I1_c12_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I234_MN4 (I1_p12_31 XI1_I1114_I234_An XI1_I1114_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I234_MN2 (XI1_I1114_I234_n1 I1_I1114_pn31 I1_p12_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I234_MN3 (VSS XI1_I1114_I234_Bn XI1_I1114_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I234_MN0 (XI1_I1114_I234_An I1_I1114_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I62_MN1 (XI1_I1114_I62_Bn I1_b12_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I62_MN5 (XI1_I1114_I62_n2 I1_b12_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I62_MN4 (I1_I1114_pn30 XI1_I1114_I62_An XI1_I1114_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I62_MN2 (XI1_I1114_I62_n1 I1_p11_29 I1_I1114_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I62_MN3 (VSS XI1_I1114_I62_Bn XI1_I1114_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I62_MN0 (XI1_I1114_I62_An I1_p11_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I50_MN1 (XI1_I1160_I50_Bn I1_b13_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I50_MN5 (XI1_I1160_I50_n2 I1_b13_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I50_MN4 (I1_I1160_pn18 XI1_I1160_I50_An XI1_I1160_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I50_MN2 (XI1_I1160_I50_n1 I1_p12_17 I1_I1160_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I50_MN3 (VSS XI1_I1160_I50_Bn XI1_I1160_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I50_MN0 (XI1_I1160_I50_An I1_p12_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I48_MN1 (XI1_I1160_I48_Bn I1_b13_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I48_MN5 (XI1_I1160_I48_n2 I1_b13_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I48_MN4 (I1_I1160_pn16 XI1_I1160_I48_An XI1_I1160_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I48_MN2 (XI1_I1160_I48_n1 I1_p12_15 I1_I1160_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I48_MN3 (VSS XI1_I1160_I48_Bn XI1_I1160_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I48_MN0 (XI1_I1160_I48_An I1_p12_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I46_MN1 (XI1_I1160_I46_Bn I1_b13_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I46_MN5 (XI1_I1160_I46_n2 I1_b13_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I46_MN4 (I1_I1160_pn14 XI1_I1160_I46_An XI1_I1160_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I46_MN2 (XI1_I1160_I46_n1 I1_p12_13 I1_I1160_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I46_MN3 (VSS XI1_I1160_I46_Bn XI1_I1160_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I46_MN0 (XI1_I1160_I46_An I1_p12_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I45_MN1 (XI1_I1160_I45_Bn I1_b13_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I45_MN5 (XI1_I1160_I45_n2 I1_b13_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I45_MN4 (I1_I1160_pn13 XI1_I1160_I45_An XI1_I1160_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I45_MN2 (XI1_I1160_I45_n1 I1_p12_12 I1_I1160_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I45_MN3 (VSS XI1_I1160_I45_Bn XI1_I1160_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I45_MN0 (XI1_I1160_I45_An I1_p12_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I42_MN1 (XI1_I1160_I42_Bn I1_b13_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I42_MN5 (XI1_I1160_I42_n2 I1_b13_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I42_MN4 (I1_I1160_pn10 XI1_I1160_I42_An XI1_I1160_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I42_MN2 (XI1_I1160_I42_n1 I1_p12_9 I1_I1160_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I42_MN3 (VSS XI1_I1160_I42_Bn XI1_I1160_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I42_MN0 (XI1_I1160_I42_An I1_p12_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I41_MN1 (XI1_I1160_I41_Bn I1_b13_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I41_MN5 (XI1_I1160_I41_n2 I1_b13_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I41_MN4 (I1_I1160_pn9 XI1_I1160_I41_An XI1_I1160_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I41_MN2 (XI1_I1160_I41_n1 I1_p12_8 I1_I1160_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I41_MN3 (VSS XI1_I1160_I41_Bn XI1_I1160_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I41_MN0 (XI1_I1160_I41_An I1_p12_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I39_MN1 (XI1_I1160_I39_Bn I1_b13_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I39_MN5 (XI1_I1160_I39_n2 I1_b13_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I39_MN4 (I1_I1160_pn7 XI1_I1160_I39_An XI1_I1160_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I39_MN2 (XI1_I1160_I39_n1 I1_p12_6 I1_I1160_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I39_MN3 (VSS XI1_I1160_I39_Bn XI1_I1160_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I39_MN0 (XI1_I1160_I39_An I1_p12_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I37_MN1 (XI1_I1160_I37_Bn I1_b13_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I37_MN5 (XI1_I1160_I37_n2 I1_b13_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I37_MN4 (I1_I1160_pn5 XI1_I1160_I37_An XI1_I1160_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I37_MN2 (XI1_I1160_I37_n1 I1_p12_4 I1_I1160_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I37_MN3 (VSS XI1_I1160_I37_Bn XI1_I1160_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I37_MN0 (XI1_I1160_I37_An I1_p12_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I60_MN1 (XI1_I976_I60_Bn I1_b9_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I60_MN5 (XI1_I976_I60_n2 I1_b9_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I60_MN4 (I1_I976_pn28 XI1_I976_I60_An XI1_I976_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I60_MN2 (XI1_I976_I60_n1 I1_p8_27 I1_I976_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I60_MN3 (VSS XI1_I976_I60_Bn XI1_I976_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I60_MN0 (XI1_I976_I60_An I1_p8_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I232_MN1 (XI1_I930_I232_Bn I1_I930_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I232_MN5 (XI1_I930_I232_n2 I1_I930_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I232_MN4 (I1_p8_29 XI1_I930_I232_An XI1_I930_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I232_MN2 (XI1_I930_I232_n1 I1_I930_pn29 I1_p8_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I232_MN3 (VSS XI1_I930_I232_Bn XI1_I930_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I232_MN0 (XI1_I930_I232_An I1_I930_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I228_MN1 (XI1_I930_I228_Bn I1_I930_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I228_MN5 (XI1_I930_I228_n2 I1_I930_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I228_MN4 (I1_p8_25 XI1_I930_I228_An XI1_I930_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I228_MN2 (XI1_I930_I228_n1 I1_I930_pn25 I1_p8_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I228_MN3 (VSS XI1_I930_I228_Bn XI1_I930_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I228_MN0 (XI1_I930_I228_An I1_I930_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I56_MN1 (XI1_I976_I56_Bn I1_b9_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I56_MN5 (XI1_I976_I56_n2 I1_b9_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I56_MN4 (I1_I976_pn24 XI1_I976_I56_An XI1_I976_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I56_MN2 (XI1_I976_I56_n1 I1_p8_23 I1_I976_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I56_MN3 (VSS XI1_I976_I56_Bn XI1_I976_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I56_MN0 (XI1_I976_I56_An I1_p8_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I226_MN1 (XI1_I930_I226_Bn I1_I930_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I226_MN5 (XI1_I930_I226_n2 I1_I930_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I226_MN4 (I1_p8_23 XI1_I930_I226_An XI1_I930_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I226_MN2 (XI1_I930_I226_n1 I1_I930_pn23 I1_p8_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I226_MN3 (VSS XI1_I930_I226_Bn XI1_I930_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I226_MN0 (XI1_I930_I226_An I1_I930_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I224_MN1 (XI1_I930_I224_Bn I1_I930_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I224_MN5 (XI1_I930_I224_n2 I1_I930_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I224_MN4 (I1_p8_21 XI1_I930_I224_An XI1_I930_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I224_MN2 (XI1_I930_I224_n1 I1_I930_pn21 I1_p8_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I224_MN3 (VSS XI1_I930_I224_Bn XI1_I930_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I224_MN0 (XI1_I930_I224_An I1_I930_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I222_MN1 (XI1_I930_I222_Bn I1_I930_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I222_MN5 (XI1_I930_I222_n2 I1_I930_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I222_MN4 (I1_p8_19 XI1_I930_I222_An XI1_I930_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I222_MN2 (XI1_I930_I222_n1 I1_I930_pn19 I1_p8_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I222_MN3 (VSS XI1_I930_I222_Bn XI1_I930_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I222_MN0 (XI1_I930_I222_An I1_I930_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I220_MN1 (XI1_I930_I220_Bn I1_I930_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I220_MN5 (XI1_I930_I220_n2 I1_I930_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I220_MN4 (I1_p8_17 XI1_I930_I220_An XI1_I930_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I220_MN2 (XI1_I930_I220_n1 I1_I930_pn17 I1_p8_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I220_MN3 (VSS XI1_I930_I220_Bn XI1_I930_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I220_MN0 (XI1_I930_I220_An I1_I930_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I49_MN1 (XI1_I976_I49_Bn I1_b9_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I49_MN5 (XI1_I976_I49_n2 I1_b9_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I49_MN4 (I1_I976_pn17 XI1_I976_I49_An XI1_I976_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I49_MN2 (XI1_I976_I49_n1 I1_p8_16 I1_I976_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I49_MN3 (VSS XI1_I976_I49_Bn XI1_I976_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I49_MN0 (XI1_I976_I49_An I1_p8_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I210_MN1 (XI1_I930_I210_Bn I1_I930_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I210_MN5 (XI1_I930_I210_n2 I1_I930_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I210_MN4 (I1_p8_7 XI1_I930_I210_An XI1_I930_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I210_MN2 (XI1_I930_I210_n1 I1_I930_pn7 I1_p8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I210_MN3 (VSS XI1_I930_I210_Bn XI1_I930_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I210_MN0 (XI1_I930_I210_An I1_I930_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I34_MN1 (XI1_I930_I34_Bn I1_b8_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I34_MN5 (XI1_I930_I34_n2 I1_b8_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I34_MN4 (I1_I930_pn2 XI1_I930_I34_An XI1_I930_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I34_MN2 (XI1_I930_I34_n1 I1_p7_1 I1_I930_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I34_MN3 (VSS XI1_I930_I34_Bn XI1_I930_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I34_MN0 (XI1_I930_I34_An I1_p7_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I32_MN1 (XI1_I700_I32_Bn I1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I700_I32_MN5 (XI1_I700_I32_n2 I1_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I32_MN4 (I1_I700_pn0 XI1_I700_I32_An XI1_I700_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I32_MN2 (XI1_I700_I32_n1 I1_aa28 I1_I700_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I32_MN3 (VSS XI1_I700_I32_Bn XI1_I700_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I32_MN0 (XI1_I700_I32_An I1_aa28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I229_MN1 (XI1_I654_I229_Bn I1_I654_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I229_MN5 (XI1_I654_I229_n2 I1_I654_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I229_MN4 (I1_p2_26 XI1_I654_I229_An XI1_I654_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I229_MN2 (XI1_I654_I229_n1 I1_I654_pn26 I1_p2_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I229_MN3 (VSS XI1_I654_I229_Bn XI1_I654_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I229_MN0 (XI1_I654_I229_An I1_I654_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I231_MN1 (XI1_I654_I231_Bn I1_I654_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I231_MN5 (XI1_I654_I231_n2 I1_I654_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I231_MN4 (I1_p2_28 XI1_I654_I231_An XI1_I654_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I231_MN2 (XI1_I654_I231_n1 I1_I654_pn28 I1_p2_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I231_MN3 (VSS XI1_I654_I231_Bn XI1_I654_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I231_MN0 (XI1_I654_I231_An I1_I654_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I233_MN1 (XI1_I654_I233_Bn I1_I654_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I233_MN5 (XI1_I654_I233_n2 I1_I654_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I233_MN4 (I1_p2_30 XI1_I654_I233_An XI1_I654_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I233_MN2 (XI1_I654_I233_n1 I1_I654_pn30 I1_p2_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I233_MN3 (VSS XI1_I654_I233_Bn XI1_I654_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I233_MN0 (XI1_I654_I233_An I1_I654_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I61_MN1 (XI1_I1436_I61_Bn I1_b19_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I61_MN5 (XI1_I1436_I61_n2 I1_b19_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I61_MN4 (I1_I1436_pn29 XI1_I1436_I61_An XI1_I1436_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I61_MN2 (XI1_I1436_I61_n1 I1_p18_28 I1_I1436_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I61_MN3 (VSS XI1_I1436_I61_Bn XI1_I1436_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I61_MN0 (XI1_I1436_I61_An I1_p18_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I60_MN1 (XI1_I1436_I60_Bn I1_b19_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I60_MN5 (XI1_I1436_I60_n2 I1_b19_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I60_MN4 (I1_I1436_pn28 XI1_I1436_I60_An XI1_I1436_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I60_MN2 (XI1_I1436_I60_n1 I1_p18_27 I1_I1436_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I60_MN3 (VSS XI1_I1436_I60_Bn XI1_I1436_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I60_MN0 (XI1_I1436_I60_An I1_p18_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I58_MN1 (XI1_I1436_I58_Bn I1_b19_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I58_MN5 (XI1_I1436_I58_n2 I1_b19_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I58_MN4 (I1_I1436_pn26 XI1_I1436_I58_An XI1_I1436_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I58_MN2 (XI1_I1436_I58_n1 I1_p18_25 I1_I1436_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I58_MN3 (VSS XI1_I1436_I58_Bn XI1_I1436_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I58_MN0 (XI1_I1436_I58_An I1_p18_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I56_MN1 (XI1_I1436_I56_Bn I1_b19_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I56_MN5 (XI1_I1436_I56_n2 I1_b19_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I56_MN4 (I1_I1436_pn24 XI1_I1436_I56_An XI1_I1436_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I56_MN2 (XI1_I1436_I56_n1 I1_p18_23 I1_I1436_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I56_MN3 (VSS XI1_I1436_I56_Bn XI1_I1436_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I56_MN0 (XI1_I1436_I56_An I1_p18_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I54_MN1 (XI1_I1436_I54_Bn I1_b19_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I54_MN5 (XI1_I1436_I54_n2 I1_b19_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I54_MN4 (I1_I1436_pn22 XI1_I1436_I54_An XI1_I1436_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I54_MN2 (XI1_I1436_I54_n1 I1_p18_21 I1_I1436_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I54_MN3 (VSS XI1_I1436_I54_Bn XI1_I1436_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I54_MN0 (XI1_I1436_I54_An I1_p18_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I52_MN1 (XI1_I1436_I52_Bn I1_b19_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I52_MN5 (XI1_I1436_I52_n2 I1_b19_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I52_MN4 (I1_I1436_pn20 XI1_I1436_I52_An XI1_I1436_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I52_MN2 (XI1_I1436_I52_n1 I1_p18_19 I1_I1436_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I52_MN3 (VSS XI1_I1436_I52_Bn XI1_I1436_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I52_MN0 (XI1_I1436_I52_An I1_p18_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I46_MN1 (XI1_I1436_I46_Bn I1_b19_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I46_MN5 (XI1_I1436_I46_n2 I1_b19_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I46_MN4 (I1_I1436_pn14 XI1_I1436_I46_An XI1_I1436_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I46_MN2 (XI1_I1436_I46_n1 I1_p18_13 I1_I1436_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I46_MN3 (VSS XI1_I1436_I46_Bn XI1_I1436_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I46_MN0 (XI1_I1436_I46_An I1_p18_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I44_MN1 (XI1_I1436_I44_Bn I1_b19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I44_MN5 (XI1_I1436_I44_n2 I1_b19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I44_MN4 (I1_I1436_pn12 XI1_I1436_I44_An XI1_I1436_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I44_MN2 (XI1_I1436_I44_n1 I1_p18_11 I1_I1436_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I44_MN3 (VSS XI1_I1436_I44_Bn XI1_I1436_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I44_MN0 (XI1_I1436_I44_An I1_p18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I42_MN1 (XI1_I1436_I42_Bn I1_b19_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I42_MN5 (XI1_I1436_I42_n2 I1_b19_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I42_MN4 (I1_I1436_pn10 XI1_I1436_I42_An XI1_I1436_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I42_MN2 (XI1_I1436_I42_n1 I1_p18_9 I1_I1436_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I42_MN3 (VSS XI1_I1436_I42_Bn XI1_I1436_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I42_MN0 (XI1_I1436_I42_An I1_p18_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I41_MN1 (XI1_I1436_I41_Bn I1_b19_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I41_MN5 (XI1_I1436_I41_n2 I1_b19_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I41_MN4 (I1_I1436_pn9 XI1_I1436_I41_An XI1_I1436_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I41_MN2 (XI1_I1436_I41_n1 I1_p18_8 I1_I1436_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I41_MN3 (VSS XI1_I1436_I41_Bn XI1_I1436_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I41_MN0 (XI1_I1436_I41_An I1_p18_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I39_MN1 (XI1_I1436_I39_Bn I1_b19_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I39_MN5 (XI1_I1436_I39_n2 I1_b19_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I39_MN4 (I1_I1436_pn7 XI1_I1436_I39_An XI1_I1436_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I39_MN2 (XI1_I1436_I39_n1 I1_p18_6 I1_I1436_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I39_MN3 (VSS XI1_I1436_I39_Bn XI1_I1436_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I39_MN0 (XI1_I1436_I39_An I1_p18_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I37_MN1 (XI1_I1436_I37_Bn I1_b19_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I37_MN5 (XI1_I1436_I37_n2 I1_b19_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I37_MN4 (I1_I1436_pn5 XI1_I1436_I37_An XI1_I1436_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I37_MN2 (XI1_I1436_I37_n1 I1_p18_4 I1_I1436_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I37_MN3 (VSS XI1_I1436_I37_Bn XI1_I1436_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I37_MN0 (XI1_I1436_I37_An I1_p18_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I36_MN1 (XI1_I1436_I36_Bn I1_b19_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I36_MN5 (XI1_I1436_I36_n2 I1_b19_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I36_MN4 (I1_I1436_pn4 XI1_I1436_I36_An XI1_I1436_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I36_MN2 (XI1_I1436_I36_n1 I1_p18_3 I1_I1436_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I36_MN3 (VSS XI1_I1436_I36_Bn XI1_I1436_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I36_MN0 (XI1_I1436_I36_An I1_p18_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I32_MN1 (XI1_I1390_I32_Bn I1_b18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I32_MN5 (XI1_I1390_I32_n2 I1_b18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I32_MN4 (I1_I1390_pn0 XI1_I1390_I32_An XI1_I1390_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I32_MN2 (XI1_I1390_I32_n1 I1_aa13 I1_I1390_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I32_MN3 (VSS XI1_I1390_I32_Bn XI1_I1390_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I32_MN0 (XI1_I1390_I32_An I1_aa13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I58_MN1 (XI1_I1114_I58_Bn I1_b12_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I58_MN5 (XI1_I1114_I58_n2 I1_b12_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I58_MN4 (I1_I1114_pn26 XI1_I1114_I58_An XI1_I1114_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I58_MN2 (XI1_I1114_I58_n1 I1_p11_25 I1_I1114_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I58_MN3 (VSS XI1_I1114_I58_Bn XI1_I1114_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I58_MN0 (XI1_I1114_I58_An I1_p11_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I233_MN1 (XI1_I1114_I233_Bn I1_I1114_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I233_MN5 (XI1_I1114_I233_n2 I1_I1114_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I233_MN4 (I1_p12_30 XI1_I1114_I233_An XI1_I1114_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I233_MN2 (XI1_I1114_I233_n1 I1_I1114_pn30 I1_p12_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I233_MN3 (VSS XI1_I1114_I233_Bn XI1_I1114_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I233_MN0 (XI1_I1114_I233_An I1_I1114_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I63_MN1 (XI1_I1114_I63_Bn I1_b12_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I63_MN5 (XI1_I1114_I63_n2 I1_b12_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I63_MN4 (I1_I1114_pn31 XI1_I1114_I63_An XI1_I1114_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I63_MN2 (XI1_I1114_I63_n1 I1_p11_30 I1_I1114_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I63_MN3 (VSS XI1_I1114_I63_Bn XI1_I1114_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I63_MN0 (XI1_I1114_I63_An I1_p11_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I51_MN1 (XI1_I1160_I51_Bn I1_b13_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I51_MN5 (XI1_I1160_I51_n2 I1_b13_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I51_MN4 (I1_I1160_pn19 XI1_I1160_I51_An XI1_I1160_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I51_MN2 (XI1_I1160_I51_n1 I1_p12_18 I1_I1160_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I51_MN3 (VSS XI1_I1160_I51_Bn XI1_I1160_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I51_MN0 (XI1_I1160_I51_An I1_p12_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I49_MN1 (XI1_I1160_I49_Bn I1_b13_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I49_MN5 (XI1_I1160_I49_n2 I1_b13_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I49_MN4 (I1_I1160_pn17 XI1_I1160_I49_An XI1_I1160_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I49_MN2 (XI1_I1160_I49_n1 I1_p12_16 I1_I1160_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I49_MN3 (VSS XI1_I1160_I49_Bn XI1_I1160_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I49_MN0 (XI1_I1160_I49_An I1_p12_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I47_MN1 (XI1_I1160_I47_Bn I1_b13_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I47_MN5 (XI1_I1160_I47_n2 I1_b13_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I47_MN4 (I1_I1160_pn15 XI1_I1160_I47_An XI1_I1160_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I47_MN2 (XI1_I1160_I47_n1 I1_p12_14 I1_I1160_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I47_MN3 (VSS XI1_I1160_I47_Bn XI1_I1160_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I47_MN0 (XI1_I1160_I47_An I1_p12_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I43_MN1 (XI1_I1160_I43_Bn I1_b13_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I43_MN5 (XI1_I1160_I43_n2 I1_b13_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I43_MN4 (I1_I1160_pn11 XI1_I1160_I43_An XI1_I1160_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I43_MN2 (XI1_I1160_I43_n1 I1_p12_10 I1_I1160_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I43_MN3 (VSS XI1_I1160_I43_Bn XI1_I1160_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I43_MN0 (XI1_I1160_I43_An I1_p12_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I233_MN1 (XI1_I1068_I233_Bn I1_I1068_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I233_MN5 (XI1_I1068_I233_n2 I1_I1068_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I233_MN4 (I1_p11_30 XI1_I1068_I233_An XI1_I1068_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I233_MN2 (XI1_I1068_I233_n1 I1_I1068_pn30 I1_p11_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I233_MN3 (VSS XI1_I1068_I233_Bn XI1_I1068_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I233_MN0 (XI1_I1068_I233_An I1_I1068_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I40_MN1 (XI1_I1160_I40_Bn I1_b13_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I40_MN5 (XI1_I1160_I40_n2 I1_b13_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I40_MN4 (I1_I1160_pn8 XI1_I1160_I40_An XI1_I1160_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I40_MN2 (XI1_I1160_I40_n1 I1_p12_7 I1_I1160_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I40_MN3 (VSS XI1_I1160_I40_Bn XI1_I1160_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I40_MN0 (XI1_I1160_I40_An I1_p12_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I60_MN1 (XI1_I1068_I60_Bn I1_b11_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I60_MN5 (XI1_I1068_I60_n2 I1_b11_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I60_MN4 (I1_I1068_pn28 XI1_I1068_I60_An XI1_I1068_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I60_MN2 (XI1_I1068_I60_n1 I1_p10_27 I1_I1068_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I60_MN3 (VSS XI1_I1068_I60_Bn XI1_I1068_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I60_MN0 (XI1_I1068_I60_An I1_p10_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I61_MN1 (XI1_I1068_I61_Bn I1_b11_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I61_MN5 (XI1_I1068_I61_n2 I1_b11_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I61_MN4 (I1_I1068_pn29 XI1_I1068_I61_An XI1_I1068_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I61_MN2 (XI1_I1068_I61_n1 I1_p10_28 I1_I1068_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I61_MN3 (VSS XI1_I1068_I61_Bn XI1_I1068_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I61_MN0 (XI1_I1068_I61_An I1_p10_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I203_MN1 (XI1_I1114_I203_Bn I1_qu20_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I203_MN5 (XI1_I1114_I203_n2 I1_qu20_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I203_MN4 (I1_p12_0 XI1_I1114_I203_An XI1_I1114_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I203_MN2 (XI1_I1114_I203_n1 I1_I1114_pn0 I1_p12_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I203_MN3 (VSS XI1_I1114_I203_Bn XI1_I1114_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I203_MN0 (XI1_I1114_I203_An I1_I1114_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I231_MN1 (XI1_I1022_I231_Bn I1_I1022_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I231_MN5 (XI1_I1022_I231_n2 I1_I1022_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I231_MN4 (I1_p10_28 XI1_I1022_I231_An XI1_I1022_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I231_MN2 (XI1_I1022_I231_n1 I1_I1022_pn28 I1_p10_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I231_MN3 (VSS XI1_I1022_I231_Bn XI1_I1022_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I231_MN0 (XI1_I1022_I231_An I1_I1022_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I63_MN1 (XI1_I976_I63_Bn I1_b9_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I63_MN5 (XI1_I976_I63_n2 I1_b9_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I63_MN4 (I1_I976_pn31 XI1_I976_I63_An XI1_I976_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I63_MN2 (XI1_I976_I63_n1 I1_p8_30 I1_I976_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I63_MN3 (VSS XI1_I976_I63_Bn XI1_I976_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I63_MN0 (XI1_I976_I63_An I1_p8_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I58_MN1 (XI1_I976_I58_Bn I1_b9_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I58_MN5 (XI1_I976_I58_n2 I1_b9_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I58_MN4 (I1_I976_pn26 XI1_I976_I58_An XI1_I976_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I58_MN2 (XI1_I976_I58_n1 I1_p8_25 I1_I976_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I58_MN3 (VSS XI1_I976_I58_Bn XI1_I976_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I58_MN0 (XI1_I976_I58_An I1_p8_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I55_MN1 (XI1_I976_I55_Bn I1_b9_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I55_MN5 (XI1_I976_I55_n2 I1_b9_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I55_MN4 (I1_I976_pn23 XI1_I976_I55_An XI1_I976_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I55_MN2 (XI1_I976_I55_n1 I1_p8_22 I1_I976_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I55_MN3 (VSS XI1_I976_I55_Bn XI1_I976_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I55_MN0 (XI1_I976_I55_An I1_p8_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I54_MN1 (XI1_I976_I54_Bn I1_b9_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I54_MN5 (XI1_I976_I54_n2 I1_b9_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I54_MN4 (I1_I976_pn22 XI1_I976_I54_An XI1_I976_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I54_MN2 (XI1_I976_I54_n1 I1_p8_21 I1_I976_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I54_MN3 (VSS XI1_I976_I54_Bn XI1_I976_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I54_MN0 (XI1_I976_I54_An I1_p8_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I52_MN1 (XI1_I976_I52_Bn I1_b9_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I52_MN5 (XI1_I976_I52_n2 I1_b9_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I52_MN4 (I1_I976_pn20 XI1_I976_I52_An XI1_I976_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I52_MN2 (XI1_I976_I52_n1 I1_p8_19 I1_I976_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I52_MN3 (VSS XI1_I976_I52_Bn XI1_I976_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I52_MN0 (XI1_I976_I52_An I1_p8_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I51_MN1 (XI1_I976_I51_Bn I1_b9_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I51_MN5 (XI1_I976_I51_n2 I1_b9_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I51_MN4 (I1_I976_pn19 XI1_I976_I51_An XI1_I976_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I51_MN2 (XI1_I976_I51_n1 I1_p8_18 I1_I976_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I51_MN3 (VSS XI1_I976_I51_Bn XI1_I976_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I51_MN0 (XI1_I976_I51_An I1_p8_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I43_MN1 (XI1_I976_I43_Bn I1_b9_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I43_MN5 (XI1_I976_I43_n2 I1_b9_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I43_MN4 (I1_I976_pn11 XI1_I976_I43_An XI1_I976_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I43_MN2 (XI1_I976_I43_n1 I1_p8_10 I1_I976_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I43_MN3 (VSS XI1_I976_I43_Bn XI1_I976_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I43_MN0 (XI1_I976_I43_An I1_p8_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I208_MN1 (XI1_I930_I208_Bn I1_I930_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I208_MN5 (XI1_I930_I208_n2 I1_I930_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I208_MN4 (I1_p8_5 XI1_I930_I208_An XI1_I930_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I208_MN2 (XI1_I930_I208_n1 I1_I930_pn5 I1_p8_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I208_MN3 (VSS XI1_I930_I208_Bn XI1_I930_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I208_MN0 (XI1_I930_I208_An I1_I930_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I33_MN1 (XI1_I654_I33_Bn I1_b2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I33_MN5 (XI1_I654_I33_n2 I1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I33_MN4 (I1_I654_pn1 XI1_I654_I33_An XI1_I654_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I33_MN2 (XI1_I654_I33_n1 I1_p1_0 I1_I654_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I33_MN3 (VSS XI1_I654_I33_Bn XI1_I654_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I33_MN0 (XI1_I654_I33_An I1_p1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I204_MN1 (XI1_I654_I204_Bn I1_I654_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I204_MN5 (XI1_I654_I204_n2 I1_I654_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I204_MN4 (I1_p2_1 XI1_I654_I204_An XI1_I654_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I204_MN2 (XI1_I654_I204_n1 I1_I654_pn1 I1_p2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I204_MN3 (VSS XI1_I654_I204_Bn XI1_I654_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I204_MN0 (XI1_I654_I204_An I1_I654_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I208_MN1 (XI1_I654_I208_Bn I1_I654_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I208_MN5 (XI1_I654_I208_n2 I1_I654_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I208_MN4 (I1_p2_5 XI1_I654_I208_An XI1_I654_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I208_MN2 (XI1_I654_I208_n1 I1_I654_pn5 I1_p2_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I208_MN3 (VSS XI1_I654_I208_Bn XI1_I654_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I208_MN0 (XI1_I654_I208_An I1_I654_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I210_MN1 (XI1_I654_I210_Bn I1_I654_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I210_MN5 (XI1_I654_I210_n2 I1_I654_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I210_MN4 (I1_p2_7 XI1_I654_I210_An XI1_I654_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I210_MN2 (XI1_I654_I210_n1 I1_I654_pn7 I1_p2_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I210_MN3 (VSS XI1_I654_I210_Bn XI1_I654_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I210_MN0 (XI1_I654_I210_An I1_I654_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I220_MN1 (XI1_I654_I220_Bn I1_I654_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I220_MN5 (XI1_I654_I220_n2 I1_I654_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I220_MN4 (I1_p2_17 XI1_I654_I220_An XI1_I654_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I220_MN2 (XI1_I654_I220_n1 I1_I654_pn17 I1_p2_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I220_MN3 (VSS XI1_I654_I220_Bn XI1_I654_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I220_MN0 (XI1_I654_I220_An I1_I654_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I222_MN1 (XI1_I654_I222_Bn I1_I654_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I222_MN5 (XI1_I654_I222_n2 I1_I654_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I222_MN4 (I1_p2_19 XI1_I654_I222_An XI1_I654_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I222_MN2 (XI1_I654_I222_n1 I1_I654_pn19 I1_p2_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I222_MN3 (VSS XI1_I654_I222_Bn XI1_I654_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I222_MN0 (XI1_I654_I222_An I1_I654_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I232_MN1 (XI1_I654_I232_Bn I1_I654_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I232_MN5 (XI1_I654_I232_n2 I1_I654_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I232_MN4 (I1_p2_29 XI1_I654_I232_An XI1_I654_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I232_MN2 (XI1_I654_I232_n1 I1_I654_pn29 I1_p2_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I232_MN3 (VSS XI1_I654_I232_Bn XI1_I654_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I232_MN0 (XI1_I654_I232_An I1_I654_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I35_MN1 (XI1_I1436_I35_Bn I1_b19_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I35_MN5 (XI1_I1436_I35_n2 I1_b19_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I35_MN4 (I1_I1436_pn3 XI1_I1436_I35_An XI1_I1436_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I35_MN2 (XI1_I1436_I35_n1 I1_p18_2 I1_I1436_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I35_MN3 (VSS XI1_I1436_I35_Bn XI1_I1436_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I35_MN0 (XI1_I1436_I35_An I1_p18_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I203_MN1 (XI1_I1390_I203_Bn I1_qu14_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I203_MN5 (XI1_I1390_I203_n2 I1_qu14_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I203_MN4 (I1_p18_0 XI1_I1390_I203_An XI1_I1390_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I203_MN2 (XI1_I1390_I203_n1 I1_I1390_pn0 I1_p18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I203_MN3 (VSS XI1_I1390_I203_Bn XI1_I1390_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I203_MN0 (XI1_I1390_I203_An I1_I1390_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I227_MN1 (XI1_I1114_I227_Bn I1_I1114_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I227_MN5 (XI1_I1114_I227_n2 I1_I1114_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I227_MN4 (I1_p12_24 XI1_I1114_I227_An XI1_I1114_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I227_MN2 (XI1_I1114_I227_n1 I1_I1114_pn24 I1_p12_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I227_MN3 (VSS XI1_I1114_I227_Bn XI1_I1114_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I227_MN0 (XI1_I1114_I227_An I1_I1114_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I229_MN1 (XI1_I1114_I229_Bn I1_I1114_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I229_MN5 (XI1_I1114_I229_n2 I1_I1114_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I229_MN4 (I1_p12_26 XI1_I1114_I229_An XI1_I1114_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I229_MN2 (XI1_I1114_I229_n1 I1_I1114_pn26 I1_p12_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I229_MN3 (VSS XI1_I1114_I229_Bn XI1_I1114_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I229_MN0 (XI1_I1114_I229_An I1_I1114_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I228_MN1 (XI1_I1114_I228_Bn I1_I1114_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I228_MN5 (XI1_I1114_I228_n2 I1_I1114_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I228_MN4 (I1_p12_25 XI1_I1114_I228_An XI1_I1114_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I228_MN2 (XI1_I1114_I228_n1 I1_I1114_pn25 I1_p12_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I228_MN3 (VSS XI1_I1114_I228_Bn XI1_I1114_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I228_MN0 (XI1_I1114_I228_An I1_I1114_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I226_MN1 (XI1_I1114_I226_Bn I1_I1114_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I226_MN5 (XI1_I1114_I226_n2 I1_I1114_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I226_MN4 (I1_p12_23 XI1_I1114_I226_An XI1_I1114_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I226_MN2 (XI1_I1114_I226_n1 I1_I1114_pn23 I1_p12_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I226_MN3 (VSS XI1_I1114_I226_Bn XI1_I1114_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I226_MN0 (XI1_I1114_I226_An I1_I1114_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I55_MN1 (XI1_I1114_I55_Bn I1_b12_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1114_I55_MN5 (XI1_I1114_I55_n2 I1_b12_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I55_MN4 (I1_I1114_pn23 XI1_I1114_I55_An XI1_I1114_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I55_MN2 (XI1_I1114_I55_n1 I1_p11_22 I1_I1114_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I55_MN3 (VSS XI1_I1114_I55_Bn XI1_I1114_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I55_MN0 (XI1_I1114_I55_An I1_p11_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I232_MN1 (XI1_I1068_I232_Bn I1_I1068_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I232_MN5 (XI1_I1068_I232_n2 I1_I1068_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I232_MN4 (I1_p11_29 XI1_I1068_I232_An XI1_I1068_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I232_MN2 (XI1_I1068_I232_n1 I1_I1068_pn29 I1_p11_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I232_MN3 (VSS XI1_I1068_I232_Bn XI1_I1068_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I232_MN0 (XI1_I1068_I232_An I1_I1068_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I230_MN1 (XI1_I1068_I230_Bn I1_I1068_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I230_MN5 (XI1_I1068_I230_n2 I1_I1068_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I230_MN4 (I1_p11_27 XI1_I1068_I230_An XI1_I1068_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I230_MN2 (XI1_I1068_I230_n1 I1_I1068_pn27 I1_p11_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I230_MN3 (VSS XI1_I1068_I230_Bn XI1_I1068_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I230_MN0 (XI1_I1068_I230_An I1_I1068_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I234_MN1 (XI1_I1068_I234_Bn I1_c11_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I234_MN5 (XI1_I1068_I234_n2 I1_c11_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I234_MN4 (I1_p11_31 XI1_I1068_I234_An XI1_I1068_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I234_MN2 (XI1_I1068_I234_n1 I1_I1068_pn31 I1_p11_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I234_MN3 (VSS XI1_I1068_I234_Bn XI1_I1068_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I234_MN0 (XI1_I1068_I234_An I1_I1068_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I44_MN1 (XI1_I1160_I44_Bn I1_b13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1160_I44_MN5 (XI1_I1160_I44_n2 I1_b13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I44_MN4 (I1_I1160_pn12 XI1_I1160_I44_An XI1_I1160_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I44_MN2 (XI1_I1160_I44_n1 I1_p12_11 I1_I1160_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I44_MN3 (VSS XI1_I1160_I44_Bn XI1_I1160_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I44_MN0 (XI1_I1160_I44_An I1_p12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I229_MN1 (XI1_I1068_I229_Bn I1_I1068_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I229_MN5 (XI1_I1068_I229_n2 I1_I1068_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I229_MN4 (I1_p11_26 XI1_I1068_I229_An XI1_I1068_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I229_MN2 (XI1_I1068_I229_n1 I1_I1068_pn26 I1_p11_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I229_MN3 (VSS XI1_I1068_I229_Bn XI1_I1068_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I229_MN0 (XI1_I1068_I229_An I1_I1068_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I231_MN1 (XI1_I1068_I231_Bn I1_I1068_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I231_MN5 (XI1_I1068_I231_n2 I1_I1068_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I231_MN4 (I1_p11_28 XI1_I1068_I231_An XI1_I1068_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I231_MN2 (XI1_I1068_I231_n1 I1_I1068_pn28 I1_p11_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I231_MN3 (VSS XI1_I1068_I231_Bn XI1_I1068_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I231_MN0 (XI1_I1068_I231_An I1_I1068_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I59_MN1 (XI1_I1068_I59_Bn I1_b11_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I59_MN5 (XI1_I1068_I59_n2 I1_b11_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I59_MN4 (I1_I1068_pn27 XI1_I1068_I59_An XI1_I1068_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I59_MN2 (XI1_I1068_I59_n1 I1_p10_26 I1_I1068_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I59_MN3 (VSS XI1_I1068_I59_Bn XI1_I1068_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I59_MN0 (XI1_I1068_I59_An I1_p10_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I62_MN1 (XI1_I1068_I62_Bn I1_b11_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I62_MN5 (XI1_I1068_I62_n2 I1_b11_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I62_MN4 (I1_I1068_pn30 XI1_I1068_I62_An XI1_I1068_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I62_MN2 (XI1_I1068_I62_n1 I1_p10_29 I1_I1068_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I62_MN3 (VSS XI1_I1068_I62_Bn XI1_I1068_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I62_MN0 (XI1_I1068_I62_An I1_p10_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I63_MN1 (XI1_I1068_I63_Bn I1_b11_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1068_I63_MN5 (XI1_I1068_I63_n2 I1_b11_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1068_I63_MN4 (I1_I1068_pn31 XI1_I1068_I63_An XI1_I1068_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I63_MN2 (XI1_I1068_I63_n1 I1_p10_30 I1_I1068_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1068_I63_MN3 (VSS XI1_I1068_I63_Bn XI1_I1068_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1068_I63_MN0 (XI1_I1068_I63_An I1_p10_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I61_MN1 (XI1_I1022_I61_Bn I1_b10_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I61_MN5 (XI1_I1022_I61_n2 I1_b10_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I61_MN4 (I1_I1022_pn29 XI1_I1022_I61_An XI1_I1022_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I61_MN2 (XI1_I1022_I61_n1 I1_p9_28 I1_I1022_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I61_MN3 (VSS XI1_I1022_I61_Bn XI1_I1022_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I61_MN0 (XI1_I1022_I61_An I1_p9_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I60_MN1 (XI1_I1022_I60_Bn I1_b10_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1022_I60_MN5 (XI1_I1022_I60_n2 I1_b10_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I60_MN4 (I1_I1022_pn28 XI1_I1022_I60_An XI1_I1022_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I60_MN2 (XI1_I1022_I60_n1 I1_p9_27 I1_I1022_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I60_MN3 (VSS XI1_I1022_I60_Bn XI1_I1022_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I60_MN0 (XI1_I1022_I60_An I1_p9_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I62_MN1 (XI1_I976_I62_Bn I1_b9_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I62_MN5 (XI1_I976_I62_n2 I1_b9_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I62_MN4 (I1_I976_pn30 XI1_I976_I62_An XI1_I976_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I62_MN2 (XI1_I976_I62_n1 I1_p8_29 I1_I976_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I62_MN3 (VSS XI1_I976_I62_Bn XI1_I976_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I62_MN0 (XI1_I976_I62_An I1_p8_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I57_MN1 (XI1_I976_I57_Bn I1_b9_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I57_MN5 (XI1_I976_I57_n2 I1_b9_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I57_MN4 (I1_I976_pn25 XI1_I976_I57_An XI1_I976_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I57_MN2 (XI1_I976_I57_n1 I1_p8_24 I1_I976_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I57_MN3 (VSS XI1_I976_I57_Bn XI1_I976_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I57_MN0 (XI1_I976_I57_An I1_p8_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I53_MN1 (XI1_I976_I53_Bn I1_b9_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I53_MN5 (XI1_I976_I53_n2 I1_b9_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I53_MN4 (I1_I976_pn21 XI1_I976_I53_An XI1_I976_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I53_MN2 (XI1_I976_I53_n1 I1_p8_20 I1_I976_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I53_MN3 (VSS XI1_I976_I53_Bn XI1_I976_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I53_MN0 (XI1_I976_I53_An I1_p8_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I50_MN1 (XI1_I976_I50_Bn I1_b9_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I50_MN5 (XI1_I976_I50_n2 I1_b9_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I50_MN4 (I1_I976_pn18 XI1_I976_I50_An XI1_I976_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I50_MN2 (XI1_I976_I50_n1 I1_p8_17 I1_I976_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I50_MN3 (VSS XI1_I976_I50_Bn XI1_I976_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I50_MN0 (XI1_I976_I50_An I1_p8_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I48_MN1 (XI1_I976_I48_Bn I1_b9_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I48_MN5 (XI1_I976_I48_n2 I1_b9_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I48_MN4 (I1_I976_pn16 XI1_I976_I48_An XI1_I976_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I48_MN2 (XI1_I976_I48_n1 I1_p8_15 I1_I976_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I48_MN3 (VSS XI1_I976_I48_Bn XI1_I976_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I48_MN0 (XI1_I976_I48_An I1_p8_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I47_MN1 (XI1_I976_I47_Bn I1_b9_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I47_MN5 (XI1_I976_I47_n2 I1_b9_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I47_MN4 (I1_I976_pn15 XI1_I976_I47_An XI1_I976_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I47_MN2 (XI1_I976_I47_n1 I1_p8_14 I1_I976_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I47_MN3 (VSS XI1_I976_I47_Bn XI1_I976_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I47_MN0 (XI1_I976_I47_An I1_p8_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I46_MN1 (XI1_I976_I46_Bn I1_b9_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I46_MN5 (XI1_I976_I46_n2 I1_b9_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I46_MN4 (I1_I976_pn14 XI1_I976_I46_An XI1_I976_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I46_MN2 (XI1_I976_I46_n1 I1_p8_13 I1_I976_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I46_MN3 (VSS XI1_I976_I46_Bn XI1_I976_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I46_MN0 (XI1_I976_I46_An I1_p8_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I44_MN1 (XI1_I976_I44_Bn I1_b9_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I44_MN5 (XI1_I976_I44_n2 I1_b9_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I44_MN4 (I1_I976_pn12 XI1_I976_I44_An XI1_I976_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I44_MN2 (XI1_I976_I44_n1 I1_p8_11 I1_I976_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I44_MN3 (VSS XI1_I976_I44_Bn XI1_I976_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I44_MN0 (XI1_I976_I44_An I1_p8_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I41_MN1 (XI1_I976_I41_Bn I1_b9_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I976_I41_MN5 (XI1_I976_I41_n2 I1_b9_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I41_MN4 (I1_I976_pn9 XI1_I976_I41_An XI1_I976_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I41_MN2 (XI1_I976_I41_n1 I1_p8_8 I1_I976_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I41_MN3 (VSS XI1_I976_I41_Bn XI1_I976_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I41_MN0 (XI1_I976_I41_An I1_p8_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I205_MN1 (XI1_I930_I205_Bn I1_I930_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I930_I205_MN5 (XI1_I930_I205_n2 I1_I930_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I205_MN4 (I1_p8_2 XI1_I930_I205_An XI1_I930_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I205_MN2 (XI1_I930_I205_n1 I1_I930_pn2 I1_p8_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I205_MN3 (VSS XI1_I930_I205_Bn XI1_I930_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I205_MN0 (XI1_I930_I205_An I1_I930_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I34_MN1 (XI1_I654_I34_Bn I1_b2_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I34_MN5 (XI1_I654_I34_n2 I1_b2_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I34_MN4 (I1_I654_pn2 XI1_I654_I34_An XI1_I654_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I34_MN2 (XI1_I654_I34_n1 I1_p1_1 I1_I654_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I34_MN3 (VSS XI1_I654_I34_Bn XI1_I654_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I34_MN0 (XI1_I654_I34_An I1_p1_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I35_MN1 (XI1_I654_I35_Bn I1_b2_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I35_MN5 (XI1_I654_I35_n2 I1_b2_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I35_MN4 (I1_I654_pn3 XI1_I654_I35_An XI1_I654_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I35_MN2 (XI1_I654_I35_n1 I1_p1_2 I1_I654_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I35_MN3 (VSS XI1_I654_I35_Bn XI1_I654_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I35_MN0 (XI1_I654_I35_An I1_p1_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I224_MN1 (XI1_I654_I224_Bn I1_I654_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I224_MN5 (XI1_I654_I224_n2 I1_I654_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I224_MN4 (I1_p2_21 XI1_I654_I224_An XI1_I654_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I224_MN2 (XI1_I654_I224_n1 I1_I654_pn21 I1_p2_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I224_MN3 (VSS XI1_I654_I224_Bn XI1_I654_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I224_MN0 (XI1_I654_I224_An I1_I654_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I226_MN1 (XI1_I654_I226_Bn I1_I654_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I226_MN5 (XI1_I654_I226_n2 I1_I654_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I226_MN4 (I1_p2_23 XI1_I654_I226_An XI1_I654_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I226_MN2 (XI1_I654_I226_n1 I1_I654_pn23 I1_p2_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I226_MN3 (VSS XI1_I654_I226_Bn XI1_I654_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I226_MN0 (XI1_I654_I226_An I1_I654_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I228_MN1 (XI1_I654_I228_Bn I1_I654_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I228_MN5 (XI1_I654_I228_n2 I1_I654_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I228_MN4 (I1_p2_25 XI1_I654_I228_An XI1_I654_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I228_MN2 (XI1_I654_I228_n1 I1_I654_pn25 I1_p2_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I228_MN3 (VSS XI1_I654_I228_Bn XI1_I654_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I228_MN0 (XI1_I654_I228_An I1_I654_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I230_MN1 (XI1_I654_I230_Bn I1_I654_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I230_MN5 (XI1_I654_I230_n2 I1_I654_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I230_MN4 (I1_p2_27 XI1_I654_I230_An XI1_I654_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I230_MN2 (XI1_I654_I230_n1 I1_I654_pn27 I1_p2_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I230_MN3 (VSS XI1_I654_I230_Bn XI1_I654_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I230_MN0 (XI1_I654_I230_An I1_I654_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I234_MN1 (XI1_I654_I234_Bn I1_c2_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I654_I234_MN5 (XI1_I654_I234_n2 I1_c2_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I234_MN4 (I1_p2_31 XI1_I654_I234_An XI1_I654_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I234_MN2 (XI1_I654_I234_n1 I1_I654_pn31 I1_p2_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I234_MN3 (VSS XI1_I654_I234_Bn XI1_I654_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I234_MN0 (XI1_I654_I234_An I1_I654_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I62_MN1 (XI1_I1436_I62_Bn I1_b19_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I62_MN5 (XI1_I1436_I62_n2 I1_b19_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I62_MN4 (I1_I1436_pn30 XI1_I1436_I62_An XI1_I1436_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I62_MN2 (XI1_I1436_I62_n1 I1_p18_29 I1_I1436_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I62_MN3 (VSS XI1_I1436_I62_Bn XI1_I1436_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I62_MN0 (XI1_I1436_I62_An I1_p18_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I230_MN1 (XI1_I1436_I230_Bn I1_I1436_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I230_MN5 (XI1_I1436_I230_n2 I1_I1436_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I230_MN4 (I1_p19_27 XI1_I1436_I230_An XI1_I1436_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I230_MN2 (XI1_I1436_I230_n1 I1_I1436_pn27 I1_p19_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I230_MN3 (VSS XI1_I1436_I230_Bn XI1_I1436_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I230_MN0 (XI1_I1436_I230_An I1_I1436_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I228_MN1 (XI1_I1436_I228_Bn I1_I1436_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1436_I228_MN5 (XI1_I1436_I228_n2 I1_I1436_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I228_MN4 (I1_p19_25 XI1_I1436_I228_An XI1_I1436_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
