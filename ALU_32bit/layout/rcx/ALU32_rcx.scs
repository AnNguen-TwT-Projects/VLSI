    I_MXI0_I1449_MP18 (VDD I0_pp13_10 XI0_I1449_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1449_MP20 (XI0_I1449_p3 I0_pp15_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1449_MP21 (XI0_I1449_sn XI0_I1449_con XI0_I1449_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1449_MP24_1 (XI0_I1449_p5 I0_pp15_6 XI0_I1449_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1547_MP24 (XI0_I1547_sn I0_pp15_9 XI0_I1547_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1547_MP26 (VDD XI0_I1547_sn I0_fa186_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1547_MP17 (XI0_I1547_con I0_pp15_9 XI0_I1547_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1547_MP14 (XI0_I1547_p1 I0_cm97_0 XI0_I1547_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1547_MP13 (VDD I0_cm96_0 XI0_I1547_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1547_MP15 (XI0_I1547_p2 I0_cm96_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1547_MP16 (VDD I0_cm97_0 XI0_I1547_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1547_MP28 (I0_fa186_1 XI0_I1547_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1547_MP22 (XI0_I1547_p4 I0_cm96_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1547_MP23 (XI0_I1547_p5 I0_cm97_0 XI0_I1547_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1547_MP23_1 (XI0_I1547_p4 I0_cm97_0 XI0_I1547_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1547_MP22_1 (VDD I0_cm96_0 XI0_I1547_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1547_MP19 (XI0_I1547_p3 I0_cm97_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1547_MP18 (VDD I0_cm96_0 XI0_I1547_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1547_MP20 (XI0_I1547_p3 I0_pp15_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1547_MP21 (XI0_I1547_sn XI0_I1547_con XI0_I1547_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1547_MP24_1 (XI0_I1547_p5 I0_pp15_9 XI0_I1547_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1421_MP24 (XI0_I1421_sn I0_pp14_1 XI0_I1421_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1421_MP26 (VDD XI0_I1421_sn I0_fa60_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1421_MP17 (XI0_I1421_con I0_pp14_1 XI0_I1421_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1421_MP14 (XI0_I1421_p1 I0_pp13_3 XI0_I1421_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1421_MP13 (VDD I0_pp12_5 XI0_I1421_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1421_MP15 (XI0_I1421_p2 I0_pp12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1421_MP16 (VDD I0_pp13_3 XI0_I1421_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1421_MP28 (I0_fa60_1 XI0_I1421_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1421_MP22 (XI0_I1421_p4 I0_pp12_5 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1421_MP23 (XI0_I1421_p5 I0_pp13_3 XI0_I1421_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1421_MP23_1 (XI0_I1421_p4 I0_pp13_3 XI0_I1421_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1421_MP22_1 (VDD I0_pp12_5 XI0_I1421_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1421_MP19 (XI0_I1421_p3 I0_pp13_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1421_MP18 (VDD I0_pp12_5 XI0_I1421_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1421_MP20 (XI0_I1421_p3 I0_pp14_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1421_MP21 (XI0_I1421_sn XI0_I1421_con XI0_I1421_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1421_MP24_1 (XI0_I1421_p5 I0_pp14_1 XI0_I1421_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1549_MP24 (XI0_I1549_sn I0_pp15_10 XI0_I1549_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1549_MP26 (VDD XI0_I1549_sn I0_fa188_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1549_MP17 (XI0_I1549_con I0_pp15_10 XI0_I1549_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1549_MP14 (XI0_I1549_p1 I0_cm100_0 XI0_I1549_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1549_MP13 (VDD I0_cm99_0 XI0_I1549_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1549_MP15 (XI0_I1549_p2 I0_cm99_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1549_MP16 (VDD I0_cm100_0 XI0_I1549_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1549_MP28 (I0_fa188_1 XI0_I1549_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1549_MP22 (XI0_I1549_p4 I0_cm99_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1549_MP23 (XI0_I1549_p5 I0_cm100_0 XI0_I1549_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1549_MP23_1 (XI0_I1549_p4 I0_cm100_0 XI0_I1549_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1549_MP22_1 (VDD I0_cm99_0 XI0_I1549_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1549_MP19 (XI0_I1549_p3 I0_cm100_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1549_MP18 (VDD I0_cm99_0 XI0_I1549_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1549_MP20 (XI0_I1549_p3 I0_pp15_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1549_MP21 (XI0_I1549_sn XI0_I1549_con XI0_I1549_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1549_MP24_1 (XI0_I1549_p5 I0_pp15_10 XI0_I1549_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1642_MP24 (XI0_I1642_sn I0_pp15_7 XI0_I1642_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1642_MP26 (VDD XI0_I1642_sn I0_fa281_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1642_MP17 (XI0_I1642_con I0_pp15_7 XI0_I1642_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1642_MP14 (XI0_I1642_p1 I0_cm231_0 XI0_I1642_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1642_MP13 (VDD I0_cm230_1 XI0_I1642_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1642_MP15 (XI0_I1642_p2 I0_cm230_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1642_MP16 (VDD I0_cm231_0 XI0_I1642_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1642_MP28 (I0_fa281_1 XI0_I1642_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1642_MP22 (XI0_I1642_p4 I0_cm230_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1642_MP23 (XI0_I1642_p5 I0_cm231_0 XI0_I1642_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1642_MP23_1 (XI0_I1642_p4 I0_cm231_0 XI0_I1642_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1642_MP22_1 (VDD I0_cm230_1 XI0_I1642_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1642_MP19 (XI0_I1642_p3 I0_cm231_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1642_MP18 (VDD I0_cm230_1 XI0_I1642_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1642_MP20 (XI0_I1642_p3 I0_pp15_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1642_MP21 (XI0_I1642_sn XI0_I1642_con XI0_I1642_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1642_MP24_1 (XI0_I1642_p5 I0_pp15_7 XI0_I1642_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1646_MP24 (XI0_I1646_sn I0_cm103_0 XI0_I1646_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1646_MP26 (VDD XI0_I1646_sn I0_fa285_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1646_MP17 (XI0_I1646_con I0_cm103_0 XI0_I1646_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1646_MP14 (XI0_I1646_p1 I0_cm235_0 XI0_I1646_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1646_MP13 (VDD I0_cm234_1 XI0_I1646_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1646_MP15 (XI0_I1646_p2 I0_cm234_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1646_MP16 (VDD I0_cm235_0 XI0_I1646_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1646_MP28 (I0_fa285_1 XI0_I1646_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1646_MP22 (XI0_I1646_p4 I0_cm234_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1646_MP23 (XI0_I1646_p5 I0_cm235_0 XI0_I1646_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1646_MP23_1 (XI0_I1646_p4 I0_cm235_0 XI0_I1646_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1646_MP22_1 (VDD I0_cm234_1 XI0_I1646_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1646_MP19 (XI0_I1646_p3 I0_cm235_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1646_MP18 (VDD I0_cm234_1 XI0_I1646_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1646_MP20 (XI0_I1646_p3 I0_cm103_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1646_MP21 (XI0_I1646_sn XI0_I1646_con XI0_I1646_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1646_MP24_1 (XI0_I1646_p5 I0_cm103_0 XI0_I1646_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1410_MP24 (XI0_I1410_sn I0_B_27_b3_5 XI0_I1410_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1410_MP26 (VDD XI0_I1410_sn I0_fa49_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1410_MP17 (XI0_I1410_con I0_B_27_b3_5 XI0_I1410_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1410_MP14 (XI0_I1410_p1 I0_pp13_0 XI0_I1410_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1410_MP13 (VDD I0_pp12_2 XI0_I1410_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1410_MP15 (XI0_I1410_p2 I0_pp12_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1410_MP16 (VDD I0_pp13_0 XI0_I1410_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1410_MP28 (I0_fa49_1 XI0_I1410_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1410_MP22 (XI0_I1410_p4 I0_pp12_2 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1410_MP23 (XI0_I1410_p5 I0_pp13_0 XI0_I1410_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1410_MP23_1 (XI0_I1410_p4 I0_pp13_0 XI0_I1410_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1410_MP22_1 (VDD I0_pp12_2 XI0_I1410_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1410_MP19 (XI0_I1410_p3 I0_pp13_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1410_MP18 (VDD I0_pp12_2 XI0_I1410_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1410_MP20 (XI0_I1410_p3 I0_B_27_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1410_MP21 (XI0_I1410_sn XI0_I1410_con XI0_I1410_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1410_MP24_1 (XI0_I1410_p5 I0_B_27_b3_5 XI0_I1410_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1417_MP24 (XI0_I1417_sn I0_pp14_0 XI0_I1417_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1417_MP26 (VDD XI0_I1417_sn I0_fa56_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1417_MP17 (XI0_I1417_con I0_pp14_0 XI0_I1417_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1417_MP14 (XI0_I1417_p1 I0_pp13_2 XI0_I1417_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1417_MP13 (VDD I0_pp12_4 XI0_I1417_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1417_MP15 (XI0_I1417_p2 I0_pp12_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1417_MP16 (VDD I0_pp13_2 XI0_I1417_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1417_MP28 (I0_fa56_1 XI0_I1417_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1417_MP22 (XI0_I1417_p4 I0_pp12_4 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1417_MP23 (XI0_I1417_p5 I0_pp13_2 XI0_I1417_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1417_MP23_1 (XI0_I1417_p4 I0_pp13_2 XI0_I1417_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1417_MP22_1 (VDD I0_pp12_4 XI0_I1417_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1417_MP19 (XI0_I1417_p3 I0_pp13_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1417_MP18 (VDD I0_pp12_4 XI0_I1417_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1417_MP20 (XI0_I1417_p3 I0_pp14_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1417_MP21 (XI0_I1417_sn XI0_I1417_con XI0_I1417_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1417_MP24_1 (XI0_I1417_p5 I0_pp14_0 XI0_I1417_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1598_MP24 (XI0_I1598_sn I0_fa192_0 XI0_I1598_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1598_MP26 (VDD XI0_I1598_sn I0_fa237_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1598_MP17 (XI0_I1598_con I0_fa192_0 XI0_I1598_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1598_MP14 (XI0_I1598_p1 I0_cm191_0 XI0_I1598_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1598_MP13 (VDD I0_cm190_1 XI0_I1598_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1598_MP15 (XI0_I1598_p2 I0_cm190_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1598_MP16 (VDD I0_cm191_0 XI0_I1598_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1598_MP28 (I0_fa237_1 XI0_I1598_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1598_MP22 (XI0_I1598_p4 I0_cm190_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1598_MP23 (XI0_I1598_p5 I0_cm191_0 XI0_I1598_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1598_MP23_1 (XI0_I1598_p4 I0_cm191_0 XI0_I1598_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1598_MP22_1 (VDD I0_cm190_1 XI0_I1598_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1598_MP19 (XI0_I1598_p3 I0_cm191_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1598_MP18 (VDD I0_cm190_1 XI0_I1598_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1598_MP20 (XI0_I1598_p3 I0_fa192_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1598_MP21 (XI0_I1598_sn XI0_I1598_con XI0_I1598_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1598_MP24_1 (XI0_I1598_p5 I0_fa192_0 XI0_I1598_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1470_MP24 (XI0_I1470_sn I0_pp15_13 XI0_I1470_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1470_MP26 (VDD XI0_I1470_sn I0_fa109_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1470_MP17 (XI0_I1470_con I0_pp15_13 XI0_I1470_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1470_MP14 (XI0_I1470_p1 I0_pp14_15 XI0_I1470_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1470_MP13 (VDD I0_pp13_17 XI0_I1470_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1470_MP15 (XI0_I1470_p2 I0_pp13_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1470_MP16 (VDD I0_pp14_15 XI0_I1470_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1470_MP28 (I0_fa109_1 XI0_I1470_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1470_MP22 (XI0_I1470_p4 I0_pp13_17 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1470_MP23 (XI0_I1470_p5 I0_pp14_15 XI0_I1470_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1470_MP23_1 (XI0_I1470_p4 I0_pp14_15 XI0_I1470_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1470_MP22_1 (VDD I0_pp13_17 XI0_I1470_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1470_MP19 (XI0_I1470_p3 I0_pp14_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1470_MP18 (VDD I0_pp13_17 XI0_I1470_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1470_MP20 (XI0_I1470_p3 I0_pp15_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1470_MP21 (XI0_I1470_sn XI0_I1470_con XI0_I1470_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1470_MP24_1 (XI0_I1470_p5 I0_pp15_13 XI0_I1470_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1553_MP24 (XI0_I1553_sn I0_cm106_2 XI0_I1553_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1553_MP26 (VDD XI0_I1553_sn I0_fa192_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1553_MP17 (XI0_I1553_con I0_cm106_2 XI0_I1553_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1553_MP14 (XI0_I1553_p1 I0_fa109_0 XI0_I1553_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1553_MP13 (VDD I0_cm108_0 XI0_I1553_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1553_MP15 (XI0_I1553_p2 I0_cm108_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1553_MP16 (VDD I0_fa109_0 XI0_I1553_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1553_MP28 (I0_fa192_1 XI0_I1553_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1553_MP22 (XI0_I1553_p4 I0_cm108_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1553_MP23 (XI0_I1553_p5 I0_fa109_0 XI0_I1553_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1553_MP23_1 (XI0_I1553_p4 I0_fa109_0 XI0_I1553_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1553_MP22_1 (VDD I0_cm108_0 XI0_I1553_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1553_MP19 (XI0_I1553_p3 I0_fa109_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1553_MP18 (VDD I0_cm108_0 XI0_I1553_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1553_MP20 (XI0_I1553_p3 I0_cm106_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1553_MP21 (XI0_I1553_sn XI0_I1553_con XI0_I1553_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1553_MP24_1 (XI0_I1553_p5 I0_cm106_2 XI0_I1553_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1648_MP24 (XI0_I1648_sn I0_cm236_2 XI0_I1648_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1648_MP26 (VDD XI0_I1648_sn I0_fa287_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1648_MP17 (XI0_I1648_con I0_cm236_2 XI0_I1648_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1648_MP14 (XI0_I1648_p1 I0_fa237_0 XI0_I1648_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1648_MP13 (VDD I0_cm236_1 XI0_I1648_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1648_MP15 (XI0_I1648_p2 I0_cm236_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1648_MP16 (VDD I0_fa237_0 XI0_I1648_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1648_MP28 (I0_fa287_1 XI0_I1648_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1648_MP22 (XI0_I1648_p4 I0_cm236_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1648_MP23 (XI0_I1648_p5 I0_fa237_0 XI0_I1648_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1648_MP23_1 (XI0_I1648_p4 I0_fa237_0 XI0_I1648_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1648_MP22_1 (VDD I0_cm236_1 XI0_I1648_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1648_MP19 (XI0_I1648_p3 I0_fa237_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1648_MP18 (VDD I0_cm236_1 XI0_I1648_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1648_MP20 (XI0_I1648_p3 I0_cm236_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1648_MP21 (XI0_I1648_sn XI0_I1648_con XI0_I1648_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1648_MP24_1 (XI0_I1648_p5 I0_cm236_2 XI0_I1648_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1473_MP24 (XI0_I1473_sn I0_pp15_14 XI0_I1473_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1473_MP26 (VDD XI0_I1473_sn I0_fa112_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1473_MP17 (XI0_I1473_con I0_pp15_14 XI0_I1473_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1473_MP14 (XI0_I1473_p1 I0_pp14_16 XI0_I1473_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1473_MP13 (VDD I0_pp13_18 XI0_I1473_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1473_MP15 (XI0_I1473_p2 I0_pp13_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1473_MP16 (VDD I0_pp14_16 XI0_I1473_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1473_MP28 (I0_fa112_1 XI0_I1473_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1473_MP22 (XI0_I1473_p4 I0_pp13_18 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1473_MP23 (XI0_I1473_p5 I0_pp14_16 XI0_I1473_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1473_MP23_1 (XI0_I1473_p4 I0_pp14_16 XI0_I1473_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1473_MP22_1 (VDD I0_pp13_18 XI0_I1473_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1473_MP19 (XI0_I1473_p3 I0_pp14_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1473_MP18 (VDD I0_pp13_18 XI0_I1473_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1473_MP20 (XI0_I1473_p3 I0_pp15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1473_MP21 (XI0_I1473_sn XI0_I1473_con XI0_I1473_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1473_MP24_1 (XI0_I1473_p5 I0_pp15_14 XI0_I1473_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1650_MP24 (XI0_I1650_sn I0_cm238_2 XI0_I1650_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1650_MP26 (VDD XI0_I1650_sn I0_fa289_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1650_MP17 (XI0_I1650_con I0_cm238_2 XI0_I1650_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1650_MP14 (XI0_I1650_p1 I0_fa239_0 XI0_I1650_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1650_MP13 (VDD I0_cm238_1 XI0_I1650_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1650_MP15 (XI0_I1650_p2 I0_cm238_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1650_MP16 (VDD I0_fa239_0 XI0_I1650_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1650_MP28 (I0_fa289_1 XI0_I1650_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1650_MP22 (XI0_I1650_p4 I0_cm238_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1650_MP23 (XI0_I1650_p5 I0_fa239_0 XI0_I1650_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1650_MP23_1 (XI0_I1650_p4 I0_fa239_0 XI0_I1650_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1650_MP22_1 (VDD I0_cm238_1 XI0_I1650_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1650_MP19 (XI0_I1650_p3 I0_fa239_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1650_MP18 (VDD I0_cm238_1 XI0_I1650_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1650_MP20 (XI0_I1650_p3 I0_cm238_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1650_MP21 (XI0_I1650_sn XI0_I1650_con XI0_I1650_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1650_MP24_1 (XI0_I1650_p5 I0_cm238_2 XI0_I1650_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1600_MP24 (XI0_I1600_sn I0_fa195_0 XI0_I1600_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1600_MP26 (VDD XI0_I1600_sn I0_fa239_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1600_MP17 (XI0_I1600_con I0_fa195_0 XI0_I1600_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1600_MP14 (XI0_I1600_p1 I0_cm194_0 XI0_I1600_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1600_MP13 (VDD I0_cm193_1 XI0_I1600_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1600_MP15 (XI0_I1600_p2 I0_cm193_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1600_MP16 (VDD I0_cm194_0 XI0_I1600_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1600_MP28 (I0_fa239_1 XI0_I1600_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1600_MP22 (XI0_I1600_p4 I0_cm193_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1600_MP23 (XI0_I1600_p5 I0_cm194_0 XI0_I1600_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1600_MP23_1 (XI0_I1600_p4 I0_cm194_0 XI0_I1600_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1600_MP22_1 (VDD I0_cm193_1 XI0_I1600_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1600_MP19 (XI0_I1600_p3 I0_cm194_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1600_MP18 (VDD I0_cm193_1 XI0_I1600_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1600_MP20 (XI0_I1600_p3 I0_fa195_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1600_MP21 (XI0_I1600_sn XI0_I1600_con XI0_I1600_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1600_MP24_1 (XI0_I1600_p5 I0_fa195_0 XI0_I1600_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1556_MP24 (XI0_I1556_sn I0_pp15_15 XI0_I1556_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1556_MP26 (VDD XI0_I1556_sn I0_fa195_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1556_MP17 (XI0_I1556_con I0_pp15_15 XI0_I1556_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1556_MP14 (XI0_I1556_p1 I0_pp14_17 XI0_I1556_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1556_MP13 (VDD I0_cm114_0 XI0_I1556_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1556_MP15 (XI0_I1556_p2 I0_cm114_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1556_MP16 (VDD I0_pp14_17 XI0_I1556_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1556_MP28 (I0_fa195_1 XI0_I1556_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1556_MP22 (XI0_I1556_p4 I0_cm114_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1556_MP23 (XI0_I1556_p5 I0_pp14_17 XI0_I1556_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1556_MP23_1 (XI0_I1556_p4 I0_pp14_17 XI0_I1556_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1556_MP22_1 (VDD I0_cm114_0 XI0_I1556_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1556_MP19 (XI0_I1556_p3 I0_pp14_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1556_MP18 (VDD I0_cm114_0 XI0_I1556_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1556_MP20 (XI0_I1556_p3 I0_pp15_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1556_MP21 (XI0_I1556_sn XI0_I1556_con XI0_I1556_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1556_MP24_1 (XI0_I1556_p5 I0_pp15_15 XI0_I1556_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1652_MP24 (XI0_I1652_sn I0_cm240_2 XI0_I1652_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI0_I1652_MP26 (VDD XI0_I1652_sn I0_fa291_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1652_MP17 (XI0_I1652_con I0_cm240_2 XI0_I1652_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1652_MP14 (XI0_I1652_p1 I0_fa241_0 XI0_I1652_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1652_MP13 (VDD I0_cm240_1 XI0_I1652_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1652_MP15 (XI0_I1652_p2 I0_cm240_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1652_MP16 (VDD I0_fa241_0 XI0_I1652_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1652_MP28 (I0_fa291_1 XI0_I1652_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI0_I1652_MP22 (XI0_I1652_p4 I0_cm240_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI0_I1652_MP23 (XI0_I1652_p5 I0_fa241_0 XI0_I1652_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1652_MP23_1 (XI0_I1652_p4 I0_fa241_0 XI0_I1652_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI0_I1652_MP22_1 (VDD I0_cm240_1 XI0_I1652_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI0_I1652_MP19 (XI0_I1652_p3 I0_fa241_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI0_I1652_MP18 (VDD I0_cm240_1 XI0_I1652_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1652_MP20 (XI0_I1652_p3 I0_cm240_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1652_MP21 (XI0_I1652_sn XI0_I1652_con XI0_I1652_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1652_MP24_1 (XI0_I1652_p5 I0_cm240_2 XI0_I1652_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI0_I1567_MP24 (XI0_I1567_sn I0_pp15_26 XI0_I1567_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI0_I1567_MP26 (VDD XI0_I1567_sn I0_fa206_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI0_I1567_MP17 (XI0_I1567_con I0_pp15_26 XI0_I1567_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI0_I1567_MP14 (XI0_I1567_p1 I0_cm132_0 XI0_I1567_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1567_MP13 (VDD I0_cm131_1 XI0_I1567_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1567_MP15 (XI0_I1567_p2 I0_cm131_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1567_MP16 (VDD I0_cm132_0 XI0_I1567_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1567_MP28 (I0_fa206_1 XI0_I1567_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI0_I1567_MP22 (XI0_I1567_p4 I0_cm131_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI0_I1567_MP23 (XI0_I1567_p5 I0_cm132_0 XI0_I1567_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1567_MP23_1 (XI0_I1567_p4 I0_cm132_0 XI0_I1567_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1567_MP22_1 (VDD I0_cm131_1 XI0_I1567_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI0_I1567_MP19 (XI0_I1567_p3 I0_cm132_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI0_I1567_MP18 (VDD I0_cm131_1 XI0_I1567_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1567_MP20 (XI0_I1567_p3 I0_pp15_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1567_MP21 (XI0_I1567_sn XI0_I1567_con XI0_I1567_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1567_MP24_1 (XI0_I1567_p5 I0_pp15_26 XI0_I1567_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI0_I1607_MP24 (XI0_I1607_sn I0_cm133_0 XI0_I1607_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI0_I1607_MP26 (VDD XI0_I1607_sn I0_fa246_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI0_I1607_MP17 (XI0_I1607_con I0_cm133_0 XI0_I1607_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI0_I1607_MP14 (XI0_I1607_p1 I0_cm132_1 XI0_I1607_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1607_MP13 (VDD I0_fa206_1 XI0_I1607_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1607_MP15 (XI0_I1607_p2 I0_fa206_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1607_MP16 (VDD I0_cm132_1 XI0_I1607_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1607_MP28 (I0_fa246_1 XI0_I1607_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI0_I1607_MP22 (XI0_I1607_p4 I0_fa206_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI0_I1607_MP23 (XI0_I1607_p5 I0_cm132_1 XI0_I1607_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1607_MP23_1 (XI0_I1607_p4 I0_cm132_1 XI0_I1607_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1607_MP22_1 (VDD I0_fa206_1 XI0_I1607_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI0_I1607_MP19 (XI0_I1607_p3 I0_cm132_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI0_I1607_MP18 (VDD I0_fa206_1 XI0_I1607_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1607_MP20 (XI0_I1607_p3 I0_cm133_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1607_MP21 (XI0_I1607_sn XI0_I1607_con XI0_I1607_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1607_MP24_1 (XI0_I1607_p5 I0_cm133_0 XI0_I1607_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI0_I1602_MP24 (XI0_I1602_sn I0_pp15_17 XI0_I1602_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI0_I1602_MP26 (VDD XI0_I1602_sn I0_fa241_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI0_I1602_MP17 (XI0_I1602_con I0_pp15_17 XI0_I1602_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI0_I1602_MP14 (XI0_I1602_p1 I0_cm197_0 XI0_I1602_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1602_MP13 (VDD I0_cm196_1 XI0_I1602_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1602_MP15 (XI0_I1602_p2 I0_cm196_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1602_MP16 (VDD I0_cm197_0 XI0_I1602_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1602_MP28 (I0_fa241_1 XI0_I1602_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI0_I1602_MP22 (XI0_I1602_p4 I0_cm196_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI0_I1602_MP23 (XI0_I1602_p5 I0_cm197_0 XI0_I1602_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1602_MP23_1 (XI0_I1602_p4 I0_cm197_0 XI0_I1602_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1602_MP22_1 (VDD I0_cm196_1 XI0_I1602_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI0_I1602_MP19 (XI0_I1602_p3 I0_cm197_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI0_I1602_MP18 (VDD I0_cm196_1 XI0_I1602_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1602_MP20 (XI0_I1602_p3 I0_pp15_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1602_MP21 (XI0_I1602_sn XI0_I1602_con XI0_I1602_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1602_MP24_1 (XI0_I1602_p5 I0_pp15_17 XI0_I1602_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI0_I1659_MP24 (XI0_I1659_sn I0_cm134_0 XI0_I1659_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI0_I1659_MP26 (VDD XI0_I1659_sn I0_fa298_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI0_I1659_MP17 (XI0_I1659_con I0_cm134_0 XI0_I1659_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI0_I1659_MP14 (XI0_I1659_p1 I0_cm133_1 XI0_I1659_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1659_MP13 (VDD I0_fa246_1 XI0_I1659_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1659_MP15 (XI0_I1659_p2 I0_fa246_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1659_MP16 (VDD I0_cm133_1 XI0_I1659_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1659_MP28 (I0_fa298_1 XI0_I1659_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI0_I1659_MP22 (XI0_I1659_p4 I0_fa246_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI0_I1659_MP23 (XI0_I1659_p5 I0_cm133_1 XI0_I1659_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1659_MP23_1 (XI0_I1659_p4 I0_cm133_1 XI0_I1659_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1659_MP22_1 (VDD I0_fa246_1 XI0_I1659_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI0_I1659_MP19 (XI0_I1659_p3 I0_cm133_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI0_I1659_MP18 (VDD I0_fa246_1 XI0_I1659_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1659_MP20 (XI0_I1659_p3 I0_cm134_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1659_MP21 (XI0_I1659_sn XI0_I1659_con XI0_I1659_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1659_MP24_1 (XI0_I1659_p5 I0_cm134_0 XI0_I1659_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI0_I1603_MP24 (XI0_I1603_sn I0_pp15_18 XI0_I1603_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI0_I1603_MP26 (VDD XI0_I1603_sn I0_fa242_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI0_I1603_MP17 (XI0_I1603_con I0_pp15_18 XI0_I1603_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI0_I1603_MP14 (XI0_I1603_p1 I0_cm198_0 XI0_I1603_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1603_MP13 (VDD I0_cm197_1 XI0_I1603_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1603_MP15 (XI0_I1603_p2 I0_cm197_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1603_MP16 (VDD I0_cm198_0 XI0_I1603_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1603_MP28 (I0_fa242_1 XI0_I1603_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI0_I1603_MP22 (XI0_I1603_p4 I0_cm197_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI0_I1603_MP23 (XI0_I1603_p5 I0_cm198_0 XI0_I1603_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1603_MP23_1 (XI0_I1603_p4 I0_cm198_0 XI0_I1603_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1603_MP22_1 (VDD I0_cm197_1 XI0_I1603_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI0_I1603_MP19 (XI0_I1603_p3 I0_cm198_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI0_I1603_MP18 (VDD I0_cm197_1 XI0_I1603_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1603_MP20 (XI0_I1603_p3 I0_pp15_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1603_MP21 (XI0_I1603_sn XI0_I1603_con XI0_I1603_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1603_MP24_1 (XI0_I1603_p5 I0_pp15_18 XI0_I1603_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI0_I1496_MP24 (XI0_I1496_sn I0_pp15_29 XI0_I1496_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI0_I1496_MP26 (VDD XI0_I1496_sn I0_fa135_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI0_I1496_MP17 (XI0_I1496_con I0_pp15_29 XI0_I1496_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI0_I1496_MP14 (XI0_I1496_p1 I0_pp14_31 XI0_I1496_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1496_MP13 (VDD I0_sn13 XI0_I1496_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1496_MP15 (XI0_I1496_p2 I0_sn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1496_MP16 (VDD I0_pp14_31 XI0_I1496_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1496_MP28 (I0_fa135_1 XI0_I1496_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI0_I1496_MP22 (XI0_I1496_p4 I0_sn13 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI0_I1496_MP23 (XI0_I1496_p5 I0_pp14_31 XI0_I1496_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1496_MP23_1 (XI0_I1496_p4 I0_pp14_31 XI0_I1496_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1496_MP22_1 (VDD I0_sn13 XI0_I1496_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI0_I1496_MP19 (XI0_I1496_p3 I0_pp14_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI0_I1496_MP18 (VDD I0_sn13 XI0_I1496_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1496_MP20 (XI0_I1496_p3 I0_pp15_29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1496_MP21 (XI0_I1496_sn XI0_I1496_con XI0_I1496_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1496_MP24_1 (XI0_I1496_p5 I0_pp15_29 XI0_I1496_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI0_I1654_MP24 (XI0_I1654_sn I0_cm199_0 XI0_I1654_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI0_I1654_MP26 (VDD XI0_I1654_sn I0_fa293_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI0_I1654_MP17 (XI0_I1654_con I0_cm199_0 XI0_I1654_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI0_I1654_MP14 (XI0_I1654_p1 I0_cm198_1 XI0_I1654_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1654_MP13 (VDD I0_fa242_1 XI0_I1654_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1654_MP15 (XI0_I1654_p2 I0_fa242_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1654_MP16 (VDD I0_cm198_1 XI0_I1654_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1654_MP28 (I0_fa293_1 XI0_I1654_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI0_I1654_MP22 (XI0_I1654_p4 I0_fa242_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI0_I1654_MP23 (XI0_I1654_p5 I0_cm198_1 XI0_I1654_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1654_MP23_1 (XI0_I1654_p4 I0_cm198_1 XI0_I1654_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1654_MP22_1 (VDD I0_fa242_1 XI0_I1654_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI0_I1654_MP19 (XI0_I1654_p3 I0_cm198_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI0_I1654_MP18 (VDD I0_fa242_1 XI0_I1654_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1654_MP20 (XI0_I1654_p3 I0_cm199_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1654_MP21 (XI0_I1654_sn XI0_I1654_con XI0_I1654_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1654_MP24_1 (XI0_I1654_p5 I0_cm199_0 XI0_I1654_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI0_I1568_MP24 (XI0_I1568_sn I0_cm134_2 XI0_I1568_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI0_I1568_MP26 (VDD XI0_I1568_sn I0_fa207_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI0_I1568_MP17 (XI0_I1568_con I0_cm134_2 XI0_I1568_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI0_I1568_MP14 (XI0_I1568_p1 I0_fa135_0 XI0_I1568_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1568_MP13 (VDD I0_cm134_1 XI0_I1568_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1568_MP15 (XI0_I1568_p2 I0_cm134_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1568_MP16 (VDD I0_fa135_0 XI0_I1568_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1568_MP28 (I0_fa207_1 XI0_I1568_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI0_I1568_MP22 (XI0_I1568_p4 I0_cm134_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI0_I1568_MP23 (XI0_I1568_p5 I0_fa135_0 XI0_I1568_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1568_MP23_1 (XI0_I1568_p4 I0_fa135_0 XI0_I1568_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1568_MP22_1 (VDD I0_cm134_1 XI0_I1568_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI0_I1568_MP19 (XI0_I1568_p3 I0_fa135_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI0_I1568_MP18 (VDD I0_cm134_1 XI0_I1568_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1568_MP20 (XI0_I1568_p3 I0_cm134_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1568_MP21 (XI0_I1568_sn XI0_I1568_con XI0_I1568_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1568_MP24_1 (XI0_I1568_p5 I0_cm134_2 XI0_I1568_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI0_I1658_MP24 (XI0_I1658_sn I0_fa206_0 XI0_I1658_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI0_I1658_MP26 (VDD XI0_I1658_sn I0_fa297_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI0_I1658_MP17 (XI0_I1658_con I0_fa206_0 XI0_I1658_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI0_I1658_MP14 (XI0_I1658_p1 I0_fa205_1 XI0_I1658_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1658_MP13 (VDD I0_fa245_1 XI0_I1658_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1658_MP15 (XI0_I1658_p2 I0_fa245_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1658_MP16 (VDD I0_fa205_1 XI0_I1658_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1658_MP28 (I0_fa297_1 XI0_I1658_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI0_I1658_MP22 (XI0_I1658_p4 I0_fa245_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI0_I1658_MP23 (XI0_I1658_p5 I0_fa205_1 XI0_I1658_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1658_MP23_1 (XI0_I1658_p4 I0_fa205_1 XI0_I1658_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1658_MP22_1 (VDD I0_fa245_1 XI0_I1658_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI0_I1658_MP19 (XI0_I1658_p3 I0_fa205_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI0_I1658_MP18 (VDD I0_fa245_1 XI0_I1658_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1658_MP20 (XI0_I1658_p3 I0_fa206_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1658_MP21 (XI0_I1658_sn XI0_I1658_con XI0_I1658_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1658_MP24_1 (XI0_I1658_p5 I0_fa206_0 XI0_I1658_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI0_I1566_MP24 (XI0_I1566_sn I0_pp15_25 XI0_I1566_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI0_I1566_MP26 (VDD XI0_I1566_sn I0_fa205_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI0_I1566_MP17 (XI0_I1566_con I0_pp15_25 XI0_I1566_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI0_I1566_MP14 (XI0_I1566_p1 I0_cm131_0 XI0_I1566_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1566_MP13 (VDD I0_cm130_1 XI0_I1566_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1566_MP15 (XI0_I1566_p2 I0_cm130_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1566_MP16 (VDD I0_cm131_0 XI0_I1566_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1566_MP28 (I0_fa205_1 XI0_I1566_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI0_I1566_MP22 (XI0_I1566_p4 I0_cm130_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI0_I1566_MP23 (XI0_I1566_p5 I0_cm131_0 XI0_I1566_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1566_MP23_1 (XI0_I1566_p4 I0_cm131_0 XI0_I1566_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1566_MP22_1 (VDD I0_cm130_1 XI0_I1566_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI0_I1566_MP19 (XI0_I1566_p3 I0_cm131_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI0_I1566_MP18 (VDD I0_cm130_1 XI0_I1566_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1566_MP20 (XI0_I1566_p3 I0_pp15_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1566_MP21 (XI0_I1566_sn XI0_I1566_con XI0_I1566_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1566_MP24_1 (XI0_I1566_p5 I0_pp15_25 XI0_I1566_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI0_I1487_MP24 (XI0_I1487_sn I0_pp15_21 XI0_I1487_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI0_I1487_MP26 (VDD XI0_I1487_sn I0_fa126_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI0_I1487_MP17 (XI0_I1487_con I0_pp15_21 XI0_I1487_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI0_I1487_MP14 (XI0_I1487_p1 I0_pp14_23 XI0_I1487_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1487_MP13 (VDD I0_pp13_25 XI0_I1487_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1487_MP15 (XI0_I1487_p2 I0_pp13_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1487_MP16 (VDD I0_pp14_23 XI0_I1487_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1487_MP28 (I0_fa126_1 XI0_I1487_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI0_I1487_MP22 (XI0_I1487_p4 I0_pp13_25 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI0_I1487_MP23 (XI0_I1487_p5 I0_pp14_23 XI0_I1487_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1487_MP23_1 (XI0_I1487_p4 I0_pp14_23 XI0_I1487_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1487_MP22_1 (VDD I0_pp13_25 XI0_I1487_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI0_I1487_MP19 (XI0_I1487_p3 I0_pp14_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI0_I1487_MP18 (VDD I0_pp13_25 XI0_I1487_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1487_MP20 (XI0_I1487_p3 I0_pp15_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1487_MP21 (XI0_I1487_sn XI0_I1487_con XI0_I1487_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1487_MP24_1 (XI0_I1487_p5 I0_pp15_21 XI0_I1487_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI0_I1489_MP24 (XI0_I1489_sn I0_pp15_22 XI0_I1489_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI0_I1489_MP26 (VDD XI0_I1489_sn I0_fa128_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI0_I1489_MP17 (XI0_I1489_con I0_pp15_22 XI0_I1489_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI0_I1489_MP14 (XI0_I1489_p1 I0_pp14_24 XI0_I1489_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1489_MP13 (VDD I0_pp13_26 XI0_I1489_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1489_MP15 (XI0_I1489_p2 I0_pp13_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1489_MP16 (VDD I0_pp14_24 XI0_I1489_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1489_MP28 (I0_fa128_1 XI0_I1489_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI0_I1489_MP22 (XI0_I1489_p4 I0_pp13_26 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI0_I1489_MP23 (XI0_I1489_p5 I0_pp14_24 XI0_I1489_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1489_MP23_1 (XI0_I1489_p4 I0_pp14_24 XI0_I1489_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1489_MP22_1 (VDD I0_pp13_26 XI0_I1489_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI0_I1489_MP19 (XI0_I1489_p3 I0_pp14_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI0_I1489_MP18 (VDD I0_pp13_26 XI0_I1489_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1489_MP20 (XI0_I1489_p3 I0_pp15_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1489_MP21 (XI0_I1489_sn XI0_I1489_con XI0_I1489_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1489_MP24_1 (XI0_I1489_p5 I0_pp15_22 XI0_I1489_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI0_I1608_MP24 (XI0_I1608_sn I0_fa136_0 XI0_I1608_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI0_I1608_MP26 (VDD XI0_I1608_sn I0_fa247_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI0_I1608_MP17 (XI0_I1608_con I0_fa136_0 XI0_I1608_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI0_I1608_MP14 (XI0_I1608_p1 I0_fa135_1 XI0_I1608_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1608_MP13 (VDD I0_fa207_1 XI0_I1608_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1608_MP15 (XI0_I1608_p2 I0_fa207_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1608_MP16 (VDD I0_fa135_1 XI0_I1608_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1608_MP28 (I0_fa247_1 XI0_I1608_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI0_I1608_MP22 (XI0_I1608_p4 I0_fa207_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI0_I1608_MP23 (XI0_I1608_p5 I0_fa135_1 XI0_I1608_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1608_MP23_1 (XI0_I1608_p4 I0_fa135_1 XI0_I1608_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1608_MP22_1 (VDD I0_fa207_1 XI0_I1608_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI0_I1608_MP19 (XI0_I1608_p3 I0_fa135_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI0_I1608_MP18 (VDD I0_fa207_1 XI0_I1608_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1608_MP20 (XI0_I1608_p3 I0_fa136_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1608_MP21 (XI0_I1608_sn XI0_I1608_con XI0_I1608_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1608_MP24_1 (XI0_I1608_p5 I0_fa136_0 XI0_I1608_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI0_I1606_MP24 (XI0_I1606_sn I0_cm204_2 XI0_I1606_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI0_I1606_MP26 (VDD XI0_I1606_sn I0_fa245_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI0_I1606_MP17 (XI0_I1606_con I0_cm204_2 XI0_I1606_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI0_I1606_MP14 (XI0_I1606_p1 I0_fa205_0 XI0_I1606_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1606_MP13 (VDD I0_cm204_1 XI0_I1606_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1606_MP15 (XI0_I1606_p2 I0_cm204_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1606_MP16 (VDD I0_fa205_0 XI0_I1606_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1606_MP28 (I0_fa245_1 XI0_I1606_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI0_I1606_MP22 (XI0_I1606_p4 I0_cm204_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI0_I1606_MP23 (XI0_I1606_p5 I0_fa205_0 XI0_I1606_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1606_MP23_1 (XI0_I1606_p4 I0_fa205_0 XI0_I1606_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1606_MP22_1 (VDD I0_cm204_1 XI0_I1606_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI0_I1606_MP19 (XI0_I1606_p3 I0_fa205_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI0_I1606_MP18 (VDD I0_cm204_1 XI0_I1606_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1606_MP20 (XI0_I1606_p3 I0_cm204_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1606_MP21 (XI0_I1606_sn XI0_I1606_con XI0_I1606_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1606_MP24_1 (XI0_I1606_p5 I0_cm204_2 XI0_I1606_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI0_I1604_MP24 (XI0_I1604_sn I0_cm124_2 XI0_I1604_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI0_I1604_MP26 (VDD XI0_I1604_sn I0_fa243_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI0_I1604_MP17 (XI0_I1604_con I0_cm124_2 XI0_I1604_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI0_I1604_MP14 (XI0_I1604_p1 I0_cm201_0 XI0_I1604_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1604_MP13 (VDD I0_cm200_1 XI0_I1604_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1604_MP15 (XI0_I1604_p2 I0_cm200_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1604_MP16 (VDD I0_cm201_0 XI0_I1604_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1604_MP28 (I0_fa243_1 XI0_I1604_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI0_I1604_MP22 (XI0_I1604_p4 I0_cm200_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI0_I1604_MP23 (XI0_I1604_p5 I0_cm201_0 XI0_I1604_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1604_MP23_1 (XI0_I1604_p4 I0_cm201_0 XI0_I1604_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1604_MP22_1 (VDD I0_cm200_1 XI0_I1604_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI0_I1604_MP19 (XI0_I1604_p3 I0_cm201_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI0_I1604_MP18 (VDD I0_cm200_1 XI0_I1604_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1604_MP20 (XI0_I1604_p3 I0_cm124_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1604_MP21 (XI0_I1604_sn XI0_I1604_con XI0_I1604_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1604_MP24_1 (XI0_I1604_p5 I0_cm124_2 XI0_I1604_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI0_I1609_MP24 (XI0_I1609_sn I0_pp15_32 XI0_I1609_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI0_I1609_MP26 (VDD XI0_I1609_sn I0_fa248_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI0_I1609_MP17 (XI0_I1609_con I0_pp15_32 XI0_I1609_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI0_I1609_MP14 (XI0_I1609_p1 VDD XI0_I1609_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1609_MP13 (VDD I0_fa208_1 XI0_I1609_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1609_MP15 (XI0_I1609_p2 I0_fa208_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1609_MP16 (VDD VDD XI0_I1609_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1609_MP28 (I0_fa248_1 XI0_I1609_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI0_I1609_MP22 (XI0_I1609_p4 I0_fa208_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI0_I1609_MP23 (XI0_I1609_p5 VDD XI0_I1609_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1609_MP23_1 (XI0_I1609_p4 VDD XI0_I1609_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1609_MP22_1 (VDD I0_fa208_1 XI0_I1609_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI0_I1609_MP19 (XI0_I1609_p3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI0_I1609_MP18 (VDD I0_fa208_1 XI0_I1609_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1609_MP20 (XI0_I1609_p3 I0_pp15_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1609_MP21 (XI0_I1609_sn XI0_I1609_con XI0_I1609_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1609_MP24_1 (XI0_I1609_p5 I0_pp15_32 XI0_I1609_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI0_I1569_MP24 (XI0_I1569_sn I0_pp15_31 XI0_I1569_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI0_I1569_MP26 (VDD XI0_I1569_sn I0_fa208_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI0_I1569_MP17 (XI0_I1569_con I0_pp15_31 XI0_I1569_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI0_I1569_MP14 (XI0_I1569_p1 I0_sn14 XI0_I1569_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1569_MP13 (VDD I0_fa136_1 XI0_I1569_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1569_MP15 (XI0_I1569_p2 I0_fa136_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1569_MP16 (VDD I0_sn14 XI0_I1569_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1569_MP28 (I0_fa208_1 XI0_I1569_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI0_I1569_MP22 (XI0_I1569_p4 I0_fa136_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI0_I1569_MP23 (XI0_I1569_p5 I0_sn14 XI0_I1569_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1569_MP23_1 (XI0_I1569_p4 I0_sn14 XI0_I1569_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1569_MP22_1 (VDD I0_fa136_1 XI0_I1569_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI0_I1569_MP19 (XI0_I1569_p3 I0_sn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI0_I1569_MP18 (VDD I0_fa136_1 XI0_I1569_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1569_MP20 (XI0_I1569_p3 I0_pp15_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1569_MP21 (XI0_I1569_sn XI0_I1569_con XI0_I1569_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1569_MP24_1 (XI0_I1569_p5 I0_pp15_31 XI0_I1569_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI0_I1497_MP24 (XI0_I1497_sn I0_pp15_30 XI0_I1497_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI0_I1497_MP26 (VDD XI0_I1497_sn I0_fa136_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI0_I1497_MP17 (XI0_I1497_con I0_pp15_30 XI0_I1497_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI0_I1497_MP14 (XI0_I1497_p1 I0_pp14_32 XI0_I1497_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1497_MP13 (VDD VDD XI0_I1497_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1497_MP15 (XI0_I1497_p2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1497_MP16 (VDD I0_pp14_32 XI0_I1497_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1497_MP28 (I0_fa136_1 XI0_I1497_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI0_I1497_MP22 (XI0_I1497_p4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI0_I1497_MP23 (XI0_I1497_p5 I0_pp14_32 XI0_I1497_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1497_MP23_1 (XI0_I1497_p4 I0_pp14_32 XI0_I1497_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1497_MP22_1 (VDD VDD XI0_I1497_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI0_I1497_MP19 (XI0_I1497_p3 I0_pp14_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI0_I1497_MP18 (VDD VDD XI0_I1497_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1497_MP20 (XI0_I1497_p3 I0_pp15_30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1497_MP21 (XI0_I1497_sn XI0_I1497_con XI0_I1497_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1497_MP24_1 (XI0_I1497_p5 I0_pp15_30 XI0_I1497_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI0_I1605_MP24 (XI0_I1605_sn I0_pp15_23 XI0_I1605_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI0_I1605_MP26 (VDD XI0_I1605_sn I0_fa244_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI0_I1605_MP17 (XI0_I1605_con I0_pp15_23 XI0_I1605_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI0_I1605_MP14 (XI0_I1605_p1 I0_cm203_0 XI0_I1605_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1605_MP13 (VDD I0_cm202_1 XI0_I1605_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1605_MP15 (XI0_I1605_p2 I0_cm202_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1605_MP16 (VDD I0_cm203_0 XI0_I1605_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1605_MP28 (I0_fa244_1 XI0_I1605_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI0_I1605_MP22 (XI0_I1605_p4 I0_cm202_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI0_I1605_MP23 (XI0_I1605_p5 I0_cm203_0 XI0_I1605_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1605_MP23_1 (XI0_I1605_p4 I0_cm203_0 XI0_I1605_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1605_MP22_1 (VDD I0_cm202_1 XI0_I1605_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI0_I1605_MP19 (XI0_I1605_p3 I0_cm203_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI0_I1605_MP18 (VDD I0_cm202_1 XI0_I1605_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1605_MP20 (XI0_I1605_p3 I0_pp15_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1605_MP21 (XI0_I1605_sn XI0_I1605_con XI0_I1605_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1605_MP24_1 (XI0_I1605_p5 I0_pp15_23 XI0_I1605_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI0_I1657_MP24 (XI0_I1657_sn I0_cm204_0 XI0_I1657_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI0_I1657_MP26 (VDD XI0_I1657_sn I0_fa296_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI0_I1657_MP17 (XI0_I1657_con I0_cm204_0 XI0_I1657_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI0_I1657_MP14 (XI0_I1657_p1 I0_cm203_1 XI0_I1657_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1657_MP13 (VDD I0_fa244_1 XI0_I1657_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1657_MP15 (XI0_I1657_p2 I0_fa244_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1657_MP16 (VDD I0_cm203_1 XI0_I1657_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1657_MP28 (I0_fa296_1 XI0_I1657_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI0_I1657_MP22 (XI0_I1657_p4 I0_fa244_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI0_I1657_MP23 (XI0_I1657_p5 I0_cm203_1 XI0_I1657_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1657_MP23_1 (XI0_I1657_p4 I0_cm203_1 XI0_I1657_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1657_MP22_1 (VDD I0_fa244_1 XI0_I1657_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI0_I1657_MP19 (XI0_I1657_p3 I0_cm203_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI0_I1657_MP18 (VDD I0_fa244_1 XI0_I1657_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1657_MP20 (XI0_I1657_p3 I0_cm204_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1657_MP21 (XI0_I1657_sn XI0_I1657_con XI0_I1657_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1657_MP24_1 (XI0_I1657_p5 I0_cm204_0 XI0_I1657_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI0_I1656_MP24 (XI0_I1656_sn I0_cm202_0 XI0_I1656_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI0_I1656_MP26 (VDD XI0_I1656_sn I0_fa295_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI0_I1656_MP17 (XI0_I1656_con I0_cm202_0 XI0_I1656_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI0_I1656_MP14 (XI0_I1656_p1 I0_cm201_1 XI0_I1656_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1656_MP13 (VDD I0_fa243_1 XI0_I1656_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1656_MP15 (XI0_I1656_p2 I0_fa243_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1656_MP16 (VDD I0_cm201_1 XI0_I1656_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1656_MP28 (I0_fa295_1 XI0_I1656_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI0_I1656_MP22 (XI0_I1656_p4 I0_fa243_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI0_I1656_MP23 (XI0_I1656_p5 I0_cm201_1 XI0_I1656_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1656_MP23_1 (XI0_I1656_p4 I0_cm201_1 XI0_I1656_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI0_I1656_MP22_1 (VDD I0_fa243_1 XI0_I1656_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI0_I1656_MP19 (XI0_I1656_p3 I0_cm201_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI0_I1656_MP18 (VDD I0_fa243_1 XI0_I1656_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1656_MP20 (XI0_I1656_p3 I0_cm202_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1656_MP21 (XI0_I1656_sn XI0_I1656_con XI0_I1656_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI0_I1656_MP24_1 (XI0_I1656_p5 I0_cm202_0 XI0_I1656_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1_I1344_I96_XG_MP2 (VDD I1_I1344_gn30 I1_I1344_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I96_XG_MP0 (XI1_I1344_I96_XG_p1 I1_I1344_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I96_XG_MP1 (I1_I1344_G30_29 I1_I1344_gn29 XI1_I1344_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I97_XG_MP2 (VDD I1_I1344_gn31 I1_I1344_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I97_XG_MP0 (XI1_I1344_I97_XG_p1 I1_I1344_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I97_XG_MP1 (I1_I1344_G31_30 I1_I1344_gn30 XI1_I1344_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I156_XG_MP2 (VDD I1_I1344_G31_28n I1_I1344_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I156_XG_MP0 (XI1_I1344_I156_XG_p1 I1_I1344_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I156_XG_MP1 (I1_I1344_G31_24 I1_I1344_G27_24n XI1_I1344_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I202_XG_MP2 (VDD I1_I1344_G31_16n I1_c17_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I202_XG_MP0 (XI1_I1344_I202_XG_p1 I1_I1344_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I202_XG_MP1 (I1_c17_o I1_I1344_G15_0n XI1_I1344_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I202_XG_MP2 (VDD I1_I1298_G31_16n I1_c16_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I202_XG_MP0 (XI1_I1298_I202_XG_p1 I1_I1298_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I202_XG_MP1 (I1_c16_o I1_I1298_G15_0n XI1_I1298_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I156_XG_MP2 (VDD I1_I1298_G31_28n I1_I1298_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I156_XG_MP0 (XI1_I1298_I156_XG_p1 I1_I1298_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I156_XG_MP1 (I1_I1298_G31_24 I1_I1298_G27_24n XI1_I1298_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I95_XG_MP2 (VDD I1_I1298_gn29 I1_I1298_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I95_XG_MP0 (XI1_I1298_I95_XG_p1 I1_I1298_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I95_XG_MP1 (I1_I1298_G29_28 I1_I1298_gn28 XI1_I1298_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I95_XG_MP2 (VDD I1_I1252_gn29 I1_I1252_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I95_XG_MP0 (XI1_I1252_I95_XG_p1 I1_I1252_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I95_XG_MP1 (I1_I1252_G29_28 I1_I1252_gn28 XI1_I1252_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I94_XG_MP2 (VDD I1_I1252_gn28 I1_I1252_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I94_XG_MP0 (XI1_I1252_I94_XG_p1 I1_I1252_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I94_XG_MP1 (I1_I1252_G28_27 I1_I1252_gn27 XI1_I1252_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I96_XG_MP2 (VDD I1_I1252_gn30 I1_I1252_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I96_XG_MP0 (XI1_I1252_I96_XG_p1 I1_I1252_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I96_XG_MP1 (I1_I1252_G30_29 I1_I1252_gn29 XI1_I1252_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I97_XG_MP2 (VDD I1_I1252_gn31 I1_I1252_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I97_XG_MP0 (XI1_I1252_I97_XG_p1 I1_I1252_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I97_XG_MP1 (I1_I1252_G31_30 I1_I1252_gn30 XI1_I1252_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I95_XG_MP2 (VDD I1_I1206_gn29 I1_I1206_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I95_XG_MP0 (XI1_I1206_I95_XG_p1 I1_I1206_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I95_XG_MP1 (I1_I1206_G29_28 I1_I1206_gn28 XI1_I1206_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I94_XG_MP2 (VDD I1_I1206_gn28 I1_I1206_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I94_XG_MP0 (XI1_I1206_I94_XG_p1 I1_I1206_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I94_XG_MP1 (I1_I1206_G28_27 I1_I1206_gn27 XI1_I1206_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I97_XG_MP2 (VDD I1_I838_gn31 I1_I838_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I97_XG_MP0 (XI1_I838_I97_XG_p1 I1_I838_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I97_XG_MP1 (I1_I838_G31_30 I1_I838_gn30 XI1_I838_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I156_XG_MP2 (VDD I1_I838_G31_28n I1_I838_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I156_XG_MP0 (XI1_I838_I156_XG_p1 I1_I838_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I156_XG_MP1 (I1_I838_G31_24 I1_I838_G27_24n XI1_I838_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I154_XG_MP2 (VDD I1_I838_G29_26n I1_I838_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I154_XG_MP0 (XI1_I838_I154_XG_p1 I1_I838_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I154_XG_MP1 (I1_I838_G29_22 I1_I838_G25_22n XI1_I838_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I152_XG_MP2 (VDD I1_I838_G27_24n I1_I838_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I152_XG_MP0 (XI1_I838_I152_XG_p1 I1_I838_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I152_XG_MP1 (I1_I838_G27_20 I1_I838_G23_20n XI1_I838_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I202_XG_MP2 (VDD I1_I838_G31_16n I1_c6_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I202_XG_MP0 (XI1_I838_I202_XG_p1 I1_I838_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I202_XG_MP1 (I1_c6_o I1_I838_G15_0n XI1_I838_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I194_XG_MP2 (VDD I1_I838_G23_8n I1_I838_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I194_XG_MP0 (XI1_I838_I194_XG_p1 I1_I838_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I194_XG_MP1 (I1_I838_G23_0 I1_I838_G7_0n XI1_I838_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I144_XG_MP2 (VDD I1_I838_G19_16n I1_I838_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I144_XG_MP0 (XI1_I838_I144_XG_p1 I1_I838_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I144_XG_MP1 (I1_I838_G19_12 I1_I838_G15_12n XI1_I838_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I140_XG_MP2 (VDD I1_I838_G15_12n I1_I838_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I140_XG_MP0 (XI1_I838_I140_XG_p1 I1_I838_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I140_XG_MP1 (I1_I838_G15_8 I1_I838_G11_8n XI1_I838_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I190_XG_MP2 (VDD I1_I838_G21_6n I1_I838_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I190_XG_MP0 (XI1_I838_I190_XG_p1 I1_I838_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I190_XG_MP1 (I1_I838_G21_0 I1_I838_G5_0n XI1_I838_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I186_XG_MP2 (VDD I1_I838_G19_4n I1_I838_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I186_XG_MP0 (XI1_I838_I186_XG_p1 I1_I838_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I186_XG_MP1 (I1_I838_G19_0 I1_I838_G3_0n XI1_I838_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I136_XG_MP2 (VDD I1_I838_G11_8n I1_I838_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I136_XG_MP0 (XI1_I838_I136_XG_p1 I1_I838_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I136_XG_MP1 (I1_I838_G11_4 I1_I838_G7_4n XI1_I838_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I200_XG_MP2 (VDD I1_I792_G29_14n I1_I792_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I200_XG_MP0 (XI1_I792_I200_XG_p1 I1_I792_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I200_XG_MP1 (I1_I792_G29_0 I1_I792_G13_0n XI1_I792_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I198_XG_MP2 (VDD I1_I792_G27_12n I1_I792_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I198_XG_MP0 (XI1_I792_I198_XG_p1 I1_I792_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I198_XG_MP1 (I1_I792_G27_0 I1_I792_G11_0n XI1_I792_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I202_XG_MP2 (VDD I1_I792_G31_16n I1_c5_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I202_XG_MP0 (XI1_I792_I202_XG_p1 I1_I792_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I202_XG_MP1 (I1_c5_o I1_I792_G15_0n XI1_I792_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I154_XG_MP2 (VDD I1_I792_G29_26n I1_I792_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I154_XG_MP0 (XI1_I792_I154_XG_p1 I1_I792_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I154_XG_MP1 (I1_I792_G29_22 I1_I792_G25_22n XI1_I792_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I152_XG_MP2 (VDD I1_I792_G27_24n I1_I792_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I152_XG_MP0 (XI1_I792_I152_XG_p1 I1_I792_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I152_XG_MP1 (I1_I792_G27_20 I1_I792_G23_20n XI1_I792_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I156_XG_MP2 (VDD I1_I792_G31_28n I1_I792_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I156_XG_MP0 (XI1_I792_I156_XG_p1 I1_I792_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I156_XG_MP1 (I1_I792_G31_24 I1_I792_G27_24n XI1_I792_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I201_XG_MP2 (VDD I1_I792_G30_15n I1_c5_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I201_XG_MP0 (XI1_I792_I201_XG_p1 I1_I792_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I201_XG_MP1 (I1_c5_m I1_I792_G14_0n XI1_I792_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I155_XG_MP2 (VDD I1_I792_G30_27n I1_I792_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I155_XG_MP0 (XI1_I792_I155_XG_p1 I1_I792_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I155_XG_MP1 (I1_I792_G30_23 I1_I792_G26_23n XI1_I792_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I91_XG_MP2 (VDD I1_I792_gn25 I1_I792_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I91_XG_MP0 (XI1_I792_I91_XG_p1 I1_I792_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I91_XG_MP1 (I1_I792_G25_24 I1_I792_gn24 XI1_I792_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I93_XG_MP2 (VDD I1_I792_gn27 I1_I792_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I93_XG_MP0 (XI1_I792_I93_XG_p1 I1_I792_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I93_XG_MP1 (I1_I792_G27_26 I1_I792_gn26 XI1_I792_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I94_XG_MP2 (VDD I1_I792_gn28 I1_I792_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I94_XG_MP0 (XI1_I792_I94_XG_p1 I1_I792_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I94_XG_MP1 (I1_I792_G28_27 I1_I792_gn27 XI1_I792_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I95_XG_MP2 (VDD I1_I792_gn29 I1_I792_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I95_XG_MP0 (XI1_I792_I95_XG_p1 I1_I792_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I95_XG_MP1 (I1_I792_G29_28 I1_I792_gn28 XI1_I792_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I96_XG_MP2 (VDD I1_I792_gn30 I1_I792_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I96_XG_MP0 (XI1_I792_I96_XG_p1 I1_I792_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I96_XG_MP1 (I1_I792_G30_29 I1_I792_gn29 XI1_I792_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I97_XG_MP2 (VDD I1_I792_gn31 I1_I792_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I97_XG_MP0 (XI1_I792_I97_XG_p1 I1_I792_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I97_XG_MP1 (I1_I792_G31_30 I1_I792_gn30 XI1_I792_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I95_XG_MP2 (VDD I1_I1344_gn29 I1_I1344_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I95_XG_MP0 (XI1_I1344_I95_XG_p1 I1_I1344_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I95_XG_MP1 (I1_I1344_G29_28 I1_I1344_gn28 XI1_I1344_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I152_XG_MP2 (VDD I1_I1344_G27_24n I1_I1344_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I152_XG_MP0 (XI1_I1344_I152_XG_p1 I1_I1344_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I152_XG_MP1 (I1_I1344_G27_20 I1_I1344_G23_20n XI1_I1344_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I148_XG_MP2 (VDD I1_I1344_G23_20n I1_I1344_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I148_XG_MP0 (XI1_I1344_I148_XG_p1 I1_I1344_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I148_XG_MP1 (I1_I1344_G23_16 I1_I1344_G19_16n XI1_I1344_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I194_XG_MP2 (VDD I1_I1344_G23_8n I1_I1344_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I194_XG_MP0 (XI1_I1344_I194_XG_p1 I1_I1344_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I194_XG_MP1 (I1_I1344_G23_0 I1_I1344_G7_0n XI1_I1344_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I198_XG_MP2 (VDD I1_I1298_G27_12n I1_I1298_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I198_XG_MP0 (XI1_I1298_I198_XG_p1 I1_I1298_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I198_XG_MP1 (I1_I1298_G27_0 I1_I1298_G11_0n XI1_I1298_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I152_XG_MP2 (VDD I1_I1298_G27_24n I1_I1298_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I152_XG_MP0 (XI1_I1298_I152_XG_p1 I1_I1298_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I152_XG_MP1 (I1_I1298_G27_20 I1_I1298_G23_20n XI1_I1298_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I200_XG_MP2 (VDD I1_I1298_G29_14n I1_I1298_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I200_XG_MP0 (XI1_I1298_I200_XG_p1 I1_I1298_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I200_XG_MP1 (I1_I1298_G29_0 I1_I1298_G13_0n XI1_I1298_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I155_XG_MP2 (VDD I1_I1298_G30_27n I1_I1298_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I155_XG_MP0 (XI1_I1298_I155_XG_p1 I1_I1298_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I155_XG_MP1 (I1_I1298_G30_23 I1_I1298_G26_23n XI1_I1298_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I92_XG_MP2 (VDD I1_I1298_gn26 I1_I1298_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I92_XG_MP0 (XI1_I1298_I92_XG_p1 I1_I1298_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I92_XG_MP1 (I1_I1298_G26_25 I1_I1298_gn25 XI1_I1298_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I201_XG_MP2 (VDD I1_I1252_G30_15n I1_c15_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I201_XG_MP0 (XI1_I1252_I201_XG_p1 I1_I1252_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I201_XG_MP1 (I1_c15_m I1_I1252_G14_0n XI1_I1252_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I155_XG_MP2 (VDD I1_I1252_G30_27n I1_I1252_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I155_XG_MP0 (XI1_I1252_I155_XG_p1 I1_I1252_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I155_XG_MP1 (I1_I1252_G30_23 I1_I1252_G26_23n XI1_I1252_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I202_XG_MP2 (VDD I1_I1252_G31_16n I1_c15_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I202_XG_MP0 (XI1_I1252_I202_XG_p1 I1_I1252_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I202_XG_MP1 (I1_c15_o I1_I1252_G15_0n XI1_I1252_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I156_XG_MP2 (VDD I1_I1252_G31_28n I1_I1252_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I156_XG_MP0 (XI1_I1252_I156_XG_p1 I1_I1252_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I156_XG_MP1 (I1_I1252_G31_24 I1_I1252_G27_24n XI1_I1252_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I93_XG_MP2 (VDD I1_I1252_gn27 I1_I1252_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I93_XG_MP0 (XI1_I1252_I93_XG_p1 I1_I1252_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I93_XG_MP1 (I1_I1252_G27_26 I1_I1252_gn26 XI1_I1252_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I92_XG_MP2 (VDD I1_I1252_gn26 I1_I1252_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I92_XG_MP0 (XI1_I1252_I92_XG_p1 I1_I1252_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I92_XG_MP1 (I1_I1252_G26_25 I1_I1252_gn25 XI1_I1252_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I97_XG_MP2 (VDD I1_I1206_gn31 I1_I1206_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I97_XG_MP0 (XI1_I1206_I97_XG_p1 I1_I1206_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I97_XG_MP1 (I1_I1206_G31_30 I1_I1206_gn30 XI1_I1206_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I96_XG_MP2 (VDD I1_I1206_gn30 I1_I1206_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I96_XG_MP0 (XI1_I1206_I96_XG_p1 I1_I1206_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I96_XG_MP1 (I1_I1206_G30_29 I1_I1206_gn29 XI1_I1206_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I93_XG_MP2 (VDD I1_I1206_gn27 I1_I1206_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I93_XG_MP0 (XI1_I1206_I93_XG_p1 I1_I1206_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I93_XG_MP1 (I1_I1206_G27_26 I1_I1206_gn26 XI1_I1206_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I92_XG_MP2 (VDD I1_I1206_gn26 I1_I1206_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I92_XG_MP0 (XI1_I1206_I92_XG_p1 I1_I1206_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I92_XG_MP1 (I1_I1206_G26_25 I1_I1206_gn25 XI1_I1206_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I95_XG_MP2 (VDD I1_I838_gn29 I1_I838_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I95_XG_MP0 (XI1_I838_I95_XG_p1 I1_I838_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I95_XG_MP1 (I1_I838_G29_28 I1_I838_gn28 XI1_I838_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I96_XG_MP2 (VDD I1_I838_gn30 I1_I838_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I96_XG_MP0 (XI1_I838_I96_XG_p1 I1_I838_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I96_XG_MP1 (I1_I838_G30_29 I1_I838_gn29 XI1_I838_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I91_XG_MP2 (VDD I1_I838_gn25 I1_I838_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I91_XG_MP0 (XI1_I838_I91_XG_p1 I1_I838_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I91_XG_MP1 (I1_I838_G25_24 I1_I838_gn24 XI1_I838_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I89_XG_MP2 (VDD I1_I838_gn23 I1_I838_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I89_XG_MP0 (XI1_I838_I89_XG_p1 I1_I838_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I89_XG_MP1 (I1_I838_G23_22 I1_I838_gn22 XI1_I838_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I200_XG_MP2 (VDD I1_I838_G29_14n I1_I838_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I200_XG_MP0 (XI1_I838_I200_XG_p1 I1_I838_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I200_XG_MP1 (I1_I838_G29_0 I1_I838_G13_0n XI1_I838_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I87_XG_MP2 (VDD I1_I838_gn21 I1_I838_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I87_XG_MP0 (XI1_I838_I87_XG_p1 I1_I838_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I87_XG_MP1 (I1_I838_G21_20 I1_I838_gn20 XI1_I838_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I150_XG_MP2 (VDD I1_I838_G25_22n I1_I838_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I150_XG_MP0 (XI1_I838_I150_XG_p1 I1_I838_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I150_XG_MP1 (I1_I838_G25_18 I1_I838_G21_18n XI1_I838_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I146_XG_MP2 (VDD I1_I838_G21_18n I1_I838_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I146_XG_MP0 (XI1_I838_I146_XG_p1 I1_I838_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I146_XG_MP1 (I1_I838_G21_14 I1_I838_G17_14n XI1_I838_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I142_XG_MP2 (VDD I1_I838_G17_14n I1_I838_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I142_XG_MP0 (XI1_I838_I142_XG_p1 I1_I838_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I142_XG_MP1 (I1_I838_G17_10 I1_I838_G13_10n XI1_I838_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I134_XG_MP2 (VDD I1_I838_G9_6n I1_I838_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I134_XG_MP0 (XI1_I838_I134_XG_p1 I1_I838_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I134_XG_MP1 (I1_I838_G9_2 I1_I838_G5_2n XI1_I838_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I132_XG_MP2 (VDD I1_I838_G7_4n I1_I838_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I132_XG_MP0 (XI1_I838_I132_XG_p1 I1_I838_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I132_XG_MP1 (I1_I838_G7_0 I1_I838_G3_0n XI1_I838_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I196_XG_MP2 (VDD I1_I792_G25_10n I1_I792_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I196_XG_MP0 (XI1_I792_I196_XG_p1 I1_I792_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I196_XG_MP1 (I1_I792_G25_0 I1_I792_G9_0n XI1_I792_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I194_XG_MP2 (VDD I1_I792_G23_8n I1_I792_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I194_XG_MP0 (XI1_I792_I194_XG_p1 I1_I792_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I194_XG_MP1 (I1_I792_G23_0 I1_I792_G7_0n XI1_I792_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I146_XG_MP2 (VDD I1_I792_G21_18n I1_I792_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I146_XG_MP0 (XI1_I792_I146_XG_p1 I1_I792_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I146_XG_MP1 (I1_I792_G21_14 I1_I792_G17_14n XI1_I792_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I199_XG_MP2 (VDD I1_I792_G28_13n I1_I792_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I199_XG_MP0 (XI1_I792_I199_XG_p1 I1_I792_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I199_XG_MP1 (I1_I792_G28_0 I1_I792_G12_0n XI1_I792_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I151_XG_MP2 (VDD I1_I792_G26_23n I1_I792_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I151_XG_MP0 (XI1_I792_I151_XG_p1 I1_I792_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I151_XG_MP1 (I1_I792_G26_19 I1_I792_G22_19n XI1_I792_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I153_XG_MP2 (VDD I1_I792_G28_25n I1_I792_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I153_XG_MP0 (XI1_I792_I153_XG_p1 I1_I792_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I153_XG_MP1 (I1_I792_G28_21 I1_I792_G24_21n XI1_I792_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I89_XG_MP2 (VDD I1_I792_gn23 I1_I792_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I89_XG_MP0 (XI1_I792_I89_XG_p1 I1_I792_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I89_XG_MP1 (I1_I792_G23_22 I1_I792_gn22 XI1_I792_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I90_XG_MP2 (VDD I1_I792_gn24 I1_I792_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I90_XG_MP0 (XI1_I792_I90_XG_p1 I1_I792_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I90_XG_MP1 (I1_I792_G24_23 I1_I792_gn23 XI1_I792_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I92_XG_MP2 (VDD I1_I792_gn26 I1_I792_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I92_XG_MP0 (XI1_I792_I92_XG_p1 I1_I792_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I92_XG_MP1 (I1_I792_G26_25 I1_I792_gn25 XI1_I792_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I94_XG_MP2 (VDD I1_I1344_gn28 I1_I1344_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I94_XG_MP0 (XI1_I1344_I94_XG_p1 I1_I1344_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I94_XG_MP1 (I1_I1344_G28_27 I1_I1344_gn27 XI1_I1344_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I154_XG_MP2 (VDD I1_I1344_G29_26n I1_I1344_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I154_XG_MP0 (XI1_I1344_I154_XG_p1 I1_I1344_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I154_XG_MP1 (I1_I1344_G29_22 I1_I1344_G25_22n XI1_I1344_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I150_XG_MP2 (VDD I1_I1344_G25_22n I1_I1344_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I150_XG_MP0 (XI1_I1344_I150_XG_p1 I1_I1344_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I150_XG_MP1 (I1_I1344_G25_18 I1_I1344_G21_18n XI1_I1344_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I200_XG_MP2 (VDD I1_I1344_G29_14n I1_I1344_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I200_XG_MP0 (XI1_I1344_I200_XG_p1 I1_I1344_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I200_XG_MP1 (I1_I1344_G29_0 I1_I1344_G13_0n XI1_I1344_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I154_XG_MP2 (VDD I1_I1298_G29_26n I1_I1298_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I154_XG_MP0 (XI1_I1298_I154_XG_p1 I1_I1298_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I154_XG_MP1 (I1_I1298_G29_22 I1_I1298_G25_22n XI1_I1298_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I201_XG_MP2 (VDD I1_I1298_G30_15n I1_c16_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I201_XG_MP0 (XI1_I1298_I201_XG_p1 I1_I1298_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I201_XG_MP1 (I1_c16_m I1_I1298_G14_0n XI1_I1298_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I90_XG_MP2 (VDD I1_I1298_gn24 I1_I1298_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I90_XG_MP0 (XI1_I1298_I90_XG_p1 I1_I1298_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I90_XG_MP1 (I1_I1298_G24_23 I1_I1298_gn23 XI1_I1298_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I91_XG_MP2 (VDD I1_I1298_gn25 I1_I1298_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I91_XG_MP0 (XI1_I1298_I91_XG_p1 I1_I1298_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I91_XG_MP1 (I1_I1298_G25_24 I1_I1298_gn24 XI1_I1298_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I199_XG_MP2 (VDD I1_I1252_G28_13n I1_I1252_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I199_XG_MP0 (XI1_I1252_I199_XG_p1 I1_I1252_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I199_XG_MP1 (I1_I1252_G28_0 I1_I1252_G12_0n XI1_I1252_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I153_XG_MP2 (VDD I1_I1252_G28_25n I1_I1252_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I153_XG_MP0 (XI1_I1252_I153_XG_p1 I1_I1252_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I153_XG_MP1 (I1_I1252_G28_21 I1_I1252_G24_21n XI1_I1252_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I200_XG_MP2 (VDD I1_I1252_G29_14n I1_I1252_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I200_XG_MP0 (XI1_I1252_I200_XG_p1 I1_I1252_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I200_XG_MP1 (I1_I1252_G29_0 I1_I1252_G13_0n XI1_I1252_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I154_XG_MP2 (VDD I1_I1252_G29_26n I1_I1252_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I154_XG_MP0 (XI1_I1252_I154_XG_p1 I1_I1252_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I154_XG_MP1 (I1_I1252_G29_22 I1_I1252_G25_22n XI1_I1252_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I90_XG_MP2 (VDD I1_I1252_gn24 I1_I1252_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I90_XG_MP0 (XI1_I1252_I90_XG_p1 I1_I1252_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I90_XG_MP1 (I1_I1252_G24_23 I1_I1252_gn23 XI1_I1252_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I91_XG_MP2 (VDD I1_I1252_gn25 I1_I1252_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I91_XG_MP0 (XI1_I1252_I91_XG_p1 I1_I1252_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I91_XG_MP1 (I1_I1252_G25_24 I1_I1252_gn24 XI1_I1252_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I90_XG_MP2 (VDD I1_I1206_gn24 I1_I1206_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I90_XG_MP0 (XI1_I1206_I90_XG_p1 I1_I1206_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I90_XG_MP1 (I1_I1206_G24_23 I1_I1206_gn23 XI1_I1206_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I156_XG_MP2 (VDD I1_I1206_G31_28n I1_I1206_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I156_XG_MP0 (XI1_I1206_I156_XG_p1 I1_I1206_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I156_XG_MP1 (I1_I1206_G31_24 I1_I1206_G27_24n XI1_I1206_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I91_XG_MP2 (VDD I1_I1206_gn25 I1_I1206_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I91_XG_MP0 (XI1_I1206_I91_XG_p1 I1_I1206_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I91_XG_MP1 (I1_I1206_G25_24 I1_I1206_gn24 XI1_I1206_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I155_XG_MP2 (VDD I1_I1206_G30_27n I1_I1206_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I155_XG_MP0 (XI1_I1206_I155_XG_p1 I1_I1206_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I155_XG_MP1 (I1_I1206_G30_23 I1_I1206_G26_23n XI1_I1206_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I94_XG_MP2 (VDD I1_I838_gn28 I1_I838_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I94_XG_MP0 (XI1_I838_I94_XG_p1 I1_I838_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I94_XG_MP1 (I1_I838_G28_27 I1_I838_gn27 XI1_I838_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I90_XG_MP2 (VDD I1_I838_gn24 I1_I838_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I90_XG_MP0 (XI1_I838_I90_XG_p1 I1_I838_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I90_XG_MP1 (I1_I838_G24_23 I1_I838_gn23 XI1_I838_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I88_XG_MP2 (VDD I1_I838_gn22 I1_I838_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I88_XG_MP0 (XI1_I838_I88_XG_p1 I1_I838_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I88_XG_MP1 (I1_I838_G22_21 I1_I838_gn21 XI1_I838_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I86_XG_MP2 (VDD I1_I838_gn20 I1_I838_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I86_XG_MP0 (XI1_I838_I86_XG_p1 I1_I838_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I86_XG_MP1 (I1_I838_G20_19 I1_I838_gn19 XI1_I838_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I85_XG_MP2 (VDD I1_I838_gn19 I1_I838_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I85_XG_MP0 (XI1_I838_I85_XG_p1 I1_I838_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I85_XG_MP1 (I1_I838_G19_18 I1_I838_gn18 XI1_I838_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I83_XG_MP2 (VDD I1_I838_gn17 I1_I838_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I83_XG_MP0 (XI1_I838_I83_XG_p1 I1_I838_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I83_XG_MP1 (I1_I838_G17_16 I1_I838_gn16 XI1_I838_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I196_XG_MP2 (VDD I1_I838_G25_10n I1_I838_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I196_XG_MP0 (XI1_I838_I196_XG_p1 I1_I838_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I196_XG_MP1 (I1_I838_G25_0 I1_I838_G9_0n XI1_I838_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I138_XG_MP2 (VDD I1_I838_G13_10n I1_I838_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I138_XG_MP0 (XI1_I838_I138_XG_p1 I1_I838_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I138_XG_MP1 (I1_I838_G13_6 I1_I838_G9_6n XI1_I838_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I184_XG_MP2 (VDD I1_I838_G17_2n I1_I838_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I184_XG_MP0 (XI1_I838_I184_XG_p1 I1_I838_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I184_XG_MP1 (I1_I838_G17_0 I1_I838_G1_0n XI1_I838_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I130_XG_MP2 (VDD I1_I838_G5_2n I1_I838_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I130_XG_MP0 (XI1_I838_I130_XG_p1 I1_I838_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I130_XG_MP1 (I1_I838_G5_0 I1_I838_G1_0n XI1_I838_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I190_XG_MP2 (VDD I1_I792_G21_6n I1_I792_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I190_XG_MP0 (XI1_I792_I190_XG_p1 I1_I792_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I190_XG_MP1 (I1_I792_G21_0 I1_I792_G5_0n XI1_I792_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I186_XG_MP2 (VDD I1_I792_G19_4n I1_I792_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I186_XG_MP0 (XI1_I792_I186_XG_p1 I1_I792_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I186_XG_MP1 (I1_I792_G19_0 I1_I792_G3_0n XI1_I792_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I144_XG_MP2 (VDD I1_I792_G19_16n I1_I792_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I144_XG_MP0 (XI1_I792_I144_XG_p1 I1_I792_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I144_XG_MP1 (I1_I792_G19_12 I1_I792_G15_12n XI1_I792_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I192_XG_MP2 (VDD I1_I792_G22_7n I1_I792_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I192_XG_MP0 (XI1_I792_I192_XG_p1 I1_I792_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I192_XG_MP1 (I1_I792_G22_0 I1_I792_G6_0n XI1_I792_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I197_XG_MP2 (VDD I1_I792_G26_11n I1_I792_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I197_XG_MP0 (XI1_I792_I197_XG_p1 I1_I792_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I197_XG_MP1 (I1_I792_G26_0 I1_I792_G10_0n XI1_I792_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I147_XG_MP2 (VDD I1_I792_G22_19n I1_I792_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I147_XG_MP0 (XI1_I792_I147_XG_p1 I1_I792_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I147_XG_MP1 (I1_I792_G22_15 I1_I792_G18_15n XI1_I792_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I149_XG_MP2 (VDD I1_I792_G24_21n I1_I792_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I149_XG_MP0 (XI1_I792_I149_XG_p1 I1_I792_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I149_XG_MP1 (I1_I792_G24_17 I1_I792_G20_17n XI1_I792_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I87_XG_MP2 (VDD I1_I792_gn21 I1_I792_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I87_XG_MP0 (XI1_I792_I87_XG_p1 I1_I792_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I87_XG_MP1 (I1_I792_G21_20 I1_I792_gn20 XI1_I792_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I88_XG_MP2 (VDD I1_I792_gn22 I1_I792_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I88_XG_MP0 (XI1_I792_I88_XG_p1 I1_I792_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I88_XG_MP1 (I1_I792_G22_21 I1_I792_gn21 XI1_I792_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I92_XG_MP2 (VDD I1_I1344_gn26 I1_I1344_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I92_XG_MP0 (XI1_I1344_I92_XG_p1 I1_I1344_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I92_XG_MP1 (I1_I1344_G26_25 I1_I1344_gn25 XI1_I1344_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I93_XG_MP2 (VDD I1_I1344_gn27 I1_I1344_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I93_XG_MP0 (XI1_I1344_I93_XG_p1 I1_I1344_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I93_XG_MP1 (I1_I1344_G27_26 I1_I1344_gn26 XI1_I1344_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I91_XG_MP2 (VDD I1_I1344_gn25 I1_I1344_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I91_XG_MP0 (XI1_I1344_I91_XG_p1 I1_I1344_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I91_XG_MP1 (I1_I1344_G25_24 I1_I1344_gn24 XI1_I1344_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I90_XG_MP2 (VDD I1_I1344_gn24 I1_I1344_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I90_XG_MP0 (XI1_I1344_I90_XG_p1 I1_I1344_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I90_XG_MP1 (I1_I1344_G24_23 I1_I1344_gn23 XI1_I1344_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I89_XG_MP2 (VDD I1_I1344_gn23 I1_I1344_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I89_XG_MP0 (XI1_I1344_I89_XG_p1 I1_I1344_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I89_XG_MP1 (I1_I1344_G23_22 I1_I1344_gn22 XI1_I1344_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I146_XG_MP2 (VDD I1_I1344_G21_18n I1_I1344_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I146_XG_MP0 (XI1_I1344_I146_XG_p1 I1_I1344_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I146_XG_MP1 (I1_I1344_G21_14 I1_I1344_G17_14n XI1_I1344_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I140_XG_MP2 (VDD I1_I1344_G15_12n I1_I1344_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I140_XG_MP0 (XI1_I1344_I140_XG_p1 I1_I1344_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I140_XG_MP1 (I1_I1344_G15_8 I1_I1344_G11_8n XI1_I1344_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I186_XG_MP2 (VDD I1_I1344_G19_4n I1_I1344_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I186_XG_MP0 (XI1_I1344_I186_XG_p1 I1_I1344_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I186_XG_MP1 (I1_I1344_G19_0 I1_I1344_G3_0n XI1_I1344_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I136_XG_MP2 (VDD I1_I1344_G11_8n I1_I1344_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I136_XG_MP0 (XI1_I1344_I136_XG_p1 I1_I1344_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I136_XG_MP1 (I1_I1344_G11_4 I1_I1344_G7_4n XI1_I1344_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I132_XG_MP2 (VDD I1_I1344_G7_4n I1_I1344_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I132_XG_MP0 (XI1_I1344_I132_XG_p1 I1_I1344_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I132_XG_MP1 (I1_I1344_G7_0 I1_I1344_G3_0n XI1_I1344_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I194_XG_MP2 (VDD I1_I1298_G23_8n I1_I1298_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I194_XG_MP0 (XI1_I1298_I194_XG_p1 I1_I1298_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I194_XG_MP1 (I1_I1298_G23_0 I1_I1298_G7_0n XI1_I1298_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I148_XG_MP2 (VDD I1_I1298_G23_20n I1_I1298_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I148_XG_MP0 (XI1_I1298_I148_XG_p1 I1_I1298_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I148_XG_MP1 (I1_I1298_G23_16 I1_I1298_G19_16n XI1_I1298_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I196_XG_MP2 (VDD I1_I1298_G25_10n I1_I1298_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I196_XG_MP0 (XI1_I1298_I196_XG_p1 I1_I1298_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I196_XG_MP1 (I1_I1298_G25_0 I1_I1298_G9_0n XI1_I1298_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I150_XG_MP2 (VDD I1_I1298_G25_22n I1_I1298_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I150_XG_MP0 (XI1_I1298_I150_XG_p1 I1_I1298_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I150_XG_MP1 (I1_I1298_G25_18 I1_I1298_G21_18n XI1_I1298_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I199_XG_MP2 (VDD I1_I1298_G28_13n I1_I1298_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I199_XG_MP0 (XI1_I1298_I199_XG_p1 I1_I1298_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I199_XG_MP1 (I1_I1298_G28_0 I1_I1298_G12_0n XI1_I1298_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I153_XG_MP2 (VDD I1_I1298_G28_25n I1_I1298_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I153_XG_MP0 (XI1_I1298_I153_XG_p1 I1_I1298_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I153_XG_MP1 (I1_I1298_G28_21 I1_I1298_G24_21n XI1_I1298_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I88_XG_MP2 (VDD I1_I1298_gn22 I1_I1298_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I88_XG_MP0 (XI1_I1298_I88_XG_p1 I1_I1298_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I88_XG_MP1 (I1_I1298_G22_21 I1_I1298_gn21 XI1_I1298_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I89_XG_MP2 (VDD I1_I1298_gn23 I1_I1298_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I89_XG_MP0 (XI1_I1298_I89_XG_p1 I1_I1298_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I89_XG_MP1 (I1_I1298_G23_22 I1_I1298_gn22 XI1_I1298_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I197_XG_MP2 (VDD I1_I1252_G26_11n I1_I1252_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I197_XG_MP0 (XI1_I1252_I197_XG_p1 I1_I1252_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I197_XG_MP1 (I1_I1252_G26_0 I1_I1252_G10_0n XI1_I1252_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I151_XG_MP2 (VDD I1_I1252_G26_23n I1_I1252_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I151_XG_MP0 (XI1_I1252_I151_XG_p1 I1_I1252_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I151_XG_MP1 (I1_I1252_G26_19 I1_I1252_G22_19n XI1_I1252_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I194_XG_MP2 (VDD I1_I1252_G23_8n I1_I1252_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I194_XG_MP0 (XI1_I1252_I194_XG_p1 I1_I1252_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I194_XG_MP1 (I1_I1252_G23_0 I1_I1252_G7_0n XI1_I1252_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I152_XG_MP2 (VDD I1_I1252_G27_24n I1_I1252_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I152_XG_MP0 (XI1_I1252_I152_XG_p1 I1_I1252_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I152_XG_MP1 (I1_I1252_G27_20 I1_I1252_G23_20n XI1_I1252_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I148_XG_MP2 (VDD I1_I1252_G23_20n I1_I1252_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I148_XG_MP0 (XI1_I1252_I148_XG_p1 I1_I1252_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I148_XG_MP1 (I1_I1252_G23_16 I1_I1252_G19_16n XI1_I1252_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I89_XG_MP2 (VDD I1_I1252_gn23 I1_I1252_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I89_XG_MP0 (XI1_I1252_I89_XG_p1 I1_I1252_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I89_XG_MP1 (I1_I1252_G23_22 I1_I1252_gn22 XI1_I1252_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I89_XG_MP2 (VDD I1_I1206_gn23 I1_I1206_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I89_XG_MP0 (XI1_I1206_I89_XG_p1 I1_I1206_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I89_XG_MP1 (I1_I1206_G23_22 I1_I1206_gn22 XI1_I1206_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I152_XG_MP2 (VDD I1_I1206_G27_24n I1_I1206_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I152_XG_MP0 (XI1_I1206_I152_XG_p1 I1_I1206_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I152_XG_MP1 (I1_I1206_G27_20 I1_I1206_G23_20n XI1_I1206_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I154_XG_MP2 (VDD I1_I1206_G29_26n I1_I1206_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I154_XG_MP0 (XI1_I1206_I154_XG_p1 I1_I1206_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I154_XG_MP1 (I1_I1206_G29_22 I1_I1206_G25_22n XI1_I1206_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I201_XG_MP2 (VDD I1_I1206_G30_15n I1_c14_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I201_XG_MP0 (XI1_I1206_I201_XG_p1 I1_I1206_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I201_XG_MP1 (I1_c14_m I1_I1206_G14_0n XI1_I1206_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I153_XG_MP2 (VDD I1_I1206_G28_25n I1_I1206_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I153_XG_MP0 (XI1_I1206_I153_XG_p1 I1_I1206_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I153_XG_MP1 (I1_I1206_G28_21 I1_I1206_G24_21n XI1_I1206_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I155_XG_MP2 (VDD I1_I838_G30_27n I1_I838_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I155_XG_MP0 (XI1_I838_I155_XG_p1 I1_I838_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I155_XG_MP1 (I1_I838_G30_23 I1_I838_G26_23n XI1_I838_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I151_XG_MP2 (VDD I1_I838_G26_23n I1_I838_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I151_XG_MP0 (XI1_I838_I151_XG_p1 I1_I838_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I151_XG_MP1 (I1_I838_G26_19 I1_I838_G22_19n XI1_I838_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I84_XG_MP2 (VDD I1_I838_gn18 I1_I838_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I84_XG_MP0 (XI1_I838_I84_XG_p1 I1_I838_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I84_XG_MP1 (I1_I838_G18_17 I1_I838_gn17 XI1_I838_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I80_XG_MP2 (VDD I1_I838_gn14 I1_I838_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I80_XG_MP0 (XI1_I838_I80_XG_p1 I1_I838_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I80_XG_MP1 (I1_I838_G14_13 I1_I838_gn13 XI1_I838_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I79_XG_MP2 (VDD I1_I838_gn13 I1_I838_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I79_XG_MP0 (XI1_I838_I79_XG_p1 I1_I838_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I79_XG_MP1 (I1_I838_G13_12 I1_I838_gn12 XI1_I838_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I142_XG_MP2 (VDD I1_I792_G17_14n I1_I792_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I142_XG_MP0 (XI1_I792_I142_XG_p1 I1_I792_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I142_XG_MP1 (I1_I792_G17_10 I1_I792_G13_10n XI1_I792_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I136_XG_MP2 (VDD I1_I792_G11_8n I1_I792_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I136_XG_MP0 (XI1_I792_I136_XG_p1 I1_I792_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I136_XG_MP1 (I1_I792_G11_4 I1_I792_G7_4n XI1_I792_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I140_XG_MP2 (VDD I1_I792_G15_12n I1_I792_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I140_XG_MP0 (XI1_I792_I140_XG_p1 I1_I792_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I140_XG_MP1 (I1_I792_G15_8 I1_I792_G11_8n XI1_I792_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I188_XG_MP2 (VDD I1_I792_G20_5n I1_I792_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I188_XG_MP0 (XI1_I792_I188_XG_p1 I1_I792_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I188_XG_MP1 (I1_I792_G20_0 I1_I792_G4_0n XI1_I792_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I143_XG_MP2 (VDD I1_I792_G18_15n I1_I792_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I143_XG_MP0 (XI1_I792_I143_XG_p1 I1_I792_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I143_XG_MP1 (I1_I792_G18_11 I1_I792_G14_11n XI1_I792_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I145_XG_MP2 (VDD I1_I792_G20_17n I1_I792_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I145_XG_MP0 (XI1_I792_I145_XG_p1 I1_I792_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I145_XG_MP1 (I1_I792_G20_13 I1_I792_G16_13n XI1_I792_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I85_XG_MP2 (VDD I1_I792_gn19 I1_I792_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I85_XG_MP0 (XI1_I792_I85_XG_p1 I1_I792_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I85_XG_MP1 (I1_I792_G19_18 I1_I792_gn18 XI1_I792_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I86_XG_MP2 (VDD I1_I792_gn20 I1_I792_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I86_XG_MP0 (XI1_I792_I86_XG_p1 I1_I792_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I86_XG_MP1 (I1_I792_G20_19 I1_I792_gn19 XI1_I792_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I192_XG_MP2 (VDD I1_I746_G22_7n I1_I746_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I192_XG_MP0 (XI1_I746_I192_XG_p1 I1_I746_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I192_XG_MP1 (I1_I746_G22_0 I1_I746_G6_0n XI1_I746_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I201_XG_MP2 (VDD I1_I746_G30_15n I1_c4_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I201_XG_MP0 (XI1_I746_I201_XG_p1 I1_I746_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I201_XG_MP1 (I1_c4_m I1_I746_G14_0n XI1_I746_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I155_XG_MP2 (VDD I1_I746_G30_27n I1_I746_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I155_XG_MP0 (XI1_I746_I155_XG_p1 I1_I746_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I155_XG_MP1 (I1_I746_G30_23 I1_I746_G26_23n XI1_I746_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I92_XG_MP2 (VDD I1_I746_gn26 I1_I746_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I92_XG_MP0 (XI1_I746_I92_XG_p1 I1_I746_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I92_XG_MP1 (I1_I746_G26_25 I1_I746_gn25 XI1_I746_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I93_XG_MP2 (VDD I1_I746_gn27 I1_I746_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I93_XG_MP0 (XI1_I746_I93_XG_p1 I1_I746_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I93_XG_MP1 (I1_I746_G27_26 I1_I746_gn26 XI1_I746_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I87_XG_MP2 (VDD I1_I1344_gn21 I1_I1344_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I87_XG_MP0 (XI1_I1344_I87_XG_p1 I1_I1344_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I87_XG_MP1 (I1_I1344_G21_20 I1_I1344_gn20 XI1_I1344_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I196_XG_MP2 (VDD I1_I1344_G25_10n I1_I1344_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I196_XG_MP0 (XI1_I1344_I196_XG_p1 I1_I1344_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I196_XG_MP1 (I1_I1344_G25_0 I1_I1344_G9_0n XI1_I1344_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I190_XG_MP2 (VDD I1_I1344_G21_6n I1_I1344_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I190_XG_MP0 (XI1_I1344_I190_XG_p1 I1_I1344_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I190_XG_MP1 (I1_I1344_G21_0 I1_I1344_G5_0n XI1_I1344_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I142_XG_MP2 (VDD I1_I1344_G17_14n I1_I1344_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I142_XG_MP0 (XI1_I1344_I142_XG_p1 I1_I1344_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I142_XG_MP1 (I1_I1344_G17_10 I1_I1344_G13_10n XI1_I1344_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I138_XG_MP2 (VDD I1_I1344_G13_10n I1_I1344_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I138_XG_MP0 (XI1_I1344_I138_XG_p1 I1_I1344_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I138_XG_MP1 (I1_I1344_G13_6 I1_I1344_G9_6n XI1_I1344_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I190_XG_MP2 (VDD I1_I1298_G21_6n I1_I1298_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I190_XG_MP0 (XI1_I1298_I190_XG_p1 I1_I1298_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I190_XG_MP1 (I1_I1298_G21_0 I1_I1298_G5_0n XI1_I1298_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I146_XG_MP2 (VDD I1_I1298_G21_18n I1_I1298_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I146_XG_MP0 (XI1_I1298_I146_XG_p1 I1_I1298_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I146_XG_MP1 (I1_I1298_G21_14 I1_I1298_G17_14n XI1_I1298_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I197_XG_MP2 (VDD I1_I1298_G26_11n I1_I1298_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I197_XG_MP0 (XI1_I1298_I197_XG_p1 I1_I1298_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I197_XG_MP1 (I1_I1298_G26_0 I1_I1298_G10_0n XI1_I1298_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I192_XG_MP2 (VDD I1_I1298_G22_7n I1_I1298_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I192_XG_MP0 (XI1_I1298_I192_XG_p1 I1_I1298_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I192_XG_MP1 (I1_I1298_G22_0 I1_I1298_G6_0n XI1_I1298_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I147_XG_MP2 (VDD I1_I1298_G22_19n I1_I1298_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I147_XG_MP0 (XI1_I1298_I147_XG_p1 I1_I1298_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I147_XG_MP1 (I1_I1298_G22_15 I1_I1298_G18_15n XI1_I1298_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I151_XG_MP2 (VDD I1_I1298_G26_23n I1_I1298_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I151_XG_MP0 (XI1_I1298_I151_XG_p1 I1_I1298_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I151_XG_MP1 (I1_I1298_G26_19 I1_I1298_G22_19n XI1_I1298_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I87_XG_MP2 (VDD I1_I1298_gn21 I1_I1298_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I87_XG_MP0 (XI1_I1298_I87_XG_p1 I1_I1298_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I87_XG_MP1 (I1_I1298_G21_20 I1_I1298_gn20 XI1_I1298_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I192_XG_MP2 (VDD I1_I1252_G22_7n I1_I1252_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I192_XG_MP0 (XI1_I1252_I192_XG_p1 I1_I1252_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I192_XG_MP1 (I1_I1252_G22_0 I1_I1252_G6_0n XI1_I1252_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I147_XG_MP2 (VDD I1_I1252_G22_19n I1_I1252_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I147_XG_MP0 (XI1_I1252_I147_XG_p1 I1_I1252_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I147_XG_MP1 (I1_I1252_G22_15 I1_I1252_G18_15n XI1_I1252_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I198_XG_MP2 (VDD I1_I1252_G27_12n I1_I1252_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I198_XG_MP0 (XI1_I1252_I198_XG_p1 I1_I1252_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I198_XG_MP1 (I1_I1252_G27_0 I1_I1252_G11_0n XI1_I1252_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I150_XG_MP2 (VDD I1_I1252_G25_22n I1_I1252_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I150_XG_MP0 (XI1_I1252_I150_XG_p1 I1_I1252_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I150_XG_MP1 (I1_I1252_G25_18 I1_I1252_G21_18n XI1_I1252_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I87_XG_MP2 (VDD I1_I1252_gn21 I1_I1252_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I87_XG_MP0 (XI1_I1252_I87_XG_p1 I1_I1252_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I87_XG_MP1 (I1_I1252_G21_20 I1_I1252_gn20 XI1_I1252_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I88_XG_MP2 (VDD I1_I1252_gn22 I1_I1252_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I88_XG_MP0 (XI1_I1252_I88_XG_p1 I1_I1252_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I88_XG_MP1 (I1_I1252_G22_21 I1_I1252_gn21 XI1_I1252_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I87_XG_MP2 (VDD I1_I1206_gn21 I1_I1206_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I87_XG_MP0 (XI1_I1206_I87_XG_p1 I1_I1206_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I87_XG_MP1 (I1_I1206_G21_20 I1_I1206_gn20 XI1_I1206_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I88_XG_MP2 (VDD I1_I1206_gn22 I1_I1206_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I88_XG_MP0 (XI1_I1206_I88_XG_p1 I1_I1206_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I88_XG_MP1 (I1_I1206_G22_21 I1_I1206_gn21 XI1_I1206_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I198_XG_MP2 (VDD I1_I1206_G27_12n I1_I1206_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I198_XG_MP0 (XI1_I1206_I198_XG_p1 I1_I1206_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I198_XG_MP1 (I1_I1206_G27_0 I1_I1206_G11_0n XI1_I1206_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I200_XG_MP2 (VDD I1_I1206_G29_14n I1_I1206_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I200_XG_MP0 (XI1_I1206_I200_XG_p1 I1_I1206_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I200_XG_MP1 (I1_I1206_G29_0 I1_I1206_G13_0n XI1_I1206_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I147_XG_MP2 (VDD I1_I1206_G22_19n I1_I1206_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I147_XG_MP0 (XI1_I1206_I147_XG_p1 I1_I1206_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I147_XG_MP1 (I1_I1206_G22_15 I1_I1206_G18_15n XI1_I1206_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I151_XG_MP2 (VDD I1_I1206_G26_23n I1_I1206_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I151_XG_MP0 (XI1_I1206_I151_XG_p1 I1_I1206_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I151_XG_MP1 (I1_I1206_G26_19 I1_I1206_G22_19n XI1_I1206_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I199_XG_MP2 (VDD I1_I1206_G28_13n I1_I1206_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I199_XG_MP0 (XI1_I1206_I199_XG_p1 I1_I1206_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I199_XG_MP1 (I1_I1206_G28_0 I1_I1206_G12_0n XI1_I1206_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I153_XG_MP2 (VDD I1_I838_G28_25n I1_I838_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I153_XG_MP0 (XI1_I838_I153_XG_p1 I1_I838_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I153_XG_MP1 (I1_I838_G28_21 I1_I838_G24_21n XI1_I838_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I147_XG_MP2 (VDD I1_I838_G22_19n I1_I838_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I147_XG_MP0 (XI1_I838_I147_XG_p1 I1_I838_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I147_XG_MP1 (I1_I838_G22_15 I1_I838_G18_15n XI1_I838_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I149_XG_MP2 (VDD I1_I838_G24_21n I1_I838_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I149_XG_MP0 (XI1_I838_I149_XG_p1 I1_I838_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I149_XG_MP1 (I1_I838_G24_17 I1_I838_G20_17n XI1_I838_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I145_XG_MP2 (VDD I1_I838_G20_17n I1_I838_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I145_XG_MP0 (XI1_I838_I145_XG_p1 I1_I838_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I145_XG_MP1 (I1_I838_G20_13 I1_I838_G16_13n XI1_I838_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I143_XG_MP2 (VDD I1_I838_G18_15n I1_I838_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I143_XG_MP0 (XI1_I838_I143_XG_p1 I1_I838_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I143_XG_MP1 (I1_I838_G18_11 I1_I838_G14_11n XI1_I838_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I139_XG_MP2 (VDD I1_I838_G14_11n I1_I838_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I139_XG_MP0 (XI1_I838_I139_XG_p1 I1_I838_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I139_XG_MP1 (I1_I838_G14_7 I1_I838_G10_7n XI1_I838_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I78_XG_MP2 (VDD I1_I838_gn12 I1_I838_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I78_XG_MP0 (XI1_I838_I78_XG_p1 I1_I838_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I78_XG_MP1 (I1_I838_G12_11 I1_I838_gn11 XI1_I838_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I77_XG_MP2 (VDD I1_I838_gn11 I1_I838_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I77_XG_MP0 (XI1_I838_I77_XG_p1 I1_I838_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I77_XG_MP1 (I1_I838_G11_10 I1_I838_gn10 XI1_I838_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I76_XG_MP2 (VDD I1_I838_gn10 I1_I838_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I76_XG_MP0 (XI1_I838_I76_XG_p1 I1_I838_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I76_XG_MP1 (I1_I838_G10_9 I1_I838_gn9 XI1_I838_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I75_XG_MP2 (VDD I1_I838_gn9 I1_I838_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I75_XG_MP0 (XI1_I838_I75_XG_p1 I1_I838_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I75_XG_MP1 (I1_I838_G9_8 I1_I838_gn8 XI1_I838_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I138_XG_MP2 (VDD I1_I792_G13_10n I1_I792_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I138_XG_MP0 (XI1_I792_I138_XG_p1 I1_I792_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I138_XG_MP1 (I1_I792_G13_6 I1_I792_G9_6n XI1_I792_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I132_XG_MP2 (VDD I1_I792_G7_4n I1_I792_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I132_XG_MP0 (XI1_I792_I132_XG_p1 I1_I792_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I132_XG_MP1 (I1_I792_G7_0 I1_I792_G3_0n XI1_I792_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I185_XG_MP2 (VDD I1_I792_G18_3n I1_I792_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I185_XG_MP0 (XI1_I792_I185_XG_p1 I1_I792_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I185_XG_MP1 (I1_I792_G18_0 I1_I792_G2_0n XI1_I792_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I195_XG_MP2 (VDD I1_I792_G24_9n I1_I792_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I195_XG_MP0 (XI1_I792_I195_XG_p1 I1_I792_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I195_XG_MP1 (I1_I792_G24_0 I1_I792_G8_0n XI1_I792_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I82_XG_MP2 (VDD I1_I792_gn16 I1_I792_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I82_XG_MP0 (XI1_I792_I82_XG_p1 I1_I792_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I82_XG_MP1 (I1_I792_G16_15 I1_I792_gn15 XI1_I792_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I83_XG_MP2 (VDD I1_I792_gn17 I1_I792_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I83_XG_MP0 (XI1_I792_I83_XG_p1 I1_I792_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I83_XG_MP1 (I1_I792_G17_16 I1_I792_gn16 XI1_I792_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I84_XG_MP2 (VDD I1_I792_gn18 I1_I792_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I84_XG_MP0 (XI1_I792_I84_XG_p1 I1_I792_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I84_XG_MP1 (I1_I792_G18_17 I1_I792_gn17 XI1_I792_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I199_XG_MP2 (VDD I1_I746_G28_13n I1_I746_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I199_XG_MP0 (XI1_I746_I199_XG_p1 I1_I746_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I199_XG_MP1 (I1_I746_G28_0 I1_I746_G12_0n XI1_I746_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I197_XG_MP2 (VDD I1_I746_G26_11n I1_I746_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I197_XG_MP0 (XI1_I746_I197_XG_p1 I1_I746_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I197_XG_MP1 (I1_I746_G26_0 I1_I746_G10_0n XI1_I746_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I147_XG_MP2 (VDD I1_I746_G22_19n I1_I746_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I147_XG_MP0 (XI1_I746_I147_XG_p1 I1_I746_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I147_XG_MP1 (I1_I746_G22_15 I1_I746_G18_15n XI1_I746_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I151_XG_MP2 (VDD I1_I746_G26_23n I1_I746_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I151_XG_MP0 (XI1_I746_I151_XG_p1 I1_I746_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I151_XG_MP1 (I1_I746_G26_19 I1_I746_G22_19n XI1_I746_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I153_XG_MP2 (VDD I1_I746_G28_25n I1_I746_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I153_XG_MP0 (XI1_I746_I153_XG_p1 I1_I746_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I153_XG_MP1 (I1_I746_G28_21 I1_I746_G24_21n XI1_I746_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I94_XG_MP2 (VDD I1_I746_gn28 I1_I746_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I94_XG_MP0 (XI1_I746_I94_XG_p1 I1_I746_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I94_XG_MP1 (I1_I746_G28_27 I1_I746_gn27 XI1_I746_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I155_XG_MP2 (VDD I1_I1344_G30_27n I1_I1344_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I155_XG_MP0 (XI1_I1344_I155_XG_p1 I1_I1344_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I155_XG_MP1 (I1_I1344_G30_23 I1_I1344_G26_23n XI1_I1344_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I88_XG_MP2 (VDD I1_I1344_gn22 I1_I1344_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I88_XG_MP0 (XI1_I1344_I88_XG_p1 I1_I1344_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I88_XG_MP1 (I1_I1344_G22_21 I1_I1344_gn21 XI1_I1344_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I85_XG_MP2 (VDD I1_I1344_gn19 I1_I1344_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I85_XG_MP0 (XI1_I1344_I85_XG_p1 I1_I1344_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I85_XG_MP1 (I1_I1344_G19_18 I1_I1344_gn18 XI1_I1344_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I84_XG_MP2 (VDD I1_I1344_gn18 I1_I1344_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I84_XG_MP0 (XI1_I1344_I84_XG_p1 I1_I1344_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I84_XG_MP1 (I1_I1344_G18_17 I1_I1344_gn17 XI1_I1344_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I83_XG_MP2 (VDD I1_I1344_gn17 I1_I1344_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I83_XG_MP0 (XI1_I1344_I83_XG_p1 I1_I1344_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I83_XG_MP1 (I1_I1344_G17_16 I1_I1344_gn16 XI1_I1344_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I134_XG_MP2 (VDD I1_I1344_G9_6n I1_I1344_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I134_XG_MP0 (XI1_I1344_I134_XG_p1 I1_I1344_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I134_XG_MP1 (I1_I1344_G9_2 I1_I1344_G5_2n XI1_I1344_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I186_XG_MP2 (VDD I1_I1298_G19_4n I1_I1298_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I186_XG_MP0 (XI1_I1298_I186_XG_p1 I1_I1298_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I186_XG_MP1 (I1_I1298_G19_0 I1_I1298_G3_0n XI1_I1298_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I144_XG_MP2 (VDD I1_I1298_G19_16n I1_I1298_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I144_XG_MP0 (XI1_I1298_I144_XG_p1 I1_I1298_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I144_XG_MP1 (I1_I1298_G19_12 I1_I1298_G15_12n XI1_I1298_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I188_XG_MP2 (VDD I1_I1298_G20_5n I1_I1298_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I188_XG_MP0 (XI1_I1298_I188_XG_p1 I1_I1298_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I188_XG_MP1 (I1_I1298_G20_0 I1_I1298_G4_0n XI1_I1298_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I149_XG_MP2 (VDD I1_I1298_G24_21n I1_I1298_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I149_XG_MP0 (XI1_I1298_I149_XG_p1 I1_I1298_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I149_XG_MP1 (I1_I1298_G24_17 I1_I1298_G20_17n XI1_I1298_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I85_XG_MP2 (VDD I1_I1298_gn19 I1_I1298_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I85_XG_MP0 (XI1_I1298_I85_XG_p1 I1_I1298_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I85_XG_MP1 (I1_I1298_G19_18 I1_I1298_gn18 XI1_I1298_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I86_XG_MP2 (VDD I1_I1298_gn20 I1_I1298_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I86_XG_MP0 (XI1_I1298_I86_XG_p1 I1_I1298_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I86_XG_MP1 (I1_I1298_G20_19 I1_I1298_gn19 XI1_I1298_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I195_XG_MP2 (VDD I1_I1252_G24_9n I1_I1252_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I195_XG_MP0 (XI1_I1252_I195_XG_p1 I1_I1252_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I195_XG_MP1 (I1_I1252_G24_0 I1_I1252_G8_0n XI1_I1252_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I149_XG_MP2 (VDD I1_I1252_G24_21n I1_I1252_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I149_XG_MP0 (XI1_I1252_I149_XG_p1 I1_I1252_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I149_XG_MP1 (I1_I1252_G24_17 I1_I1252_G20_17n XI1_I1252_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I190_XG_MP2 (VDD I1_I1252_G21_6n I1_I1252_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I190_XG_MP0 (XI1_I1252_I190_XG_p1 I1_I1252_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I190_XG_MP1 (I1_I1252_G21_0 I1_I1252_G5_0n XI1_I1252_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I144_XG_MP2 (VDD I1_I1252_G19_16n I1_I1252_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I144_XG_MP0 (XI1_I1252_I144_XG_p1 I1_I1252_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I144_XG_MP1 (I1_I1252_G19_12 I1_I1252_G15_12n XI1_I1252_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I146_XG_MP2 (VDD I1_I1252_G21_18n I1_I1252_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I146_XG_MP0 (XI1_I1252_I146_XG_p1 I1_I1252_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I146_XG_MP1 (I1_I1252_G21_14 I1_I1252_G17_14n XI1_I1252_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I85_XG_MP2 (VDD I1_I1252_gn19 I1_I1252_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I85_XG_MP0 (XI1_I1252_I85_XG_p1 I1_I1252_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I85_XG_MP1 (I1_I1252_G19_18 I1_I1252_gn18 XI1_I1252_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I86_XG_MP2 (VDD I1_I1252_gn20 I1_I1252_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I86_XG_MP0 (XI1_I1252_I86_XG_p1 I1_I1252_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I86_XG_MP1 (I1_I1252_G20_19 I1_I1252_gn19 XI1_I1252_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I86_XG_MP2 (VDD I1_I1206_gn20 I1_I1206_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I86_XG_MP0 (XI1_I1206_I86_XG_p1 I1_I1206_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I86_XG_MP1 (I1_I1206_G20_19 I1_I1206_gn19 XI1_I1206_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I148_XG_MP2 (VDD I1_I1206_G23_20n I1_I1206_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I148_XG_MP0 (XI1_I1206_I148_XG_p1 I1_I1206_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I148_XG_MP1 (I1_I1206_G23_16 I1_I1206_G19_16n XI1_I1206_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I194_XG_MP2 (VDD I1_I1206_G23_8n I1_I1206_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I194_XG_MP0 (XI1_I1206_I194_XG_p1 I1_I1206_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I194_XG_MP1 (I1_I1206_G23_0 I1_I1206_G7_0n XI1_I1206_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I150_XG_MP2 (VDD I1_I1206_G25_22n I1_I1206_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I150_XG_MP0 (XI1_I1206_I150_XG_p1 I1_I1206_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I150_XG_MP1 (I1_I1206_G25_18 I1_I1206_G21_18n XI1_I1206_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I192_XG_MP2 (VDD I1_I1206_G22_7n I1_I1206_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I192_XG_MP0 (XI1_I1206_I192_XG_p1 I1_I1206_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I192_XG_MP1 (I1_I1206_G22_0 I1_I1206_G6_0n XI1_I1206_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I197_XG_MP2 (VDD I1_I1206_G26_11n I1_I1206_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I197_XG_MP0 (XI1_I1206_I197_XG_p1 I1_I1206_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I197_XG_MP1 (I1_I1206_G26_0 I1_I1206_G10_0n XI1_I1206_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I145_XG_MP2 (VDD I1_I1206_G20_17n I1_I1206_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I145_XG_MP0 (XI1_I1206_I145_XG_p1 I1_I1206_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I145_XG_MP1 (I1_I1206_G20_13 I1_I1206_G16_13n XI1_I1206_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I149_XG_MP2 (VDD I1_I1206_G24_21n I1_I1206_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I149_XG_MP0 (XI1_I1206_I149_XG_p1 I1_I1206_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I149_XG_MP1 (I1_I1206_G24_17 I1_I1206_G20_17n XI1_I1206_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I201_XG_MP2 (VDD I1_I838_G30_15n I1_c6_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I201_XG_MP0 (XI1_I838_I201_XG_p1 I1_I838_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I201_XG_MP1 (I1_c6_m I1_I838_G14_0n XI1_I838_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I199_XG_MP2 (VDD I1_I838_G28_13n I1_I838_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I199_XG_MP0 (XI1_I838_I199_XG_p1 I1_I838_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I199_XG_MP1 (I1_I838_G28_0 I1_I838_G12_0n XI1_I838_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I197_XG_MP2 (VDD I1_I838_G26_11n I1_I838_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I197_XG_MP0 (XI1_I838_I197_XG_p1 I1_I838_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I197_XG_MP1 (I1_I838_G26_0 I1_I838_G10_0n XI1_I838_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I192_XG_MP2 (VDD I1_I838_G22_7n I1_I838_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I192_XG_MP0 (XI1_I838_I192_XG_p1 I1_I838_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I192_XG_MP1 (I1_I838_G22_0 I1_I838_G6_0n XI1_I838_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I195_XG_MP2 (VDD I1_I838_G24_9n I1_I838_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I195_XG_MP0 (XI1_I838_I195_XG_p1 I1_I838_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I195_XG_MP1 (I1_I838_G24_0 I1_I838_G8_0n XI1_I838_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I141_XG_MP2 (VDD I1_I838_G16_13n I1_I838_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I141_XG_MP0 (XI1_I838_I141_XG_p1 I1_I838_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I141_XG_MP1 (I1_I838_G16_9 I1_I838_G12_9n XI1_I838_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I185_XG_MP2 (VDD I1_I838_G18_3n I1_I838_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I185_XG_MP0 (XI1_I838_I185_XG_p1 I1_I838_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I185_XG_MP1 (I1_I838_G18_0 I1_I838_G2_0n XI1_I838_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I135_XG_MP2 (VDD I1_I838_G10_7n I1_I838_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I135_XG_MP0 (XI1_I838_I135_XG_p1 I1_I838_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I135_XG_MP1 (I1_I838_G10_3 I1_I838_G6_3n XI1_I838_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I74_XG_MP2 (VDD I1_I838_gn8 I1_I838_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I74_XG_MP0 (XI1_I838_I74_XG_p1 I1_I838_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I74_XG_MP1 (I1_I838_G8_7 I1_I838_gn7 XI1_I838_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I184_XG_MP2 (VDD I1_I792_G17_2n I1_I792_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I184_XG_MP0 (XI1_I792_I184_XG_p1 I1_I792_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I184_XG_MP1 (I1_I792_G17_0 I1_I792_G1_0n XI1_I792_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I134_XG_MP2 (VDD I1_I792_G9_6n I1_I792_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I134_XG_MP0 (XI1_I792_I134_XG_p1 I1_I792_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I134_XG_MP1 (I1_I792_G9_2 I1_I792_G5_2n XI1_I792_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I131_XG_MP2 (VDD I1_I792_G6_3n I1_I792_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I131_XG_MP0 (XI1_I792_I131_XG_p1 I1_I792_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I131_XG_MP1 (I1_I792_G6_0 I1_I792_G2_0n XI1_I792_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I135_XG_MP2 (VDD I1_I792_G10_7n I1_I792_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I135_XG_MP0 (XI1_I792_I135_XG_p1 I1_I792_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I135_XG_MP1 (I1_I792_G10_3 I1_I792_G6_3n XI1_I792_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I137_XG_MP2 (VDD I1_I792_G12_9n I1_I792_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I137_XG_MP0 (XI1_I792_I137_XG_p1 I1_I792_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I137_XG_MP1 (I1_I792_G12_5 I1_I792_G8_5n XI1_I792_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I141_XG_MP2 (VDD I1_I792_G16_13n I1_I792_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I141_XG_MP0 (XI1_I792_I141_XG_p1 I1_I792_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I141_XG_MP1 (I1_I792_G16_9 I1_I792_G12_9n XI1_I792_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I139_XG_MP2 (VDD I1_I792_G14_11n I1_I792_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I139_XG_MP0 (XI1_I792_I139_XG_p1 I1_I792_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I139_XG_MP1 (I1_I792_G14_7 I1_I792_G10_7n XI1_I792_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I81_XG_MP2 (VDD I1_I792_gn15 I1_I792_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I81_XG_MP0 (XI1_I792_I81_XG_p1 I1_I792_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I81_XG_MP1 (I1_I792_G15_14 I1_I792_gn14 XI1_I792_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I185_XG_MP2 (VDD I1_I746_G18_3n I1_I746_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I185_XG_MP0 (XI1_I746_I185_XG_p1 I1_I746_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I185_XG_MP1 (I1_I746_G18_0 I1_I746_G2_0n XI1_I746_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I195_XG_MP2 (VDD I1_I746_G24_9n I1_I746_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I195_XG_MP0 (XI1_I746_I195_XG_p1 I1_I746_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I195_XG_MP1 (I1_I746_G24_0 I1_I746_G8_0n XI1_I746_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I188_XG_MP2 (VDD I1_I746_G20_5n I1_I746_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I188_XG_MP0 (XI1_I746_I188_XG_p1 I1_I746_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I188_XG_MP1 (I1_I746_G20_0 I1_I746_G4_0n XI1_I746_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I139_XG_MP2 (VDD I1_I746_G14_11n I1_I746_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I139_XG_MP0 (XI1_I746_I139_XG_p1 I1_I746_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I139_XG_MP1 (I1_I746_G14_7 I1_I746_G10_7n XI1_I746_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I145_XG_MP2 (VDD I1_I746_G20_17n I1_I746_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I145_XG_MP0 (XI1_I746_I145_XG_p1 I1_I746_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I145_XG_MP1 (I1_I746_G20_13 I1_I746_G16_13n XI1_I746_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I143_XG_MP2 (VDD I1_I746_G18_15n I1_I746_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I143_XG_MP0 (XI1_I746_I143_XG_p1 I1_I746_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I143_XG_MP1 (I1_I746_G18_11 I1_I746_G14_11n XI1_I746_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I149_XG_MP2 (VDD I1_I746_G24_21n I1_I746_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I149_XG_MP0 (XI1_I746_I149_XG_p1 I1_I746_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I149_XG_MP1 (I1_I746_G24_17 I1_I746_G20_17n XI1_I746_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I90_XG_MP2 (VDD I1_I746_gn24 I1_I746_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I90_XG_MP0 (XI1_I746_I90_XG_p1 I1_I746_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I90_XG_MP1 (I1_I746_G24_23 I1_I746_gn23 XI1_I746_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I91_XG_MP2 (VDD I1_I746_gn25 I1_I746_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I91_XG_MP0 (XI1_I746_I91_XG_p1 I1_I746_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I91_XG_MP1 (I1_I746_G25_24 I1_I746_gn24 XI1_I746_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I95_XG_MP2 (VDD I1_I746_gn29 I1_I746_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I95_XG_MP0 (XI1_I746_I95_XG_p1 I1_I746_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I95_XG_MP1 (I1_I746_G29_28 I1_I746_gn28 XI1_I746_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I96_XG_MP2 (VDD I1_I746_gn30 I1_I746_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I96_XG_MP0 (XI1_I746_I96_XG_p1 I1_I746_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I96_XG_MP1 (I1_I746_G30_29 I1_I746_gn29 XI1_I746_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I147_XG_MP2 (VDD I1_I1344_G22_19n I1_I1344_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I147_XG_MP0 (XI1_I1344_I147_XG_p1 I1_I1344_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I147_XG_MP1 (I1_I1344_G22_15 I1_I1344_G18_15n XI1_I1344_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I86_XG_MP2 (VDD I1_I1344_gn20 I1_I1344_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I86_XG_MP0 (XI1_I1344_I86_XG_p1 I1_I1344_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I86_XG_MP1 (I1_I1344_G20_19 I1_I1344_gn19 XI1_I1344_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I82_XG_MP2 (VDD I1_I1344_gn16 I1_I1344_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I82_XG_MP0 (XI1_I1344_I82_XG_p1 I1_I1344_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I82_XG_MP1 (I1_I1344_G16_15 I1_I1344_gn15 XI1_I1344_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I81_XG_MP2 (VDD I1_I1344_gn15 I1_I1344_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I81_XG_MP0 (XI1_I1344_I81_XG_p1 I1_I1344_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I81_XG_MP1 (I1_I1344_G15_14 I1_I1344_gn14 XI1_I1344_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I184_XG_MP2 (VDD I1_I1344_G17_2n I1_I1344_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I184_XG_MP0 (XI1_I1344_I184_XG_p1 I1_I1344_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I184_XG_MP1 (I1_I1344_G17_0 I1_I1344_G1_0n XI1_I1344_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I130_XG_MP2 (VDD I1_I1344_G5_2n I1_I1344_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I130_XG_MP0 (XI1_I1344_I130_XG_p1 I1_I1344_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I130_XG_MP1 (I1_I1344_G5_0 I1_I1344_G1_0n XI1_I1344_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I140_XG_MP2 (VDD I1_I1298_G15_12n I1_I1298_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I140_XG_MP0 (XI1_I1298_I140_XG_p1 I1_I1298_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I140_XG_MP1 (I1_I1298_G15_8 I1_I1298_G11_8n XI1_I1298_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I142_XG_MP2 (VDD I1_I1298_G17_14n I1_I1298_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I142_XG_MP0 (XI1_I1298_I142_XG_p1 I1_I1298_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I142_XG_MP1 (I1_I1298_G17_10 I1_I1298_G13_10n XI1_I1298_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I143_XG_MP2 (VDD I1_I1298_G18_15n I1_I1298_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I143_XG_MP0 (XI1_I1298_I143_XG_p1 I1_I1298_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I143_XG_MP1 (I1_I1298_G18_11 I1_I1298_G14_11n XI1_I1298_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I145_XG_MP2 (VDD I1_I1298_G20_17n I1_I1298_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I145_XG_MP0 (XI1_I1298_I145_XG_p1 I1_I1298_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I145_XG_MP1 (I1_I1298_G20_13 I1_I1298_G16_13n XI1_I1298_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I84_XG_MP2 (VDD I1_I1298_gn18 I1_I1298_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I84_XG_MP0 (XI1_I1298_I84_XG_p1 I1_I1298_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I84_XG_MP1 (I1_I1298_G18_17 I1_I1298_gn17 XI1_I1298_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I83_XG_MP2 (VDD I1_I1298_gn17 I1_I1298_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I83_XG_MP0 (XI1_I1298_I83_XG_p1 I1_I1298_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I83_XG_MP1 (I1_I1298_G17_16 I1_I1298_gn16 XI1_I1298_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I188_XG_MP2 (VDD I1_I1252_G20_5n I1_I1252_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I188_XG_MP0 (XI1_I1252_I188_XG_p1 I1_I1252_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I188_XG_MP1 (I1_I1252_G20_0 I1_I1252_G4_0n XI1_I1252_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I143_XG_MP2 (VDD I1_I1252_G18_15n I1_I1252_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I143_XG_MP0 (XI1_I1252_I143_XG_p1 I1_I1252_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I143_XG_MP1 (I1_I1252_G18_11 I1_I1252_G14_11n XI1_I1252_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I145_XG_MP2 (VDD I1_I1252_G20_17n I1_I1252_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I145_XG_MP0 (XI1_I1252_I145_XG_p1 I1_I1252_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I145_XG_MP1 (I1_I1252_G20_13 I1_I1252_G16_13n XI1_I1252_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I196_XG_MP2 (VDD I1_I1252_G25_10n I1_I1252_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I196_XG_MP0 (XI1_I1252_I196_XG_p1 I1_I1252_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I196_XG_MP1 (I1_I1252_G25_0 I1_I1252_G9_0n XI1_I1252_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I84_XG_MP2 (VDD I1_I1252_gn18 I1_I1252_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I84_XG_MP0 (XI1_I1252_I84_XG_p1 I1_I1252_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I84_XG_MP1 (I1_I1252_G18_17 I1_I1252_gn17 XI1_I1252_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I83_XG_MP2 (VDD I1_I1252_gn17 I1_I1252_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I83_XG_MP0 (XI1_I1252_I83_XG_p1 I1_I1252_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I83_XG_MP1 (I1_I1252_G17_16 I1_I1252_gn16 XI1_I1252_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I84_XG_MP2 (VDD I1_I1206_gn18 I1_I1206_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I84_XG_MP0 (XI1_I1206_I84_XG_p1 I1_I1206_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I84_XG_MP1 (I1_I1206_G18_17 I1_I1206_gn17 XI1_I1206_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I85_XG_MP2 (VDD I1_I1206_gn19 I1_I1206_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I85_XG_MP0 (XI1_I1206_I85_XG_p1 I1_I1206_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I85_XG_MP1 (I1_I1206_G19_18 I1_I1206_gn18 XI1_I1206_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I202_XG_MP2 (VDD I1_I1206_G31_16n I1_c14_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I202_XG_MP0 (XI1_I1206_I202_XG_p1 I1_I1206_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I202_XG_MP1 (I1_c14_o I1_I1206_G15_0n XI1_I1206_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I196_XG_MP2 (VDD I1_I1206_G25_10n I1_I1206_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I196_XG_MP0 (XI1_I1206_I196_XG_p1 I1_I1206_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I196_XG_MP1 (I1_I1206_G25_0 I1_I1206_G9_0n XI1_I1206_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I143_XG_MP2 (VDD I1_I1206_G18_15n I1_I1206_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I143_XG_MP0 (XI1_I1206_I143_XG_p1 I1_I1206_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I143_XG_MP1 (I1_I1206_G18_11 I1_I1206_G14_11n XI1_I1206_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I195_XG_MP2 (VDD I1_I1206_G24_9n I1_I1206_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I195_XG_MP0 (XI1_I1206_I195_XG_p1 I1_I1206_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I195_XG_MP1 (I1_I1206_G24_0 I1_I1206_G8_0n XI1_I1206_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I188_XG_MP2 (VDD I1_I838_G20_5n I1_I838_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I188_XG_MP0 (XI1_I838_I188_XG_p1 I1_I838_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I188_XG_MP1 (I1_I838_G20_0 I1_I838_G4_0n XI1_I838_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I137_XG_MP2 (VDD I1_I838_G12_9n I1_I838_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I137_XG_MP0 (XI1_I838_I137_XG_p1 I1_I838_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I137_XG_MP1 (I1_I838_G12_5 I1_I838_G8_5n XI1_I838_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I133_XG_MP2 (VDD I1_I838_G8_5n I1_I838_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I133_XG_MP0 (XI1_I838_I133_XG_p1 I1_I838_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I133_XG_MP1 (I1_I838_G8_1 I1_I838_G4_1n XI1_I838_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I131_XG_MP2 (VDD I1_I838_G6_3n I1_I838_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I131_XG_MP0 (XI1_I838_I131_XG_p1 I1_I838_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I131_XG_MP1 (I1_I838_G6_0 I1_I838_G2_0n XI1_I838_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I73_XG_MP2 (VDD I1_I838_gn7 I1_I838_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I73_XG_MP0 (XI1_I838_I73_XG_p1 I1_I838_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I73_XG_MP1 (I1_I838_G7_6 I1_I838_gn6 XI1_I838_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I130_XG_MP2 (VDD I1_I792_G5_2n I1_I792_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I130_XG_MP0 (XI1_I792_I130_XG_p1 I1_I792_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I130_XG_MP1 (I1_I792_G5_0 I1_I792_G1_0n XI1_I792_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I183_XG_MP2 (VDD I1_I792_G16_1n I1_I792_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I183_XG_MP0 (XI1_I792_I183_XG_p1 I1_I792_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I183_XG_MP1 (I1_I792_G16_0 I1_I792_G0_0n XI1_I792_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I133_XG_MP2 (VDD I1_I792_G8_5n I1_I792_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I133_XG_MP0 (XI1_I792_I133_XG_p1 I1_I792_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I133_XG_MP1 (I1_I792_G8_1 I1_I792_G4_1n XI1_I792_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I78_XG_MP2 (VDD I1_I792_gn12 I1_I792_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I78_XG_MP0 (XI1_I792_I78_XG_p1 I1_I792_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I78_XG_MP1 (I1_I792_G12_11 I1_I792_gn11 XI1_I792_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I79_XG_MP2 (VDD I1_I792_gn13 I1_I792_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I79_XG_MP0 (XI1_I792_I79_XG_p1 I1_I792_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I79_XG_MP1 (I1_I792_G13_12 I1_I792_gn12 XI1_I792_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I80_XG_MP2 (VDD I1_I792_gn14 I1_I792_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I80_XG_MP0 (XI1_I792_I80_XG_p1 I1_I792_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I80_XG_MP1 (I1_I792_G14_13 I1_I792_gn13 XI1_I792_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I183_XG_MP2 (VDD I1_I746_G16_1n I1_I746_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I183_XG_MP0 (XI1_I746_I183_XG_p1 I1_I746_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I183_XG_MP1 (I1_I746_G16_0 I1_I746_G0_0n XI1_I746_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I135_XG_MP2 (VDD I1_I746_G10_7n I1_I746_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I135_XG_MP0 (XI1_I746_I135_XG_p1 I1_I746_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I135_XG_MP1 (I1_I746_G10_3 I1_I746_G6_3n XI1_I746_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I137_XG_MP2 (VDD I1_I746_G12_9n I1_I746_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I137_XG_MP0 (XI1_I746_I137_XG_p1 I1_I746_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I137_XG_MP1 (I1_I746_G12_5 I1_I746_G8_5n XI1_I746_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I141_XG_MP2 (VDD I1_I746_G16_13n I1_I746_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I141_XG_MP0 (XI1_I746_I141_XG_p1 I1_I746_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I141_XG_MP1 (I1_I746_G16_9 I1_I746_G12_9n XI1_I746_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I190_XG_MP2 (VDD I1_I746_G21_6n I1_I746_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I190_XG_MP0 (XI1_I746_I190_XG_p1 I1_I746_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I190_XG_MP1 (I1_I746_G21_0 I1_I746_G5_0n XI1_I746_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I200_XG_MP2 (VDD I1_I746_G29_14n I1_I746_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I200_XG_MP0 (XI1_I746_I200_XG_p1 I1_I746_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I200_XG_MP1 (I1_I746_G29_0 I1_I746_G13_0n XI1_I746_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I201_XG_MP2 (VDD I1_I1344_G30_15n I1_c17_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I201_XG_MP0 (XI1_I1344_I201_XG_p1 I1_I1344_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I201_XG_MP1 (I1_c17_m I1_I1344_G14_0n XI1_I1344_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I199_XG_MP2 (VDD I1_I1344_G28_13n I1_I1344_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I199_XG_MP0 (XI1_I1344_I199_XG_p1 I1_I1344_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I199_XG_MP1 (I1_I1344_G28_0 I1_I1344_G12_0n XI1_I1344_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I149_XG_MP2 (VDD I1_I1344_G24_21n I1_I1344_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I149_XG_MP0 (XI1_I1344_I149_XG_p1 I1_I1344_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I149_XG_MP1 (I1_I1344_G24_17 I1_I1344_G20_17n XI1_I1344_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I145_XG_MP2 (VDD I1_I1344_G20_17n I1_I1344_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I145_XG_MP0 (XI1_I1344_I145_XG_p1 I1_I1344_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I145_XG_MP1 (I1_I1344_G20_13 I1_I1344_G16_13n XI1_I1344_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I80_XG_MP2 (VDD I1_I1344_gn14 I1_I1344_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I80_XG_MP0 (XI1_I1344_I80_XG_p1 I1_I1344_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I80_XG_MP1 (I1_I1344_G14_13 I1_I1344_gn13 XI1_I1344_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I79_XG_MP2 (VDD I1_I1344_gn13 I1_I1344_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I79_XG_MP0 (XI1_I1344_I79_XG_p1 I1_I1344_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I79_XG_MP1 (I1_I1344_G13_12 I1_I1344_gn12 XI1_I1344_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I136_XG_MP2 (VDD I1_I1298_G11_8n I1_I1298_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I136_XG_MP0 (XI1_I1298_I136_XG_p1 I1_I1298_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I136_XG_MP1 (I1_I1298_G11_4 I1_I1298_G7_4n XI1_I1298_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I138_XG_MP2 (VDD I1_I1298_G13_10n I1_I1298_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I138_XG_MP0 (XI1_I1298_I138_XG_p1 I1_I1298_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I138_XG_MP1 (I1_I1298_G13_6 I1_I1298_G9_6n XI1_I1298_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I139_XG_MP2 (VDD I1_I1298_G14_11n I1_I1298_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I139_XG_MP0 (XI1_I1298_I139_XG_p1 I1_I1298_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I139_XG_MP1 (I1_I1298_G14_7 I1_I1298_G10_7n XI1_I1298_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I82_XG_MP2 (VDD I1_I1298_gn16 I1_I1298_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I82_XG_MP0 (XI1_I1298_I82_XG_p1 I1_I1298_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I82_XG_MP1 (I1_I1298_G16_15 I1_I1298_gn15 XI1_I1298_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I80_XG_MP2 (VDD I1_I1298_gn14 I1_I1298_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I80_XG_MP0 (XI1_I1298_I80_XG_p1 I1_I1298_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I80_XG_MP1 (I1_I1298_G14_13 I1_I1298_gn13 XI1_I1298_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I81_XG_MP2 (VDD I1_I1298_gn15 I1_I1298_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I81_XG_MP0 (XI1_I1298_I81_XG_p1 I1_I1298_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I81_XG_MP1 (I1_I1298_G15_14 I1_I1298_gn14 XI1_I1298_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I185_XG_MP2 (VDD I1_I1252_G18_3n I1_I1252_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I185_XG_MP0 (XI1_I1252_I185_XG_p1 I1_I1252_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I185_XG_MP1 (I1_I1252_G18_0 I1_I1252_G2_0n XI1_I1252_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I139_XG_MP2 (VDD I1_I1252_G14_11n I1_I1252_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I139_XG_MP0 (XI1_I1252_I139_XG_p1 I1_I1252_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I139_XG_MP1 (I1_I1252_G14_7 I1_I1252_G10_7n XI1_I1252_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I186_XG_MP2 (VDD I1_I1252_G19_4n I1_I1252_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I186_XG_MP0 (XI1_I1252_I186_XG_p1 I1_I1252_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I186_XG_MP1 (I1_I1252_G19_0 I1_I1252_G3_0n XI1_I1252_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I140_XG_MP2 (VDD I1_I1252_G15_12n I1_I1252_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I140_XG_MP0 (XI1_I1252_I140_XG_p1 I1_I1252_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I140_XG_MP1 (I1_I1252_G15_8 I1_I1252_G11_8n XI1_I1252_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I81_XG_MP2 (VDD I1_I1252_gn15 I1_I1252_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I81_XG_MP0 (XI1_I1252_I81_XG_p1 I1_I1252_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I81_XG_MP1 (I1_I1252_G15_14 I1_I1252_gn14 XI1_I1252_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I82_XG_MP2 (VDD I1_I1252_gn16 I1_I1252_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I82_XG_MP0 (XI1_I1252_I82_XG_p1 I1_I1252_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I82_XG_MP1 (I1_I1252_G16_15 I1_I1252_gn15 XI1_I1252_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I83_XG_MP2 (VDD I1_I1206_gn17 I1_I1206_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I83_XG_MP0 (XI1_I1206_I83_XG_p1 I1_I1206_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I83_XG_MP1 (I1_I1206_G17_16 I1_I1206_gn16 XI1_I1206_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I144_XG_MP2 (VDD I1_I1206_G19_16n I1_I1206_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I144_XG_MP0 (XI1_I1206_I144_XG_p1 I1_I1206_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I144_XG_MP1 (I1_I1206_G19_12 I1_I1206_G15_12n XI1_I1206_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I140_XG_MP2 (VDD I1_I1206_G15_12n I1_I1206_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I140_XG_MP0 (XI1_I1206_I140_XG_p1 I1_I1206_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I140_XG_MP1 (I1_I1206_G15_8 I1_I1206_G11_8n XI1_I1206_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I186_XG_MP2 (VDD I1_I1206_G19_4n I1_I1206_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I186_XG_MP0 (XI1_I1206_I186_XG_p1 I1_I1206_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I186_XG_MP1 (I1_I1206_G19_0 I1_I1206_G3_0n XI1_I1206_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I142_XG_MP2 (VDD I1_I1206_G17_14n I1_I1206_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I142_XG_MP0 (XI1_I1206_I142_XG_p1 I1_I1206_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I142_XG_MP1 (I1_I1206_G17_10 I1_I1206_G13_10n XI1_I1206_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I184_XG_MP2 (VDD I1_I1206_G17_2n I1_I1206_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I184_XG_MP0 (XI1_I1206_I184_XG_p1 I1_I1206_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I184_XG_MP1 (I1_I1206_G17_0 I1_I1206_G1_0n XI1_I1206_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I185_XG_MP2 (VDD I1_I1206_G18_3n I1_I1206_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I185_XG_MP0 (XI1_I1206_I185_XG_p1 I1_I1206_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I185_XG_MP1 (I1_I1206_G18_0 I1_I1206_G2_0n XI1_I1206_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I188_XG_MP2 (VDD I1_I1206_G20_5n I1_I1206_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I188_XG_MP0 (XI1_I1206_I188_XG_p1 I1_I1206_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I188_XG_MP1 (I1_I1206_G20_0 I1_I1206_G4_0n XI1_I1206_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I93_XG_MP2 (VDD I1_I884_gn27 I1_I884_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I93_XG_MP0 (XI1_I884_I93_XG_p1 I1_I884_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I93_XG_MP1 (I1_I884_G27_26 I1_I884_gn26 XI1_I884_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I89_XG_MP2 (VDD I1_I884_gn23 I1_I884_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I89_XG_MP0 (XI1_I884_I89_XG_p1 I1_I884_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I89_XG_MP1 (I1_I884_G23_22 I1_I884_gn22 XI1_I884_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I183_XG_MP2 (VDD I1_I838_G16_1n I1_I838_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I183_XG_MP0 (XI1_I838_I183_XG_p1 I1_I838_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I183_XG_MP1 (I1_I838_G16_0 I1_I838_G0_0n XI1_I838_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I128_XG_MP2 (VDD I1_I838_G4_1n I1_I838_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I128_XG_MP0 (XI1_I838_I128_XG_p1 I1_I838_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I128_XG_MP1 (I1_I838_G4_0 I1_I838_G0_0n XI1_I838_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I72_XG_MP2 (VDD I1_I838_gn6 I1_I838_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I72_XG_MP0 (XI1_I838_I72_XG_p1 I1_I838_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I72_XG_MP1 (I1_I838_G6_5 I1_I838_gn5 XI1_I838_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I71_XG_MP2 (VDD I1_I838_gn5 I1_I838_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I71_XG_MP0 (XI1_I838_I71_XG_p1 I1_I838_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I71_XG_MP1 (I1_I838_G5_4 I1_I838_gn4 XI1_I838_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I128_XG_MP2 (VDD I1_I792_G4_1n I1_I792_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I128_XG_MP0 (XI1_I792_I128_XG_p1 I1_I792_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I128_XG_MP1 (I1_I792_G4_0 I1_I792_G0_0n XI1_I792_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I74_XG_MP2 (VDD I1_I792_gn8 I1_I792_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I74_XG_MP0 (XI1_I792_I74_XG_p1 I1_I792_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I74_XG_MP1 (I1_I792_G8_7 I1_I792_gn7 XI1_I792_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I75_XG_MP2 (VDD I1_I792_gn9 I1_I792_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I75_XG_MP0 (XI1_I792_I75_XG_p1 I1_I792_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I75_XG_MP1 (I1_I792_G9_8 I1_I792_gn8 XI1_I792_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I131_XG_MP2 (VDD I1_I746_G6_3n I1_I746_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I131_XG_MP0 (XI1_I746_I131_XG_p1 I1_I746_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I131_XG_MP1 (I1_I746_G6_0 I1_I746_G2_0n XI1_I746_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I196_XG_MP2 (VDD I1_I746_G25_10n I1_I746_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I196_XG_MP0 (XI1_I746_I196_XG_p1 I1_I746_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I196_XG_MP1 (I1_I746_G25_0 I1_I746_G9_0n XI1_I746_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I146_XG_MP2 (VDD I1_I746_G21_18n I1_I746_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I146_XG_MP0 (XI1_I746_I146_XG_p1 I1_I746_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I146_XG_MP1 (I1_I746_G21_14 I1_I746_G17_14n XI1_I746_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I150_XG_MP2 (VDD I1_I746_G25_22n I1_I746_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I150_XG_MP0 (XI1_I746_I150_XG_p1 I1_I746_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I150_XG_MP1 (I1_I746_G25_18 I1_I746_G21_18n XI1_I746_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I154_XG_MP2 (VDD I1_I746_G29_26n I1_I746_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I154_XG_MP0 (XI1_I746_I154_XG_p1 I1_I746_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I154_XG_MP1 (I1_I746_G29_22 I1_I746_G25_22n XI1_I746_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I152_XG_MP2 (VDD I1_I746_G27_24n I1_I746_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I152_XG_MP0 (XI1_I746_I152_XG_p1 I1_I746_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I152_XG_MP1 (I1_I746_G27_20 I1_I746_G23_20n XI1_I746_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I156_XG_MP2 (VDD I1_I746_G31_28n I1_I746_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I156_XG_MP0 (XI1_I746_I156_XG_p1 I1_I746_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I156_XG_MP1 (I1_I746_G31_24 I1_I746_G27_24n XI1_I746_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I97_XG_MP2 (VDD I1_I746_gn31 I1_I746_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I97_XG_MP0 (XI1_I746_I97_XG_p1 I1_I746_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I97_XG_MP1 (I1_I746_G31_30 I1_I746_gn30 XI1_I746_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I197_XG_MP2 (VDD I1_I1344_G26_11n I1_I1344_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I197_XG_MP0 (XI1_I1344_I197_XG_p1 I1_I1344_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I197_XG_MP1 (I1_I1344_G26_0 I1_I1344_G10_0n XI1_I1344_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I195_XG_MP2 (VDD I1_I1344_G24_9n I1_I1344_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I195_XG_MP0 (XI1_I1344_I195_XG_p1 I1_I1344_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I195_XG_MP1 (I1_I1344_G24_0 I1_I1344_G8_0n XI1_I1344_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I143_XG_MP2 (VDD I1_I1344_G18_15n I1_I1344_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I143_XG_MP0 (XI1_I1344_I143_XG_p1 I1_I1344_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I143_XG_MP1 (I1_I1344_G18_11 I1_I1344_G14_11n XI1_I1344_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I139_XG_MP2 (VDD I1_I1344_G14_11n I1_I1344_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I139_XG_MP0 (XI1_I1344_I139_XG_p1 I1_I1344_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I139_XG_MP1 (I1_I1344_G14_7 I1_I1344_G10_7n XI1_I1344_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I141_XG_MP2 (VDD I1_I1344_G16_13n I1_I1344_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I141_XG_MP0 (XI1_I1344_I141_XG_p1 I1_I1344_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I141_XG_MP1 (I1_I1344_G16_9 I1_I1344_G12_9n XI1_I1344_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I137_XG_MP2 (VDD I1_I1344_G12_9n I1_I1344_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I137_XG_MP0 (XI1_I1344_I137_XG_p1 I1_I1344_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I137_XG_MP1 (I1_I1344_G12_5 I1_I1344_G8_5n XI1_I1344_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I78_XG_MP2 (VDD I1_I1344_gn12 I1_I1344_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I78_XG_MP0 (XI1_I1344_I78_XG_p1 I1_I1344_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I78_XG_MP1 (I1_I1344_G12_11 I1_I1344_gn11 XI1_I1344_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I77_XG_MP2 (VDD I1_I1344_gn11 I1_I1344_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I77_XG_MP0 (XI1_I1344_I77_XG_p1 I1_I1344_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I77_XG_MP1 (I1_I1344_G11_10 I1_I1344_gn10 XI1_I1344_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I132_XG_MP2 (VDD I1_I1298_G7_4n I1_I1298_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I132_XG_MP0 (XI1_I1298_I132_XG_p1 I1_I1298_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I132_XG_MP1 (I1_I1298_G7_0 I1_I1298_G3_0n XI1_I1298_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I184_XG_MP2 (VDD I1_I1298_G17_2n I1_I1298_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I184_XG_MP0 (XI1_I1298_I184_XG_p1 I1_I1298_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I184_XG_MP1 (I1_I1298_G17_0 I1_I1298_G1_0n XI1_I1298_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I185_XG_MP2 (VDD I1_I1298_G18_3n I1_I1298_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I185_XG_MP0 (XI1_I1298_I185_XG_p1 I1_I1298_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I185_XG_MP1 (I1_I1298_G18_0 I1_I1298_G2_0n XI1_I1298_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I195_XG_MP2 (VDD I1_I1298_G24_9n I1_I1298_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I195_XG_MP0 (XI1_I1298_I195_XG_p1 I1_I1298_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I195_XG_MP1 (I1_I1298_G24_0 I1_I1298_G8_0n XI1_I1298_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I141_XG_MP2 (VDD I1_I1298_G16_13n I1_I1298_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I141_XG_MP0 (XI1_I1298_I141_XG_p1 I1_I1298_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I141_XG_MP1 (I1_I1298_G16_9 I1_I1298_G12_9n XI1_I1298_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I78_XG_MP2 (VDD I1_I1298_gn12 I1_I1298_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I78_XG_MP0 (XI1_I1298_I78_XG_p1 I1_I1298_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I78_XG_MP1 (I1_I1298_G12_11 I1_I1298_gn11 XI1_I1298_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I79_XG_MP2 (VDD I1_I1298_gn13 I1_I1298_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I79_XG_MP0 (XI1_I1298_I79_XG_p1 I1_I1298_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I79_XG_MP1 (I1_I1298_G13_12 I1_I1298_gn12 XI1_I1298_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I141_XG_MP2 (VDD I1_I1252_G16_13n I1_I1252_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I141_XG_MP0 (XI1_I1252_I141_XG_p1 I1_I1252_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I141_XG_MP1 (I1_I1252_G16_9 I1_I1252_G12_9n XI1_I1252_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I184_XG_MP2 (VDD I1_I1252_G17_2n I1_I1252_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I184_XG_MP0 (XI1_I1252_I184_XG_p1 I1_I1252_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I184_XG_MP1 (I1_I1252_G17_0 I1_I1252_G1_0n XI1_I1252_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I138_XG_MP2 (VDD I1_I1252_G13_10n I1_I1252_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I138_XG_MP0 (XI1_I1252_I138_XG_p1 I1_I1252_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I138_XG_MP1 (I1_I1252_G13_6 I1_I1252_G9_6n XI1_I1252_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I142_XG_MP2 (VDD I1_I1252_G17_14n I1_I1252_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I142_XG_MP0 (XI1_I1252_I142_XG_p1 I1_I1252_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I142_XG_MP1 (I1_I1252_G17_10 I1_I1252_G13_10n XI1_I1252_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I79_XG_MP2 (VDD I1_I1252_gn13 I1_I1252_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I79_XG_MP0 (XI1_I1252_I79_XG_p1 I1_I1252_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I79_XG_MP1 (I1_I1252_G13_12 I1_I1252_gn12 XI1_I1252_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I80_XG_MP2 (VDD I1_I1252_gn14 I1_I1252_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I80_XG_MP0 (XI1_I1252_I80_XG_p1 I1_I1252_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I80_XG_MP1 (I1_I1252_G14_13 I1_I1252_gn13 XI1_I1252_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I82_XG_MP2 (VDD I1_I1206_gn16 I1_I1206_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I82_XG_MP0 (XI1_I1206_I82_XG_p1 I1_I1206_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I82_XG_MP1 (I1_I1206_G16_15 I1_I1206_gn15 XI1_I1206_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I81_XG_MP2 (VDD I1_I1206_gn15 I1_I1206_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I81_XG_MP0 (XI1_I1206_I81_XG_p1 I1_I1206_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I81_XG_MP1 (I1_I1206_G15_14 I1_I1206_gn14 XI1_I1206_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I139_XG_MP2 (VDD I1_I1206_G14_11n I1_I1206_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I139_XG_MP0 (XI1_I1206_I139_XG_p1 I1_I1206_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I139_XG_MP1 (I1_I1206_G14_7 I1_I1206_G10_7n XI1_I1206_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I95_XG_MP2 (VDD I1_I884_gn29 I1_I884_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I95_XG_MP0 (XI1_I884_I95_XG_p1 I1_I884_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I95_XG_MP1 (I1_I884_G29_28 I1_I884_gn28 XI1_I884_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I94_XG_MP2 (VDD I1_I884_gn28 I1_I884_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I94_XG_MP0 (XI1_I884_I94_XG_p1 I1_I884_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I94_XG_MP1 (I1_I884_G28_27 I1_I884_gn27 XI1_I884_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I92_XG_MP2 (VDD I1_I884_gn26 I1_I884_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I92_XG_MP0 (XI1_I884_I92_XG_p1 I1_I884_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I92_XG_MP1 (I1_I884_G26_25 I1_I884_gn25 XI1_I884_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I91_XG_MP2 (VDD I1_I884_gn25 I1_I884_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I91_XG_MP0 (XI1_I884_I91_XG_p1 I1_I884_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I91_XG_MP1 (I1_I884_G25_24 I1_I884_gn24 XI1_I884_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I90_XG_MP2 (VDD I1_I884_gn24 I1_I884_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I90_XG_MP0 (XI1_I884_I90_XG_p1 I1_I884_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I90_XG_MP1 (I1_I884_G24_23 I1_I884_gn23 XI1_I884_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I86_XG_MP2 (VDD I1_I884_gn20 I1_I884_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I86_XG_MP0 (XI1_I884_I86_XG_p1 I1_I884_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I86_XG_MP1 (I1_I884_G20_19 I1_I884_gn19 XI1_I884_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I85_XG_MP2 (VDD I1_I884_gn19 I1_I884_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I85_XG_MP0 (XI1_I884_I85_XG_p1 I1_I884_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I85_XG_MP1 (I1_I884_G19_18 I1_I884_gn18 XI1_I884_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I84_XG_MP2 (VDD I1_I884_gn18 I1_I884_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I84_XG_MP0 (XI1_I884_I84_XG_p1 I1_I884_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I84_XG_MP1 (I1_I884_G18_17 I1_I884_gn17 XI1_I884_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I83_XG_MP2 (VDD I1_I884_gn17 I1_I884_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I83_XG_MP0 (XI1_I884_I83_XG_p1 I1_I884_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I83_XG_MP1 (I1_I884_G17_16 I1_I884_gn16 XI1_I884_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I82_XG_MP2 (VDD I1_I884_gn16 I1_I884_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I82_XG_MP0 (XI1_I884_I82_XG_p1 I1_I884_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I82_XG_MP1 (I1_I884_G16_15 I1_I884_gn15 XI1_I884_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I70_XG_MP2 (VDD I1_I838_gn4 I1_I838_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I70_XG_MP0 (XI1_I838_I70_XG_p1 I1_I838_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I70_XG_MP1 (I1_I838_G4_3 I1_I838_gn3 XI1_I838_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I128_XG_MP2 (VDD I1_I746_G4_1n I1_I746_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I128_XG_MP0 (XI1_I746_I128_XG_p1 I1_I746_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I128_XG_MP1 (I1_I746_G4_0 I1_I746_G0_0n XI1_I746_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I133_XG_MP2 (VDD I1_I746_G8_5n I1_I746_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I133_XG_MP0 (XI1_I746_I133_XG_p1 I1_I746_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I133_XG_MP1 (I1_I746_G8_1 I1_I746_G4_1n XI1_I746_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I134_XG_MP2 (VDD I1_I746_G9_6n I1_I746_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I134_XG_MP0 (XI1_I746_I134_XG_p1 I1_I746_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I134_XG_MP1 (I1_I746_G9_2 I1_I746_G5_2n XI1_I746_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I184_XG_MP2 (VDD I1_I746_G17_2n I1_I746_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I184_XG_MP0 (XI1_I746_I184_XG_p1 I1_I746_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I184_XG_MP1 (I1_I746_G17_0 I1_I746_G1_0n XI1_I746_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I186_XG_MP2 (VDD I1_I746_G19_4n I1_I746_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I186_XG_MP0 (XI1_I746_I186_XG_p1 I1_I746_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I186_XG_MP1 (I1_I746_G19_0 I1_I746_G3_0n XI1_I746_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I138_XG_MP2 (VDD I1_I746_G13_10n I1_I746_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I138_XG_MP0 (XI1_I746_I138_XG_p1 I1_I746_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I138_XG_MP1 (I1_I746_G13_6 I1_I746_G9_6n XI1_I746_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I142_XG_MP2 (VDD I1_I746_G17_14n I1_I746_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I142_XG_MP0 (XI1_I746_I142_XG_p1 I1_I746_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I142_XG_MP1 (I1_I746_G17_10 I1_I746_G13_10n XI1_I746_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I144_XG_MP2 (VDD I1_I746_G19_16n I1_I746_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I144_XG_MP0 (XI1_I746_I144_XG_p1 I1_I746_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I144_XG_MP1 (I1_I746_G19_12 I1_I746_G15_12n XI1_I746_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I198_XG_MP2 (VDD I1_I746_G27_12n I1_I746_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I198_XG_MP0 (XI1_I746_I198_XG_p1 I1_I746_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I198_XG_MP1 (I1_I746_G27_0 I1_I746_G11_0n XI1_I746_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I89_XG_MP2 (VDD I1_I746_gn23 I1_I746_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I89_XG_MP0 (XI1_I746_I89_XG_p1 I1_I746_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I89_XG_MP1 (I1_I746_G23_22 I1_I746_gn22 XI1_I746_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I148_XG_MP2 (VDD I1_I746_G23_20n I1_I746_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I148_XG_MP0 (XI1_I746_I148_XG_p1 I1_I746_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I148_XG_MP1 (I1_I746_G23_16 I1_I746_G19_16n XI1_I746_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I192_XG_MP2 (VDD I1_I1344_G22_7n I1_I1344_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I192_XG_MP0 (XI1_I1344_I192_XG_p1 I1_I1344_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I192_XG_MP1 (I1_I1344_G22_0 I1_I1344_G6_0n XI1_I1344_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I188_XG_MP2 (VDD I1_I1344_G20_5n I1_I1344_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I188_XG_MP0 (XI1_I1344_I188_XG_p1 I1_I1344_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I188_XG_MP1 (I1_I1344_G20_0 I1_I1344_G4_0n XI1_I1344_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I135_XG_MP2 (VDD I1_I1344_G10_7n I1_I1344_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I135_XG_MP0 (XI1_I1344_I135_XG_p1 I1_I1344_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I135_XG_MP1 (I1_I1344_G10_3 I1_I1344_G6_3n XI1_I1344_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I76_XG_MP2 (VDD I1_I1344_gn10 I1_I1344_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I76_XG_MP0 (XI1_I1344_I76_XG_p1 I1_I1344_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I76_XG_MP1 (I1_I1344_G10_9 I1_I1344_gn9 XI1_I1344_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I75_XG_MP2 (VDD I1_I1344_gn9 I1_I1344_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I75_XG_MP0 (XI1_I1344_I75_XG_p1 I1_I1344_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I75_XG_MP1 (I1_I1344_G9_8 I1_I1344_gn8 XI1_I1344_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I134_XG_MP2 (VDD I1_I1298_G9_6n I1_I1298_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I134_XG_MP0 (XI1_I1298_I134_XG_p1 I1_I1298_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I134_XG_MP1 (I1_I1298_G9_2 I1_I1298_G5_2n XI1_I1298_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I135_XG_MP2 (VDD I1_I1298_G10_7n I1_I1298_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I135_XG_MP0 (XI1_I1298_I135_XG_p1 I1_I1298_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I135_XG_MP1 (I1_I1298_G10_3 I1_I1298_G6_3n XI1_I1298_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I137_XG_MP2 (VDD I1_I1298_G12_9n I1_I1298_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I137_XG_MP0 (XI1_I1298_I137_XG_p1 I1_I1298_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I137_XG_MP1 (I1_I1298_G12_5 I1_I1298_G8_5n XI1_I1298_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I77_XG_MP2 (VDD I1_I1298_gn11 I1_I1298_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I77_XG_MP0 (XI1_I1298_I77_XG_p1 I1_I1298_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I77_XG_MP1 (I1_I1298_G11_10 I1_I1298_gn10 XI1_I1298_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I183_XG_MP2 (VDD I1_I1252_G16_1n I1_I1252_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I183_XG_MP0 (XI1_I1252_I183_XG_p1 I1_I1252_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I183_XG_MP1 (I1_I1252_G16_0 I1_I1252_G0_0n XI1_I1252_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I135_XG_MP2 (VDD I1_I1252_G10_7n I1_I1252_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I135_XG_MP0 (XI1_I1252_I135_XG_p1 I1_I1252_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I135_XG_MP1 (I1_I1252_G10_3 I1_I1252_G6_3n XI1_I1252_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I137_XG_MP2 (VDD I1_I1252_G12_9n I1_I1252_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I137_XG_MP0 (XI1_I1252_I137_XG_p1 I1_I1252_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I137_XG_MP1 (I1_I1252_G12_5 I1_I1252_G8_5n XI1_I1252_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I134_XG_MP2 (VDD I1_I1252_G9_6n I1_I1252_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I134_XG_MP0 (XI1_I1252_I134_XG_p1 I1_I1252_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I134_XG_MP1 (I1_I1252_G9_2 I1_I1252_G5_2n XI1_I1252_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I136_XG_MP2 (VDD I1_I1252_G11_8n I1_I1252_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I136_XG_MP0 (XI1_I1252_I136_XG_p1 I1_I1252_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I136_XG_MP1 (I1_I1252_G11_4 I1_I1252_G7_4n XI1_I1252_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I77_XG_MP2 (VDD I1_I1252_gn11 I1_I1252_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I77_XG_MP0 (XI1_I1252_I77_XG_p1 I1_I1252_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I77_XG_MP1 (I1_I1252_G11_10 I1_I1252_gn10 XI1_I1252_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I78_XG_MP2 (VDD I1_I1252_gn12 I1_I1252_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I78_XG_MP0 (XI1_I1252_I78_XG_p1 I1_I1252_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I78_XG_MP1 (I1_I1252_G12_11 I1_I1252_gn11 XI1_I1252_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I80_XG_MP2 (VDD I1_I1206_gn14 I1_I1206_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I80_XG_MP0 (XI1_I1206_I80_XG_p1 I1_I1206_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I80_XG_MP1 (I1_I1206_G14_13 I1_I1206_gn13 XI1_I1206_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I132_XG_MP2 (VDD I1_I1206_G7_4n I1_I1206_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I132_XG_MP0 (XI1_I1206_I132_XG_p1 I1_I1206_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I132_XG_MP1 (I1_I1206_G7_0 I1_I1206_G3_0n XI1_I1206_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I134_XG_MP2 (VDD I1_I1206_G9_6n I1_I1206_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I134_XG_MP0 (XI1_I1206_I134_XG_p1 I1_I1206_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I134_XG_MP1 (I1_I1206_G9_2 I1_I1206_G5_2n XI1_I1206_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I135_XG_MP2 (VDD I1_I1206_G10_7n I1_I1206_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I135_XG_MP0 (XI1_I1206_I135_XG_p1 I1_I1206_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I135_XG_MP1 (I1_I1206_G10_3 I1_I1206_G6_3n XI1_I1206_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I141_XG_MP2 (VDD I1_I1206_G16_13n I1_I1206_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I141_XG_MP0 (XI1_I1206_I141_XG_p1 I1_I1206_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I141_XG_MP1 (I1_I1206_G16_9 I1_I1206_G12_9n XI1_I1206_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I137_XG_MP2 (VDD I1_I1206_G12_9n I1_I1206_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I137_XG_MP0 (XI1_I1206_I137_XG_p1 I1_I1206_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I137_XG_MP1 (I1_I1206_G12_5 I1_I1206_G8_5n XI1_I1206_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I97_XG_MP2 (VDD I1_I884_gn31 I1_I884_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I97_XG_MP0 (XI1_I884_I97_XG_p1 I1_I884_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I97_XG_MP1 (I1_I884_G31_30 I1_I884_gn30 XI1_I884_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I96_XG_MP2 (VDD I1_I884_gn30 I1_I884_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I96_XG_MP0 (XI1_I884_I96_XG_p1 I1_I884_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I96_XG_MP1 (I1_I884_G30_29 I1_I884_gn29 XI1_I884_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I156_XG_MP2 (VDD I1_I884_G31_28n I1_I884_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I156_XG_MP0 (XI1_I884_I156_XG_p1 I1_I884_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I156_XG_MP1 (I1_I884_G31_24 I1_I884_G27_24n XI1_I884_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I154_XG_MP2 (VDD I1_I884_G29_26n I1_I884_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I154_XG_MP0 (XI1_I884_I154_XG_p1 I1_I884_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I154_XG_MP1 (I1_I884_G29_22 I1_I884_G25_22n XI1_I884_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I152_XG_MP2 (VDD I1_I884_G27_24n I1_I884_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I152_XG_MP0 (XI1_I884_I152_XG_p1 I1_I884_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I152_XG_MP1 (I1_I884_G27_20 I1_I884_G23_20n XI1_I884_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I148_XG_MP2 (VDD I1_I884_G23_20n I1_I884_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I148_XG_MP0 (XI1_I884_I148_XG_p1 I1_I884_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I148_XG_MP1 (I1_I884_G23_16 I1_I884_G19_16n XI1_I884_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I150_XG_MP2 (VDD I1_I884_G25_22n I1_I884_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I150_XG_MP0 (XI1_I884_I150_XG_p1 I1_I884_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I150_XG_MP1 (I1_I884_G25_18 I1_I884_G21_18n XI1_I884_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I142_XG_MP2 (VDD I1_I884_G17_14n I1_I884_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I142_XG_MP0 (XI1_I884_I142_XG_p1 I1_I884_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I142_XG_MP1 (I1_I884_G17_10 I1_I884_G13_10n XI1_I884_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I81_XG_MP2 (VDD I1_I884_gn15 I1_I884_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I81_XG_MP0 (XI1_I884_I81_XG_p1 I1_I884_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I81_XG_MP1 (I1_I884_G15_14 I1_I884_gn14 XI1_I884_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I80_XG_MP2 (VDD I1_I884_gn14 I1_I884_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I80_XG_MP0 (XI1_I884_I80_XG_p1 I1_I884_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I80_XG_MP1 (I1_I884_G14_13 I1_I884_gn13 XI1_I884_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I79_XG_MP2 (VDD I1_I884_gn13 I1_I884_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I79_XG_MP0 (XI1_I884_I79_XG_p1 I1_I884_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I79_XG_MP1 (I1_I884_G13_12 I1_I884_gn12 XI1_I884_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I78_XG_MP2 (VDD I1_I884_gn12 I1_I884_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I78_XG_MP0 (XI1_I884_I78_XG_p1 I1_I884_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I78_XG_MP1 (I1_I884_G12_11 I1_I884_gn11 XI1_I884_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I77_XG_MP2 (VDD I1_I884_gn11 I1_I884_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I77_XG_MP0 (XI1_I884_I77_XG_p1 I1_I884_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I77_XG_MP1 (I1_I884_G11_10 I1_I884_gn10 XI1_I884_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I76_XG_MP2 (VDD I1_I884_gn10 I1_I884_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I76_XG_MP0 (XI1_I884_I76_XG_p1 I1_I884_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I76_XG_MP1 (I1_I884_G10_9 I1_I884_gn9 XI1_I884_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I67_XG_MP2 (VDD I1_I838_gn1 I1_I838_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I67_XG_MP0 (XI1_I838_I67_XG_p1 I1_I838_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I67_XG_MP1 (I1_I838_G1_0 I1_I838_G0_0n XI1_I838_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I69_XG_MP2 (VDD I1_I838_gn3 I1_I838_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I69_XG_MP0 (XI1_I838_I69_XG_p1 I1_I838_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I69_XG_MP1 (I1_I838_G3_2 I1_I838_gn2 XI1_I838_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I68_XG_MP2 (VDD I1_I838_gn2 I1_I838_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I68_XG_MP0 (XI1_I838_I68_XG_p1 I1_I838_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I68_XG_MP1 (I1_I838_G2_1 I1_I838_gn1 XI1_I838_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I70_XG_MP2 (VDD I1_I792_gn4 I1_I792_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I70_XG_MP0 (XI1_I792_I70_XG_p1 I1_I792_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I70_XG_MP1 (I1_I792_G4_3 I1_I792_gn3 XI1_I792_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I71_XG_MP2 (VDD I1_I792_gn5 I1_I792_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I71_XG_MP0 (XI1_I792_I71_XG_p1 I1_I792_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I71_XG_MP1 (I1_I792_G5_4 I1_I792_gn4 XI1_I792_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I130_XG_MP2 (VDD I1_I746_G5_2n I1_I746_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I130_XG_MP0 (XI1_I746_I130_XG_p1 I1_I746_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I130_XG_MP1 (I1_I746_G5_0 I1_I746_G1_0n XI1_I746_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I132_XG_MP2 (VDD I1_I746_G7_4n I1_I746_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I132_XG_MP0 (XI1_I746_I132_XG_p1 I1_I746_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I132_XG_MP1 (I1_I746_G7_0 I1_I746_G3_0n XI1_I746_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I136_XG_MP2 (VDD I1_I746_G11_8n I1_I746_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I136_XG_MP0 (XI1_I746_I136_XG_p1 I1_I746_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I136_XG_MP1 (I1_I746_G11_4 I1_I746_G7_4n XI1_I746_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I81_XG_MP2 (VDD I1_I746_gn15 I1_I746_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I81_XG_MP0 (XI1_I746_I81_XG_p1 I1_I746_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I81_XG_MP1 (I1_I746_G15_14 I1_I746_gn14 XI1_I746_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I83_XG_MP2 (VDD I1_I746_gn17 I1_I746_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I83_XG_MP0 (XI1_I746_I83_XG_p1 I1_I746_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I83_XG_MP1 (I1_I746_G17_16 I1_I746_gn16 XI1_I746_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I140_XG_MP2 (VDD I1_I746_G15_12n I1_I746_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I140_XG_MP0 (XI1_I746_I140_XG_p1 I1_I746_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I140_XG_MP1 (I1_I746_G15_8 I1_I746_G11_8n XI1_I746_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I84_XG_MP2 (VDD I1_I746_gn18 I1_I746_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I84_XG_MP0 (XI1_I746_I84_XG_p1 I1_I746_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I84_XG_MP1 (I1_I746_G18_17 I1_I746_gn17 XI1_I746_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I85_XG_MP2 (VDD I1_I746_gn19 I1_I746_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I85_XG_MP0 (XI1_I746_I85_XG_p1 I1_I746_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I85_XG_MP1 (I1_I746_G19_18 I1_I746_gn18 XI1_I746_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I88_XG_MP2 (VDD I1_I746_gn22 I1_I746_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I88_XG_MP0 (XI1_I746_I88_XG_p1 I1_I746_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I88_XG_MP1 (I1_I746_G22_21 I1_I746_gn21 XI1_I746_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I194_XG_MP2 (VDD I1_I746_G23_8n I1_I746_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I194_XG_MP0 (XI1_I746_I194_XG_p1 I1_I746_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I194_XG_MP1 (I1_I746_G23_0 I1_I746_G7_0n XI1_I746_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I202_XG_MP2 (VDD I1_I746_G31_16n I1_c4_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I202_XG_MP0 (XI1_I746_I202_XG_p1 I1_I746_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I202_XG_MP1 (I1_c4_o I1_I746_G15_0n XI1_I746_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I185_XG_MP2 (VDD I1_I1344_G18_3n I1_I1344_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I185_XG_MP0 (XI1_I1344_I185_XG_p1 I1_I1344_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I185_XG_MP1 (I1_I1344_G18_0 I1_I1344_G2_0n XI1_I1344_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I131_XG_MP2 (VDD I1_I1344_G6_3n I1_I1344_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I131_XG_MP0 (XI1_I1344_I131_XG_p1 I1_I1344_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I131_XG_MP1 (I1_I1344_G6_0 I1_I1344_G2_0n XI1_I1344_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I130_XG_MP2 (VDD I1_I1298_G5_2n I1_I1298_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I130_XG_MP0 (XI1_I1298_I130_XG_p1 I1_I1298_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I130_XG_MP1 (I1_I1298_G5_0 I1_I1298_G1_0n XI1_I1298_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I183_XG_MP2 (VDD I1_I1298_G16_1n I1_I1298_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I183_XG_MP0 (XI1_I1298_I183_XG_p1 I1_I1298_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I183_XG_MP1 (I1_I1298_G16_0 I1_I1298_G0_0n XI1_I1298_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I75_XG_MP2 (VDD I1_I1298_gn9 I1_I1298_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I75_XG_MP0 (XI1_I1298_I75_XG_p1 I1_I1298_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I75_XG_MP1 (I1_I1298_G9_8 I1_I1298_gn8 XI1_I1298_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I76_XG_MP2 (VDD I1_I1298_gn10 I1_I1298_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I76_XG_MP0 (XI1_I1298_I76_XG_p1 I1_I1298_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I76_XG_MP1 (I1_I1298_G10_9 I1_I1298_gn9 XI1_I1298_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I131_XG_MP2 (VDD I1_I1252_G6_3n I1_I1252_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I131_XG_MP0 (XI1_I1252_I131_XG_p1 I1_I1252_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I131_XG_MP1 (I1_I1252_G6_0 I1_I1252_G2_0n XI1_I1252_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I132_XG_MP2 (VDD I1_I1252_G7_4n I1_I1252_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I132_XG_MP0 (XI1_I1252_I132_XG_p1 I1_I1252_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I132_XG_MP1 (I1_I1252_G7_0 I1_I1252_G3_0n XI1_I1252_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I74_XG_MP2 (VDD I1_I1252_gn8 I1_I1252_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I74_XG_MP0 (XI1_I1252_I74_XG_p1 I1_I1252_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I74_XG_MP1 (I1_I1252_G8_7 I1_I1252_gn7 XI1_I1252_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I75_XG_MP2 (VDD I1_I1252_gn9 I1_I1252_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I75_XG_MP0 (XI1_I1252_I75_XG_p1 I1_I1252_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I75_XG_MP1 (I1_I1252_G9_8 I1_I1252_gn8 XI1_I1252_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I76_XG_MP2 (VDD I1_I1252_gn10 I1_I1252_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I76_XG_MP0 (XI1_I1252_I76_XG_p1 I1_I1252_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I76_XG_MP1 (I1_I1252_G10_9 I1_I1252_gn9 XI1_I1252_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I79_XG_MP2 (VDD I1_I1206_gn13 I1_I1206_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I79_XG_MP0 (XI1_I1206_I79_XG_p1 I1_I1206_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I79_XG_MP1 (I1_I1206_G13_12 I1_I1206_gn12 XI1_I1206_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I78_XG_MP2 (VDD I1_I1206_gn12 I1_I1206_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I78_XG_MP0 (XI1_I1206_I78_XG_p1 I1_I1206_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I78_XG_MP1 (I1_I1206_G12_11 I1_I1206_gn11 XI1_I1206_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I77_XG_MP2 (VDD I1_I1206_gn11 I1_I1206_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I77_XG_MP0 (XI1_I1206_I77_XG_p1 I1_I1206_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I77_XG_MP1 (I1_I1206_G11_10 I1_I1206_gn10 XI1_I1206_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I76_XG_MP2 (VDD I1_I1206_gn10 I1_I1206_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I76_XG_MP0 (XI1_I1206_I76_XG_p1 I1_I1206_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I76_XG_MP1 (I1_I1206_G10_9 I1_I1206_gn9 XI1_I1206_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I130_XG_MP2 (VDD I1_I1206_G5_2n I1_I1206_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I130_XG_MP0 (XI1_I1206_I130_XG_p1 I1_I1206_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I130_XG_MP1 (I1_I1206_G5_0 I1_I1206_G1_0n XI1_I1206_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I131_XG_MP2 (VDD I1_I1206_G6_3n I1_I1206_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I131_XG_MP0 (XI1_I1206_I131_XG_p1 I1_I1206_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I131_XG_MP1 (I1_I1206_G6_0 I1_I1206_G2_0n XI1_I1206_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I133_XG_MP2 (VDD I1_I1206_G8_5n I1_I1206_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I133_XG_MP0 (XI1_I1206_I133_XG_p1 I1_I1206_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I133_XG_MP1 (I1_I1206_G8_1 I1_I1206_G4_1n XI1_I1206_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I183_XG_MP2 (VDD I1_I1206_G16_1n I1_I1206_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I183_XG_MP0 (XI1_I1206_I183_XG_p1 I1_I1206_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I183_XG_MP1 (I1_I1206_G16_0 I1_I1206_G0_0n XI1_I1206_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I202_XG_MP2 (VDD I1_I884_G31_16n I1_c7_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I202_XG_MP0 (XI1_I884_I202_XG_p1 I1_I884_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I202_XG_MP1 (I1_c7_o I1_I884_G15_0n XI1_I884_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I200_XG_MP2 (VDD I1_I884_G29_14n I1_I884_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I200_XG_MP0 (XI1_I884_I200_XG_p1 I1_I884_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I200_XG_MP1 (I1_I884_G29_0 I1_I884_G13_0n XI1_I884_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I198_XG_MP2 (VDD I1_I884_G27_12n I1_I884_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I198_XG_MP0 (XI1_I884_I198_XG_p1 I1_I884_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I198_XG_MP1 (I1_I884_G27_0 I1_I884_G11_0n XI1_I884_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I190_XG_MP2 (VDD I1_I884_G21_6n I1_I884_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I190_XG_MP0 (XI1_I884_I190_XG_p1 I1_I884_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I190_XG_MP1 (I1_I884_G21_0 I1_I884_G5_0n XI1_I884_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I140_XG_MP2 (VDD I1_I884_G15_12n I1_I884_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I140_XG_MP0 (XI1_I884_I140_XG_p1 I1_I884_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I140_XG_MP1 (I1_I884_G15_8 I1_I884_G11_8n XI1_I884_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I138_XG_MP2 (VDD I1_I884_G13_10n I1_I884_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I138_XG_MP0 (XI1_I884_I138_XG_p1 I1_I884_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I138_XG_MP1 (I1_I884_G13_6 I1_I884_G9_6n XI1_I884_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I136_XG_MP2 (VDD I1_I884_G11_8n I1_I884_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I136_XG_MP0 (XI1_I884_I136_XG_p1 I1_I884_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I136_XG_MP1 (I1_I884_G11_4 I1_I884_G7_4n XI1_I884_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I75_XG_MP2 (VDD I1_I884_gn9 I1_I884_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I75_XG_MP0 (XI1_I884_I75_XG_p1 I1_I884_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I75_XG_MP1 (I1_I884_G9_8 I1_I884_gn8 XI1_I884_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I68_XG_MP2 (VDD I1_I792_gn2 I1_I792_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I68_XG_MP0 (XI1_I792_I68_XG_p1 I1_I792_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I68_XG_MP1 (I1_I792_G2_1 I1_I792_gn1 XI1_I792_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I67_XG_MP2 (VDD I1_I746_gn1 I1_I746_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I67_XG_MP0 (XI1_I746_I67_XG_p1 I1_I746_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I67_XG_MP1 (I1_I746_G1_0 I1_I746_G0_0n XI1_I746_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I75_XG_MP2 (VDD I1_I746_gn9 I1_I746_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I75_XG_MP0 (XI1_I746_I75_XG_p1 I1_I746_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I75_XG_MP1 (I1_I746_G9_8 I1_I746_gn8 XI1_I746_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I76_XG_MP2 (VDD I1_I746_gn10 I1_I746_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I76_XG_MP0 (XI1_I746_I76_XG_p1 I1_I746_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I76_XG_MP1 (I1_I746_G10_9 I1_I746_gn9 XI1_I746_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I77_XG_MP2 (VDD I1_I746_gn11 I1_I746_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I77_XG_MP0 (XI1_I746_I77_XG_p1 I1_I746_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I77_XG_MP1 (I1_I746_G11_10 I1_I746_gn10 XI1_I746_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I80_XG_MP2 (VDD I1_I746_gn14 I1_I746_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I80_XG_MP0 (XI1_I746_I80_XG_p1 I1_I746_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I80_XG_MP1 (I1_I746_G14_13 I1_I746_gn13 XI1_I746_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I82_XG_MP2 (VDD I1_I746_gn16 I1_I746_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I82_XG_MP0 (XI1_I746_I82_XG_p1 I1_I746_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I82_XG_MP1 (I1_I746_G16_15 I1_I746_gn15 XI1_I746_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I94_XG_MP2 (VDD I1_I1390_gn28 I1_I1390_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I94_XG_MP0 (XI1_I1390_I94_XG_p1 I1_I1390_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I94_XG_MP1 (I1_I1390_G28_27 I1_I1390_gn27 XI1_I1390_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I91_XG_MP2 (VDD I1_I1390_gn25 I1_I1390_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I91_XG_MP0 (XI1_I1390_I91_XG_p1 I1_I1390_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I91_XG_MP1 (I1_I1390_G25_24 I1_I1390_gn24 XI1_I1390_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I183_XG_MP2 (VDD I1_I1344_G16_1n I1_I1344_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I183_XG_MP0 (XI1_I1344_I183_XG_p1 I1_I1344_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I183_XG_MP1 (I1_I1344_G16_0 I1_I1344_G0_0n XI1_I1344_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I133_XG_MP2 (VDD I1_I1344_G8_5n I1_I1344_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I133_XG_MP0 (XI1_I1344_I133_XG_p1 I1_I1344_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I133_XG_MP1 (I1_I1344_G8_1 I1_I1344_G4_1n XI1_I1344_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I74_XG_MP2 (VDD I1_I1344_gn8 I1_I1344_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I74_XG_MP0 (XI1_I1344_I74_XG_p1 I1_I1344_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I74_XG_MP1 (I1_I1344_G8_7 I1_I1344_gn7 XI1_I1344_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I73_XG_MP2 (VDD I1_I1344_gn7 I1_I1344_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I73_XG_MP0 (XI1_I1344_I73_XG_p1 I1_I1344_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I73_XG_MP1 (I1_I1344_G7_6 I1_I1344_gn6 XI1_I1344_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I131_XG_MP2 (VDD I1_I1298_G6_3n I1_I1298_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I131_XG_MP0 (XI1_I1298_I131_XG_p1 I1_I1298_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I131_XG_MP1 (I1_I1298_G6_0 I1_I1298_G2_0n XI1_I1298_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I133_XG_MP2 (VDD I1_I1298_G8_5n I1_I1298_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I133_XG_MP0 (XI1_I1298_I133_XG_p1 I1_I1298_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I133_XG_MP1 (I1_I1298_G8_1 I1_I1298_G4_1n XI1_I1298_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I74_XG_MP2 (VDD I1_I1298_gn8 I1_I1298_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I74_XG_MP0 (XI1_I1298_I74_XG_p1 I1_I1298_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I74_XG_MP1 (I1_I1298_G8_7 I1_I1298_gn7 XI1_I1298_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I73_XG_MP2 (VDD I1_I1298_gn7 I1_I1298_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I73_XG_MP0 (XI1_I1298_I73_XG_p1 I1_I1298_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I73_XG_MP1 (I1_I1298_G7_6 I1_I1298_gn6 XI1_I1298_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I128_XG_MP2 (VDD I1_I1252_G4_1n I1_I1252_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I128_XG_MP0 (XI1_I1252_I128_XG_p1 I1_I1252_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I128_XG_MP1 (I1_I1252_G4_0 I1_I1252_G0_0n XI1_I1252_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I133_XG_MP2 (VDD I1_I1252_G8_5n I1_I1252_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I133_XG_MP0 (XI1_I1252_I133_XG_p1 I1_I1252_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I133_XG_MP1 (I1_I1252_G8_1 I1_I1252_G4_1n XI1_I1252_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I130_XG_MP2 (VDD I1_I1252_G5_2n I1_I1252_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I130_XG_MP0 (XI1_I1252_I130_XG_p1 I1_I1252_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I130_XG_MP1 (I1_I1252_G5_0 I1_I1252_G1_0n XI1_I1252_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I73_XG_MP2 (VDD I1_I1252_gn7 I1_I1252_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I73_XG_MP0 (XI1_I1252_I73_XG_p1 I1_I1252_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I73_XG_MP1 (I1_I1252_G7_6 I1_I1252_gn6 XI1_I1252_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I73_XG_MP2 (VDD I1_I1206_gn7 I1_I1206_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I73_XG_MP0 (XI1_I1206_I73_XG_p1 I1_I1206_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I73_XG_MP1 (I1_I1206_G7_6 I1_I1206_gn6 XI1_I1206_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I128_XG_MP2 (VDD I1_I1206_G4_1n I1_I1206_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I128_XG_MP0 (XI1_I1206_I128_XG_p1 I1_I1206_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I128_XG_MP1 (I1_I1206_G4_0 I1_I1206_G0_0n XI1_I1206_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I155_XG_MP2 (VDD I1_I884_G30_27n I1_I884_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I155_XG_MP0 (XI1_I884_I155_XG_p1 I1_I884_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I155_XG_MP1 (I1_I884_G30_23 I1_I884_G26_23n XI1_I884_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I194_XG_MP2 (VDD I1_I884_G23_8n I1_I884_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I194_XG_MP0 (XI1_I884_I194_XG_p1 I1_I884_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I194_XG_MP1 (I1_I884_G23_0 I1_I884_G7_0n XI1_I884_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I196_XG_MP2 (VDD I1_I884_G25_10n I1_I884_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I196_XG_MP0 (XI1_I884_I196_XG_p1 I1_I884_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I196_XG_MP1 (I1_I884_G25_0 I1_I884_G9_0n XI1_I884_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I186_XG_MP2 (VDD I1_I884_G19_4n I1_I884_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I186_XG_MP0 (XI1_I884_I186_XG_p1 I1_I884_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I186_XG_MP1 (I1_I884_G19_0 I1_I884_G3_0n XI1_I884_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I184_XG_MP2 (VDD I1_I884_G17_2n I1_I884_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I184_XG_MP0 (XI1_I884_I184_XG_p1 I1_I884_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I184_XG_MP1 (I1_I884_G17_0 I1_I884_G1_0n XI1_I884_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I134_XG_MP2 (VDD I1_I884_G9_6n I1_I884_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I134_XG_MP0 (XI1_I884_I134_XG_p1 I1_I884_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I134_XG_MP1 (I1_I884_G9_2 I1_I884_G5_2n XI1_I884_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I130_XG_MP2 (VDD I1_I884_G5_2n I1_I884_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I130_XG_MP0 (XI1_I884_I130_XG_p1 I1_I884_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I130_XG_MP1 (I1_I884_G5_0 I1_I884_G1_0n XI1_I884_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I132_XG_MP2 (VDD I1_I884_G7_4n I1_I884_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I132_XG_MP0 (XI1_I884_I132_XG_p1 I1_I884_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I132_XG_MP1 (I1_I884_G7_0 I1_I884_G3_0n XI1_I884_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I68_XG_MP2 (VDD I1_I746_gn2 I1_I746_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I68_XG_MP0 (XI1_I746_I68_XG_p1 I1_I746_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I68_XG_MP1 (I1_I746_G2_1 I1_I746_gn1 XI1_I746_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I69_XG_MP2 (VDD I1_I746_gn3 I1_I746_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I69_XG_MP0 (XI1_I746_I69_XG_p1 I1_I746_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I69_XG_MP1 (I1_I746_G3_2 I1_I746_gn2 XI1_I746_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I70_XG_MP2 (VDD I1_I746_gn4 I1_I746_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I70_XG_MP0 (XI1_I746_I70_XG_p1 I1_I746_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I70_XG_MP1 (I1_I746_G4_3 I1_I746_gn3 XI1_I746_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I71_XG_MP2 (VDD I1_I746_gn5 I1_I746_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I71_XG_MP0 (XI1_I746_I71_XG_p1 I1_I746_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I71_XG_MP1 (I1_I746_G5_4 I1_I746_gn4 XI1_I746_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I74_XG_MP2 (VDD I1_I746_gn8 I1_I746_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I746_I74_XG_MP0 (XI1_I746_I74_XG_p1 I1_I746_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I74_XG_MP1 (I1_I746_G8_7 I1_I746_gn7 XI1_I746_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I194_XG_MP2 (VDD I1_I700_G23_8n I1_I700_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I194_XG_MP0 (XI1_I700_I194_XG_p1 I1_I700_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I194_XG_MP1 (I1_I700_G23_0 I1_I700_G7_0n XI1_I700_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I202_XG_MP2 (VDD I1_I700_G31_16n I1_c3_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I202_XG_MP0 (XI1_I700_I202_XG_p1 I1_I700_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I202_XG_MP1 (I1_c3_o I1_I700_G15_0n XI1_I700_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I97_XG_MP2 (VDD I1_I1390_gn31 I1_I1390_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I97_XG_MP0 (XI1_I1390_I97_XG_p1 I1_I1390_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I97_XG_MP1 (I1_I1390_G31_30 I1_I1390_gn30 XI1_I1390_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I96_XG_MP2 (VDD I1_I1390_gn30 I1_I1390_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I96_XG_MP0 (XI1_I1390_I96_XG_p1 I1_I1390_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I96_XG_MP1 (I1_I1390_G30_29 I1_I1390_gn29 XI1_I1390_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I95_XG_MP2 (VDD I1_I1390_gn29 I1_I1390_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I95_XG_MP0 (XI1_I1390_I95_XG_p1 I1_I1390_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I95_XG_MP1 (I1_I1390_G29_28 I1_I1390_gn28 XI1_I1390_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I93_XG_MP2 (VDD I1_I1390_gn27 I1_I1390_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I93_XG_MP0 (XI1_I1390_I93_XG_p1 I1_I1390_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I93_XG_MP1 (I1_I1390_G27_26 I1_I1390_gn26 XI1_I1390_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I89_XG_MP2 (VDD I1_I1390_gn23 I1_I1390_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I89_XG_MP0 (XI1_I1390_I89_XG_p1 I1_I1390_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I89_XG_MP1 (I1_I1390_G23_22 I1_I1390_gn22 XI1_I1390_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I88_XG_MP2 (VDD I1_I1390_gn22 I1_I1390_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I88_XG_MP0 (XI1_I1390_I88_XG_p1 I1_I1390_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I88_XG_MP1 (I1_I1390_G22_21 I1_I1390_gn21 XI1_I1390_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I87_XG_MP2 (VDD I1_I1390_gn21 I1_I1390_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I87_XG_MP0 (XI1_I1390_I87_XG_p1 I1_I1390_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I87_XG_MP1 (I1_I1390_G21_20 I1_I1390_gn20 XI1_I1390_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I86_XG_MP2 (VDD I1_I1390_gn20 I1_I1390_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I86_XG_MP0 (XI1_I1390_I86_XG_p1 I1_I1390_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I86_XG_MP1 (I1_I1390_G20_19 I1_I1390_gn19 XI1_I1390_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I85_XG_MP2 (VDD I1_I1390_gn19 I1_I1390_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I85_XG_MP0 (XI1_I1390_I85_XG_p1 I1_I1390_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I85_XG_MP1 (I1_I1390_G19_18 I1_I1390_gn18 XI1_I1390_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I84_XG_MP2 (VDD I1_I1390_gn18 I1_I1390_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I84_XG_MP0 (XI1_I1390_I84_XG_p1 I1_I1390_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I84_XG_MP1 (I1_I1390_G18_17 I1_I1390_gn17 XI1_I1390_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I128_XG_MP2 (VDD I1_I1344_G4_1n I1_I1344_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I128_XG_MP0 (XI1_I1344_I128_XG_p1 I1_I1344_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I128_XG_MP1 (I1_I1344_G4_0 I1_I1344_G0_0n XI1_I1344_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I72_XG_MP2 (VDD I1_I1344_gn6 I1_I1344_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I72_XG_MP0 (XI1_I1344_I72_XG_p1 I1_I1344_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I72_XG_MP1 (I1_I1344_G6_5 I1_I1344_gn5 XI1_I1344_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I71_XG_MP2 (VDD I1_I1344_gn5 I1_I1344_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I71_XG_MP0 (XI1_I1344_I71_XG_p1 I1_I1344_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I71_XG_MP1 (I1_I1344_G5_4 I1_I1344_gn4 XI1_I1344_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I128_XG_MP2 (VDD I1_I1298_G4_1n I1_I1298_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I128_XG_MP0 (XI1_I1298_I128_XG_p1 I1_I1298_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I128_XG_MP1 (I1_I1298_G4_0 I1_I1298_G0_0n XI1_I1298_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I72_XG_MP2 (VDD I1_I1298_gn6 I1_I1298_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I72_XG_MP0 (XI1_I1298_I72_XG_p1 I1_I1298_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I72_XG_MP1 (I1_I1298_G6_5 I1_I1298_gn5 XI1_I1298_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I70_XG_MP2 (VDD I1_I1252_gn4 I1_I1252_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I70_XG_MP0 (XI1_I1252_I70_XG_p1 I1_I1252_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I70_XG_MP1 (I1_I1252_G4_3 I1_I1252_gn3 XI1_I1252_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I71_XG_MP2 (VDD I1_I1252_gn5 I1_I1252_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I71_XG_MP0 (XI1_I1252_I71_XG_p1 I1_I1252_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I71_XG_MP1 (I1_I1252_G5_4 I1_I1252_gn4 XI1_I1252_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I72_XG_MP2 (VDD I1_I1252_gn6 I1_I1252_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I72_XG_MP0 (XI1_I1252_I72_XG_p1 I1_I1252_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I72_XG_MP1 (I1_I1252_G6_5 I1_I1252_gn5 XI1_I1252_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I198_XG_MP2 (VDD I1_I1160_G27_12n I1_I1160_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1160_I198_XG_MP0 (XI1_I1160_I198_XG_p1 I1_I1160_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I198_XG_MP1 (I1_I1160_G27_0 I1_I1160_G11_0n XI1_I1160_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I186_XG_MP2 (VDD I1_I1160_G19_4n I1_I1160_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1160_I186_XG_MP0 (XI1_I1160_I186_XG_p1 I1_I1160_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I186_XG_MP1 (I1_I1160_G19_0 I1_I1160_G3_0n XI1_I1160_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I72_XG_MP2 (VDD I1_I1206_gn6 I1_I1206_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I72_XG_MP0 (XI1_I1206_I72_XG_p1 I1_I1206_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I72_XG_MP1 (I1_I1206_G6_5 I1_I1206_gn5 XI1_I1206_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I153_XG_MP2 (VDD I1_I884_G28_25n I1_I884_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I153_XG_MP0 (XI1_I884_I153_XG_p1 I1_I884_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I153_XG_MP1 (I1_I884_G28_21 I1_I884_G24_21n XI1_I884_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I151_XG_MP2 (VDD I1_I884_G26_23n I1_I884_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I151_XG_MP0 (XI1_I884_I151_XG_p1 I1_I884_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I151_XG_MP1 (I1_I884_G26_19 I1_I884_G22_19n XI1_I884_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I147_XG_MP2 (VDD I1_I884_G22_19n I1_I884_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I147_XG_MP0 (XI1_I884_I147_XG_p1 I1_I884_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I147_XG_MP1 (I1_I884_G22_15 I1_I884_G18_15n XI1_I884_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I149_XG_MP2 (VDD I1_I884_G24_21n I1_I884_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I149_XG_MP0 (XI1_I884_I149_XG_p1 I1_I884_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I149_XG_MP1 (I1_I884_G24_17 I1_I884_G20_17n XI1_I884_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I145_XG_MP2 (VDD I1_I884_G20_17n I1_I884_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I145_XG_MP0 (XI1_I884_I145_XG_p1 I1_I884_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I145_XG_MP1 (I1_I884_G20_13 I1_I884_G16_13n XI1_I884_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I143_XG_MP2 (VDD I1_I884_G18_15n I1_I884_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I143_XG_MP0 (XI1_I884_I143_XG_p1 I1_I884_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I143_XG_MP1 (I1_I884_G18_11 I1_I884_G14_11n XI1_I884_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I139_XG_MP2 (VDD I1_I884_G14_11n I1_I884_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I139_XG_MP0 (XI1_I884_I139_XG_p1 I1_I884_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I139_XG_MP1 (I1_I884_G14_7 I1_I884_G10_7n XI1_I884_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I141_XG_MP2 (VDD I1_I884_G16_13n I1_I884_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I141_XG_MP0 (XI1_I884_I141_XG_p1 I1_I884_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I141_XG_MP1 (I1_I884_G16_9 I1_I884_G12_9n XI1_I884_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I137_XG_MP2 (VDD I1_I884_G12_9n I1_I884_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I137_XG_MP0 (XI1_I884_I137_XG_p1 I1_I884_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I137_XG_MP1 (I1_I884_G12_5 I1_I884_G8_5n XI1_I884_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I70_XG_MP2 (VDD I1_I884_gn4 I1_I884_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I70_XG_MP0 (XI1_I884_I70_XG_p1 I1_I884_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I70_XG_MP1 (I1_I884_G4_3 I1_I884_gn3 XI1_I884_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I132_XG_MP2 (VDD I1_I700_G7_4n I1_I700_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I132_XG_MP0 (XI1_I700_I132_XG_p1 I1_I700_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I132_XG_MP1 (I1_I700_G7_0 I1_I700_G3_0n XI1_I700_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I136_XG_MP2 (VDD I1_I700_G11_8n I1_I700_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I136_XG_MP0 (XI1_I700_I136_XG_p1 I1_I700_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I136_XG_MP1 (I1_I700_G11_4 I1_I700_G7_4n XI1_I700_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I140_XG_MP2 (VDD I1_I700_G15_12n I1_I700_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I140_XG_MP0 (XI1_I700_I140_XG_p1 I1_I700_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I140_XG_MP1 (I1_I700_G15_8 I1_I700_G11_8n XI1_I700_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I186_XG_MP2 (VDD I1_I700_G19_4n I1_I700_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I186_XG_MP0 (XI1_I700_I186_XG_p1 I1_I700_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I186_XG_MP1 (I1_I700_G19_0 I1_I700_G3_0n XI1_I700_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I190_XG_MP2 (VDD I1_I700_G21_6n I1_I700_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I190_XG_MP0 (XI1_I700_I190_XG_p1 I1_I700_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I190_XG_MP1 (I1_I700_G21_0 I1_I700_G5_0n XI1_I700_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I196_XG_MP2 (VDD I1_I700_G25_10n I1_I700_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I196_XG_MP0 (XI1_I700_I196_XG_p1 I1_I700_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I196_XG_MP1 (I1_I700_G25_0 I1_I700_G9_0n XI1_I700_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I198_XG_MP2 (VDD I1_I700_G27_12n I1_I700_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I198_XG_MP0 (XI1_I700_I198_XG_p1 I1_I700_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I198_XG_MP1 (I1_I700_G27_0 I1_I700_G11_0n XI1_I700_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I200_XG_MP2 (VDD I1_I700_G29_14n I1_I700_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I200_XG_MP0 (XI1_I700_I200_XG_p1 I1_I700_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I200_XG_MP1 (I1_I700_G29_0 I1_I700_G13_0n XI1_I700_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I156_XG_MP2 (VDD I1_I700_G31_28n I1_I700_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I156_XG_MP0 (XI1_I700_I156_XG_p1 I1_I700_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I156_XG_MP1 (I1_I700_G31_24 I1_I700_G27_24n XI1_I700_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I156_XG_MP2 (VDD I1_I1390_G31_28n I1_I1390_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I156_XG_MP0 (XI1_I1390_I156_XG_p1 I1_I1390_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I156_XG_MP1 (I1_I1390_G31_24 I1_I1390_G27_24n XI1_I1390_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I154_XG_MP2 (VDD I1_I1390_G29_26n I1_I1390_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I154_XG_MP0 (XI1_I1390_I154_XG_p1 I1_I1390_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I154_XG_MP1 (I1_I1390_G29_22 I1_I1390_G25_22n XI1_I1390_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I152_XG_MP2 (VDD I1_I1390_G27_24n I1_I1390_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I152_XG_MP0 (XI1_I1390_I152_XG_p1 I1_I1390_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I152_XG_MP1 (I1_I1390_G27_20 I1_I1390_G23_20n XI1_I1390_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I148_XG_MP2 (VDD I1_I1390_G23_20n I1_I1390_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I148_XG_MP0 (XI1_I1390_I148_XG_p1 I1_I1390_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I148_XG_MP1 (I1_I1390_G23_16 I1_I1390_G19_16n XI1_I1390_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I150_XG_MP2 (VDD I1_I1390_G25_22n I1_I1390_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I150_XG_MP0 (XI1_I1390_I150_XG_p1 I1_I1390_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I150_XG_MP1 (I1_I1390_G25_18 I1_I1390_G21_18n XI1_I1390_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I146_XG_MP2 (VDD I1_I1390_G21_18n I1_I1390_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I146_XG_MP0 (XI1_I1390_I146_XG_p1 I1_I1390_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I146_XG_MP1 (I1_I1390_G21_14 I1_I1390_G17_14n XI1_I1390_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I144_XG_MP2 (VDD I1_I1390_G19_16n I1_I1390_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I144_XG_MP0 (XI1_I1390_I144_XG_p1 I1_I1390_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I144_XG_MP1 (I1_I1390_G19_12 I1_I1390_G15_12n XI1_I1390_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I83_XG_MP2 (VDD I1_I1390_gn17 I1_I1390_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I83_XG_MP0 (XI1_I1390_I83_XG_p1 I1_I1390_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I83_XG_MP1 (I1_I1390_G17_16 I1_I1390_gn16 XI1_I1390_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I82_XG_MP2 (VDD I1_I1390_gn16 I1_I1390_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I82_XG_MP0 (XI1_I1390_I82_XG_p1 I1_I1390_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I82_XG_MP1 (I1_I1390_G16_15 I1_I1390_gn15 XI1_I1390_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I81_XG_MP2 (VDD I1_I1390_gn15 I1_I1390_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I81_XG_MP0 (XI1_I1390_I81_XG_p1 I1_I1390_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I81_XG_MP1 (I1_I1390_G15_14 I1_I1390_gn14 XI1_I1390_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I70_XG_MP2 (VDD I1_I1344_gn4 I1_I1344_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I70_XG_MP0 (XI1_I1344_I70_XG_p1 I1_I1344_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I70_XG_MP1 (I1_I1344_G4_3 I1_I1344_gn3 XI1_I1344_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I71_XG_MP2 (VDD I1_I1298_gn5 I1_I1298_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I71_XG_MP0 (XI1_I1298_I71_XG_p1 I1_I1298_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I71_XG_MP1 (I1_I1298_G5_4 I1_I1298_gn4 XI1_I1298_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I70_XG_MP2 (VDD I1_I1298_gn4 I1_I1298_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I70_XG_MP0 (XI1_I1298_I70_XG_p1 I1_I1298_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I70_XG_MP1 (I1_I1298_G4_3 I1_I1298_gn3 XI1_I1298_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I69_XG_MP2 (VDD I1_I1252_gn3 I1_I1252_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I69_XG_MP0 (XI1_I1252_I69_XG_p1 I1_I1252_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I69_XG_MP1 (I1_I1252_G3_2 I1_I1252_gn2 XI1_I1252_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I202_XG_MP2 (VDD I1_I1160_G31_16n I1_c13_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1160_I202_XG_MP0 (XI1_I1160_I202_XG_p1 I1_I1160_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I202_XG_MP1 (I1_c13_o I1_I1160_G15_0n XI1_I1160_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I194_XG_MP2 (VDD I1_I1160_G23_8n I1_I1160_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1160_I194_XG_MP0 (XI1_I1160_I194_XG_p1 I1_I1160_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I194_XG_MP1 (I1_I1160_G23_0 I1_I1160_G7_0n XI1_I1160_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I200_XG_MP2 (VDD I1_I1160_G29_14n I1_I1160_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1160_I200_XG_MP0 (XI1_I1160_I200_XG_p1 I1_I1160_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I200_XG_MP1 (I1_I1160_G29_0 I1_I1160_G13_0n XI1_I1160_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I190_XG_MP2 (VDD I1_I1160_G21_6n I1_I1160_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1160_I190_XG_MP0 (XI1_I1160_I190_XG_p1 I1_I1160_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I190_XG_MP1 (I1_I1160_G21_0 I1_I1160_G5_0n XI1_I1160_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I196_XG_MP2 (VDD I1_I1160_G25_10n I1_I1160_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1160_I196_XG_MP0 (XI1_I1160_I196_XG_p1 I1_I1160_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I196_XG_MP1 (I1_I1160_G25_0 I1_I1160_G9_0n XI1_I1160_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I136_XG_MP2 (VDD I1_I1160_G11_8n I1_I1160_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1160_I136_XG_MP0 (XI1_I1160_I136_XG_p1 I1_I1160_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I136_XG_MP1 (I1_I1160_G11_4 I1_I1160_G7_4n XI1_I1160_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I132_XG_MP2 (VDD I1_I1160_G7_4n I1_I1160_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1160_I132_XG_MP0 (XI1_I1160_I132_XG_p1 I1_I1160_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I132_XG_MP1 (I1_I1160_G7_0 I1_I1160_G3_0n XI1_I1160_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I71_XG_MP2 (VDD I1_I1206_gn5 I1_I1206_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I71_XG_MP0 (XI1_I1206_I71_XG_p1 I1_I1206_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I71_XG_MP1 (I1_I1206_G5_4 I1_I1206_gn4 XI1_I1206_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I70_XG_MP2 (VDD I1_I1206_gn4 I1_I1206_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I70_XG_MP0 (XI1_I1206_I70_XG_p1 I1_I1206_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I70_XG_MP1 (I1_I1206_G4_3 I1_I1206_gn3 XI1_I1206_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I69_XG_MP2 (VDD I1_I1206_gn3 I1_I1206_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I69_XG_MP0 (XI1_I1206_I69_XG_p1 I1_I1206_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I69_XG_MP1 (I1_I1206_G3_2 I1_I1206_gn2 XI1_I1206_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I68_XG_MP2 (VDD I1_I1206_gn2 I1_I1206_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I68_XG_MP0 (XI1_I1206_I68_XG_p1 I1_I1206_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I68_XG_MP1 (I1_I1206_G2_1 I1_I1206_gn1 XI1_I1206_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I67_XG_MP2 (VDD I1_I1206_gn1 I1_I1206_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I67_XG_MP0 (XI1_I1206_I67_XG_p1 I1_I1206_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I67_XG_MP1 (I1_I1206_G1_0 I1_I1206_G0_0n XI1_I1206_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I201_XG_MP2 (VDD I1_I884_G30_15n I1_c7_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I201_XG_MP0 (XI1_I884_I201_XG_p1 I1_I884_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I201_XG_MP1 (I1_c7_m I1_I884_G14_0n XI1_I884_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I199_XG_MP2 (VDD I1_I884_G28_13n I1_I884_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I199_XG_MP0 (XI1_I884_I199_XG_p1 I1_I884_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I199_XG_MP1 (I1_I884_G28_0 I1_I884_G12_0n XI1_I884_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I197_XG_MP2 (VDD I1_I884_G26_11n I1_I884_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I197_XG_MP0 (XI1_I884_I197_XG_p1 I1_I884_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I197_XG_MP1 (I1_I884_G26_0 I1_I884_G10_0n XI1_I884_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I192_XG_MP2 (VDD I1_I884_G22_7n I1_I884_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I192_XG_MP0 (XI1_I884_I192_XG_p1 I1_I884_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I192_XG_MP1 (I1_I884_G22_0 I1_I884_G6_0n XI1_I884_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I195_XG_MP2 (VDD I1_I884_G24_9n I1_I884_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I195_XG_MP0 (XI1_I884_I195_XG_p1 I1_I884_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I195_XG_MP1 (I1_I884_G24_0 I1_I884_G8_0n XI1_I884_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I188_XG_MP2 (VDD I1_I884_G20_5n I1_I884_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I188_XG_MP0 (XI1_I884_I188_XG_p1 I1_I884_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I188_XG_MP1 (I1_I884_G20_0 I1_I884_G4_0n XI1_I884_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I185_XG_MP2 (VDD I1_I884_G18_3n I1_I884_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I185_XG_MP0 (XI1_I884_I185_XG_p1 I1_I884_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I185_XG_MP1 (I1_I884_G18_0 I1_I884_G2_0n XI1_I884_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I135_XG_MP2 (VDD I1_I884_G10_7n I1_I884_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I135_XG_MP0 (XI1_I884_I135_XG_p1 I1_I884_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I135_XG_MP1 (I1_I884_G10_3 I1_I884_G6_3n XI1_I884_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I183_XG_MP2 (VDD I1_I884_G16_1n I1_I884_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I183_XG_MP0 (XI1_I884_I183_XG_p1 I1_I884_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I183_XG_MP1 (I1_I884_G16_0 I1_I884_G0_0n XI1_I884_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I131_XG_MP2 (VDD I1_I884_G6_3n I1_I884_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I131_XG_MP0 (XI1_I884_I131_XG_p1 I1_I884_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I131_XG_MP1 (I1_I884_G6_0 I1_I884_G2_0n XI1_I884_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I133_XG_MP2 (VDD I1_I884_G8_5n I1_I884_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I133_XG_MP0 (XI1_I884_I133_XG_p1 I1_I884_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I133_XG_MP1 (I1_I884_G8_1 I1_I884_G4_1n XI1_I884_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I128_XG_MP2 (VDD I1_I884_G4_1n I1_I884_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I128_XG_MP0 (XI1_I884_I128_XG_p1 I1_I884_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I128_XG_MP1 (I1_I884_G4_0 I1_I884_G0_0n XI1_I884_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I69_XG_MP2 (VDD I1_I884_gn3 I1_I884_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I69_XG_MP0 (XI1_I884_I69_XG_p1 I1_I884_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I69_XG_MP1 (I1_I884_G3_2 I1_I884_gn2 XI1_I884_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I130_XG_MP2 (VDD I1_I700_G5_2n I1_I700_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I130_XG_MP0 (XI1_I700_I130_XG_p1 I1_I700_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I130_XG_MP1 (I1_I700_G5_0 I1_I700_G1_0n XI1_I700_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I134_XG_MP2 (VDD I1_I700_G9_6n I1_I700_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I134_XG_MP0 (XI1_I700_I134_XG_p1 I1_I700_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I134_XG_MP1 (I1_I700_G9_2 I1_I700_G5_2n XI1_I700_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I184_XG_MP2 (VDD I1_I700_G17_2n I1_I700_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I184_XG_MP0 (XI1_I700_I184_XG_p1 I1_I700_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I184_XG_MP1 (I1_I700_G17_0 I1_I700_G1_0n XI1_I700_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I138_XG_MP2 (VDD I1_I700_G13_10n I1_I700_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I138_XG_MP0 (XI1_I700_I138_XG_p1 I1_I700_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I138_XG_MP1 (I1_I700_G13_6 I1_I700_G9_6n XI1_I700_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I142_XG_MP2 (VDD I1_I700_G17_14n I1_I700_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I142_XG_MP0 (XI1_I700_I142_XG_p1 I1_I700_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I142_XG_MP1 (I1_I700_G17_10 I1_I700_G13_10n XI1_I700_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I144_XG_MP2 (VDD I1_I700_G19_16n I1_I700_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I144_XG_MP0 (XI1_I700_I144_XG_p1 I1_I700_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I144_XG_MP1 (I1_I700_G19_12 I1_I700_G15_12n XI1_I700_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I146_XG_MP2 (VDD I1_I700_G21_18n I1_I700_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I146_XG_MP0 (XI1_I700_I146_XG_p1 I1_I700_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I146_XG_MP1 (I1_I700_G21_14 I1_I700_G17_14n XI1_I700_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I150_XG_MP2 (VDD I1_I700_G25_22n I1_I700_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I150_XG_MP0 (XI1_I700_I150_XG_p1 I1_I700_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I150_XG_MP1 (I1_I700_G25_18 I1_I700_G21_18n XI1_I700_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I154_XG_MP2 (VDD I1_I700_G29_26n I1_I700_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I154_XG_MP0 (XI1_I700_I154_XG_p1 I1_I700_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I154_XG_MP1 (I1_I700_G29_22 I1_I700_G25_22n XI1_I700_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I202_XG_MP2 (VDD I1_I1390_G31_16n I1_c18_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I202_XG_MP0 (XI1_I1390_I202_XG_p1 I1_I1390_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I202_XG_MP1 (I1_c18_o I1_I1390_G15_0n XI1_I1390_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I200_XG_MP2 (VDD I1_I1390_G29_14n I1_I1390_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I200_XG_MP0 (XI1_I1390_I200_XG_p1 I1_I1390_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I200_XG_MP1 (I1_I1390_G29_0 I1_I1390_G13_0n XI1_I1390_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I80_XG_MP2 (VDD I1_I1390_gn14 I1_I1390_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I80_XG_MP0 (XI1_I1390_I80_XG_p1 I1_I1390_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I80_XG_MP1 (I1_I1390_G14_13 I1_I1390_gn13 XI1_I1390_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I79_XG_MP2 (VDD I1_I1390_gn13 I1_I1390_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I79_XG_MP0 (XI1_I1390_I79_XG_p1 I1_I1390_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I79_XG_MP1 (I1_I1390_G13_12 I1_I1390_gn12 XI1_I1390_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I78_XG_MP2 (VDD I1_I1390_gn12 I1_I1390_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I78_XG_MP0 (XI1_I1390_I78_XG_p1 I1_I1390_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I78_XG_MP1 (I1_I1390_G12_11 I1_I1390_gn11 XI1_I1390_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I77_XG_MP2 (VDD I1_I1390_gn11 I1_I1390_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I77_XG_MP0 (XI1_I1390_I77_XG_p1 I1_I1390_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I77_XG_MP1 (I1_I1390_G11_10 I1_I1390_gn10 XI1_I1390_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I76_XG_MP2 (VDD I1_I1390_gn10 I1_I1390_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I76_XG_MP0 (XI1_I1390_I76_XG_p1 I1_I1390_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I76_XG_MP1 (I1_I1390_G10_9 I1_I1390_gn9 XI1_I1390_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I69_XG_MP2 (VDD I1_I1344_gn3 I1_I1344_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I69_XG_MP0 (XI1_I1344_I69_XG_p1 I1_I1344_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I69_XG_MP1 (I1_I1344_G3_2 I1_I1344_gn2 XI1_I1344_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I68_XG_MP2 (VDD I1_I1344_gn2 I1_I1344_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I68_XG_MP0 (XI1_I1344_I68_XG_p1 I1_I1344_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I68_XG_MP1 (I1_I1344_G2_1 I1_I1344_gn1 XI1_I1344_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I67_XG_MP2 (VDD I1_I1298_gn1 I1_I1298_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I67_XG_MP0 (XI1_I1298_I67_XG_p1 I1_I1298_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I67_XG_MP1 (I1_I1298_G1_0 I1_I1298_G0_0n XI1_I1298_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I68_XG_MP2 (VDD I1_I1298_gn2 I1_I1298_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I68_XG_MP0 (XI1_I1298_I68_XG_p1 I1_I1298_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I68_XG_MP1 (I1_I1298_G2_1 I1_I1298_gn1 XI1_I1298_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I69_XG_MP2 (VDD I1_I1298_gn3 I1_I1298_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I69_XG_MP0 (XI1_I1298_I69_XG_p1 I1_I1298_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I69_XG_MP1 (I1_I1298_G3_2 I1_I1298_gn2 XI1_I1298_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I67_XG_MP2 (VDD I1_I1252_gn1 I1_I1252_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I67_XG_MP0 (XI1_I1252_I67_XG_p1 I1_I1252_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I67_XG_MP1 (I1_I1252_G1_0 I1_I1252_G0_0n XI1_I1252_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I68_XG_MP2 (VDD I1_I1252_gn2 I1_I1252_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I68_XG_MP0 (XI1_I1252_I68_XG_p1 I1_I1252_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I68_XG_MP1 (I1_I1252_G2_1 I1_I1252_gn1 XI1_I1252_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I152_XG_MP2 (VDD I1_I1160_G27_24n I1_I1160_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1160_I152_XG_MP0 (XI1_I1160_I152_XG_p1 I1_I1160_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I152_XG_MP1 (I1_I1160_G27_20 I1_I1160_G23_20n XI1_I1160_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I184_XG_MP2 (VDD I1_I1160_G17_2n I1_I1160_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1160_I184_XG_MP0 (XI1_I1160_I184_XG_p1 I1_I1160_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I184_XG_MP1 (I1_I1160_G17_0 I1_I1160_G1_0n XI1_I1160_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I130_XG_MP2 (VDD I1_I1160_G5_2n I1_I1160_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1160_I130_XG_MP0 (XI1_I1160_I130_XG_p1 I1_I1160_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I130_XG_MP1 (I1_I1160_G5_0 I1_I1160_G1_0n XI1_I1160_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I67_XG_MP2 (VDD I1_I884_gn1 I1_I884_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I67_XG_MP0 (XI1_I884_I67_XG_p1 I1_I884_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I67_XG_MP1 (I1_I884_G1_0 I1_I884_G0_0n XI1_I884_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I68_XG_MP2 (VDD I1_I884_gn2 I1_I884_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I884_I68_XG_MP0 (XI1_I884_I68_XG_p1 I1_I884_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I68_XG_MP1 (I1_I884_G2_1 I1_I884_gn1 XI1_I884_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I65_XG_MP2 (VDD I1_I792_gn0 I1_I792_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I792_I65_XG_MP0 (XI1_I792_I65_XG_p1 I1_I792_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I65_XG_MP1 (I1_I792_G0_0 I1_I792_cinn XI1_I792_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I185_XG_MP2 (VDD I1_I700_G18_3n I1_I700_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I185_XG_MP0 (XI1_I700_I185_XG_p1 I1_I700_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I185_XG_MP1 (I1_I700_G18_0 I1_I700_G2_0n XI1_I700_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I188_XG_MP2 (VDD I1_I700_G20_5n I1_I700_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I188_XG_MP0 (XI1_I700_I188_XG_p1 I1_I700_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I188_XG_MP1 (I1_I700_G20_0 I1_I700_G4_0n XI1_I700_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I192_XG_MP2 (VDD I1_I700_G22_7n I1_I700_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I192_XG_MP0 (XI1_I700_I192_XG_p1 I1_I700_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I192_XG_MP1 (I1_I700_G22_0 I1_I700_G6_0n XI1_I700_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I194_XG_MP2 (VDD I1_I1390_G23_8n I1_I1390_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I194_XG_MP0 (XI1_I1390_I194_XG_p1 I1_I1390_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I194_XG_MP1 (I1_I1390_G23_0 I1_I1390_G7_0n XI1_I1390_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I198_XG_MP2 (VDD I1_I1390_G27_12n I1_I1390_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I198_XG_MP0 (XI1_I1390_I198_XG_p1 I1_I1390_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I198_XG_MP1 (I1_I1390_G27_0 I1_I1390_G11_0n XI1_I1390_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I196_XG_MP2 (VDD I1_I1390_G25_10n I1_I1390_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I196_XG_MP0 (XI1_I1390_I196_XG_p1 I1_I1390_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I196_XG_MP1 (I1_I1390_G25_0 I1_I1390_G9_0n XI1_I1390_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I190_XG_MP2 (VDD I1_I1390_G21_6n I1_I1390_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I190_XG_MP0 (XI1_I1390_I190_XG_p1 I1_I1390_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I190_XG_MP1 (I1_I1390_G21_0 I1_I1390_G5_0n XI1_I1390_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I138_XG_MP2 (VDD I1_I1390_G13_10n I1_I1390_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I138_XG_MP0 (XI1_I1390_I138_XG_p1 I1_I1390_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I138_XG_MP1 (I1_I1390_G13_6 I1_I1390_G9_6n XI1_I1390_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I136_XG_MP2 (VDD I1_I1390_G11_8n I1_I1390_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I136_XG_MP0 (XI1_I1390_I136_XG_p1 I1_I1390_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I136_XG_MP1 (I1_I1390_G11_4 I1_I1390_G7_4n XI1_I1390_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I134_XG_MP2 (VDD I1_I1390_G9_6n I1_I1390_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I134_XG_MP0 (XI1_I1390_I134_XG_p1 I1_I1390_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I134_XG_MP1 (I1_I1390_G9_2 I1_I1390_G5_2n XI1_I1390_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I75_XG_MP2 (VDD I1_I1390_gn9 I1_I1390_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I75_XG_MP0 (XI1_I1390_I75_XG_p1 I1_I1390_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I75_XG_MP1 (I1_I1390_G9_8 I1_I1390_gn8 XI1_I1390_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I74_XG_MP2 (VDD I1_I1390_gn8 I1_I1390_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I74_XG_MP0 (XI1_I1390_I74_XG_p1 I1_I1390_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I74_XG_MP1 (I1_I1390_G8_7 I1_I1390_gn7 XI1_I1390_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I67_XG_MP2 (VDD I1_I1344_gn1 I1_I1344_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1344_I67_XG_MP0 (XI1_I1344_I67_XG_p1 I1_I1344_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I67_XG_MP1 (I1_I1344_G1_0 I1_I1344_G0_0n XI1_I1344_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I65_XG_MP2 (VDD I1_I1252_gn0 I1_I1252_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1252_I65_XG_MP0 (XI1_I1252_I65_XG_p1 I1_I1252_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I65_XG_MP1 (I1_I1252_G0_0 I1_I1252_cinn XI1_I1252_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I146_XG_MP2 (VDD I1_I1160_G21_18n I1_I1160_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1160_I146_XG_MP0 (XI1_I1160_I146_XG_p1 I1_I1160_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I146_XG_MP1 (I1_I1160_G21_14 I1_I1160_G17_14n XI1_I1160_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I134_XG_MP2 (VDD I1_I1160_G9_6n I1_I1160_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1160_I134_XG_MP0 (XI1_I1160_I134_XG_p1 I1_I1160_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I134_XG_MP1 (I1_I1160_G9_2 I1_I1160_G5_2n XI1_I1160_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I65_XG_MP2 (VDD I1_I1206_gn0 I1_I1206_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1206_I65_XG_MP0 (XI1_I1206_I65_XG_p1 I1_I1206_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I65_XG_MP1 (I1_I1206_G0_0 I1_I1206_cinn XI1_I1206_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I89_XG_MP2 (VDD I1_I930_gn23 I1_I930_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I930_I89_XG_MP0 (XI1_I930_I89_XG_p1 I1_I930_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I89_XG_MP1 (I1_I930_G23_22 I1_I930_gn22 XI1_I930_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I88_XG_MP2 (VDD I1_I930_gn22 I1_I930_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I930_I88_XG_MP0 (XI1_I930_I88_XG_p1 I1_I930_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I88_XG_MP1 (I1_I930_G22_21 I1_I930_gn21 XI1_I930_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I84_XG_MP2 (VDD I1_I930_gn18 I1_I930_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I930_I84_XG_MP0 (XI1_I930_I84_XG_p1 I1_I930_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I84_XG_MP1 (I1_I930_G18_17 I1_I930_gn17 XI1_I930_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I81_XG_MP2 (VDD I1_I930_gn15 I1_I930_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I930_I81_XG_MP0 (XI1_I930_I81_XG_p1 I1_I930_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I81_XG_MP1 (I1_I930_G15_14 I1_I930_gn14 XI1_I930_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I67_XG_MP2 (VDD I1_I700_gn1 I1_I700_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I67_XG_MP0 (XI1_I700_I67_XG_p1 I1_I700_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I67_XG_MP1 (I1_I700_G1_0 I1_I700_G0_0n XI1_I700_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I128_XG_MP2 (VDD I1_I700_G4_1n I1_I700_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I128_XG_MP0 (XI1_I700_I128_XG_p1 I1_I700_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I128_XG_MP1 (I1_I700_G4_0 I1_I700_G0_0n XI1_I700_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I133_XG_MP2 (VDD I1_I700_G8_5n I1_I700_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I133_XG_MP0 (XI1_I700_I133_XG_p1 I1_I700_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I133_XG_MP1 (I1_I700_G8_1 I1_I700_G4_1n XI1_I700_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I183_XG_MP2 (VDD I1_I700_G16_1n I1_I700_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I183_XG_MP0 (XI1_I700_I183_XG_p1 I1_I700_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I183_XG_MP1 (I1_I700_G16_0 I1_I700_G0_0n XI1_I700_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I131_XG_MP2 (VDD I1_I700_G6_3n I1_I700_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I131_XG_MP0 (XI1_I700_I131_XG_p1 I1_I700_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I131_XG_MP1 (I1_I700_G6_0 I1_I700_G2_0n XI1_I700_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I135_XG_MP2 (VDD I1_I700_G10_7n I1_I700_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I135_XG_MP0 (XI1_I700_I135_XG_p1 I1_I700_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I135_XG_MP1 (I1_I700_G10_3 I1_I700_G6_3n XI1_I700_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I195_XG_MP2 (VDD I1_I700_G24_9n I1_I700_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I195_XG_MP0 (XI1_I700_I195_XG_p1 I1_I700_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I195_XG_MP1 (I1_I700_G24_0 I1_I700_G8_0n XI1_I700_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I197_XG_MP2 (VDD I1_I700_G26_11n I1_I700_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I197_XG_MP0 (XI1_I700_I197_XG_p1 I1_I700_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I197_XG_MP1 (I1_I700_G26_0 I1_I700_G10_0n XI1_I700_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I151_XG_MP2 (VDD I1_I700_G26_23n I1_I700_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I151_XG_MP0 (XI1_I700_I151_XG_p1 I1_I700_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I151_XG_MP1 (I1_I700_G26_19 I1_I700_G22_19n XI1_I700_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I155_XG_MP2 (VDD I1_I700_G30_27n I1_I700_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I155_XG_MP0 (XI1_I700_I155_XG_p1 I1_I700_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I155_XG_MP1 (I1_I700_G30_23 I1_I700_G26_23n XI1_I700_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I151_XG_MP2 (VDD I1_I1390_G26_23n I1_I1390_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I151_XG_MP0 (XI1_I1390_I151_XG_p1 I1_I1390_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I151_XG_MP1 (I1_I1390_G26_19 I1_I1390_G22_19n XI1_I1390_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I186_XG_MP2 (VDD I1_I1390_G19_4n I1_I1390_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I186_XG_MP0 (XI1_I1390_I186_XG_p1 I1_I1390_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I186_XG_MP1 (I1_I1390_G19_0 I1_I1390_G3_0n XI1_I1390_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I184_XG_MP2 (VDD I1_I1390_G17_2n I1_I1390_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I184_XG_MP0 (XI1_I1390_I184_XG_p1 I1_I1390_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I184_XG_MP1 (I1_I1390_G17_0 I1_I1390_G1_0n XI1_I1390_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I130_XG_MP2 (VDD I1_I1390_G5_2n I1_I1390_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I130_XG_MP0 (XI1_I1390_I130_XG_p1 I1_I1390_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I130_XG_MP1 (I1_I1390_G5_0 I1_I1390_G1_0n XI1_I1390_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I132_XG_MP2 (VDD I1_I1390_G7_4n I1_I1390_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I132_XG_MP0 (XI1_I1390_I132_XG_p1 I1_I1390_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I132_XG_MP1 (I1_I1390_G7_0 I1_I1390_G3_0n XI1_I1390_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I73_XG_MP2 (VDD I1_I1390_gn7 I1_I1390_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1390_I73_XG_MP0 (XI1_I1390_I73_XG_p1 I1_I1390_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I73_XG_MP1 (I1_I1390_G7_6 I1_I1390_gn6 XI1_I1390_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I65_XG_MP2 (VDD I1_I1298_gn0 I1_I1298_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1298_I65_XG_MP0 (XI1_I1298_I65_XG_p1 I1_I1298_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I65_XG_MP1 (I1_I1298_G0_0 I1_I1298_cinn XI1_I1298_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I95_XG_MP2 (VDD I1_I1160_gn29 I1_I1160_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1160_I95_XG_MP0 (XI1_I1160_I95_XG_p1 I1_I1160_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I95_XG_MP1 (I1_I1160_G29_28 I1_I1160_gn28 XI1_I1160_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I97_XG_MP2 (VDD I1_I1160_gn31 I1_I1160_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1160_I97_XG_MP0 (XI1_I1160_I97_XG_p1 I1_I1160_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I97_XG_MP1 (I1_I1160_G31_30 I1_I1160_gn30 XI1_I1160_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I96_XG_MP2 (VDD I1_I1160_gn30 I1_I1160_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1160_I96_XG_MP0 (XI1_I1160_I96_XG_p1 I1_I1160_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I96_XG_MP1 (I1_I1160_G30_29 I1_I1160_gn29 XI1_I1160_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I201_XG_MP2 (VDD I1_I1160_G30_15n I1_c13_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1160_I201_XG_MP0 (XI1_I1160_I201_XG_p1 I1_I1160_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I201_XG_MP1 (I1_c13_m I1_I1160_G14_0n XI1_I1160_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I192_XG_MP2 (VDD I1_I1160_G22_7n I1_I1160_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1160_I192_XG_MP0 (XI1_I1160_I192_XG_p1 I1_I1160_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I192_XG_MP1 (I1_I1160_G22_0 I1_I1160_G6_0n XI1_I1160_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I199_XG_MP2 (VDD I1_I1160_G28_13n I1_I1160_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1160_I199_XG_MP0 (XI1_I1160_I199_XG_p1 I1_I1160_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I199_XG_MP1 (I1_I1160_G28_0 I1_I1160_G12_0n XI1_I1160_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I188_XG_MP2 (VDD I1_I1160_G20_5n I1_I1160_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1160_I188_XG_MP0 (XI1_I1160_I188_XG_p1 I1_I1160_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I188_XG_MP1 (I1_I1160_G20_0 I1_I1160_G4_0n XI1_I1160_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I195_XG_MP2 (VDD I1_I1160_G24_9n I1_I1160_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1160_I195_XG_MP0 (XI1_I1160_I195_XG_p1 I1_I1160_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I195_XG_MP1 (I1_I1160_G24_0 I1_I1160_G8_0n XI1_I1160_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I183_XG_MP2 (VDD I1_I1160_G16_1n I1_I1160_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1160_I183_XG_MP0 (XI1_I1160_I183_XG_p1 I1_I1160_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I183_XG_MP1 (I1_I1160_G16_0 I1_I1160_G0_0n XI1_I1160_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I128_XG_MP2 (VDD I1_I1160_G4_1n I1_I1160_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1160_I128_XG_MP0 (XI1_I1160_I128_XG_p1 I1_I1160_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I128_XG_MP1 (I1_I1160_G4_0 I1_I1160_G0_0n XI1_I1160_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I67_XG_MP2 (VDD I1_I1160_gn1 I1_I1160_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I1160_I67_XG_MP0 (XI1_I1160_I67_XG_p1 I1_I1160_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I67_XG_MP1 (I1_I1160_G1_0 I1_I1160_G0_0n XI1_I1160_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I95_XG_MP2 (VDD I1_I930_gn29 I1_I930_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I930_I95_XG_MP0 (XI1_I930_I95_XG_p1 I1_I930_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I95_XG_MP1 (I1_I930_G29_28 I1_I930_gn28 XI1_I930_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I90_XG_MP2 (VDD I1_I930_gn24 I1_I930_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I930_I90_XG_MP0 (XI1_I930_I90_XG_p1 I1_I930_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I90_XG_MP1 (I1_I930_G24_23 I1_I930_gn23 XI1_I930_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I154_XG_MP2 (VDD I1_I930_G29_26n I1_I930_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I930_I154_XG_MP0 (XI1_I930_I154_XG_p1 I1_I930_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I154_XG_MP1 (I1_I930_G29_22 I1_I930_G25_22n XI1_I930_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I152_XG_MP2 (VDD I1_I930_G27_24n I1_I930_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I930_I152_XG_MP0 (XI1_I930_I152_XG_p1 I1_I930_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I152_XG_MP1 (I1_I930_G27_20 I1_I930_G23_20n XI1_I930_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I148_XG_MP2 (VDD I1_I930_G23_20n I1_I930_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I930_I148_XG_MP0 (XI1_I930_I148_XG_p1 I1_I930_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I148_XG_MP1 (I1_I930_G23_16 I1_I930_G19_16n XI1_I930_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I150_XG_MP2 (VDD I1_I930_G25_22n I1_I930_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I930_I150_XG_MP0 (XI1_I930_I150_XG_p1 I1_I930_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I150_XG_MP1 (I1_I930_G25_18 I1_I930_G21_18n XI1_I930_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I146_XG_MP2 (VDD I1_I930_G21_18n I1_I930_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I930_I146_XG_MP0 (XI1_I930_I146_XG_p1 I1_I930_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I146_XG_MP1 (I1_I930_G21_14 I1_I930_G17_14n XI1_I930_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I80_XG_MP2 (VDD I1_I930_gn14 I1_I930_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I930_I80_XG_MP0 (XI1_I930_I80_XG_p1 I1_I930_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I80_XG_MP1 (I1_I930_G14_13 I1_I930_gn13 XI1_I930_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I142_XG_MP2 (VDD I1_I930_G17_14n I1_I930_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I930_I142_XG_MP0 (XI1_I930_I142_XG_p1 I1_I930_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I142_XG_MP1 (I1_I930_G17_10 I1_I930_G13_10n XI1_I930_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I79_XG_MP2 (VDD I1_I930_gn13 I1_I930_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I930_I79_XG_MP0 (XI1_I930_I79_XG_p1 I1_I930_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I79_XG_MP1 (I1_I930_G13_12 I1_I930_gn12 XI1_I930_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I78_XG_MP2 (VDD I1_I930_gn12 I1_I930_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I930_I78_XG_MP0 (XI1_I930_I78_XG_p1 I1_I930_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I78_XG_MP1 (I1_I930_G12_11 I1_I930_gn11 XI1_I930_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I77_XG_MP2 (VDD I1_I930_gn11 I1_I930_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I930_I77_XG_MP0 (XI1_I930_I77_XG_p1 I1_I930_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I77_XG_MP1 (I1_I930_G11_10 I1_I930_gn10 XI1_I930_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I76_XG_MP2 (VDD I1_I930_gn10 I1_I930_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I930_I76_XG_MP0 (XI1_I930_I76_XG_p1 I1_I930_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I76_XG_MP1 (I1_I930_G10_9 I1_I930_gn9 XI1_I930_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I65_XG_MP2 (VDD I1_I838_gn0 I1_I838_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I838_I65_XG_MP0 (XI1_I838_I65_XG_p1 I1_I838_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I65_XG_MP1 (I1_I838_G0_0 I1_I838_cinn XI1_I838_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I68_XG_MP2 (VDD I1_I700_gn2 I1_I700_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I68_XG_MP0 (XI1_I700_I68_XG_p1 I1_I700_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I68_XG_MP1 (I1_I700_G2_1 I1_I700_gn1 XI1_I700_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I69_XG_MP2 (VDD I1_I700_gn3 I1_I700_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I69_XG_MP0 (XI1_I700_I69_XG_p1 I1_I700_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I69_XG_MP1 (I1_I700_G3_2 I1_I700_gn2 XI1_I700_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I71_XG_MP2 (VDD I1_I700_gn5 I1_I700_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I71_XG_MP0 (XI1_I700_I71_XG_p1 I1_I700_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I71_XG_MP1 (I1_I700_G5_4 I1_I700_gn4 XI1_I700_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I72_XG_MP2 (VDD I1_I700_gn6 I1_I700_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I72_XG_MP0 (XI1_I700_I72_XG_p1 I1_I700_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I72_XG_MP1 (I1_I700_G6_5 I1_I700_gn5 XI1_I700_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I73_XG_MP2 (VDD I1_I700_gn7 I1_I700_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I73_XG_MP0 (XI1_I700_I73_XG_p1 I1_I700_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I73_XG_MP1 (I1_I700_G7_6 I1_I700_gn6 XI1_I700_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I74_XG_MP2 (VDD I1_I700_gn8 I1_I700_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I74_XG_MP0 (XI1_I700_I74_XG_p1 I1_I700_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I74_XG_MP1 (I1_I700_G8_7 I1_I700_gn7 XI1_I700_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I137_XG_MP2 (VDD I1_I700_G12_9n I1_I700_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I137_XG_MP0 (XI1_I700_I137_XG_p1 I1_I700_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I137_XG_MP1 (I1_I700_G12_5 I1_I700_G8_5n XI1_I700_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I141_XG_MP2 (VDD I1_I700_G16_13n I1_I700_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.91999u ps=1.15999u
    I_MXI1_I700_I141_XG_MP0 (XI1_I700_I141_XG_p1 I1_I700_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I141_XG_MP1 (I1_I700_G16_9 I1_I700_G12_9n XI1_I700_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.63999u ps=0.91999u
