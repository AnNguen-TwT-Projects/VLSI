    I_MXI0_I1356_MN3 (XI0_I1356_xn I0_two15_b3_5 XI0_I1356_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1356_MN1 (XI0_I1356_n1 I0_one15_b3_5 XI0_I1356_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1356_MN9 (VSS XI0_I1356_xn XI0_I1356_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1354_MN11 (VSS I0_B_31_b3_4 XI0_I1354_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1354_MN14 (VSS XI0_I1354_xbn XI0_I1354_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1354_MN16 (XI0_I1354_xn2 I0_B_31_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1354_MN15 (I0_pp15_26 XI0_I1354_xan XI0_I1354_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1354_MN13 (XI0_I1354_xn1 XI0_I1354_xn I0_pp15_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1354_MN2 (VSS I0_A_26_b3_5 XI0_I1354_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1354_MN4 (XI0_I1354_n2 I0_A_25_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1354_MN3 (XI0_I1354_xn I0_two15_b3_4 XI0_I1354_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1354_MN1 (XI0_I1354_n1 I0_one15_b3_4 XI0_I1354_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1354_MN9 (VSS XI0_I1354_xn XI0_I1354_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1350_MN11 (VSS I0_B_31_b3_3 XI0_I1350_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1350_MN14 (VSS XI0_I1350_xbn XI0_I1350_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1350_MN16 (XI0_I1350_xn2 I0_B_31_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1350_MN15 (I0_pp15_22 XI0_I1350_xan XI0_I1350_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1350_MN13 (XI0_I1350_xn1 XI0_I1350_xn I0_pp15_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1350_MN2 (VSS I0_A_22_b3_5 XI0_I1350_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1350_MN4 (XI0_I1350_n2 I0_A_21_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1350_MN3 (XI0_I1350_xn I0_two15_b3_4 XI0_I1350_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1350_MN1 (XI0_I1350_n1 I0_one15_b3_4 XI0_I1350_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1350_MN9 (VSS XI0_I1350_xn XI0_I1350_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1349_MN11 (VSS I0_B_31_b3_3 XI0_I1349_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1349_MN14 (VSS XI0_I1349_xbn XI0_I1349_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1349_MN16 (XI0_I1349_xn2 I0_B_31_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1349_MN15 (I0_pp15_21 XI0_I1349_xan XI0_I1349_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1349_MN13 (XI0_I1349_xn1 XI0_I1349_xn I0_pp15_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1349_MN2 (VSS I0_A_21_b3_5 XI0_I1349_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1349_MN4 (XI0_I1349_n2 I0_A_20_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1349_MN3 (XI0_I1349_xn I0_two15_b3_3 XI0_I1349_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1349_MN1 (XI0_I1349_n1 I0_one15_b3_3 XI0_I1349_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1349_MN9 (VSS XI0_I1349_xn XI0_I1349_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1295_MN11 (VSS I0_B_29_b3_3 XI0_I1295_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1295_MN14 (VSS XI0_I1295_xbn XI0_I1295_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1295_MN16 (XI0_I1295_xn2 I0_B_29_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1295_MN15 (I0_pp14_22 XI0_I1295_xan XI0_I1295_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1295_MN13 (XI0_I1295_xn1 XI0_I1295_xn I0_pp14_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1295_MN2 (VSS I0_A_22_b3_5 XI0_I1295_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1295_MN4 (XI0_I1295_n2 I0_A_21_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1295_MN3 (XI0_I1295_xn I0_two14_b3_4 XI0_I1295_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1295_MN1 (XI0_I1295_n1 I0_one14_b3_4 XI0_I1295_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1295_MN9 (VSS XI0_I1295_xn XI0_I1295_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1188_MN11 (VSS I0_B_25_b3_4 XI0_I1188_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1188_MN14 (VSS XI0_I1188_xbn XI0_I1188_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1188_MN16 (XI0_I1188_xn2 I0_B_25_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1188_MN15 (I0_pp12_25 XI0_I1188_xan XI0_I1188_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1188_MN13 (XI0_I1188_xn1 XI0_I1188_xn I0_pp12_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1188_MN2 (VSS I0_A_25_b3_4 XI0_I1188_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1188_MN4 (XI0_I1188_n2 I0_A_24_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1188_MN3 (XI0_I1188_xn I0_two12_b3_4 XI0_I1188_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1188_MN1 (XI0_I1188_n1 I0_one12_b3_4 XI0_I1188_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1188_MN9 (VSS XI0_I1188_xn XI0_I1188_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1347_MN11 (VSS I0_B_31_b3_3 XI0_I1347_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1347_MN14 (VSS XI0_I1347_xbn XI0_I1347_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1347_MN16 (XI0_I1347_xn2 I0_B_31_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1347_MN15 (I0_pp15_19 XI0_I1347_xan XI0_I1347_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1347_MN13 (XI0_I1347_xn1 XI0_I1347_xn I0_pp15_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1347_MN2 (VSS I0_A_19_b3_5 XI0_I1347_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1347_MN4 (XI0_I1347_n2 I0_A_18_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1347_MN3 (XI0_I1347_xn I0_two15_b3_3 XI0_I1347_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1347_MN1 (XI0_I1347_n1 I0_one15_b3_3 XI0_I1347_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1347_MN9 (VSS XI0_I1347_xn XI0_I1347_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1348_MN11 (VSS I0_B_31_b3_3 XI0_I1348_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1348_MN14 (VSS XI0_I1348_xbn XI0_I1348_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1348_MN16 (XI0_I1348_xn2 I0_B_31_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1348_MN15 (I0_pp15_20 XI0_I1348_xan XI0_I1348_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1348_MN13 (XI0_I1348_xn1 XI0_I1348_xn I0_pp15_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1348_MN2 (VSS I0_A_20_b3_5 XI0_I1348_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1348_MN4 (XI0_I1348_n2 I0_A_19_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1348_MN3 (XI0_I1348_xn I0_two15_b3_3 XI0_I1348_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1348_MN1 (XI0_I1348_n1 I0_one15_b3_3 XI0_I1348_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1348_MN9 (VSS XI0_I1348_xn XI0_I1348_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1187_MN11 (VSS I0_B_25_b3_4 XI0_I1187_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1187_MN14 (VSS XI0_I1187_xbn XI0_I1187_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1187_MN16 (XI0_I1187_xn2 I0_B_25_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1187_MN15 (I0_pp12_24 XI0_I1187_xan XI0_I1187_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1187_MN13 (XI0_I1187_xn1 XI0_I1187_xn I0_pp12_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1187_MN2 (VSS I0_A_24_b3_4 XI0_I1187_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1187_MN4 (XI0_I1187_n2 I0_A_23_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1187_MN3 (XI0_I1187_xn I0_two12_b3_4 XI0_I1187_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1187_MN1 (XI0_I1187_n1 I0_one12_b3_4 XI0_I1187_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1187_MN9 (VSS XI0_I1187_xn XI0_I1187_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1134_MN11 (VSS I0_B_23_b3_4 XI0_I1134_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1134_MN14 (VSS XI0_I1134_xbn XI0_I1134_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1134_MN16 (XI0_I1134_xn2 I0_B_23_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1134_MN15 (I0_pp11_26 XI0_I1134_xan XI0_I1134_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1134_MN13 (XI0_I1134_xn1 XI0_I1134_xn I0_pp11_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1134_MN2 (VSS I0_A_26_b3_4 XI0_I1134_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1134_MN4 (XI0_I1134_n2 I0_A_25_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1134_MN3 (XI0_I1134_xn I0_two11_b3_4 XI0_I1134_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1134_MN1 (XI0_I1134_n1 I0_one11_b3_4 XI0_I1134_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1134_MN9 (VSS XI0_I1134_xn XI0_I1134_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1029_MN11 (VSS I0_B_19_b3_5 XI0_I1029_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1029_MN14 (VSS XI0_I1029_xbn XI0_I1029_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1029_MN16 (XI0_I1029_xn2 I0_B_19_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1029_MN15 (I0_pp9_31 XI0_I1029_xan XI0_I1029_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1029_MN13 (XI0_I1029_xn1 XI0_I1029_xn I0_pp9_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1029_MN2 (VSS I0_A_31_b3_4 XI0_I1029_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1029_MN4 (XI0_I1029_n2 I0_A_30_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1029_MN3 (XI0_I1029_xn I0_two9_b3_5 XI0_I1029_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1029_MN1 (XI0_I1029_n1 I0_one9_b3_5 XI0_I1029_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1029_MN9 (VSS XI0_I1029_xn XI0_I1029_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I974_MN11 (VSS I0_B_17_b3_5 XI0_I974_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I974_MN14 (VSS XI0_I974_xbn XI0_I974_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I974_MN16 (XI0_I974_xn2 I0_B_17_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I974_MN15 (I0_pp8_31 XI0_I974_xan XI0_I974_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I974_MN13 (XI0_I974_xn1 XI0_I974_xn I0_pp8_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I974_MN2 (VSS I0_A_31_b3_4 XI0_I974_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I974_MN4 (XI0_I974_n2 I0_A_30_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I974_MN3 (XI0_I974_xn I0_two8_b3_5 XI0_I974_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I974_MN1 (XI0_I974_n1 I0_one8_b3_5 XI0_I974_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I974_MN9 (VSS XI0_I974_xn XI0_I974_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I975_MN11 (VSS I0_B_17_b3_5 XI0_I975_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I975_MN14 (VSS XI0_I975_xbn XI0_I975_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I975_MN16 (XI0_I975_xn2 I0_B_17_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I975_MN15 (I0_pp8_32 XI0_I975_xan XI0_I975_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I975_MN13 (XI0_I975_xn1 XI0_I975_xn I0_pp8_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I975_MN2 (VSS I0_A_31_b3_4 XI0_I975_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I975_MN4 (XI0_I975_n2 I0_A_31_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I975_MN3 (XI0_I975_xn I0_two8_b3_5 XI0_I975_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I975_MN1 (XI0_I975_n1 I0_one8_b3_5 XI0_I975_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I975_MN9 (VSS XI0_I975_xn XI0_I975_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1305_MN11 (VSS I0_B_29_b3_5 XI0_I1305_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1305_MN14 (VSS XI0_I1305_xbn XI0_I1305_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1305_MN16 (XI0_I1305_xn2 I0_B_29_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1305_MN15 (I0_pp14_32 XI0_I1305_xan XI0_I1305_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1305_MN13 (XI0_I1305_xn1 XI0_I1305_xn I0_pp14_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1305_MN2 (VSS I0_A_31_b3_7 XI0_I1305_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1305_MN4 (XI0_I1305_n2 I0_A_31_b3_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1305_MN3 (XI0_I1305_xn I0_two14_b3_5 XI0_I1305_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1305_MN1 (XI0_I1305_n1 I0_one14_b3_5 XI0_I1305_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1305_MN9 (VSS XI0_I1305_xn XI0_I1305_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1304_MN11 (VSS I0_B_29_b3_5 XI0_I1304_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1304_MN14 (VSS XI0_I1304_xbn XI0_I1304_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1304_MN16 (XI0_I1304_xn2 I0_B_29_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1304_MN15 (I0_pp14_31 XI0_I1304_xan XI0_I1304_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1304_MN13 (XI0_I1304_xn1 XI0_I1304_xn I0_pp14_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1304_MN2 (VSS I0_A_31_b3_7 XI0_I1304_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1304_MN4 (XI0_I1304_n2 I0_A_30_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1304_MN3 (XI0_I1304_xn I0_two14_b3_5 XI0_I1304_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1304_MN1 (XI0_I1304_n1 I0_one14_b3_5 XI0_I1304_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1304_MN9 (VSS XI0_I1304_xn XI0_I1304_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1353_MN11 (VSS I0_B_31_b3_4 XI0_I1353_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1353_MN14 (VSS XI0_I1353_xbn XI0_I1353_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1353_MN16 (XI0_I1353_xn2 I0_B_31_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1353_MN15 (I0_pp15_25 XI0_I1353_xan XI0_I1353_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1353_MN13 (XI0_I1353_xn1 XI0_I1353_xn I0_pp15_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1353_MN2 (VSS I0_A_25_b3_5 XI0_I1353_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1353_MN4 (XI0_I1353_n2 I0_A_24_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1353_MN3 (XI0_I1353_xn I0_two15_b3_4 XI0_I1353_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1353_MN1 (XI0_I1353_n1 I0_one15_b3_4 XI0_I1353_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1353_MN9 (VSS XI0_I1353_xn XI0_I1353_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1357_MN11 (VSS I0_B_31_b3_5 XI0_I1357_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1357_MN14 (VSS XI0_I1357_xbn XI0_I1357_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1357_MN16 (XI0_I1357_xn2 I0_B_31_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1357_MN15 (I0_pp15_29 XI0_I1357_xan XI0_I1357_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1357_MN13 (XI0_I1357_xn1 XI0_I1357_xn I0_pp15_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1357_MN2 (VSS I0_A_29_b3_5 XI0_I1357_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1357_MN4 (XI0_I1357_n2 I0_A_28_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1357_MN3 (XI0_I1357_xn I0_two15_b3_5 XI0_I1357_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1357_MN1 (XI0_I1357_n1 I0_one15_b3_5 XI0_I1357_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1357_MN9 (VSS XI0_I1357_xn XI0_I1357_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1352_MN11 (VSS I0_B_31_b3_4 XI0_I1352_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1352_MN14 (VSS XI0_I1352_xbn XI0_I1352_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1352_MN16 (XI0_I1352_xn2 I0_B_31_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1352_MN15 (I0_pp15_24 XI0_I1352_xan XI0_I1352_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1352_MN13 (XI0_I1352_xn1 XI0_I1352_xn I0_pp15_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1352_MN2 (VSS I0_A_24_b3_5 XI0_I1352_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1352_MN4 (XI0_I1352_n2 I0_A_23_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1352_MN3 (XI0_I1352_xn I0_two15_b3_4 XI0_I1352_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1352_MN1 (XI0_I1352_n1 I0_one15_b3_4 XI0_I1352_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1352_MN9 (VSS XI0_I1352_xn XI0_I1352_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1299_MN11 (VSS I0_B_29_b3_4 XI0_I1299_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1299_MN14 (VSS XI0_I1299_xbn XI0_I1299_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1299_MN16 (XI0_I1299_xn2 I0_B_29_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1299_MN15 (I0_pp14_26 XI0_I1299_xan XI0_I1299_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1299_MN13 (XI0_I1299_xn1 XI0_I1299_xn I0_pp14_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1299_MN2 (VSS I0_A_26_b3_5 XI0_I1299_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1299_MN4 (XI0_I1299_n2 I0_A_25_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1299_MN3 (XI0_I1299_xn I0_two14_b3_4 XI0_I1299_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1299_MN1 (XI0_I1299_n1 I0_one14_b3_4 XI0_I1299_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1299_MN9 (VSS XI0_I1299_xn XI0_I1299_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1298_MN11 (VSS I0_B_29_b3_4 XI0_I1298_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1298_MN14 (VSS XI0_I1298_xbn XI0_I1298_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1298_MN16 (XI0_I1298_xn2 I0_B_29_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1298_MN15 (I0_pp14_25 XI0_I1298_xan XI0_I1298_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1298_MN13 (XI0_I1298_xn1 XI0_I1298_xn I0_pp14_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1298_MN2 (VSS I0_A_25_b3_5 XI0_I1298_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1298_MN4 (XI0_I1298_n2 I0_A_24_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1298_MN3 (XI0_I1298_xn I0_two14_b3_4 XI0_I1298_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1298_MN1 (XI0_I1298_n1 I0_one14_b3_4 XI0_I1298_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1298_MN9 (VSS XI0_I1298_xn XI0_I1298_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1243_MN11 (VSS I0_B_27_b3_4 XI0_I1243_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1243_MN14 (VSS XI0_I1243_xbn XI0_I1243_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1243_MN16 (XI0_I1243_xn2 I0_B_27_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1243_MN15 (I0_pp13_25 XI0_I1243_xan XI0_I1243_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1243_MN13 (XI0_I1243_xn1 XI0_I1243_xn I0_pp13_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1243_MN2 (VSS I0_A_25_b3_4 XI0_I1243_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1243_MN4 (XI0_I1243_n2 I0_A_24_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1243_MN3 (XI0_I1243_xn I0_two13_b3_4 XI0_I1243_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1243_MN1 (XI0_I1243_n1 I0_one13_b3_4 XI0_I1243_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1243_MN9 (VSS XI0_I1243_xn XI0_I1243_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1296_MN11 (VSS I0_B_29_b3_4 XI0_I1296_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1296_MN14 (VSS XI0_I1296_xbn XI0_I1296_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1296_MN16 (XI0_I1296_xn2 I0_B_29_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1296_MN15 (I0_pp14_23 XI0_I1296_xan XI0_I1296_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1296_MN13 (XI0_I1296_xn1 XI0_I1296_xn I0_pp14_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1296_MN2 (VSS I0_A_23_b3_5 XI0_I1296_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1296_MN4 (XI0_I1296_n2 I0_A_22_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1296_MN3 (XI0_I1296_xn I0_two14_b3_4 XI0_I1296_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1296_MN1 (XI0_I1296_n1 I0_one14_b3_4 XI0_I1296_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1296_MN9 (VSS XI0_I1296_xn XI0_I1296_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1241_MN11 (VSS I0_B_27_b3_4 XI0_I1241_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1241_MN14 (VSS XI0_I1241_xbn XI0_I1241_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1241_MN16 (XI0_I1241_xn2 I0_B_27_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1241_MN15 (I0_pp13_23 XI0_I1241_xan XI0_I1241_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1241_MN13 (XI0_I1241_xn1 XI0_I1241_xn I0_pp13_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1241_MN2 (VSS I0_A_23_b3_4 XI0_I1241_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1241_MN4 (XI0_I1241_n2 I0_A_22_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1241_MN3 (XI0_I1241_xn I0_two13_b3_4 XI0_I1241_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1241_MN1 (XI0_I1241_n1 I0_one13_b3_4 XI0_I1241_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1241_MN9 (VSS XI0_I1241_xn XI0_I1241_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1244_MN11 (VSS I0_B_27_b3_4 XI0_I1244_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1244_MN14 (VSS XI0_I1244_xbn XI0_I1244_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1244_MN16 (XI0_I1244_xn2 I0_B_27_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1244_MN15 (I0_pp13_26 XI0_I1244_xan XI0_I1244_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1244_MN13 (XI0_I1244_xn1 XI0_I1244_xn I0_pp13_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1244_MN2 (VSS I0_A_26_b3_4 XI0_I1244_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1244_MN4 (XI0_I1244_n2 I0_A_25_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1244_MN3 (XI0_I1244_xn I0_two13_b3_4 XI0_I1244_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1244_MN1 (XI0_I1244_n1 I0_one13_b3_4 XI0_I1244_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1244_MN9 (VSS XI0_I1244_xn XI0_I1244_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1242_MN11 (VSS I0_B_27_b3_4 XI0_I1242_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1242_MN14 (VSS XI0_I1242_xbn XI0_I1242_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1242_MN16 (XI0_I1242_xn2 I0_B_27_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1242_MN15 (I0_pp13_24 XI0_I1242_xan XI0_I1242_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1242_MN13 (XI0_I1242_xn1 XI0_I1242_xn I0_pp13_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1242_MN2 (VSS I0_A_24_b3_4 XI0_I1242_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1242_MN4 (XI0_I1242_n2 I0_A_23_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1242_MN3 (XI0_I1242_xn I0_two13_b3_4 XI0_I1242_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1242_MN1 (XI0_I1242_n1 I0_one13_b3_4 XI0_I1242_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1242_MN9 (VSS XI0_I1242_xn XI0_I1242_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1189_MN11 (VSS I0_B_25_b3_4 XI0_I1189_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1189_MN14 (VSS XI0_I1189_xbn XI0_I1189_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1189_MN16 (XI0_I1189_xn2 I0_B_25_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1189_MN15 (I0_pp12_26 XI0_I1189_xan XI0_I1189_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1189_MN13 (XI0_I1189_xn1 XI0_I1189_xn I0_pp12_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1189_MN2 (VSS I0_A_26_b3_4 XI0_I1189_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1189_MN4 (XI0_I1189_n2 I0_A_25_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1189_MN3 (XI0_I1189_xn I0_two12_b3_4 XI0_I1189_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1189_MN1 (XI0_I1189_n1 I0_one12_b3_4 XI0_I1189_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1189_MN9 (VSS XI0_I1189_xn XI0_I1189_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1190_MN11 (VSS I0_B_25_b3_4 XI0_I1190_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1190_MN14 (VSS XI0_I1190_xbn XI0_I1190_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1190_MN16 (XI0_I1190_xn2 I0_B_25_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1190_MN15 (I0_pp12_27 XI0_I1190_xan XI0_I1190_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1190_MN13 (XI0_I1190_xn1 XI0_I1190_xn I0_pp12_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1190_MN2 (VSS I0_A_27_b3_4 XI0_I1190_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1190_MN4 (XI0_I1190_n2 I0_A_26_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1190_MN3 (XI0_I1190_xn I0_two12_b3_4 XI0_I1190_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1190_MN1 (XI0_I1190_n1 I0_one12_b3_4 XI0_I1190_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1190_MN9 (VSS XI0_I1190_xn XI0_I1190_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1135_MN11 (VSS I0_B_23_b3_4 XI0_I1135_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1135_MN14 (VSS XI0_I1135_xbn XI0_I1135_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1135_MN16 (XI0_I1135_xn2 I0_B_23_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1135_MN15 (I0_pp11_27 XI0_I1135_xan XI0_I1135_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1135_MN13 (XI0_I1135_xn1 XI0_I1135_xn I0_pp11_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1135_MN2 (VSS I0_A_27_b3_4 XI0_I1135_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1135_MN4 (XI0_I1135_n2 I0_A_26_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1135_MN3 (XI0_I1135_xn I0_two11_b3_4 XI0_I1135_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1135_MN1 (XI0_I1135_n1 I0_one11_b3_4 XI0_I1135_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1135_MN9 (VSS XI0_I1135_xn XI0_I1135_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1030_MN11 (VSS I0_B_19_b3_5 XI0_I1030_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1030_MN14 (VSS XI0_I1030_xbn XI0_I1030_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1030_MN16 (XI0_I1030_xn2 I0_B_19_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1030_MN15 (I0_pp9_32 XI0_I1030_xan XI0_I1030_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1030_MN13 (XI0_I1030_xn1 XI0_I1030_xn I0_pp9_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1030_MN2 (VSS I0_A_31_b3_4 XI0_I1030_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1030_MN4 (XI0_I1030_n2 I0_A_31_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1030_MN3 (XI0_I1030_xn I0_two9_b3_5 XI0_I1030_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1030_MN1 (XI0_I1030_n1 I0_one9_b3_5 XI0_I1030_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1030_MN9 (VSS XI0_I1030_xn XI0_I1030_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1028_MN11 (VSS I0_B_19_b3_5 XI0_I1028_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1028_MN14 (VSS XI0_I1028_xbn XI0_I1028_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1028_MN16 (XI0_I1028_xn2 I0_B_19_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1028_MN15 (I0_pp9_30 XI0_I1028_xan XI0_I1028_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1028_MN13 (XI0_I1028_xn1 XI0_I1028_xn I0_pp9_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1028_MN2 (VSS I0_A_30_b3_3 XI0_I1028_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1028_MN4 (XI0_I1028_n2 I0_A_29_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1028_MN3 (XI0_I1028_xn I0_two9_b3_5 XI0_I1028_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1028_MN1 (XI0_I1028_n1 I0_one9_b3_5 XI0_I1028_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1028_MN9 (VSS XI0_I1028_xn XI0_I1028_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1351_MN11 (VSS I0_B_31_b3_4 XI0_I1351_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1351_MN14 (VSS XI0_I1351_xbn XI0_I1351_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1351_MN16 (XI0_I1351_xn2 I0_B_31_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1351_MN15 (I0_pp15_23 XI0_I1351_xan XI0_I1351_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1351_MN13 (XI0_I1351_xn1 XI0_I1351_xn I0_pp15_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1351_MN2 (VSS I0_A_23_b3_5 XI0_I1351_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1351_MN4 (XI0_I1351_n2 I0_A_22_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1351_MN3 (XI0_I1351_xn I0_two15_b3_4 XI0_I1351_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1351_MN1 (XI0_I1351_n1 I0_one15_b3_4 XI0_I1351_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1351_MN9 (VSS XI0_I1351_xn XI0_I1351_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1297_MN11 (VSS I0_B_29_b3_4 XI0_I1297_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1297_MN14 (VSS XI0_I1297_xbn XI0_I1297_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1297_MN16 (XI0_I1297_xn2 I0_B_29_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1297_MN15 (I0_pp14_24 XI0_I1297_xan XI0_I1297_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1297_MN13 (XI0_I1297_xn1 XI0_I1297_xn I0_pp14_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1297_MN2 (VSS I0_A_24_b3_5 XI0_I1297_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1297_MN4 (XI0_I1297_n2 I0_A_23_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1297_MN3 (XI0_I1297_xn I0_two14_b3_4 XI0_I1297_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1297_MN1 (XI0_I1297_n1 I0_one14_b3_4 XI0_I1297_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1297_MN9 (VSS XI0_I1297_xn XI0_I1297_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1358_MN11 (VSS I0_B_31_b3_5 XI0_I1358_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1358_MN14 (VSS XI0_I1358_xbn XI0_I1358_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1358_MN16 (XI0_I1358_xn2 I0_B_31_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1358_MN15 (I0_pp15_30 XI0_I1358_xan XI0_I1358_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1358_MN13 (XI0_I1358_xn1 XI0_I1358_xn I0_pp15_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1358_MN2 (VSS I0_A_30_b3_5 XI0_I1358_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1358_MN4 (XI0_I1358_n2 I0_A_29_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1358_MN3 (XI0_I1358_xn I0_two15_b3_5 XI0_I1358_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1358_MN1 (XI0_I1358_n1 I0_one15_b3_5 XI0_I1358_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1358_MN9 (VSS XI0_I1358_xn XI0_I1358_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1359_MN11 (VSS I0_B_31_b3_5 XI0_I1359_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1359_MN14 (VSS XI0_I1359_xbn XI0_I1359_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1359_MN16 (XI0_I1359_xn2 I0_B_31_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1359_MN15 (I0_pp15_31 XI0_I1359_xan XI0_I1359_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1359_MN13 (XI0_I1359_xn1 XI0_I1359_xn I0_pp15_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1359_MN2 (VSS I0_A_31_b3_7 XI0_I1359_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1359_MN4 (XI0_I1359_n2 I0_A_30_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1359_MN3 (XI0_I1359_xn I0_two15_b3_5 XI0_I1359_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1359_MN1 (XI0_I1359_n1 I0_one15_b3_5 XI0_I1359_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1359_MN9 (VSS XI0_I1359_xn XI0_I1359_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1360_MN11 (VSS I0_B_31_b3_5 XI0_I1360_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1360_MN14 (VSS XI0_I1360_xbn XI0_I1360_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1360_MN16 (XI0_I1360_xn2 I0_B_31_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1360_MN15 (I0_pp15_32 XI0_I1360_xan XI0_I1360_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1360_MN13 (XI0_I1360_xn1 XI0_I1360_xn I0_pp15_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1360_MN2 (VSS I0_A_31_b3_7 XI0_I1360_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1360_MN4 (XI0_I1360_n2 I0_A_31_b3_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1360_MN3 (XI0_I1360_xn I0_two15_b3_5 XI0_I1360_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1360_MN1 (XI0_I1360_n1 I0_one15_b3_5 XI0_I1360_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1360_MN9 (VSS XI0_I1360_xn XI0_I1360_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I30_MN1 (XI1_I1344_I30_n1 I1_b17_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I30_MN0 (I1_I1344_gn30 I1_p16_29 XI1_I1344_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I31_MN1 (XI1_I1344_I31_n1 I1_b17_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I31_MN0 (I1_I1344_gn31 I1_p16_30 XI1_I1344_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I182_XP_MN1 (XI1_I1344_I182_XP_n1 I1_I1344_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I182_XP_MN0 (I1_I1344_P31_16n I1_I1344_P31_24 XI1_I1344_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I127_XP_MN1 (XI1_I1298_I127_XP_n1 I1_I1298_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I127_XP_MN0 (I1_I1298_P31_28n I1_I1298_P31_30 XI1_I1298_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I29_MN1 (XI1_I1298_I29_n1 I1_b16_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I29_MN0 (I1_I1298_gn29 I1_p15_28 XI1_I1298_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I28_MN1 (XI1_I1298_I28_n1 I1_b16_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I28_MN0 (I1_I1298_gn28 I1_p15_27 XI1_I1298_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I30_MN1 (XI1_I1298_I30_n1 I1_b16_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I30_MN0 (I1_I1298_gn30 I1_p15_29 XI1_I1298_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I31_MN1 (XI1_I1298_I31_n1 I1_b16_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I31_MN0 (I1_I1298_gn31 I1_p15_30 XI1_I1298_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I127_XP_MN1 (XI1_I1252_I127_XP_n1 I1_I1252_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I127_XP_MN0 (I1_I1252_P31_28n I1_I1252_P31_30 XI1_I1252_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I28_MN1 (XI1_I1252_I28_n1 I1_b15_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I28_MN0 (I1_I1252_gn28 I1_p14_27 XI1_I1252_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I29_MN1 (XI1_I1252_I29_n1 I1_b15_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I29_MN0 (I1_I1252_gn29 I1_p14_28 XI1_I1252_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I31_MN1 (XI1_I1252_I31_n1 I1_b15_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I31_MN0 (I1_I1252_gn31 I1_p14_30 XI1_I1252_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I30_MN1 (XI1_I1252_I30_n1 I1_b15_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I30_MN0 (I1_I1252_gn30 I1_p14_29 XI1_I1252_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I29_MN1 (XI1_I1206_I29_n1 I1_b14_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I29_MN0 (I1_I1206_gn29 I1_p13_28 XI1_I1206_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I28_MN1 (XI1_I1206_I28_n1 I1_b14_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I28_MN0 (I1_I1206_gn28 I1_p13_27 XI1_I1206_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I27_MN1 (XI1_I1206_I27_n1 I1_b14_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I27_MN0 (I1_I1206_gn27 I1_p13_26 XI1_I1206_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I29_MN1 (XI1_I838_I29_n1 I1_b6_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I29_MN0 (I1_I838_gn29 I1_p5_28 XI1_I838_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I30_MN1 (XI1_I838_I30_n1 I1_b6_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I30_MN0 (I1_I838_gn30 I1_p5_29 XI1_I838_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I31_MN1 (XI1_I838_I31_n1 I1_b6_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I31_MN0 (I1_I838_gn31 I1_p5_30 XI1_I838_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I125_XP_MN1 (XI1_I838_I125_XP_n1 I1_I838_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I125_XP_MN0 (I1_I838_P29_26n I1_I838_P29_28 XI1_I838_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I127_XP_MN1 (XI1_I838_I127_XP_n1 I1_I838_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I127_XP_MN0 (I1_I838_P31_28n I1_I838_P31_30 XI1_I838_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I123_XP_MN1 (XI1_I838_I123_XP_n1 I1_I838_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I123_XP_MN0 (I1_I838_P27_24n I1_I838_P27_26 XI1_I838_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I180_XP_MN1 (XI1_I838_I180_XP_n1 I1_I838_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I180_XP_MN0 (I1_I838_P29_14n I1_I838_P29_22 XI1_I838_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I178_XP_MN1 (XI1_I838_I178_XP_n1 I1_I838_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I178_XP_MN0 (I1_I838_P27_12n I1_I838_P27_20 XI1_I838_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I182_XP_MN1 (XI1_I838_I182_XP_n1 I1_I838_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I182_XP_MN0 (I1_I838_P31_16n I1_I838_P31_24 XI1_I838_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I174_XP_MN1 (XI1_I838_I174_XP_n1 I1_I838_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I174_XP_MN0 (I1_I838_P23_8n I1_I838_P23_16 XI1_I838_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I172_XP_MN1 (XI1_I838_I172_XP_n1 I1_I838_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I172_XP_MN0 (I1_I838_P21_6n I1_I838_P21_14 XI1_I838_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I170_XP_MN1 (XI1_I838_I170_XP_n1 I1_I838_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I170_XP_MN0 (I1_I838_P19_4n I1_I838_P19_12 XI1_I838_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I178_XP_MN1 (XI1_I792_I178_XP_n1 I1_I792_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I178_XP_MN0 (I1_I792_P27_12n I1_I792_P27_20 XI1_I792_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I182_XP_MN1 (XI1_I792_I182_XP_n1 I1_I792_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I182_XP_MN0 (I1_I792_P31_16n I1_I792_P31_24 XI1_I792_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I123_XP_MN1 (XI1_I792_I123_XP_n1 I1_I792_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I123_XP_MN0 (I1_I792_P27_24n I1_I792_P27_26 XI1_I792_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I125_XP_MN1 (XI1_I792_I125_XP_n1 I1_I792_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I125_XP_MN0 (I1_I792_P29_26n I1_I792_P29_28 XI1_I792_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I127_XP_MN1 (XI1_I792_I127_XP_n1 I1_I792_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I127_XP_MN0 (I1_I792_P31_28n I1_I792_P31_30 XI1_I792_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I124_XP_MN1 (XI1_I792_I124_XP_n1 I1_I792_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I124_XP_MN0 (I1_I792_P28_25n I1_I792_P28_27 XI1_I792_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I126_XP_MN1 (XI1_I792_I126_XP_n1 I1_I792_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I126_XP_MN0 (I1_I792_P30_27n I1_I792_P30_29 XI1_I792_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I30_MN1 (XI1_I792_I30_n1 I1_b5_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I30_MN0 (I1_I792_gn30 I1_p4_29 XI1_I792_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I31_MN1 (XI1_I792_I31_n1 I1_b5_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I31_MN0 (I1_I792_gn31 I1_p4_30 XI1_I792_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I28_MN1 (XI1_I792_I28_n1 I1_b5_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I28_MN0 (I1_I792_gn28 I1_p4_27 XI1_I792_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I27_MN1 (XI1_I792_I27_n1 I1_b5_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I27_MN0 (I1_I792_gn27 I1_p4_26 XI1_I792_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I29_MN1 (XI1_I792_I29_n1 I1_b5_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I29_MN0 (I1_I792_gn29 I1_p4_28 XI1_I792_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I28_MN1 (XI1_I1344_I28_n1 I1_b17_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I28_MN0 (I1_I1344_gn28 I1_p16_27 XI1_I1344_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I29_MN1 (XI1_I1344_I29_n1 I1_b17_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I29_MN0 (I1_I1344_gn29 I1_p16_28 XI1_I1344_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I125_XP_MN1 (XI1_I1344_I125_XP_n1 I1_I1344_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I125_XP_MN0 (I1_I1344_P29_26n I1_I1344_P29_28 XI1_I1344_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I127_XP_MN1 (XI1_I1344_I127_XP_n1 I1_I1344_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I127_XP_MN0 (I1_I1344_P31_28n I1_I1344_P31_30 XI1_I1344_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I123_XP_MN1 (XI1_I1344_I123_XP_n1 I1_I1344_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I123_XP_MN0 (I1_I1344_P27_24n I1_I1344_P27_26 XI1_I1344_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I174_XP_MN1 (XI1_I1344_I174_XP_n1 I1_I1344_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I174_XP_MN0 (I1_I1344_P23_8n I1_I1344_P23_16 XI1_I1344_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I182_XP_MN1 (XI1_I1298_I182_XP_n1 I1_I1298_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I182_XP_MN0 (I1_I1298_P31_16n I1_I1298_P31_24 XI1_I1298_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I125_XP_MN1 (XI1_I1298_I125_XP_n1 I1_I1298_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I125_XP_MN0 (I1_I1298_P29_26n I1_I1298_P29_28 XI1_I1298_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I123_XP_MN1 (XI1_I1298_I123_XP_n1 I1_I1298_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I123_XP_MN0 (I1_I1298_P27_24n I1_I1298_P27_26 XI1_I1298_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I126_XP_MN1 (XI1_I1298_I126_XP_n1 I1_I1298_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I126_XP_MN0 (I1_I1298_P30_27n I1_I1298_P30_29 XI1_I1298_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I27_MN1 (XI1_I1298_I27_n1 I1_b16_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I27_MN0 (I1_I1298_gn27 I1_p15_26 XI1_I1298_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I26_MN1 (XI1_I1298_I26_n1 I1_b16_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I26_MN0 (I1_I1298_gn26 I1_p15_25 XI1_I1298_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I181_XP_MN1 (XI1_I1252_I181_XP_n1 I1_I1252_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I181_XP_MN0 (I1_I1252_P30_15n I1_I1252_P30_23 XI1_I1252_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I124_XP_MN1 (XI1_I1252_I124_XP_n1 I1_I1252_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I124_XP_MN0 (I1_I1252_P28_25n I1_I1252_P28_27 XI1_I1252_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I126_XP_MN1 (XI1_I1252_I126_XP_n1 I1_I1252_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I126_XP_MN0 (I1_I1252_P30_27n I1_I1252_P30_29 XI1_I1252_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I125_XP_MN1 (XI1_I1252_I125_XP_n1 I1_I1252_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I125_XP_MN0 (I1_I1252_P29_26n I1_I1252_P29_28 XI1_I1252_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I27_MN1 (XI1_I1252_I27_n1 I1_b15_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I27_MN0 (I1_I1252_gn27 I1_p14_26 XI1_I1252_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I26_MN1 (XI1_I1252_I26_n1 I1_b15_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I26_MN0 (I1_I1252_gn26 I1_p14_25 XI1_I1252_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I127_XP_MN1 (XI1_I1206_I127_XP_n1 I1_I1206_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I127_XP_MN0 (I1_I1206_P31_28n I1_I1206_P31_30 XI1_I1206_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I126_XP_MN1 (XI1_I1206_I126_XP_n1 I1_I1206_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I126_XP_MN0 (I1_I1206_P30_27n I1_I1206_P30_29 XI1_I1206_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I28_MN1 (XI1_I838_I28_n1 I1_b6_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I28_MN0 (I1_I838_gn28 I1_p5_27 XI1_I838_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I25_MN1 (XI1_I838_I25_n1 I1_b6_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I25_MN0 (I1_I838_gn25 I1_p5_24 XI1_I838_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I121_XP_MN1 (XI1_I838_I121_XP_n1 I1_I838_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I121_XP_MN0 (I1_I838_P25_22n I1_I838_P25_24 XI1_I838_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I119_XP_MN1 (XI1_I838_I119_XP_n1 I1_I838_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I119_XP_MN0 (I1_I838_P23_20n I1_I838_P23_22 XI1_I838_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I117_XP_MN1 (XI1_I838_I117_XP_n1 I1_I838_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I117_XP_MN0 (I1_I838_P21_18n I1_I838_P21_20 XI1_I838_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I115_XP_MN1 (XI1_I838_I115_XP_n1 I1_I838_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I115_XP_MN0 (I1_I838_P19_16n I1_I838_P19_18 XI1_I838_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I113_XP_MN1 (XI1_I838_I113_XP_n1 I1_I838_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I113_XP_MN0 (I1_I838_P17_14n I1_I838_P17_16 XI1_I838_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I111_XP_MN1 (XI1_I838_I111_XP_n1 I1_I838_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I111_XP_MN0 (I1_I838_P15_12n I1_I838_P15_14 XI1_I838_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I168_XP_MN1 (XI1_I838_I168_XP_n1 I1_I838_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I168_XP_MN0 (I1_I838_P17_2n I1_I838_P17_10 XI1_I838_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I180_XP_MN1 (XI1_I792_I180_XP_n1 I1_I792_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I180_XP_MN0 (I1_I792_P29_14n I1_I792_P29_22 XI1_I792_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I176_XP_MN1 (XI1_I792_I176_XP_n1 I1_I792_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I176_XP_MN0 (I1_I792_P25_10n I1_I792_P25_18 XI1_I792_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I174_XP_MN1 (XI1_I792_I174_XP_n1 I1_I792_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I174_XP_MN0 (I1_I792_P23_8n I1_I792_P23_16 XI1_I792_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I119_XP_MN1 (XI1_I792_I119_XP_n1 I1_I792_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I119_XP_MN0 (I1_I792_P23_20n I1_I792_P23_22 XI1_I792_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I121_XP_MN1 (XI1_I792_I121_XP_n1 I1_I792_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I121_XP_MN0 (I1_I792_P25_22n I1_I792_P25_24 XI1_I792_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I179_XP_MN1 (XI1_I792_I179_XP_n1 I1_I792_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I179_XP_MN0 (I1_I792_P28_13n I1_I792_P28_21 XI1_I792_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I181_XP_MN1 (XI1_I792_I181_XP_n1 I1_I792_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I181_XP_MN0 (I1_I792_P30_15n I1_I792_P30_23 XI1_I792_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I120_XP_MN1 (XI1_I792_I120_XP_n1 I1_I792_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I120_XP_MN0 (I1_I792_P24_21n I1_I792_P24_23 XI1_I792_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I122_XP_MN1 (XI1_I792_I122_XP_n1 I1_I792_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I122_XP_MN0 (I1_I792_P26_23n I1_I792_P26_25 XI1_I792_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I23_MN1 (XI1_I792_I23_n1 I1_b5_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I23_MN0 (I1_I792_gn23 I1_p4_22 XI1_I792_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I26_MN1 (XI1_I792_I26_n1 I1_b5_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I26_MN0 (I1_I792_gn26 I1_p4_25 XI1_I792_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I24_MN1 (XI1_I792_I24_n1 I1_b5_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I24_MN0 (I1_I792_gn24 I1_p4_23 XI1_I792_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I25_MN1 (XI1_I792_I25_n1 I1_b5_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I25_MN0 (I1_I792_gn25 I1_p4_24 XI1_I792_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I121_XP_MN1 (XI1_I1344_I121_XP_n1 I1_I1344_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I121_XP_MN0 (I1_I1344_P25_22n I1_I1344_P25_24 XI1_I1344_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I119_XP_MN1 (XI1_I1344_I119_XP_n1 I1_I1344_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I119_XP_MN0 (I1_I1344_P23_20n I1_I1344_P23_22 XI1_I1344_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I180_XP_MN1 (XI1_I1344_I180_XP_n1 I1_I1344_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I180_XP_MN0 (I1_I1344_P29_14n I1_I1344_P29_22 XI1_I1344_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I178_XP_MN1 (XI1_I1344_I178_XP_n1 I1_I1344_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I178_XP_MN0 (I1_I1344_P27_12n I1_I1344_P27_20 XI1_I1344_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I170_XP_MN1 (XI1_I1344_I170_XP_n1 I1_I1344_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I170_XP_MN0 (I1_I1344_P19_4n I1_I1344_P19_12 XI1_I1344_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I178_XP_MN1 (XI1_I1298_I178_XP_n1 I1_I1298_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I178_XP_MN0 (I1_I1298_P27_12n I1_I1298_P27_20 XI1_I1298_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I180_XP_MN1 (XI1_I1298_I180_XP_n1 I1_I1298_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I180_XP_MN0 (I1_I1298_P29_14n I1_I1298_P29_22 XI1_I1298_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I121_XP_MN1 (XI1_I1298_I121_XP_n1 I1_I1298_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I121_XP_MN0 (I1_I1298_P25_22n I1_I1298_P25_24 XI1_I1298_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I181_XP_MN1 (XI1_I1298_I181_XP_n1 I1_I1298_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I181_XP_MN0 (I1_I1298_P30_15n I1_I1298_P30_23 XI1_I1298_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I124_XP_MN1 (XI1_I1298_I124_XP_n1 I1_I1298_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I124_XP_MN0 (I1_I1298_P28_25n I1_I1298_P28_27 XI1_I1298_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I122_XP_MN1 (XI1_I1298_I122_XP_n1 I1_I1298_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I122_XP_MN0 (I1_I1298_P26_23n I1_I1298_P26_25 XI1_I1298_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I25_MN1 (XI1_I1298_I25_n1 I1_b16_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I25_MN0 (I1_I1298_gn25 I1_p15_24 XI1_I1298_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I24_MN1 (XI1_I1298_I24_n1 I1_b16_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I24_MN0 (I1_I1298_gn24 I1_p15_23 XI1_I1298_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I179_XP_MN1 (XI1_I1252_I179_XP_n1 I1_I1252_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I179_XP_MN0 (I1_I1252_P28_13n I1_I1252_P28_21 XI1_I1252_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I122_XP_MN1 (XI1_I1252_I122_XP_n1 I1_I1252_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I122_XP_MN0 (I1_I1252_P26_23n I1_I1252_P26_25 XI1_I1252_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I182_XP_MN1 (XI1_I1252_I182_XP_n1 I1_I1252_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I182_XP_MN0 (I1_I1252_P31_16n I1_I1252_P31_24 XI1_I1252_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I123_XP_MN1 (XI1_I1252_I123_XP_n1 I1_I1252_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I123_XP_MN0 (I1_I1252_P27_24n I1_I1252_P27_26 XI1_I1252_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I23_MN1 (XI1_I1252_I23_n1 I1_b15_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I23_MN0 (I1_I1252_gn23 I1_p14_22 XI1_I1252_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I24_MN1 (XI1_I1252_I24_n1 I1_b15_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I24_MN0 (I1_I1252_gn24 I1_p14_23 XI1_I1252_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I25_MN1 (XI1_I1252_I25_n1 I1_b15_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I25_MN0 (I1_I1252_gn25 I1_p14_24 XI1_I1252_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I31_MN1 (XI1_I1206_I31_n1 I1_b14_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I31_MN0 (I1_I1206_gn31 I1_p13_30 XI1_I1206_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I30_MN1 (XI1_I1206_I30_n1 I1_b14_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I30_MN0 (I1_I1206_gn30 I1_p13_29 XI1_I1206_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I24_MN1 (XI1_I1206_I24_n1 I1_b14_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I24_MN0 (I1_I1206_gn24 I1_p13_23 XI1_I1206_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I123_XP_MN1 (XI1_I1206_I123_XP_n1 I1_I1206_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I123_XP_MN0 (I1_I1206_P27_24n I1_I1206_P27_26 XI1_I1206_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I125_XP_MN1 (XI1_I1206_I125_XP_n1 I1_I1206_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I125_XP_MN0 (I1_I1206_P29_26n I1_I1206_P29_28 XI1_I1206_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I25_MN1 (XI1_I1206_I25_n1 I1_b14_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I25_MN0 (I1_I1206_gn25 I1_p13_24 XI1_I1206_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I26_MN1 (XI1_I1206_I26_n1 I1_b14_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I26_MN0 (I1_I1206_gn26 I1_p13_25 XI1_I1206_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I124_XP_MN1 (XI1_I1206_I124_XP_n1 I1_I1206_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I124_XP_MN0 (I1_I1206_P28_25n I1_I1206_P28_27 XI1_I1206_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I27_MN1 (XI1_I838_I27_n1 I1_b6_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I27_MN0 (I1_I838_gn27 I1_p5_26 XI1_I838_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I26_MN1 (XI1_I838_I26_n1 I1_b6_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I26_MN0 (I1_I838_gn26 I1_p5_25 XI1_I838_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I24_MN1 (XI1_I838_I24_n1 I1_b6_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I24_MN0 (I1_I838_gn24 I1_p5_23 XI1_I838_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I23_MN1 (XI1_I838_I23_n1 I1_b6_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I23_MN0 (I1_I838_gn23 I1_p5_22 XI1_I838_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I22_MN1 (XI1_I838_I22_n1 I1_b6_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I22_MN0 (I1_I838_gn22 I1_p5_21 XI1_I838_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I21_MN1 (XI1_I838_I21_n1 I1_b6_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I21_MN0 (I1_I838_gn21 I1_p5_20 XI1_I838_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I17_MN1 (XI1_I838_I17_n1 I1_b6_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I17_MN0 (I1_I838_gn17 I1_p5_16 XI1_I838_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I176_XP_MN1 (XI1_I838_I176_XP_n1 I1_I838_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I176_XP_MN0 (I1_I838_P25_10n I1_I838_P25_18 XI1_I838_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I15_MN1 (XI1_I838_I15_n1 I1_b6_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I15_MN0 (I1_I838_gn15 I1_p5_14 XI1_I838_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I109_XP_MN1 (XI1_I838_I109_XP_n1 I1_I838_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I109_XP_MN0 (I1_I838_P13_10n I1_I838_P13_12 XI1_I838_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I107_XP_MN1 (XI1_I838_I107_XP_n1 I1_I838_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I107_XP_MN0 (I1_I838_P11_8n I1_I838_P11_10 XI1_I838_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I105_XP_MN1 (XI1_I838_I105_XP_n1 I1_I838_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I105_XP_MN0 (I1_I838_P9_6n I1_I838_P9_8 XI1_I838_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I103_XP_MN1 (XI1_I838_I103_XP_n1 I1_I838_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I103_XP_MN0 (I1_I838_P7_4n I1_I838_P7_6 XI1_I838_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I101_XP_MN1 (XI1_I838_I101_XP_n1 I1_I838_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I101_XP_MN0 (I1_I838_P5_2n I1_I838_P5_4 XI1_I838_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I172_XP_MN1 (XI1_I792_I172_XP_n1 I1_I792_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I172_XP_MN0 (I1_I792_P21_6n I1_I792_P21_14 XI1_I792_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I170_XP_MN1 (XI1_I792_I170_XP_n1 I1_I792_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I170_XP_MN0 (I1_I792_P19_4n I1_I792_P19_12 XI1_I792_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I115_XP_MN1 (XI1_I792_I115_XP_n1 I1_I792_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I115_XP_MN0 (I1_I792_P19_16n I1_I792_P19_18 XI1_I792_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I117_XP_MN1 (XI1_I792_I117_XP_n1 I1_I792_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I117_XP_MN0 (I1_I792_P21_18n I1_I792_P21_20 XI1_I792_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I173_XP_MN1 (XI1_I792_I173_XP_n1 I1_I792_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I173_XP_MN0 (I1_I792_P22_7n I1_I792_P22_15 XI1_I792_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I177_XP_MN1 (XI1_I792_I177_XP_n1 I1_I792_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I177_XP_MN0 (I1_I792_P26_11n I1_I792_P26_19 XI1_I792_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I118_XP_MN1 (XI1_I792_I118_XP_n1 I1_I792_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I118_XP_MN0 (I1_I792_P22_19n I1_I792_P22_21 XI1_I792_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I21_MN1 (XI1_I792_I21_n1 I1_b5_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I21_MN0 (I1_I792_gn21 I1_p4_20 XI1_I792_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I22_MN1 (XI1_I792_I22_n1 I1_b5_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I22_MN0 (I1_I792_gn22 I1_p4_21 XI1_I792_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I126_XP_MN1 (XI1_I746_I126_XP_n1 I1_I746_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I126_XP_MN0 (I1_I746_P30_27n I1_I746_P30_29 XI1_I746_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I26_MN1 (XI1_I746_I26_n1 I1_b4_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I26_MN0 (I1_I746_gn26 I1_p3_25 XI1_I746_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I27_MN1 (XI1_I1344_I27_n1 I1_b17_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I27_MN0 (I1_I1344_gn27 I1_p16_26 XI1_I1344_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I25_MN1 (XI1_I1344_I25_n1 I1_b17_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I25_MN0 (I1_I1344_gn25 I1_p16_24 XI1_I1344_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I126_XP_MN1 (XI1_I1344_I126_XP_n1 I1_I1344_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I126_XP_MN0 (I1_I1344_P30_27n I1_I1344_P30_29 XI1_I1344_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I24_MN1 (XI1_I1344_I24_n1 I1_b17_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I24_MN0 (I1_I1344_gn24 I1_p16_23 XI1_I1344_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I23_MN1 (XI1_I1344_I23_n1 I1_b17_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I23_MN0 (I1_I1344_gn23 I1_p16_22 XI1_I1344_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I117_XP_MN1 (XI1_I1344_I117_XP_n1 I1_I1344_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I117_XP_MN0 (I1_I1344_P21_18n I1_I1344_P21_20 XI1_I1344_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I115_XP_MN1 (XI1_I1344_I115_XP_n1 I1_I1344_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I115_XP_MN0 (I1_I1344_P19_16n I1_I1344_P19_18 XI1_I1344_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I113_XP_MN1 (XI1_I1344_I113_XP_n1 I1_I1344_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I113_XP_MN0 (I1_I1344_P17_14n I1_I1344_P17_16 XI1_I1344_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I111_XP_MN1 (XI1_I1344_I111_XP_n1 I1_I1344_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I111_XP_MN0 (I1_I1344_P15_12n I1_I1344_P15_14 XI1_I1344_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I174_XP_MN1 (XI1_I1298_I174_XP_n1 I1_I1298_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I174_XP_MN0 (I1_I1298_P23_8n I1_I1298_P23_16 XI1_I1298_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I119_XP_MN1 (XI1_I1298_I119_XP_n1 I1_I1298_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I119_XP_MN0 (I1_I1298_P23_20n I1_I1298_P23_22 XI1_I1298_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I179_XP_MN1 (XI1_I1298_I179_XP_n1 I1_I1298_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I179_XP_MN0 (I1_I1298_P28_13n I1_I1298_P28_21 XI1_I1298_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I120_XP_MN1 (XI1_I1298_I120_XP_n1 I1_I1298_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I120_XP_MN0 (I1_I1298_P24_21n I1_I1298_P24_23 XI1_I1298_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I23_MN1 (XI1_I1298_I23_n1 I1_b16_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I23_MN0 (I1_I1298_gn23 I1_p15_22 XI1_I1298_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I177_XP_MN1 (XI1_I1252_I177_XP_n1 I1_I1252_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I177_XP_MN0 (I1_I1252_P26_11n I1_I1252_P26_19 XI1_I1252_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I120_XP_MN1 (XI1_I1252_I120_XP_n1 I1_I1252_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I120_XP_MN0 (I1_I1252_P24_21n I1_I1252_P24_23 XI1_I1252_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I174_XP_MN1 (XI1_I1252_I174_XP_n1 I1_I1252_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I174_XP_MN0 (I1_I1252_P23_8n I1_I1252_P23_16 XI1_I1252_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I180_XP_MN1 (XI1_I1252_I180_XP_n1 I1_I1252_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I180_XP_MN0 (I1_I1252_P29_14n I1_I1252_P29_22 XI1_I1252_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I121_XP_MN1 (XI1_I1252_I121_XP_n1 I1_I1252_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I121_XP_MN0 (I1_I1252_P25_22n I1_I1252_P25_24 XI1_I1252_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I22_MN1 (XI1_I1252_I22_n1 I1_b15_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I22_MN0 (I1_I1252_gn22 I1_p14_21 XI1_I1252_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I23_MN1 (XI1_I1206_I23_n1 I1_b14_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I23_MN0 (I1_I1206_gn23 I1_p13_22 XI1_I1206_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I22_MN1 (XI1_I1206_I22_n1 I1_b14_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I22_MN0 (I1_I1206_gn22 I1_p13_21 XI1_I1206_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I122_XP_MN1 (XI1_I1206_I122_XP_n1 I1_I1206_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I122_XP_MN0 (I1_I1206_P26_23n I1_I1206_P26_25 XI1_I1206_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I126_XP_MN1 (XI1_I838_I126_XP_n1 I1_I838_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I126_XP_MN0 (I1_I838_P30_27n I1_I838_P30_29 XI1_I838_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I124_XP_MN1 (XI1_I838_I124_XP_n1 I1_I838_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I124_XP_MN0 (I1_I838_P28_25n I1_I838_P28_27 XI1_I838_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I122_XP_MN1 (XI1_I838_I122_XP_n1 I1_I838_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I122_XP_MN0 (I1_I838_P26_23n I1_I838_P26_25 XI1_I838_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I120_XP_MN1 (XI1_I838_I120_XP_n1 I1_I838_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I120_XP_MN0 (I1_I838_P24_21n I1_I838_P24_23 XI1_I838_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I20_MN1 (XI1_I838_I20_n1 I1_b6_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I20_MN0 (I1_I838_gn20 I1_p5_19 XI1_I838_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I18_MN1 (XI1_I838_I18_n1 I1_b6_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I18_MN0 (I1_I838_gn18 I1_p5_17 XI1_I838_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I16_MN1 (XI1_I838_I16_n1 I1_b6_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I16_MN0 (I1_I838_gn16 I1_p5_15 XI1_I838_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I13_MN1 (XI1_I838_I13_n1 I1_b6_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I13_MN0 (I1_I838_gn13 I1_p5_12 XI1_I838_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I113_XP_MN1 (XI1_I792_I113_XP_n1 I1_I792_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I113_XP_MN0 (I1_I792_P17_14n I1_I792_P17_16 XI1_I792_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I111_XP_MN1 (XI1_I792_I111_XP_n1 I1_I792_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I111_XP_MN0 (I1_I792_P15_12n I1_I792_P15_14 XI1_I792_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I171_XP_MN1 (XI1_I792_I171_XP_n1 I1_I792_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I171_XP_MN0 (I1_I792_P20_5n I1_I792_P20_13 XI1_I792_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I116_XP_MN1 (XI1_I792_I116_XP_n1 I1_I792_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I116_XP_MN0 (I1_I792_P20_17n I1_I792_P20_19 XI1_I792_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I19_MN1 (XI1_I792_I19_n1 I1_b5_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I19_MN0 (I1_I792_gn19 I1_p4_18 XI1_I792_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I20_MN1 (XI1_I792_I20_n1 I1_b5_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I20_MN0 (I1_I792_gn20 I1_p4_19 XI1_I792_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I181_XP_MN1 (XI1_I746_I181_XP_n1 I1_I746_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I181_XP_MN0 (I1_I746_P30_15n I1_I746_P30_23 XI1_I746_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I124_XP_MN1 (XI1_I746_I124_XP_n1 I1_I746_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I124_XP_MN0 (I1_I746_P28_25n I1_I746_P28_27 XI1_I746_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I27_MN1 (XI1_I746_I27_n1 I1_b4_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I27_MN0 (I1_I746_gn27 I1_p3_26 XI1_I746_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I26_MN1 (XI1_I1344_I26_n1 I1_b17_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I26_MN0 (I1_I1344_gn26 I1_p16_25 XI1_I1344_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I124_XP_MN1 (XI1_I1344_I124_XP_n1 I1_I1344_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I124_XP_MN0 (I1_I1344_P28_25n I1_I1344_P28_27 XI1_I1344_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I22_MN1 (XI1_I1344_I22_n1 I1_b17_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I22_MN0 (I1_I1344_gn22 I1_p16_21 XI1_I1344_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I21_MN1 (XI1_I1344_I21_n1 I1_b17_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I21_MN0 (I1_I1344_gn21 I1_p16_20 XI1_I1344_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I176_XP_MN1 (XI1_I1344_I176_XP_n1 I1_I1344_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I176_XP_MN0 (I1_I1344_P25_10n I1_I1344_P25_18 XI1_I1344_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I172_XP_MN1 (XI1_I1344_I172_XP_n1 I1_I1344_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I172_XP_MN0 (I1_I1344_P21_6n I1_I1344_P21_14 XI1_I1344_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I109_XP_MN1 (XI1_I1344_I109_XP_n1 I1_I1344_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I109_XP_MN0 (I1_I1344_P13_10n I1_I1344_P13_12 XI1_I1344_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I107_XP_MN1 (XI1_I1344_I107_XP_n1 I1_I1344_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I107_XP_MN0 (I1_I1344_P11_8n I1_I1344_P11_10 XI1_I1344_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I176_XP_MN1 (XI1_I1298_I176_XP_n1 I1_I1298_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I176_XP_MN0 (I1_I1298_P25_10n I1_I1298_P25_18 XI1_I1298_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I117_XP_MN1 (XI1_I1298_I117_XP_n1 I1_I1298_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I117_XP_MN0 (I1_I1298_P21_18n I1_I1298_P21_20 XI1_I1298_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I177_XP_MN1 (XI1_I1298_I177_XP_n1 I1_I1298_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I177_XP_MN0 (I1_I1298_P26_11n I1_I1298_P26_19 XI1_I1298_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I118_XP_MN1 (XI1_I1298_I118_XP_n1 I1_I1298_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I118_XP_MN0 (I1_I1298_P22_19n I1_I1298_P22_21 XI1_I1298_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I22_MN1 (XI1_I1298_I22_n1 I1_b16_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I22_MN0 (I1_I1298_gn22 I1_p15_21 XI1_I1298_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I20_MN1 (XI1_I1298_I20_n1 I1_b16_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I20_MN0 (I1_I1298_gn20 I1_p15_19 XI1_I1298_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I21_MN1 (XI1_I1298_I21_n1 I1_b16_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I21_MN0 (I1_I1298_gn21 I1_p15_20 XI1_I1298_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I173_XP_MN1 (XI1_I1252_I173_XP_n1 I1_I1252_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I173_XP_MN0 (I1_I1252_P22_7n I1_I1252_P22_15 XI1_I1252_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I118_XP_MN1 (XI1_I1252_I118_XP_n1 I1_I1252_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I118_XP_MN0 (I1_I1252_P22_19n I1_I1252_P22_21 XI1_I1252_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I178_XP_MN1 (XI1_I1252_I178_XP_n1 I1_I1252_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I178_XP_MN0 (I1_I1252_P27_12n I1_I1252_P27_20 XI1_I1252_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I119_XP_MN1 (XI1_I1252_I119_XP_n1 I1_I1252_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I119_XP_MN0 (I1_I1252_P23_20n I1_I1252_P23_22 XI1_I1252_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I21_MN1 (XI1_I1252_I21_n1 I1_b15_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I21_MN0 (I1_I1252_gn21 I1_p14_20 XI1_I1252_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I21_MN1 (XI1_I1206_I21_n1 I1_b14_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I21_MN0 (I1_I1206_gn21 I1_p13_20 XI1_I1206_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I119_XP_MN1 (XI1_I1206_I119_XP_n1 I1_I1206_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I119_XP_MN0 (I1_I1206_P23_20n I1_I1206_P23_22 XI1_I1206_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I121_XP_MN1 (XI1_I1206_I121_XP_n1 I1_I1206_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I121_XP_MN0 (I1_I1206_P25_22n I1_I1206_P25_24 XI1_I1206_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I180_XP_MN1 (XI1_I1206_I180_XP_n1 I1_I1206_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I180_XP_MN0 (I1_I1206_P29_14n I1_I1206_P29_22 XI1_I1206_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I118_XP_MN1 (XI1_I1206_I118_XP_n1 I1_I1206_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I118_XP_MN0 (I1_I1206_P22_19n I1_I1206_P22_21 XI1_I1206_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I181_XP_MN1 (XI1_I1206_I181_XP_n1 I1_I1206_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I181_XP_MN0 (I1_I1206_P30_15n I1_I1206_P30_23 XI1_I1206_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I120_XP_MN1 (XI1_I1206_I120_XP_n1 I1_I1206_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I120_XP_MN0 (I1_I1206_P24_21n I1_I1206_P24_23 XI1_I1206_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I179_XP_MN1 (XI1_I838_I179_XP_n1 I1_I838_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I179_XP_MN0 (I1_I838_P28_13n I1_I838_P28_21 XI1_I838_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I118_XP_MN1 (XI1_I838_I118_XP_n1 I1_I838_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I118_XP_MN0 (I1_I838_P22_19n I1_I838_P22_21 XI1_I838_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I19_MN1 (XI1_I838_I19_n1 I1_b6_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I19_MN0 (I1_I838_gn19 I1_p5_18 XI1_I838_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I116_XP_MN1 (XI1_I838_I116_XP_n1 I1_I838_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I116_XP_MN0 (I1_I838_P20_17n I1_I838_P20_19 XI1_I838_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I114_XP_MN1 (XI1_I838_I114_XP_n1 I1_I838_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I114_XP_MN0 (I1_I838_P18_15n I1_I838_P18_17 XI1_I838_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I112_XP_MN1 (XI1_I838_I112_XP_n1 I1_I838_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I112_XP_MN0 (I1_I838_P16_13n I1_I838_P16_15 XI1_I838_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I110_XP_MN1 (XI1_I838_I110_XP_n1 I1_I838_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I110_XP_MN0 (I1_I838_P14_11n I1_I838_P14_13 XI1_I838_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I14_MN1 (XI1_I838_I14_n1 I1_b6_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I14_MN0 (I1_I838_gn14 I1_p5_13 XI1_I838_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I12_MN1 (XI1_I838_I12_n1 I1_b6_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I12_MN0 (I1_I838_gn12 I1_p5_11 XI1_I838_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I11_MN1 (XI1_I838_I11_n1 I1_b6_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I11_MN0 (I1_I838_gn11 I1_p5_10 XI1_I838_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I9_MN1 (XI1_I838_I9_n1 I1_b6_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I9_MN0 (I1_I838_gn9 I1_p5_8 XI1_I838_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I107_XP_MN1 (XI1_I792_I107_XP_n1 I1_I792_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I107_XP_MN0 (I1_I792_P11_8n I1_I792_P11_10 XI1_I792_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I109_XP_MN1 (XI1_I792_I109_XP_n1 I1_I792_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I109_XP_MN0 (I1_I792_P13_10n I1_I792_P13_12 XI1_I792_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I169_XP_MN1 (XI1_I792_I169_XP_n1 I1_I792_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I169_XP_MN0 (I1_I792_P18_3n I1_I792_P18_11 XI1_I792_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I175_XP_MN1 (XI1_I792_I175_XP_n1 I1_I792_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I175_XP_MN0 (I1_I792_P24_9n I1_I792_P24_17 XI1_I792_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I114_XP_MN1 (XI1_I792_I114_XP_n1 I1_I792_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I114_XP_MN0 (I1_I792_P18_15n I1_I792_P18_17 XI1_I792_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I16_MN1 (XI1_I792_I16_n1 I1_b5_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I16_MN0 (I1_I792_gn16 I1_p4_15 XI1_I792_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I18_MN1 (XI1_I792_I18_n1 I1_b5_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I18_MN0 (I1_I792_gn18 I1_p4_17 XI1_I792_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I179_XP_MN1 (XI1_I746_I179_XP_n1 I1_I746_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I179_XP_MN0 (I1_I746_P28_13n I1_I746_P28_21 XI1_I746_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I173_XP_MN1 (XI1_I746_I173_XP_n1 I1_I746_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I173_XP_MN0 (I1_I746_P22_7n I1_I746_P22_15 XI1_I746_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I122_XP_MN1 (XI1_I746_I122_XP_n1 I1_I746_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I122_XP_MN0 (I1_I746_P26_23n I1_I746_P26_25 XI1_I746_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I28_MN1 (XI1_I746_I28_n1 I1_b4_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I28_MN0 (I1_I746_gn28 I1_p3_27 XI1_I746_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I122_XP_MN1 (XI1_I1344_I122_XP_n1 I1_I1344_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I122_XP_MN0 (I1_I1344_P26_23n I1_I1344_P26_25 XI1_I1344_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I20_MN1 (XI1_I1344_I20_n1 I1_b17_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I20_MN0 (I1_I1344_gn20 I1_p16_19 XI1_I1344_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I18_MN1 (XI1_I1344_I18_n1 I1_b17_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I18_MN0 (I1_I1344_gn18 I1_p16_17 XI1_I1344_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I17_MN1 (XI1_I1344_I17_n1 I1_b17_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I17_MN0 (I1_I1344_gn17 I1_p16_16 XI1_I1344_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I168_XP_MN1 (XI1_I1344_I168_XP_n1 I1_I1344_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I168_XP_MN0 (I1_I1344_P17_2n I1_I1344_P17_10 XI1_I1344_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I172_XP_MN1 (XI1_I1298_I172_XP_n1 I1_I1298_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I172_XP_MN0 (I1_I1298_P21_6n I1_I1298_P21_14 XI1_I1298_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I115_XP_MN1 (XI1_I1298_I115_XP_n1 I1_I1298_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I115_XP_MN0 (I1_I1298_P19_16n I1_I1298_P19_18 XI1_I1298_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I173_XP_MN1 (XI1_I1298_I173_XP_n1 I1_I1298_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I173_XP_MN0 (I1_I1298_P22_7n I1_I1298_P22_15 XI1_I1298_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I116_XP_MN1 (XI1_I1298_I116_XP_n1 I1_I1298_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I116_XP_MN0 (I1_I1298_P20_17n I1_I1298_P20_19 XI1_I1298_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I19_MN1 (XI1_I1298_I19_n1 I1_b16_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I19_MN0 (I1_I1298_gn19 I1_p15_18 XI1_I1298_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I18_MN1 (XI1_I1298_I18_n1 I1_b16_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I18_MN0 (I1_I1298_gn18 I1_p15_17 XI1_I1298_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I116_XP_MN1 (XI1_I1252_I116_XP_n1 I1_I1252_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I116_XP_MN0 (I1_I1252_P20_17n I1_I1252_P20_19 XI1_I1252_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I172_XP_MN1 (XI1_I1252_I172_XP_n1 I1_I1252_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I172_XP_MN0 (I1_I1252_P21_6n I1_I1252_P21_14 XI1_I1252_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I117_XP_MN1 (XI1_I1252_I117_XP_n1 I1_I1252_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I117_XP_MN0 (I1_I1252_P21_18n I1_I1252_P21_20 XI1_I1252_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I20_MN1 (XI1_I1252_I20_n1 I1_b15_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I20_MN0 (I1_I1252_gn20 I1_p14_19 XI1_I1252_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I20_MN1 (XI1_I1206_I20_n1 I1_b14_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I20_MN0 (I1_I1206_gn20 I1_p13_19 XI1_I1206_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I19_MN1 (XI1_I1206_I19_n1 I1_b14_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I19_MN0 (I1_I1206_gn19 I1_p13_18 XI1_I1206_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I117_XP_MN1 (XI1_I1206_I117_XP_n1 I1_I1206_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I117_XP_MN0 (I1_I1206_P21_18n I1_I1206_P21_20 XI1_I1206_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I178_XP_MN1 (XI1_I1206_I178_XP_n1 I1_I1206_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I178_XP_MN0 (I1_I1206_P27_12n I1_I1206_P27_20 XI1_I1206_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I179_XP_MN1 (XI1_I1206_I179_XP_n1 I1_I1206_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I179_XP_MN0 (I1_I1206_P28_13n I1_I1206_P28_21 XI1_I1206_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I25_MN1 (XI1_I884_I25_n1 I1_b7_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I25_MN0 (I1_I884_gn25 I1_p6_24 XI1_I884_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I181_XP_MN1 (XI1_I838_I181_XP_n1 I1_I838_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I181_XP_MN0 (I1_I838_P30_15n I1_I838_P30_23 XI1_I838_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I177_XP_MN1 (XI1_I838_I177_XP_n1 I1_I838_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I177_XP_MN0 (I1_I838_P26_11n I1_I838_P26_19 XI1_I838_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I173_XP_MN1 (XI1_I838_I173_XP_n1 I1_I838_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I173_XP_MN0 (I1_I838_P22_7n I1_I838_P22_15 XI1_I838_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I175_XP_MN1 (XI1_I838_I175_XP_n1 I1_I838_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I175_XP_MN0 (I1_I838_P24_9n I1_I838_P24_17 XI1_I838_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I169_XP_MN1 (XI1_I838_I169_XP_n1 I1_I838_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I169_XP_MN0 (I1_I838_P18_3n I1_I838_P18_11 XI1_I838_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I108_XP_MN1 (XI1_I838_I108_XP_n1 I1_I838_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I108_XP_MN0 (I1_I838_P12_9n I1_I838_P12_11 XI1_I838_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I106_XP_MN1 (XI1_I838_I106_XP_n1 I1_I838_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I106_XP_MN0 (I1_I838_P10_7n I1_I838_P10_9 XI1_I838_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I10_MN1 (XI1_I838_I10_n1 I1_b6_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I10_MN0 (I1_I838_gn10 I1_p5_9 XI1_I838_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I168_XP_MN1 (XI1_I792_I168_XP_n1 I1_I792_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I168_XP_MN0 (I1_I792_P17_2n I1_I792_P17_10 XI1_I792_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I110_XP_MN1 (XI1_I792_I110_XP_n1 I1_I792_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I110_XP_MN0 (I1_I792_P14_11n I1_I792_P14_13 XI1_I792_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I112_XP_MN1 (XI1_I792_I112_XP_n1 I1_I792_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I112_XP_MN0 (I1_I792_P16_13n I1_I792_P16_15 XI1_I792_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I169_XP_MN1 (XI1_I746_I169_XP_n1 I1_I746_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I169_XP_MN0 (I1_I746_P18_3n I1_I746_P18_11 XI1_I746_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I171_XP_MN1 (XI1_I746_I171_XP_n1 I1_I746_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I171_XP_MN0 (I1_I746_P20_5n I1_I746_P20_13 XI1_I746_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I177_XP_MN1 (XI1_I746_I177_XP_n1 I1_I746_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I177_XP_MN0 (I1_I746_P26_11n I1_I746_P26_19 XI1_I746_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I118_XP_MN1 (XI1_I746_I118_XP_n1 I1_I746_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I118_XP_MN0 (I1_I746_P22_19n I1_I746_P22_21 XI1_I746_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I120_XP_MN1 (XI1_I746_I120_XP_n1 I1_I746_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I120_XP_MN0 (I1_I746_P24_21n I1_I746_P24_23 XI1_I746_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I25_MN1 (XI1_I746_I25_n1 I1_b4_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I25_MN0 (I1_I746_gn25 I1_p3_24 XI1_I746_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I29_MN1 (XI1_I746_I29_n1 I1_b4_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I29_MN0 (I1_I746_gn29 I1_p3_28 XI1_I746_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I120_XP_MN1 (XI1_I1344_I120_XP_n1 I1_I1344_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I120_XP_MN0 (I1_I1344_P24_21n I1_I1344_P24_23 XI1_I1344_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I118_XP_MN1 (XI1_I1344_I118_XP_n1 I1_I1344_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I118_XP_MN0 (I1_I1344_P22_19n I1_I1344_P22_21 XI1_I1344_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I16_MN1 (XI1_I1344_I16_n1 I1_b17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I16_MN0 (I1_I1344_gn16 I1_p16_15 XI1_I1344_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I15_MN1 (XI1_I1344_I15_n1 I1_b17_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I15_MN0 (I1_I1344_gn15 I1_p16_14 XI1_I1344_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I170_XP_MN1 (XI1_I1298_I170_XP_n1 I1_I1298_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I170_XP_MN0 (I1_I1298_P19_4n I1_I1298_P19_12 XI1_I1298_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I113_XP_MN1 (XI1_I1298_I113_XP_n1 I1_I1298_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I113_XP_MN0 (I1_I1298_P17_14n I1_I1298_P17_16 XI1_I1298_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I171_XP_MN1 (XI1_I1298_I171_XP_n1 I1_I1298_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I171_XP_MN0 (I1_I1298_P20_5n I1_I1298_P20_13 XI1_I1298_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I114_XP_MN1 (XI1_I1298_I114_XP_n1 I1_I1298_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I114_XP_MN0 (I1_I1298_P18_15n I1_I1298_P18_17 XI1_I1298_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I17_MN1 (XI1_I1298_I17_n1 I1_b16_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I17_MN0 (I1_I1298_gn17 I1_p15_16 XI1_I1298_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I171_XP_MN1 (XI1_I1252_I171_XP_n1 I1_I1252_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I171_XP_MN0 (I1_I1252_P20_5n I1_I1252_P20_13 XI1_I1252_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I175_XP_MN1 (XI1_I1252_I175_XP_n1 I1_I1252_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I175_XP_MN0 (I1_I1252_P24_9n I1_I1252_P24_17 XI1_I1252_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I176_XP_MN1 (XI1_I1252_I176_XP_n1 I1_I1252_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I176_XP_MN0 (I1_I1252_P25_10n I1_I1252_P25_18 XI1_I1252_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I113_XP_MN1 (XI1_I1252_I113_XP_n1 I1_I1252_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I113_XP_MN0 (I1_I1252_P17_14n I1_I1252_P17_16 XI1_I1252_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I115_XP_MN1 (XI1_I1252_I115_XP_n1 I1_I1252_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I115_XP_MN0 (I1_I1252_P19_16n I1_I1252_P19_18 XI1_I1252_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I17_MN1 (XI1_I1252_I17_n1 I1_b15_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I17_MN0 (I1_I1252_gn17 I1_p14_16 XI1_I1252_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I19_MN1 (XI1_I1252_I19_n1 I1_b15_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I19_MN0 (I1_I1252_gn19 I1_p14_18 XI1_I1252_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I18_MN1 (XI1_I1252_I18_n1 I1_b15_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I18_MN0 (I1_I1252_gn18 I1_p14_17 XI1_I1252_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I18_MN1 (XI1_I1206_I18_n1 I1_b14_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I18_MN0 (I1_I1206_gn18 I1_p13_17 XI1_I1206_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I115_XP_MN1 (XI1_I1206_I115_XP_n1 I1_I1206_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I115_XP_MN0 (I1_I1206_P19_16n I1_I1206_P19_18 XI1_I1206_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I182_XP_MN1 (XI1_I1206_I182_XP_n1 I1_I1206_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I182_XP_MN0 (I1_I1206_P31_16n I1_I1206_P31_24 XI1_I1206_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I174_XP_MN1 (XI1_I1206_I174_XP_n1 I1_I1206_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I174_XP_MN0 (I1_I1206_P23_8n I1_I1206_P23_16 XI1_I1206_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I172_XP_MN1 (XI1_I1206_I172_XP_n1 I1_I1206_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I172_XP_MN0 (I1_I1206_P21_6n I1_I1206_P21_14 XI1_I1206_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I116_XP_MN1 (XI1_I1206_I116_XP_n1 I1_I1206_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I116_XP_MN0 (I1_I1206_P20_17n I1_I1206_P20_19 XI1_I1206_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I173_XP_MN1 (XI1_I1206_I173_XP_n1 I1_I1206_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I173_XP_MN0 (I1_I1206_P22_7n I1_I1206_P22_15 XI1_I1206_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I177_XP_MN1 (XI1_I1206_I177_XP_n1 I1_I1206_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I177_XP_MN0 (I1_I1206_P26_11n I1_I1206_P26_19 XI1_I1206_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I27_MN1 (XI1_I884_I27_n1 I1_b7_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I27_MN0 (I1_I884_gn27 I1_p6_26 XI1_I884_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I23_MN1 (XI1_I884_I23_n1 I1_b7_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I23_MN0 (I1_I884_gn23 I1_p6_22 XI1_I884_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I171_XP_MN1 (XI1_I838_I171_XP_n1 I1_I838_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I171_XP_MN0 (I1_I838_P20_5n I1_I838_P20_13 XI1_I838_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I167_XP_MN1 (XI1_I838_I167_XP_n1 I1_I838_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I167_XP_MN0 (I1_I838_P16_1n I1_I838_P16_9 XI1_I838_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I6_MN1 (XI1_I838_I6_n1 I1_b6_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I6_MN0 (I1_I838_gn6 I1_p5_5 XI1_I838_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I8_MN1 (XI1_I838_I8_n1 I1_b6_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I8_MN0 (I1_I838_gn8 I1_p5_7 XI1_I838_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I7_MN1 (XI1_I838_I7_n1 I1_b6_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I7_MN0 (I1_I838_gn7 I1_p5_6 XI1_I838_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I103_XP_MN1 (XI1_I792_I103_XP_n1 I1_I792_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I103_XP_MN0 (I1_I792_P7_4n I1_I792_P7_6 XI1_I792_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I105_XP_MN1 (XI1_I792_I105_XP_n1 I1_I792_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I105_XP_MN0 (I1_I792_P9_6n I1_I792_P9_8 XI1_I792_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I167_XP_MN1 (XI1_I792_I167_XP_n1 I1_I792_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I167_XP_MN0 (I1_I792_P16_1n I1_I792_P16_9 XI1_I792_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I106_XP_MN1 (XI1_I792_I106_XP_n1 I1_I792_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I106_XP_MN0 (I1_I792_P10_7n I1_I792_P10_9 XI1_I792_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I108_XP_MN1 (XI1_I792_I108_XP_n1 I1_I792_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I108_XP_MN0 (I1_I792_P12_9n I1_I792_P12_11 XI1_I792_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I12_MN1 (XI1_I792_I12_n1 I1_b5_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I12_MN0 (I1_I792_gn12 I1_p4_11 XI1_I792_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I14_MN1 (XI1_I792_I14_n1 I1_b5_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I14_MN0 (I1_I792_gn14 I1_p4_13 XI1_I792_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I15_MN1 (XI1_I792_I15_n1 I1_b5_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I15_MN0 (I1_I792_gn15 I1_p4_14 XI1_I792_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I167_XP_MN1 (XI1_I746_I167_XP_n1 I1_I746_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I167_XP_MN0 (I1_I746_P16_1n I1_I746_P16_9 XI1_I746_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I17_MN1 (XI1_I792_I17_n1 I1_b5_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I17_MN0 (I1_I792_gn17 I1_p4_16 XI1_I792_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I175_XP_MN1 (XI1_I746_I175_XP_n1 I1_I746_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I175_XP_MN0 (I1_I746_P24_9n I1_I746_P24_17 XI1_I746_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I110_XP_MN1 (XI1_I746_I110_XP_n1 I1_I746_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I110_XP_MN0 (I1_I746_P14_11n I1_I746_P14_13 XI1_I746_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I112_XP_MN1 (XI1_I746_I112_XP_n1 I1_I746_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I112_XP_MN0 (I1_I746_P16_13n I1_I746_P16_15 XI1_I746_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I114_XP_MN1 (XI1_I746_I114_XP_n1 I1_I746_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I114_XP_MN0 (I1_I746_P18_15n I1_I746_P18_17 XI1_I746_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I116_XP_MN1 (XI1_I746_I116_XP_n1 I1_I746_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I116_XP_MN0 (I1_I746_P20_17n I1_I746_P20_19 XI1_I746_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I180_XP_MN1 (XI1_I746_I180_XP_n1 I1_I746_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I180_XP_MN0 (I1_I746_P29_14n I1_I746_P29_22 XI1_I746_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I24_MN1 (XI1_I746_I24_n1 I1_b4_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I24_MN0 (I1_I746_gn24 I1_p3_23 XI1_I746_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I125_XP_MN1 (XI1_I746_I125_XP_n1 I1_I746_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I125_XP_MN0 (I1_I746_P29_26n I1_I746_P29_28 XI1_I746_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I127_XP_MN1 (XI1_I746_I127_XP_n1 I1_I746_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I127_XP_MN0 (I1_I746_P31_28n I1_I746_P31_30 XI1_I746_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I30_MN1 (XI1_I746_I30_n1 I1_b4_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I30_MN0 (I1_I746_gn30 I1_p3_29 XI1_I746_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I29_MN1 (XI1_I1390_I29_n1 I1_b18_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I29_MN0 (I1_I1390_gn29 I1_p17_28 XI1_I1390_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I181_XP_MN1 (XI1_I1344_I181_XP_n1 I1_I1344_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I181_XP_MN0 (I1_I1344_P30_15n I1_I1344_P30_23 XI1_I1344_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I179_XP_MN1 (XI1_I1344_I179_XP_n1 I1_I1344_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I179_XP_MN0 (I1_I1344_P28_13n I1_I1344_P28_21 XI1_I1344_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I116_XP_MN1 (XI1_I1344_I116_XP_n1 I1_I1344_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I116_XP_MN0 (I1_I1344_P20_17n I1_I1344_P20_19 XI1_I1344_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I19_MN1 (XI1_I1344_I19_n1 I1_b17_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I19_MN0 (I1_I1344_gn19 I1_p16_18 XI1_I1344_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I114_XP_MN1 (XI1_I1344_I114_XP_n1 I1_I1344_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I114_XP_MN0 (I1_I1344_P18_15n I1_I1344_P18_17 XI1_I1344_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I112_XP_MN1 (XI1_I1344_I112_XP_n1 I1_I1344_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I112_XP_MN0 (I1_I1344_P16_13n I1_I1344_P16_15 XI1_I1344_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I14_MN1 (XI1_I1344_I14_n1 I1_b17_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I14_MN0 (I1_I1344_gn14 I1_p16_13 XI1_I1344_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I13_MN1 (XI1_I1344_I13_n1 I1_b17_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I13_MN0 (I1_I1344_gn13 I1_p16_12 XI1_I1344_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I105_XP_MN1 (XI1_I1344_I105_XP_n1 I1_I1344_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I105_XP_MN0 (I1_I1344_P9_6n I1_I1344_P9_8 XI1_I1344_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I111_XP_MN1 (XI1_I1298_I111_XP_n1 I1_I1298_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I111_XP_MN0 (I1_I1298_P15_12n I1_I1298_P15_14 XI1_I1298_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I112_XP_MN1 (XI1_I1298_I112_XP_n1 I1_I1298_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I112_XP_MN0 (I1_I1298_P16_13n I1_I1298_P16_15 XI1_I1298_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I13_MN1 (XI1_I1298_I13_n1 I1_b16_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I13_MN0 (I1_I1298_gn13 I1_p15_12 XI1_I1298_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I14_MN1 (XI1_I1298_I14_n1 I1_b16_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I14_MN0 (I1_I1298_gn14 I1_p15_13 XI1_I1298_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I16_MN1 (XI1_I1298_I16_n1 I1_b16_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I16_MN0 (I1_I1298_gn16 I1_p15_15 XI1_I1298_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I15_MN1 (XI1_I1298_I15_n1 I1_b16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I15_MN0 (I1_I1298_gn15 I1_p15_14 XI1_I1298_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I112_XP_MN1 (XI1_I1252_I112_XP_n1 I1_I1252_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I112_XP_MN0 (I1_I1252_P16_13n I1_I1252_P16_15 XI1_I1252_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I114_XP_MN1 (XI1_I1252_I114_XP_n1 I1_I1252_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I114_XP_MN0 (I1_I1252_P18_15n I1_I1252_P18_17 XI1_I1252_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I170_XP_MN1 (XI1_I1252_I170_XP_n1 I1_I1252_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I170_XP_MN0 (I1_I1252_P19_4n I1_I1252_P19_12 XI1_I1252_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I111_XP_MN1 (XI1_I1252_I111_XP_n1 I1_I1252_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I111_XP_MN0 (I1_I1252_P15_12n I1_I1252_P15_14 XI1_I1252_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I16_MN1 (XI1_I1252_I16_n1 I1_b15_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I16_MN0 (I1_I1252_gn16 I1_p14_15 XI1_I1252_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I15_MN1 (XI1_I1252_I15_n1 I1_b15_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I15_MN0 (I1_I1252_gn15 I1_p14_14 XI1_I1252_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I170_XP_MN1 (XI1_I1206_I170_XP_n1 I1_I1206_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I170_XP_MN0 (I1_I1206_P19_4n I1_I1206_P19_12 XI1_I1206_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I176_XP_MN1 (XI1_I1206_I176_XP_n1 I1_I1206_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I176_XP_MN0 (I1_I1206_P25_10n I1_I1206_P25_18 XI1_I1206_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I114_XP_MN1 (XI1_I1206_I114_XP_n1 I1_I1206_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I114_XP_MN0 (I1_I1206_P18_15n I1_I1206_P18_17 XI1_I1206_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I169_XP_MN1 (XI1_I1206_I169_XP_n1 I1_I1206_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I169_XP_MN0 (I1_I1206_P18_3n I1_I1206_P18_11 XI1_I1206_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I175_XP_MN1 (XI1_I1206_I175_XP_n1 I1_I1206_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I175_XP_MN0 (I1_I1206_P24_9n I1_I1206_P24_17 XI1_I1206_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I29_MN1 (XI1_I884_I29_n1 I1_b7_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I29_MN0 (I1_I884_gn29 I1_p6_28 XI1_I884_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I28_MN1 (XI1_I884_I28_n1 I1_b7_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I28_MN0 (I1_I884_gn28 I1_p6_27 XI1_I884_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I26_MN1 (XI1_I884_I26_n1 I1_b7_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I26_MN0 (I1_I884_gn26 I1_p6_25 XI1_I884_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I24_MN1 (XI1_I884_I24_n1 I1_b7_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I24_MN0 (I1_I884_gn24 I1_p6_23 XI1_I884_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I21_MN1 (XI1_I884_I21_n1 I1_b7_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I21_MN0 (I1_I884_gn21 I1_p6_20 XI1_I884_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I19_MN1 (XI1_I884_I19_n1 I1_b7_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I19_MN0 (I1_I884_gn19 I1_p6_18 XI1_I884_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I17_MN1 (XI1_I884_I17_n1 I1_b7_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I17_MN0 (I1_I884_gn17 I1_p6_16 XI1_I884_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I15_MN1 (XI1_I884_I15_n1 I1_b7_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I15_MN0 (I1_I884_gn15 I1_p6_14 XI1_I884_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I5_MN1 (XI1_I838_I5_n1 I1_b6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I5_MN0 (I1_I838_gn5 I1_p5_4 XI1_I838_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I101_XP_MN1 (XI1_I792_I101_XP_n1 I1_I792_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I101_XP_MN0 (I1_I792_P5_2n I1_I792_P5_4 XI1_I792_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I100_XP_MN1 (XI1_I792_I100_XP_n1 I1_I792_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I100_XP_MN0 (I1_I792_P4_1n I1_I792_P4_3 XI1_I792_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I102_XP_MN1 (XI1_I792_I102_XP_n1 I1_I792_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I102_XP_MN0 (I1_I792_P6_3n I1_I792_P6_5 XI1_I792_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I104_XP_MN1 (XI1_I792_I104_XP_n1 I1_I792_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I104_XP_MN0 (I1_I792_P8_5n I1_I792_P8_7 XI1_I792_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I10_MN1 (XI1_I792_I10_n1 I1_b5_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I10_MN0 (I1_I792_gn10 I1_p4_9 XI1_I792_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I11_MN1 (XI1_I792_I11_n1 I1_b5_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I11_MN0 (I1_I792_gn11 I1_p4_10 XI1_I792_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I106_XP_MN1 (XI1_I746_I106_XP_n1 I1_I746_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I106_XP_MN0 (I1_I746_P10_7n I1_I746_P10_9 XI1_I746_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I108_XP_MN1 (XI1_I746_I108_XP_n1 I1_I746_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I108_XP_MN0 (I1_I746_P12_9n I1_I746_P12_11 XI1_I746_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I172_XP_MN1 (XI1_I746_I172_XP_n1 I1_I746_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I172_XP_MN0 (I1_I746_P21_6n I1_I746_P21_14 XI1_I746_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I121_XP_MN1 (XI1_I746_I121_XP_n1 I1_I746_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I121_XP_MN0 (I1_I746_P25_22n I1_I746_P25_24 XI1_I746_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I123_XP_MN1 (XI1_I746_I123_XP_n1 I1_I746_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I123_XP_MN0 (I1_I746_P27_24n I1_I746_P27_26 XI1_I746_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I177_XP_MN1 (XI1_I1344_I177_XP_n1 I1_I1344_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I177_XP_MN0 (I1_I1344_P26_11n I1_I1344_P26_19 XI1_I1344_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I173_XP_MN1 (XI1_I1344_I173_XP_n1 I1_I1344_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I173_XP_MN0 (I1_I1344_P22_7n I1_I1344_P22_15 XI1_I1344_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I171_XP_MN1 (XI1_I1344_I171_XP_n1 I1_I1344_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I171_XP_MN0 (I1_I1344_P20_5n I1_I1344_P20_13 XI1_I1344_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I110_XP_MN1 (XI1_I1344_I110_XP_n1 I1_I1344_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I110_XP_MN0 (I1_I1344_P14_11n I1_I1344_P14_13 XI1_I1344_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I12_MN1 (XI1_I1344_I12_n1 I1_b17_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I12_MN0 (I1_I1344_gn12 I1_p16_11 XI1_I1344_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I11_MN1 (XI1_I1344_I11_n1 I1_b17_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I11_MN0 (I1_I1344_gn11 I1_p16_10 XI1_I1344_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I103_XP_MN1 (XI1_I1344_I103_XP_n1 I1_I1344_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I103_XP_MN0 (I1_I1344_P7_4n I1_I1344_P7_6 XI1_I1344_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I168_XP_MN1 (XI1_I1298_I168_XP_n1 I1_I1298_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I168_XP_MN0 (I1_I1298_P17_2n I1_I1298_P17_10 XI1_I1298_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I109_XP_MN1 (XI1_I1298_I109_XP_n1 I1_I1298_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I109_XP_MN0 (I1_I1298_P13_10n I1_I1298_P13_12 XI1_I1298_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I107_XP_MN1 (XI1_I1298_I107_XP_n1 I1_I1298_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I107_XP_MN0 (I1_I1298_P11_8n I1_I1298_P11_10 XI1_I1298_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I169_XP_MN1 (XI1_I1298_I169_XP_n1 I1_I1298_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I169_XP_MN0 (I1_I1298_P18_3n I1_I1298_P18_11 XI1_I1298_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I110_XP_MN1 (XI1_I1298_I110_XP_n1 I1_I1298_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I110_XP_MN0 (I1_I1298_P14_11n I1_I1298_P14_13 XI1_I1298_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I12_MN1 (XI1_I1298_I12_n1 I1_b16_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I12_MN0 (I1_I1298_gn12 I1_p15_11 XI1_I1298_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I169_XP_MN1 (XI1_I1252_I169_XP_n1 I1_I1252_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I169_XP_MN0 (I1_I1252_P18_3n I1_I1252_P18_11 XI1_I1252_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I110_XP_MN1 (XI1_I1252_I110_XP_n1 I1_I1252_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I110_XP_MN0 (I1_I1252_P14_11n I1_I1252_P14_13 XI1_I1252_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I13_MN1 (XI1_I1252_I13_n1 I1_b15_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I13_MN0 (I1_I1252_gn13 I1_p14_12 XI1_I1252_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I14_MN1 (XI1_I1252_I14_n1 I1_b15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I14_MN0 (I1_I1252_gn14 I1_p14_13 XI1_I1252_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I17_MN1 (XI1_I1206_I17_n1 I1_b14_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I17_MN0 (I1_I1206_gn17 I1_p13_16 XI1_I1206_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I113_XP_MN1 (XI1_I1206_I113_XP_n1 I1_I1206_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I113_XP_MN0 (I1_I1206_P17_14n I1_I1206_P17_16 XI1_I1206_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I111_XP_MN1 (XI1_I1206_I111_XP_n1 I1_I1206_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I111_XP_MN0 (I1_I1206_P15_12n I1_I1206_P15_14 XI1_I1206_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I109_XP_MN1 (XI1_I1206_I109_XP_n1 I1_I1206_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I109_XP_MN0 (I1_I1206_P13_10n I1_I1206_P13_12 XI1_I1206_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I168_XP_MN1 (XI1_I1206_I168_XP_n1 I1_I1206_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I168_XP_MN0 (I1_I1206_P17_2n I1_I1206_P17_10 XI1_I1206_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I112_XP_MN1 (XI1_I1206_I112_XP_n1 I1_I1206_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I112_XP_MN0 (I1_I1206_P16_13n I1_I1206_P16_15 XI1_I1206_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I171_XP_MN1 (XI1_I1206_I171_XP_n1 I1_I1206_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I171_XP_MN0 (I1_I1206_P20_5n I1_I1206_P20_13 XI1_I1206_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I31_MN1 (XI1_I884_I31_n1 I1_b7_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I31_MN0 (I1_I884_gn31 I1_p6_30 XI1_I884_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I22_MN1 (XI1_I884_I22_n1 I1_b7_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I22_MN0 (I1_I884_gn22 I1_p6_21 XI1_I884_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I20_MN1 (XI1_I884_I20_n1 I1_b7_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I20_MN0 (I1_I884_gn20 I1_p6_19 XI1_I884_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I18_MN1 (XI1_I884_I18_n1 I1_b7_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I18_MN0 (I1_I884_gn18 I1_p6_17 XI1_I884_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I16_MN1 (XI1_I884_I16_n1 I1_b7_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I16_MN0 (I1_I884_gn16 I1_p6_15 XI1_I884_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I14_MN1 (XI1_I884_I14_n1 I1_b7_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I14_MN0 (I1_I884_gn14 I1_p6_13 XI1_I884_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I13_MN1 (XI1_I884_I13_n1 I1_b7_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I13_MN0 (I1_I884_gn13 I1_p6_12 XI1_I884_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I11_MN1 (XI1_I884_I11_n1 I1_b7_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I11_MN0 (I1_I884_gn11 I1_p6_10 XI1_I884_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I100_XP_MN1 (XI1_I838_I100_XP_n1 I1_I838_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I100_XP_MN0 (I1_I838_P4_1n I1_I838_P4_3 XI1_I838_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I4_MN1 (XI1_I838_I4_n1 I1_b6_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I4_MN0 (I1_I838_gn4 I1_p5_3 XI1_I838_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I8_MN1 (XI1_I792_I8_n1 I1_b5_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I8_MN0 (I1_I792_gn8 I1_p4_7 XI1_I792_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I100_XP_MN1 (XI1_I746_I100_XP_n1 I1_I746_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I100_XP_MN0 (I1_I746_P4_1n I1_I746_P4_3 XI1_I746_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I13_MN1 (XI1_I792_I13_n1 I1_b5_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I13_MN0 (I1_I792_gn13 I1_p4_12 XI1_I792_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I102_XP_MN1 (XI1_I746_I102_XP_n1 I1_I746_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I102_XP_MN0 (I1_I746_P6_3n I1_I746_P6_5 XI1_I746_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I104_XP_MN1 (XI1_I746_I104_XP_n1 I1_I746_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I104_XP_MN0 (I1_I746_P8_5n I1_I746_P8_7 XI1_I746_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I168_XP_MN1 (XI1_I746_I168_XP_n1 I1_I746_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I168_XP_MN0 (I1_I746_P17_2n I1_I746_P17_10 XI1_I746_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I113_XP_MN1 (XI1_I746_I113_XP_n1 I1_I746_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I113_XP_MN0 (I1_I746_P17_14n I1_I746_P17_16 XI1_I746_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I176_XP_MN1 (XI1_I746_I176_XP_n1 I1_I746_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I176_XP_MN0 (I1_I746_P25_10n I1_I746_P25_18 XI1_I746_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I115_XP_MN1 (XI1_I746_I115_XP_n1 I1_I746_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I115_XP_MN0 (I1_I746_P19_16n I1_I746_P19_18 XI1_I746_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I117_XP_MN1 (XI1_I746_I117_XP_n1 I1_I746_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I117_XP_MN0 (I1_I746_P21_18n I1_I746_P21_20 XI1_I746_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I178_XP_MN1 (XI1_I746_I178_XP_n1 I1_I746_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I178_XP_MN0 (I1_I746_P27_12n I1_I746_P27_20 XI1_I746_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I119_XP_MN1 (XI1_I746_I119_XP_n1 I1_I746_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I119_XP_MN0 (I1_I746_P23_20n I1_I746_P23_22 XI1_I746_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I31_MN1 (XI1_I746_I31_n1 I1_b4_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I31_MN0 (I1_I746_gn31 I1_p3_30 XI1_I746_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I27_MN1 (XI1_I1390_I27_n1 I1_b18_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I27_MN0 (I1_I1390_gn27 I1_p17_26 XI1_I1390_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I28_MN1 (XI1_I1390_I28_n1 I1_b18_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I28_MN0 (I1_I1390_gn28 I1_p17_27 XI1_I1390_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I25_MN1 (XI1_I1390_I25_n1 I1_b18_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I25_MN0 (I1_I1390_gn25 I1_p17_24 XI1_I1390_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I22_MN1 (XI1_I1390_I22_n1 I1_b18_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I22_MN0 (I1_I1390_gn22 I1_p17_21 XI1_I1390_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I175_XP_MN1 (XI1_I1344_I175_XP_n1 I1_I1344_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I175_XP_MN0 (I1_I1344_P24_9n I1_I1344_P24_17 XI1_I1344_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I108_XP_MN1 (XI1_I1344_I108_XP_n1 I1_I1344_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I108_XP_MN0 (I1_I1344_P12_9n I1_I1344_P12_11 XI1_I1344_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I9_MN1 (XI1_I1344_I9_n1 I1_b17_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I9_MN0 (I1_I1344_gn9 I1_p16_8 XI1_I1344_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I105_XP_MN1 (XI1_I1298_I105_XP_n1 I1_I1298_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I105_XP_MN0 (I1_I1298_P9_6n I1_I1298_P9_8 XI1_I1298_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I175_XP_MN1 (XI1_I1298_I175_XP_n1 I1_I1298_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I175_XP_MN0 (I1_I1298_P24_9n I1_I1298_P24_17 XI1_I1298_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I108_XP_MN1 (XI1_I1298_I108_XP_n1 I1_I1298_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I108_XP_MN0 (I1_I1298_P12_9n I1_I1298_P12_11 XI1_I1298_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I11_MN1 (XI1_I1298_I11_n1 I1_b16_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I11_MN0 (I1_I1298_gn11 I1_p15_10 XI1_I1298_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I108_XP_MN1 (XI1_I1252_I108_XP_n1 I1_I1252_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I108_XP_MN0 (I1_I1252_P12_9n I1_I1252_P12_11 XI1_I1252_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I168_XP_MN1 (XI1_I1252_I168_XP_n1 I1_I1252_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I168_XP_MN0 (I1_I1252_P17_2n I1_I1252_P17_10 XI1_I1252_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I107_XP_MN1 (XI1_I1252_I107_XP_n1 I1_I1252_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I107_XP_MN0 (I1_I1252_P11_8n I1_I1252_P11_10 XI1_I1252_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I109_XP_MN1 (XI1_I1252_I109_XP_n1 I1_I1252_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I109_XP_MN0 (I1_I1252_P13_10n I1_I1252_P13_12 XI1_I1252_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I11_MN1 (XI1_I1252_I11_n1 I1_b15_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I11_MN0 (I1_I1252_gn11 I1_p14_10 XI1_I1252_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I12_MN1 (XI1_I1252_I12_n1 I1_b15_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I12_MN0 (I1_I1252_gn12 I1_p14_11 XI1_I1252_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I16_MN1 (XI1_I1206_I16_n1 I1_b14_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I16_MN0 (I1_I1206_gn16 I1_p13_15 XI1_I1206_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I15_MN1 (XI1_I1206_I15_n1 I1_b14_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I15_MN0 (I1_I1206_gn15 I1_p13_14 XI1_I1206_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I14_MN1 (XI1_I1206_I14_n1 I1_b14_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I14_MN0 (I1_I1206_gn14 I1_p13_13 XI1_I1206_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I107_XP_MN1 (XI1_I1206_I107_XP_n1 I1_I1206_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I107_XP_MN0 (I1_I1206_P11_8n I1_I1206_P11_10 XI1_I1206_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I105_XP_MN1 (XI1_I1206_I105_XP_n1 I1_I1206_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I105_XP_MN0 (I1_I1206_P9_6n I1_I1206_P9_8 XI1_I1206_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I110_XP_MN1 (XI1_I1206_I110_XP_n1 I1_I1206_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I110_XP_MN0 (I1_I1206_P14_11n I1_I1206_P14_13 XI1_I1206_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I108_XP_MN1 (XI1_I1206_I108_XP_n1 I1_I1206_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I108_XP_MN0 (I1_I1206_P12_9n I1_I1206_P12_11 XI1_I1206_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I30_MN1 (XI1_I884_I30_n1 I1_b7_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I30_MN0 (I1_I884_gn30 I1_p6_29 XI1_I884_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I127_XP_MN1 (XI1_I884_I127_XP_n1 I1_I884_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I127_XP_MN0 (I1_I884_P31_28n I1_I884_P31_30 XI1_I884_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I125_XP_MN1 (XI1_I884_I125_XP_n1 I1_I884_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I125_XP_MN0 (I1_I884_P29_26n I1_I884_P29_28 XI1_I884_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I123_XP_MN1 (XI1_I884_I123_XP_n1 I1_I884_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I123_XP_MN0 (I1_I884_P27_24n I1_I884_P27_26 XI1_I884_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I121_XP_MN1 (XI1_I884_I121_XP_n1 I1_I884_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I121_XP_MN0 (I1_I884_P25_22n I1_I884_P25_24 XI1_I884_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I119_XP_MN1 (XI1_I884_I119_XP_n1 I1_I884_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I119_XP_MN0 (I1_I884_P23_20n I1_I884_P23_22 XI1_I884_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I117_XP_MN1 (XI1_I884_I117_XP_n1 I1_I884_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I117_XP_MN0 (I1_I884_P21_18n I1_I884_P21_20 XI1_I884_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I115_XP_MN1 (XI1_I884_I115_XP_n1 I1_I884_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I115_XP_MN0 (I1_I884_P19_16n I1_I884_P19_18 XI1_I884_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I113_XP_MN1 (XI1_I884_I113_XP_n1 I1_I884_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I113_XP_MN0 (I1_I884_P17_14n I1_I884_P17_16 XI1_I884_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I12_MN1 (XI1_I884_I12_n1 I1_b7_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I12_MN0 (I1_I884_gn12 I1_p6_11 XI1_I884_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I10_MN1 (XI1_I884_I10_n1 I1_b7_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I10_MN0 (I1_I884_gn10 I1_p6_9 XI1_I884_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I9_MN1 (XI1_I884_I9_n1 I1_b7_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I9_MN0 (I1_I884_gn9 I1_p6_8 XI1_I884_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I3_MN1 (XI1_I838_I3_n1 I1_b6_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I3_MN0 (I1_I838_gn3 I1_p5_2 XI1_I838_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I6_MN1 (XI1_I792_I6_n1 I1_b5_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I6_MN0 (I1_I792_gn6 I1_p4_5 XI1_I792_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I7_MN1 (XI1_I792_I7_n1 I1_b5_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I7_MN0 (I1_I792_gn7 I1_p4_6 XI1_I792_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I9_MN1 (XI1_I792_I9_n1 I1_b5_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I9_MN0 (I1_I792_gn9 I1_p4_8 XI1_I792_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I103_XP_MN1 (XI1_I746_I103_XP_n1 I1_I746_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I103_XP_MN0 (I1_I746_P7_4n I1_I746_P7_6 XI1_I746_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I105_XP_MN1 (XI1_I746_I105_XP_n1 I1_I746_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I105_XP_MN0 (I1_I746_P9_6n I1_I746_P9_8 XI1_I746_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I107_XP_MN1 (XI1_I746_I107_XP_n1 I1_I746_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I107_XP_MN0 (I1_I746_P11_8n I1_I746_P11_10 XI1_I746_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I170_XP_MN1 (XI1_I746_I170_XP_n1 I1_I746_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I170_XP_MN0 (I1_I746_P19_4n I1_I746_P19_12 XI1_I746_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I109_XP_MN1 (XI1_I746_I109_XP_n1 I1_I746_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I109_XP_MN0 (I1_I746_P13_10n I1_I746_P13_12 XI1_I746_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I111_XP_MN1 (XI1_I746_I111_XP_n1 I1_I746_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I111_XP_MN0 (I1_I746_P15_12n I1_I746_P15_14 XI1_I746_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I174_XP_MN1 (XI1_I746_I174_XP_n1 I1_I746_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I174_XP_MN0 (I1_I746_P23_8n I1_I746_P23_16 XI1_I746_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I182_XP_MN1 (XI1_I746_I182_XP_n1 I1_I746_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I182_XP_MN0 (I1_I746_P31_16n I1_I746_P31_24 XI1_I746_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I31_MN1 (XI1_I1390_I31_n1 I1_b18_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I31_MN0 (I1_I1390_gn31 I1_p17_30 XI1_I1390_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I26_MN1 (XI1_I1390_I26_n1 I1_b18_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I26_MN0 (I1_I1390_gn26 I1_p17_25 XI1_I1390_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I24_MN1 (XI1_I1390_I24_n1 I1_b18_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I24_MN0 (I1_I1390_gn24 I1_p17_23 XI1_I1390_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I169_XP_MN1 (XI1_I1344_I169_XP_n1 I1_I1344_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I169_XP_MN0 (I1_I1344_P18_3n I1_I1344_P18_11 XI1_I1344_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I106_XP_MN1 (XI1_I1344_I106_XP_n1 I1_I1344_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I106_XP_MN0 (I1_I1344_P10_7n I1_I1344_P10_9 XI1_I1344_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I10_MN1 (XI1_I1344_I10_n1 I1_b17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I10_MN0 (I1_I1344_gn10 I1_p16_9 XI1_I1344_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I101_XP_MN1 (XI1_I1344_I101_XP_n1 I1_I1344_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I101_XP_MN0 (I1_I1344_P5_2n I1_I1344_P5_4 XI1_I1344_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I103_XP_MN1 (XI1_I1298_I103_XP_n1 I1_I1298_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I103_XP_MN0 (I1_I1298_P7_4n I1_I1298_P7_6 XI1_I1298_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I167_XP_MN1 (XI1_I1298_I167_XP_n1 I1_I1298_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I167_XP_MN0 (I1_I1298_P16_1n I1_I1298_P16_9 XI1_I1298_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I106_XP_MN1 (XI1_I1298_I106_XP_n1 I1_I1298_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I106_XP_MN0 (I1_I1298_P10_7n I1_I1298_P10_9 XI1_I1298_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I10_MN1 (XI1_I1298_I10_n1 I1_b16_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I10_MN0 (I1_I1298_gn10 I1_p15_9 XI1_I1298_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I9_MN1 (XI1_I1298_I9_n1 I1_b16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I9_MN0 (I1_I1298_gn9 I1_p15_8 XI1_I1298_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I167_XP_MN1 (XI1_I1252_I167_XP_n1 I1_I1252_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I167_XP_MN0 (I1_I1252_P16_1n I1_I1252_P16_9 XI1_I1252_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I106_XP_MN1 (XI1_I1252_I106_XP_n1 I1_I1252_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I106_XP_MN0 (I1_I1252_P10_7n I1_I1252_P10_9 XI1_I1252_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I105_XP_MN1 (XI1_I1252_I105_XP_n1 I1_I1252_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I105_XP_MN0 (I1_I1252_P9_6n I1_I1252_P9_8 XI1_I1252_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I8_MN1 (XI1_I1252_I8_n1 I1_b15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I8_MN0 (I1_I1252_gn8 I1_p14_7 XI1_I1252_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I9_MN1 (XI1_I1252_I9_n1 I1_b15_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I9_MN0 (I1_I1252_gn9 I1_p14_8 XI1_I1252_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I10_MN1 (XI1_I1252_I10_n1 I1_b15_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I10_MN0 (I1_I1252_gn10 I1_p14_9 XI1_I1252_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I13_MN1 (XI1_I1206_I13_n1 I1_b14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I13_MN0 (I1_I1206_gn13 I1_p13_12 XI1_I1206_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I103_XP_MN1 (XI1_I1206_I103_XP_n1 I1_I1206_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I103_XP_MN0 (I1_I1206_P7_4n I1_I1206_P7_6 XI1_I1206_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I101_XP_MN1 (XI1_I1206_I101_XP_n1 I1_I1206_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I101_XP_MN0 (I1_I1206_P5_2n I1_I1206_P5_4 XI1_I1206_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I106_XP_MN1 (XI1_I1206_I106_XP_n1 I1_I1206_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I106_XP_MN0 (I1_I1206_P10_7n I1_I1206_P10_9 XI1_I1206_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I167_XP_MN1 (XI1_I1206_I167_XP_n1 I1_I1206_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I167_XP_MN0 (I1_I1206_P16_1n I1_I1206_P16_9 XI1_I1206_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I182_XP_MN1 (XI1_I884_I182_XP_n1 I1_I884_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I182_XP_MN0 (I1_I884_P31_16n I1_I884_P31_24 XI1_I884_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I180_XP_MN1 (XI1_I884_I180_XP_n1 I1_I884_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I180_XP_MN0 (I1_I884_P29_14n I1_I884_P29_22 XI1_I884_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I174_XP_MN1 (XI1_I884_I174_XP_n1 I1_I884_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I174_XP_MN0 (I1_I884_P23_8n I1_I884_P23_16 XI1_I884_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I178_XP_MN1 (XI1_I884_I178_XP_n1 I1_I884_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I178_XP_MN0 (I1_I884_P27_12n I1_I884_P27_20 XI1_I884_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I172_XP_MN1 (XI1_I884_I172_XP_n1 I1_I884_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I172_XP_MN0 (I1_I884_P21_6n I1_I884_P21_14 XI1_I884_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I170_XP_MN1 (XI1_I884_I170_XP_n1 I1_I884_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I170_XP_MN0 (I1_I884_P19_4n I1_I884_P19_12 XI1_I884_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I111_XP_MN1 (XI1_I884_I111_XP_n1 I1_I884_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I111_XP_MN0 (I1_I884_P15_12n I1_I884_P15_14 XI1_I884_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I109_XP_MN1 (XI1_I884_I109_XP_n1 I1_I884_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I109_XP_MN0 (I1_I884_P13_10n I1_I884_P13_12 XI1_I884_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I107_XP_MN1 (XI1_I884_I107_XP_n1 I1_I884_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I107_XP_MN0 (I1_I884_P11_8n I1_I884_P11_10 XI1_I884_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I8_MN1 (XI1_I884_I8_n1 I1_b7_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I8_MN0 (I1_I884_gn8 I1_p6_7 XI1_I884_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I7_MN1 (XI1_I884_I7_n1 I1_b7_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I7_MN0 (I1_I884_gn7 I1_p6_6 XI1_I884_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I6_MN1 (XI1_I884_I6_n1 I1_b7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I6_MN0 (I1_I884_gn6 I1_p6_5 XI1_I884_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I5_MN1 (XI1_I884_I5_n1 I1_b7_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I5_MN0 (I1_I884_gn5 I1_p6_4 XI1_I884_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I2_MN1 (XI1_I838_I2_n1 I1_b6_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I2_MN0 (I1_I838_gn2 I1_p5_1 XI1_I838_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I4_MN1 (XI1_I792_I4_n1 I1_b5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I4_MN0 (I1_I792_gn4 I1_p4_3 XI1_I792_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I5_MN1 (XI1_I792_I5_n1 I1_b5_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I5_MN0 (I1_I792_gn5 I1_p4_4 XI1_I792_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I101_XP_MN1 (XI1_I746_I101_XP_n1 I1_I746_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I101_XP_MN0 (I1_I746_P5_2n I1_I746_P5_4 XI1_I746_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I12_MN1 (XI1_I746_I12_n1 I1_b4_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I12_MN0 (I1_I746_gn12 I1_p3_11 XI1_I746_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I14_MN1 (XI1_I746_I14_n1 I1_b4_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I14_MN0 (I1_I746_gn14 I1_p3_13 XI1_I746_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I16_MN1 (XI1_I746_I16_n1 I1_b4_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I16_MN0 (I1_I746_gn16 I1_p3_15 XI1_I746_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I17_MN1 (XI1_I746_I17_n1 I1_b4_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I17_MN0 (I1_I746_gn17 I1_p3_16 XI1_I746_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I18_MN1 (XI1_I746_I18_n1 I1_b4_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I18_MN0 (I1_I746_gn18 I1_p3_17 XI1_I746_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I20_MN1 (XI1_I746_I20_n1 I1_b4_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I20_MN0 (I1_I746_gn20 I1_p3_19 XI1_I746_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I21_MN1 (XI1_I746_I21_n1 I1_b4_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I21_MN0 (I1_I746_gn21 I1_p3_20 XI1_I746_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I22_MN1 (XI1_I746_I22_n1 I1_b4_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I22_MN0 (I1_I746_gn22 I1_p3_21 XI1_I746_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I23_MN1 (XI1_I746_I23_n1 I1_b4_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I23_MN0 (I1_I746_gn23 I1_p3_22 XI1_I746_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I30_MN1 (XI1_I1390_I30_n1 I1_b18_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I30_MN0 (I1_I1390_gn30 I1_p17_29 XI1_I1390_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I23_MN1 (XI1_I1390_I23_n1 I1_b18_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I23_MN0 (I1_I1390_gn23 I1_p17_22 XI1_I1390_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I21_MN1 (XI1_I1390_I21_n1 I1_b18_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I21_MN0 (I1_I1390_gn21 I1_p17_20 XI1_I1390_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I20_MN1 (XI1_I1390_I20_n1 I1_b18_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I20_MN0 (I1_I1390_gn20 I1_p17_19 XI1_I1390_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I19_MN1 (XI1_I1390_I19_n1 I1_b18_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I19_MN0 (I1_I1390_gn19 I1_p17_18 XI1_I1390_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I17_MN1 (XI1_I1390_I17_n1 I1_b18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I17_MN0 (I1_I1390_gn17 I1_p17_16 XI1_I1390_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I167_XP_MN1 (XI1_I1344_I167_XP_n1 I1_I1344_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I167_XP_MN0 (I1_I1344_P16_1n I1_I1344_P16_9 XI1_I1344_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I104_XP_MN1 (XI1_I1344_I104_XP_n1 I1_I1344_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I104_XP_MN0 (I1_I1344_P8_5n I1_I1344_P8_7 XI1_I1344_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I8_MN1 (XI1_I1344_I8_n1 I1_b17_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I8_MN0 (I1_I1344_gn8 I1_p16_7 XI1_I1344_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I7_MN1 (XI1_I1344_I7_n1 I1_b17_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I7_MN0 (I1_I1344_gn7 I1_p16_6 XI1_I1344_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I101_XP_MN1 (XI1_I1298_I101_XP_n1 I1_I1298_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I101_XP_MN0 (I1_I1298_P5_2n I1_I1298_P5_4 XI1_I1298_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I104_XP_MN1 (XI1_I1298_I104_XP_n1 I1_I1298_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I104_XP_MN0 (I1_I1298_P8_5n I1_I1298_P8_7 XI1_I1298_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I7_MN1 (XI1_I1298_I7_n1 I1_b16_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I7_MN0 (I1_I1298_gn7 I1_p15_6 XI1_I1298_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I8_MN1 (XI1_I1298_I8_n1 I1_b16_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I8_MN0 (I1_I1298_gn8 I1_p15_7 XI1_I1298_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I104_XP_MN1 (XI1_I1252_I104_XP_n1 I1_I1252_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I104_XP_MN0 (I1_I1252_P8_5n I1_I1252_P8_7 XI1_I1252_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I103_XP_MN1 (XI1_I1252_I103_XP_n1 I1_I1252_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I103_XP_MN0 (I1_I1252_P7_4n I1_I1252_P7_6 XI1_I1252_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I6_MN1 (XI1_I1252_I6_n1 I1_b15_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I6_MN0 (I1_I1252_gn6 I1_p14_5 XI1_I1252_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I7_MN1 (XI1_I1252_I7_n1 I1_b15_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I7_MN0 (I1_I1252_gn7 I1_p14_6 XI1_I1252_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I12_MN1 (XI1_I1206_I12_n1 I1_b14_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I12_MN0 (I1_I1206_gn12 I1_p13_11 XI1_I1206_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I11_MN1 (XI1_I1206_I11_n1 I1_b14_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I11_MN0 (I1_I1206_gn11 I1_p13_10 XI1_I1206_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I10_MN1 (XI1_I1206_I10_n1 I1_b14_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I10_MN0 (I1_I1206_gn10 I1_p13_9 XI1_I1206_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I9_MN1 (XI1_I1206_I9_n1 I1_b14_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I9_MN0 (I1_I1206_gn9 I1_p13_8 XI1_I1206_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I8_MN1 (XI1_I1206_I8_n1 I1_b14_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I8_MN0 (I1_I1206_gn8 I1_p13_7 XI1_I1206_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I102_XP_MN1 (XI1_I1206_I102_XP_n1 I1_I1206_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I102_XP_MN0 (I1_I1206_P6_3n I1_I1206_P6_5 XI1_I1206_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I104_XP_MN1 (XI1_I1206_I104_XP_n1 I1_I1206_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I104_XP_MN0 (I1_I1206_P8_5n I1_I1206_P8_7 XI1_I1206_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I126_XP_MN1 (XI1_I884_I126_XP_n1 I1_I884_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I126_XP_MN0 (I1_I884_P30_27n I1_I884_P30_29 XI1_I884_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I176_XP_MN1 (XI1_I884_I176_XP_n1 I1_I884_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I176_XP_MN0 (I1_I884_P25_10n I1_I884_P25_18 XI1_I884_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I168_XP_MN1 (XI1_I884_I168_XP_n1 I1_I884_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I168_XP_MN0 (I1_I884_P17_2n I1_I884_P17_10 XI1_I884_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I105_XP_MN1 (XI1_I884_I105_XP_n1 I1_I884_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I105_XP_MN0 (I1_I884_P9_6n I1_I884_P9_8 XI1_I884_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I103_XP_MN1 (XI1_I884_I103_XP_n1 I1_I884_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I103_XP_MN0 (I1_I884_P7_4n I1_I884_P7_6 XI1_I884_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I4_MN1 (XI1_I884_I4_n1 I1_b7_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I4_MN0 (I1_I884_gn4 I1_p6_3 XI1_I884_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I2_MN1 (XI1_I792_I2_n1 I1_b5_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I2_MN0 (I1_I792_gn2 I1_p4_1 XI1_I792_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I3_MN1 (XI1_I792_I3_n1 I1_b5_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I3_MN0 (I1_I792_gn3 I1_p4_2 XI1_I792_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I6_MN1 (XI1_I746_I6_n1 I1_b4_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I6_MN0 (I1_I746_gn6 I1_p3_5 XI1_I746_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I9_MN1 (XI1_I746_I9_n1 I1_b4_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I9_MN0 (I1_I746_gn9 I1_p3_8 XI1_I746_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I11_MN1 (XI1_I746_I11_n1 I1_b4_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I11_MN0 (I1_I746_gn11 I1_p3_10 XI1_I746_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I10_MN1 (XI1_I746_I10_n1 I1_b4_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I10_MN0 (I1_I746_gn10 I1_p3_9 XI1_I746_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I13_MN1 (XI1_I746_I13_n1 I1_b4_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I13_MN0 (I1_I746_gn13 I1_p3_12 XI1_I746_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I15_MN1 (XI1_I746_I15_n1 I1_b4_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I15_MN0 (I1_I746_gn15 I1_p3_14 XI1_I746_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I174_XP_MN1 (XI1_I700_I174_XP_n1 I1_I700_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I174_XP_MN0 (I1_I700_P23_8n I1_I700_P23_16 XI1_I700_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I182_XP_MN1 (XI1_I700_I182_XP_n1 I1_I700_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I182_XP_MN0 (I1_I700_P31_16n I1_I700_P31_24 XI1_I700_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I18_MN1 (XI1_I1390_I18_n1 I1_b18_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I18_MN0 (I1_I1390_gn18 I1_p17_17 XI1_I1390_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I16_MN1 (XI1_I1390_I16_n1 I1_b18_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I16_MN0 (I1_I1390_gn16 I1_p17_15 XI1_I1390_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I15_MN1 (XI1_I1390_I15_n1 I1_b18_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I15_MN0 (I1_I1390_gn15 I1_p17_14 XI1_I1390_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I102_XP_MN1 (XI1_I1344_I102_XP_n1 I1_I1344_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I102_XP_MN0 (I1_I1344_P6_3n I1_I1344_P6_5 XI1_I1344_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I100_XP_MN1 (XI1_I1344_I100_XP_n1 I1_I1344_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I100_XP_MN0 (I1_I1344_P4_1n I1_I1344_P4_3 XI1_I1344_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I6_MN1 (XI1_I1344_I6_n1 I1_b17_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I6_MN0 (I1_I1344_gn6 I1_p16_5 XI1_I1344_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I5_MN1 (XI1_I1344_I5_n1 I1_b17_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I5_MN0 (I1_I1344_gn5 I1_p16_4 XI1_I1344_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I102_XP_MN1 (XI1_I1298_I102_XP_n1 I1_I1298_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I102_XP_MN0 (I1_I1298_P6_3n I1_I1298_P6_5 XI1_I1298_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I6_MN1 (XI1_I1298_I6_n1 I1_b16_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I6_MN0 (I1_I1298_gn6 I1_p15_5 XI1_I1298_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I100_XP_MN1 (XI1_I1252_I100_XP_n1 I1_I1252_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I100_XP_MN0 (I1_I1252_P4_1n I1_I1252_P4_3 XI1_I1252_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I102_XP_MN1 (XI1_I1252_I102_XP_n1 I1_I1252_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I102_XP_MN0 (I1_I1252_P6_3n I1_I1252_P6_5 XI1_I1252_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I101_XP_MN1 (XI1_I1252_I101_XP_n1 I1_I1252_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I101_XP_MN0 (I1_I1252_P5_2n I1_I1252_P5_4 XI1_I1252_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I5_MN1 (XI1_I1252_I5_n1 I1_b15_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I5_MN0 (I1_I1252_gn5 I1_p14_4 XI1_I1252_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I178_XP_MN1 (XI1_I1160_I178_XP_n1 I1_I1160_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I178_XP_MN0 (I1_I1160_P27_12n I1_I1160_P27_20 XI1_I1160_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I170_XP_MN1 (XI1_I1160_I170_XP_n1 I1_I1160_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I170_XP_MN0 (I1_I1160_P19_4n I1_I1160_P19_12 XI1_I1160_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I6_MN1 (XI1_I1206_I6_n1 I1_b14_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I6_MN0 (I1_I1206_gn6 I1_p13_5 XI1_I1206_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I100_XP_MN1 (XI1_I1206_I100_XP_n1 I1_I1206_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I100_XP_MN0 (I1_I1206_P4_1n I1_I1206_P4_3 XI1_I1206_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I124_XP_MN1 (XI1_I884_I124_XP_n1 I1_I884_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I124_XP_MN0 (I1_I884_P28_25n I1_I884_P28_27 XI1_I884_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I122_XP_MN1 (XI1_I884_I122_XP_n1 I1_I884_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I122_XP_MN0 (I1_I884_P26_23n I1_I884_P26_25 XI1_I884_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I120_XP_MN1 (XI1_I884_I120_XP_n1 I1_I884_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I120_XP_MN0 (I1_I884_P24_21n I1_I884_P24_23 XI1_I884_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I118_XP_MN1 (XI1_I884_I118_XP_n1 I1_I884_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I118_XP_MN0 (I1_I884_P22_19n I1_I884_P22_21 XI1_I884_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I116_XP_MN1 (XI1_I884_I116_XP_n1 I1_I884_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I116_XP_MN0 (I1_I884_P20_17n I1_I884_P20_19 XI1_I884_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I114_XP_MN1 (XI1_I884_I114_XP_n1 I1_I884_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I114_XP_MN0 (I1_I884_P18_15n I1_I884_P18_17 XI1_I884_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I112_XP_MN1 (XI1_I884_I112_XP_n1 I1_I884_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I112_XP_MN0 (I1_I884_P16_13n I1_I884_P16_15 XI1_I884_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I110_XP_MN1 (XI1_I884_I110_XP_n1 I1_I884_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I110_XP_MN0 (I1_I884_P14_11n I1_I884_P14_13 XI1_I884_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I108_XP_MN1 (XI1_I884_I108_XP_n1 I1_I884_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I108_XP_MN0 (I1_I884_P12_9n I1_I884_P12_11 XI1_I884_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I106_XP_MN1 (XI1_I884_I106_XP_n1 I1_I884_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I106_XP_MN0 (I1_I884_P10_7n I1_I884_P10_9 XI1_I884_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I104_XP_MN1 (XI1_I884_I104_XP_n1 I1_I884_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I104_XP_MN0 (I1_I884_P8_5n I1_I884_P8_7 XI1_I884_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I101_XP_MN1 (XI1_I884_I101_XP_n1 I1_I884_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I101_XP_MN0 (I1_I884_P5_2n I1_I884_P5_4 XI1_I884_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I3_MN1 (XI1_I884_I3_n1 I1_b7_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I3_MN0 (I1_I884_gn3 I1_p6_2 XI1_I884_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I5_MN1 (XI1_I746_I5_n1 I1_b4_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I5_MN0 (I1_I746_gn5 I1_p3_4 XI1_I746_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I7_MN1 (XI1_I746_I7_n1 I1_b4_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I7_MN0 (I1_I746_gn7 I1_p3_6 XI1_I746_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I8_MN1 (XI1_I746_I8_n1 I1_b4_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I8_MN0 (I1_I746_gn8 I1_p3_7 XI1_I746_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I170_XP_MN1 (XI1_I700_I170_XP_n1 I1_I700_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I170_XP_MN0 (I1_I700_P19_4n I1_I700_P19_12 XI1_I700_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I19_MN1 (XI1_I746_I19_n1 I1_b4_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I19_MN0 (I1_I746_gn19 I1_p3_18 XI1_I746_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I172_XP_MN1 (XI1_I700_I172_XP_n1 I1_I700_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I172_XP_MN0 (I1_I700_P21_6n I1_I700_P21_14 XI1_I700_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I178_XP_MN1 (XI1_I700_I178_XP_n1 I1_I700_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I178_XP_MN0 (I1_I700_P27_12n I1_I700_P27_20 XI1_I700_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I180_XP_MN1 (XI1_I700_I180_XP_n1 I1_I700_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I180_XP_MN0 (I1_I700_P29_14n I1_I700_P29_22 XI1_I700_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I127_XP_MN1 (XI1_I1390_I127_XP_n1 I1_I1390_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I127_XP_MN0 (I1_I1390_P31_28n I1_I1390_P31_30 XI1_I1390_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I125_XP_MN1 (XI1_I1390_I125_XP_n1 I1_I1390_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I125_XP_MN0 (I1_I1390_P29_26n I1_I1390_P29_28 XI1_I1390_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I123_XP_MN1 (XI1_I1390_I123_XP_n1 I1_I1390_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I123_XP_MN0 (I1_I1390_P27_24n I1_I1390_P27_26 XI1_I1390_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I121_XP_MN1 (XI1_I1390_I121_XP_n1 I1_I1390_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I121_XP_MN0 (I1_I1390_P25_22n I1_I1390_P25_24 XI1_I1390_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I119_XP_MN1 (XI1_I1390_I119_XP_n1 I1_I1390_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I119_XP_MN0 (I1_I1390_P23_20n I1_I1390_P23_22 XI1_I1390_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I117_XP_MN1 (XI1_I1390_I117_XP_n1 I1_I1390_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I117_XP_MN0 (I1_I1390_P21_18n I1_I1390_P21_20 XI1_I1390_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I115_XP_MN1 (XI1_I1390_I115_XP_n1 I1_I1390_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I115_XP_MN0 (I1_I1390_P19_16n I1_I1390_P19_18 XI1_I1390_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I14_MN1 (XI1_I1390_I14_n1 I1_b18_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I14_MN0 (I1_I1390_gn14 I1_p17_13 XI1_I1390_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I12_MN1 (XI1_I1390_I12_n1 I1_b18_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I12_MN0 (I1_I1390_gn12 I1_p17_11 XI1_I1390_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I13_MN1 (XI1_I1390_I13_n1 I1_b18_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I13_MN0 (I1_I1390_gn13 I1_p17_12 XI1_I1390_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I10_MN1 (XI1_I1390_I10_n1 I1_b18_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I10_MN0 (I1_I1390_gn10 I1_p17_9 XI1_I1390_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I4_MN1 (XI1_I1344_I4_n1 I1_b17_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I4_MN0 (I1_I1344_gn4 I1_p16_3 XI1_I1344_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I100_XP_MN1 (XI1_I1298_I100_XP_n1 I1_I1298_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I100_XP_MN0 (I1_I1298_P4_1n I1_I1298_P4_3 XI1_I1298_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I4_MN1 (XI1_I1298_I4_n1 I1_b16_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I4_MN0 (I1_I1298_gn4 I1_p15_3 XI1_I1298_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I5_MN1 (XI1_I1298_I5_n1 I1_b16_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I5_MN0 (I1_I1298_gn5 I1_p15_4 XI1_I1298_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I3_MN1 (XI1_I1252_I3_n1 I1_b15_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I3_MN0 (I1_I1252_gn3 I1_p14_2 XI1_I1252_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I4_MN1 (XI1_I1252_I4_n1 I1_b15_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I4_MN0 (I1_I1252_gn4 I1_p14_3 XI1_I1252_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I174_XP_MN1 (XI1_I1160_I174_XP_n1 I1_I1160_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I174_XP_MN0 (I1_I1160_P23_8n I1_I1160_P23_16 XI1_I1160_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I7_MN1 (XI1_I1206_I7_n1 I1_b14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I7_MN0 (I1_I1206_gn7 I1_p13_6 XI1_I1206_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I181_XP_MN1 (XI1_I884_I181_XP_n1 I1_I884_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I181_XP_MN0 (I1_I884_P30_15n I1_I884_P30_23 XI1_I884_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I179_XP_MN1 (XI1_I884_I179_XP_n1 I1_I884_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I179_XP_MN0 (I1_I884_P28_13n I1_I884_P28_21 XI1_I884_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I177_XP_MN1 (XI1_I884_I177_XP_n1 I1_I884_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I177_XP_MN0 (I1_I884_P26_11n I1_I884_P26_19 XI1_I884_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I173_XP_MN1 (XI1_I884_I173_XP_n1 I1_I884_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I173_XP_MN0 (I1_I884_P22_7n I1_I884_P22_15 XI1_I884_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I175_XP_MN1 (XI1_I884_I175_XP_n1 I1_I884_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I175_XP_MN0 (I1_I884_P24_9n I1_I884_P24_17 XI1_I884_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I171_XP_MN1 (XI1_I884_I171_XP_n1 I1_I884_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I171_XP_MN0 (I1_I884_P20_5n I1_I884_P20_13 XI1_I884_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I169_XP_MN1 (XI1_I884_I169_XP_n1 I1_I884_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I169_XP_MN0 (I1_I884_P18_3n I1_I884_P18_11 XI1_I884_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I167_XP_MN1 (XI1_I884_I167_XP_n1 I1_I884_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I167_XP_MN0 (I1_I884_P16_1n I1_I884_P16_9 XI1_I884_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I100_XP_MN1 (XI1_I884_I100_XP_n1 I1_I884_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I100_XP_MN0 (I1_I884_P4_1n I1_I884_P4_3 XI1_I884_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I102_XP_MN1 (XI1_I884_I102_XP_n1 I1_I884_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I102_XP_MN0 (I1_I884_P6_3n I1_I884_P6_5 XI1_I884_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I2_MN1 (XI1_I884_I2_n1 I1_b7_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I2_MN0 (I1_I884_gn2 I1_p6_1 XI1_I884_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I1_MN1 (XI1_I838_I1_n1 I1_b6_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I1_MN0 (I1_I838_gn1 I1_p5_0 XI1_I838_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I1_MN1 (XI1_I792_I1_n1 I1_b5_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I1_MN0 (I1_I792_gn1 I1_p4_0 XI1_I792_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I3_MN1 (XI1_I746_I3_n1 I1_b4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I3_MN0 (I1_I746_gn3 I1_p3_2 XI1_I746_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I101_XP_MN1 (XI1_I700_I101_XP_n1 I1_I700_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I101_XP_MN0 (I1_I700_P5_2n I1_I700_P5_4 XI1_I700_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I168_XP_MN1 (XI1_I700_I168_XP_n1 I1_I700_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I168_XP_MN0 (I1_I700_P17_2n I1_I700_P17_10 XI1_I700_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I109_XP_MN1 (XI1_I700_I109_XP_n1 I1_I700_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I109_XP_MN0 (I1_I700_P13_10n I1_I700_P13_12 XI1_I700_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I111_XP_MN1 (XI1_I700_I111_XP_n1 I1_I700_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I111_XP_MN0 (I1_I700_P15_12n I1_I700_P15_14 XI1_I700_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I113_XP_MN1 (XI1_I700_I113_XP_n1 I1_I700_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I113_XP_MN0 (I1_I700_P17_14n I1_I700_P17_16 XI1_I700_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I115_XP_MN1 (XI1_I700_I115_XP_n1 I1_I700_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I115_XP_MN0 (I1_I700_P19_16n I1_I700_P19_18 XI1_I700_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I117_XP_MN1 (XI1_I700_I117_XP_n1 I1_I700_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I117_XP_MN0 (I1_I700_P21_18n I1_I700_P21_20 XI1_I700_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I176_XP_MN1 (XI1_I700_I176_XP_n1 I1_I700_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I176_XP_MN0 (I1_I700_P25_10n I1_I700_P25_18 XI1_I700_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I119_XP_MN1 (XI1_I700_I119_XP_n1 I1_I700_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I119_XP_MN0 (I1_I700_P23_20n I1_I700_P23_22 XI1_I700_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I123_XP_MN1 (XI1_I700_I123_XP_n1 I1_I700_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I123_XP_MN0 (I1_I700_P27_24n I1_I700_P27_26 XI1_I700_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I125_XP_MN1 (XI1_I700_I125_XP_n1 I1_I700_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I125_XP_MN0 (I1_I700_P29_26n I1_I700_P29_28 XI1_I700_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I127_XP_MN1 (XI1_I700_I127_XP_n1 I1_I700_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I127_XP_MN0 (I1_I700_P31_28n I1_I700_P31_30 XI1_I700_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I182_XP_MN1 (XI1_I1390_I182_XP_n1 I1_I1390_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I182_XP_MN0 (I1_I1390_P31_16n I1_I1390_P31_24 XI1_I1390_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I180_XP_MN1 (XI1_I1390_I180_XP_n1 I1_I1390_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I180_XP_MN0 (I1_I1390_P29_14n I1_I1390_P29_22 XI1_I1390_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I178_XP_MN1 (XI1_I1390_I178_XP_n1 I1_I1390_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I178_XP_MN0 (I1_I1390_P27_12n I1_I1390_P27_20 XI1_I1390_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I113_XP_MN1 (XI1_I1390_I113_XP_n1 I1_I1390_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I113_XP_MN0 (I1_I1390_P17_14n I1_I1390_P17_16 XI1_I1390_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I111_XP_MN1 (XI1_I1390_I111_XP_n1 I1_I1390_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I111_XP_MN0 (I1_I1390_P15_12n I1_I1390_P15_14 XI1_I1390_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I11_MN1 (XI1_I1390_I11_n1 I1_b18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I11_MN0 (I1_I1390_gn11 I1_p17_10 XI1_I1390_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I9_MN1 (XI1_I1390_I9_n1 I1_b18_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I9_MN0 (I1_I1390_gn9 I1_p17_8 XI1_I1390_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I3_MN1 (XI1_I1298_I3_n1 I1_b16_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I3_MN0 (I1_I1298_gn3 I1_p15_2 XI1_I1298_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I1_MN1 (XI1_I1252_I1_n1 I1_b15_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I1_MN0 (I1_I1252_gn1 I1_p14_0 XI1_I1252_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I2_MN1 (XI1_I1252_I2_n1 I1_b15_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I2_MN0 (I1_I1252_gn2 I1_p14_1 XI1_I1252_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I127_XP_MN1 (XI1_I1160_I127_XP_n1 I1_I1160_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I127_XP_MN0 (I1_I1160_P31_28n I1_I1160_P31_30 XI1_I1160_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I182_XP_MN1 (XI1_I1160_I182_XP_n1 I1_I1160_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I182_XP_MN0 (I1_I1160_P31_16n I1_I1160_P31_24 XI1_I1160_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I180_XP_MN1 (XI1_I1160_I180_XP_n1 I1_I1160_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I180_XP_MN0 (I1_I1160_P29_14n I1_I1160_P29_22 XI1_I1160_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I172_XP_MN1 (XI1_I1160_I172_XP_n1 I1_I1160_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I172_XP_MN0 (I1_I1160_P21_6n I1_I1160_P21_14 XI1_I1160_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I176_XP_MN1 (XI1_I1160_I176_XP_n1 I1_I1160_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I176_XP_MN0 (I1_I1160_P25_10n I1_I1160_P25_18 XI1_I1160_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I168_XP_MN1 (XI1_I1160_I168_XP_n1 I1_I1160_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I168_XP_MN0 (I1_I1160_P17_2n I1_I1160_P17_10 XI1_I1160_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I103_XP_MN1 (XI1_I1160_I103_XP_n1 I1_I1160_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I103_XP_MN0 (I1_I1160_P7_4n I1_I1160_P7_6 XI1_I1160_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I5_MN1 (XI1_I1206_I5_n1 I1_b14_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I5_MN0 (I1_I1206_gn5 I1_p13_4 XI1_I1206_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I4_MN1 (XI1_I1206_I4_n1 I1_b14_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I4_MN0 (I1_I1206_gn4 I1_p13_3 XI1_I1206_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I3_MN1 (XI1_I1206_I3_n1 I1_b14_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I3_MN0 (I1_I1206_gn3 I1_p13_2 XI1_I1206_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I2_MN1 (XI1_I1206_I2_n1 I1_b14_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I2_MN0 (I1_I1206_gn2 I1_p13_1 XI1_I1206_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I1_MN1 (XI1_I1206_I1_n1 I1_b14_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I1_MN0 (I1_I1206_gn1 I1_p13_0 XI1_I1206_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I27_MN1 (XI1_I930_I27_n1 I1_b8_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I27_MN0 (I1_I930_gn27 I1_p7_26 XI1_I930_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I20_MN1 (XI1_I930_I20_n1 I1_b8_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I20_MN0 (I1_I930_gn20 I1_p7_19 XI1_I930_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I18_MN1 (XI1_I930_I18_n1 I1_b8_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I18_MN0 (I1_I930_gn18 I1_p7_17 XI1_I930_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I17_MN1 (XI1_I930_I17_n1 I1_b8_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I17_MN0 (I1_I930_gn17 I1_p7_16 XI1_I930_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I14_MN1 (XI1_I930_I14_n1 I1_b8_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I14_MN0 (I1_I930_gn14 I1_p7_13 XI1_I930_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I1_MN1 (XI1_I884_I1_n1 I1_b7_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I1_MN0 (I1_I884_gn1 I1_p6_0 XI1_I884_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I2_MN1 (XI1_I746_I2_n1 I1_b4_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I2_MN0 (I1_I746_gn2 I1_p3_1 XI1_I746_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I4_MN1 (XI1_I746_I4_n1 I1_b4_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I4_MN0 (I1_I746_gn4 I1_p3_3 XI1_I746_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I103_XP_MN1 (XI1_I700_I103_XP_n1 I1_I700_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I103_XP_MN0 (I1_I700_P7_4n I1_I700_P7_6 XI1_I700_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I105_XP_MN1 (XI1_I700_I105_XP_n1 I1_I700_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I105_XP_MN0 (I1_I700_P9_6n I1_I700_P9_8 XI1_I700_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I107_XP_MN1 (XI1_I700_I107_XP_n1 I1_I700_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I107_XP_MN0 (I1_I700_P11_8n I1_I700_P11_10 XI1_I700_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I121_XP_MN1 (XI1_I700_I121_XP_n1 I1_I700_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I121_XP_MN0 (I1_I700_P25_22n I1_I700_P25_24 XI1_I700_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I174_XP_MN1 (XI1_I1390_I174_XP_n1 I1_I1390_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I174_XP_MN0 (I1_I1390_P23_8n I1_I1390_P23_16 XI1_I1390_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I176_XP_MN1 (XI1_I1390_I176_XP_n1 I1_I1390_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I176_XP_MN0 (I1_I1390_P25_10n I1_I1390_P25_18 XI1_I1390_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I172_XP_MN1 (XI1_I1390_I172_XP_n1 I1_I1390_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I172_XP_MN0 (I1_I1390_P21_6n I1_I1390_P21_14 XI1_I1390_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I170_XP_MN1 (XI1_I1390_I170_XP_n1 I1_I1390_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I170_XP_MN0 (I1_I1390_P19_4n I1_I1390_P19_12 XI1_I1390_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I109_XP_MN1 (XI1_I1390_I109_XP_n1 I1_I1390_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I109_XP_MN0 (I1_I1390_P13_10n I1_I1390_P13_12 XI1_I1390_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I107_XP_MN1 (XI1_I1390_I107_XP_n1 I1_I1390_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I107_XP_MN0 (I1_I1390_P11_8n I1_I1390_P11_10 XI1_I1390_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I8_MN1 (XI1_I1390_I8_n1 I1_b18_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I8_MN0 (I1_I1390_gn8 I1_p17_7 XI1_I1390_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I7_MN1 (XI1_I1390_I7_n1 I1_b18_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I7_MN0 (I1_I1390_gn7 I1_p17_6 XI1_I1390_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I3_MN1 (XI1_I1344_I3_n1 I1_b17_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I3_MN0 (I1_I1344_gn3 I1_p16_2 XI1_I1344_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I2_MN1 (XI1_I1344_I2_n1 I1_b17_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I2_MN0 (I1_I1344_gn2 I1_p16_1 XI1_I1344_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I1_MN1 (XI1_I1298_I1_n1 I1_b16_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I1_MN0 (I1_I1298_gn1 I1_p15_0 XI1_I1298_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I2_MN1 (XI1_I1298_I2_n1 I1_b16_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I2_MN0 (I1_I1298_gn2 I1_p15_1 XI1_I1298_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I0_MN1 (XI1_I1252_I0_n1 I1_b15_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I0_MN0 (I1_I1252_gn0 I1_aa16 XI1_I1252_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I125_XP_MN1 (XI1_I1160_I125_XP_n1 I1_I1160_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I125_XP_MN0 (I1_I1160_P29_26n I1_I1160_P29_28 XI1_I1160_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I123_XP_MN1 (XI1_I1160_I123_XP_n1 I1_I1160_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I123_XP_MN0 (I1_I1160_P27_24n I1_I1160_P27_26 XI1_I1160_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I121_XP_MN1 (XI1_I1160_I121_XP_n1 I1_I1160_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I121_XP_MN0 (I1_I1160_P25_22n I1_I1160_P25_24 XI1_I1160_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I119_XP_MN1 (XI1_I1160_I119_XP_n1 I1_I1160_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I119_XP_MN0 (I1_I1160_P23_20n I1_I1160_P23_22 XI1_I1160_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I117_XP_MN1 (XI1_I1160_I117_XP_n1 I1_I1160_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I117_XP_MN0 (I1_I1160_P21_18n I1_I1160_P21_20 XI1_I1160_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I115_XP_MN1 (XI1_I1160_I115_XP_n1 I1_I1160_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I115_XP_MN0 (I1_I1160_P19_16n I1_I1160_P19_18 XI1_I1160_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I113_XP_MN1 (XI1_I1160_I113_XP_n1 I1_I1160_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I113_XP_MN0 (I1_I1160_P17_14n I1_I1160_P17_16 XI1_I1160_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I111_XP_MN1 (XI1_I1160_I111_XP_n1 I1_I1160_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I111_XP_MN0 (I1_I1160_P15_12n I1_I1160_P15_14 XI1_I1160_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I109_XP_MN1 (XI1_I1160_I109_XP_n1 I1_I1160_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I109_XP_MN0 (I1_I1160_P13_10n I1_I1160_P13_12 XI1_I1160_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I107_XP_MN1 (XI1_I1160_I107_XP_n1 I1_I1160_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I107_XP_MN0 (I1_I1160_P11_8n I1_I1160_P11_10 XI1_I1160_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I105_XP_MN1 (XI1_I1160_I105_XP_n1 I1_I1160_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I105_XP_MN0 (I1_I1160_P9_6n I1_I1160_P9_8 XI1_I1160_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I101_XP_MN1 (XI1_I1160_I101_XP_n1 I1_I1160_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I101_XP_MN0 (I1_I1160_P5_2n I1_I1160_P5_4 XI1_I1160_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I28_MN1 (XI1_I930_I28_n1 I1_b8_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I28_MN0 (I1_I930_gn28 I1_p7_27 XI1_I930_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I26_MN1 (XI1_I930_I26_n1 I1_b8_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I26_MN0 (I1_I930_gn26 I1_p7_25 XI1_I930_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I25_MN1 (XI1_I930_I25_n1 I1_b8_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I25_MN0 (I1_I930_gn25 I1_p7_24 XI1_I930_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I24_MN1 (XI1_I930_I24_n1 I1_b8_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I24_MN0 (I1_I930_gn24 I1_p7_23 XI1_I930_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I23_MN1 (XI1_I930_I23_n1 I1_b8_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I23_MN0 (I1_I930_gn23 I1_p7_22 XI1_I930_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I22_MN1 (XI1_I930_I22_n1 I1_b8_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I22_MN0 (I1_I930_gn22 I1_p7_21 XI1_I930_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I21_MN1 (XI1_I930_I21_n1 I1_b8_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I21_MN0 (I1_I930_gn21 I1_p7_20 XI1_I930_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I19_MN1 (XI1_I930_I19_n1 I1_b8_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I19_MN0 (I1_I930_gn19 I1_p7_18 XI1_I930_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I16_MN1 (XI1_I930_I16_n1 I1_b8_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I16_MN0 (I1_I930_gn16 I1_p7_15 XI1_I930_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I15_MN1 (XI1_I930_I15_n1 I1_b8_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I15_MN0 (I1_I930_gn15 I1_p7_14 XI1_I930_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I13_MN1 (XI1_I930_I13_n1 I1_b8_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I13_MN0 (I1_I930_gn13 I1_p7_12 XI1_I930_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I12_MN1 (XI1_I930_I12_n1 I1_b8_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I12_MN0 (I1_I930_gn12 I1_p7_11 XI1_I930_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I11_MN1 (XI1_I930_I11_n1 I1_b8_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I11_MN0 (I1_I930_gn11 I1_p7_10 XI1_I930_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I9_MN1 (XI1_I930_I9_n1 I1_b8_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I9_MN0 (I1_I930_gn9 I1_p7_8 XI1_I930_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I10_MN1 (XI1_I930_I10_n1 I1_b8_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I10_MN0 (I1_I930_gn10 I1_p7_9 XI1_I930_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I7_MN1 (XI1_I930_I7_n1 I1_b8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I7_MN0 (I1_I930_gn7 I1_p7_6 XI1_I930_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I0_MN1 (XI1_I792_I0_n1 I1_b5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I0_MN0 (I1_I792_gn0 I1_aa26 XI1_I792_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I1_MN1 (XI1_I746_I1_n1 I1_b4_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I1_MN0 (I1_I746_gn1 I1_p3_0 XI1_I746_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I100_XP_MN1 (XI1_I700_I100_XP_n1 I1_I700_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I100_XP_MN0 (I1_I700_P4_1n I1_I700_P4_3 XI1_I700_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I102_XP_MN1 (XI1_I700_I102_XP_n1 I1_I700_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I102_XP_MN0 (I1_I700_P6_3n I1_I700_P6_5 XI1_I700_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I104_XP_MN1 (XI1_I700_I104_XP_n1 I1_I700_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I104_XP_MN0 (I1_I700_P8_5n I1_I700_P8_7 XI1_I700_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I167_XP_MN1 (XI1_I700_I167_XP_n1 I1_I700_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I167_XP_MN0 (I1_I700_P16_1n I1_I700_P16_9 XI1_I700_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I175_XP_MN1 (XI1_I700_I175_XP_n1 I1_I700_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I175_XP_MN0 (I1_I700_P24_9n I1_I700_P24_17 XI1_I700_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I169_XP_MN1 (XI1_I700_I169_XP_n1 I1_I700_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I169_XP_MN0 (I1_I700_P18_3n I1_I700_P18_11 XI1_I700_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I171_XP_MN1 (XI1_I700_I171_XP_n1 I1_I700_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I171_XP_MN0 (I1_I700_P20_5n I1_I700_P20_13 XI1_I700_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I177_XP_MN1 (XI1_I700_I177_XP_n1 I1_I700_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I177_XP_MN0 (I1_I700_P26_11n I1_I700_P26_19 XI1_I700_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I173_XP_MN1 (XI1_I700_I173_XP_n1 I1_I700_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I173_XP_MN0 (I1_I700_P22_7n I1_I700_P22_15 XI1_I700_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I179_XP_MN1 (XI1_I700_I179_XP_n1 I1_I700_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I179_XP_MN0 (I1_I700_P28_13n I1_I700_P28_21 XI1_I700_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I181_XP_MN1 (XI1_I700_I181_XP_n1 I1_I700_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I181_XP_MN0 (I1_I700_P30_15n I1_I700_P30_23 XI1_I700_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I126_XP_MN1 (XI1_I700_I126_XP_n1 I1_I700_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I126_XP_MN0 (I1_I700_P30_27n I1_I700_P30_29 XI1_I700_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I126_XP_MN1 (XI1_I1390_I126_XP_n1 I1_I1390_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I126_XP_MN0 (I1_I1390_P30_27n I1_I1390_P30_29 XI1_I1390_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I124_XP_MN1 (XI1_I1390_I124_XP_n1 I1_I1390_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I124_XP_MN0 (I1_I1390_P28_25n I1_I1390_P28_27 XI1_I1390_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I122_XP_MN1 (XI1_I1390_I122_XP_n1 I1_I1390_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I122_XP_MN0 (I1_I1390_P26_23n I1_I1390_P26_25 XI1_I1390_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I120_XP_MN1 (XI1_I1390_I120_XP_n1 I1_I1390_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I120_XP_MN0 (I1_I1390_P24_21n I1_I1390_P24_23 XI1_I1390_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I118_XP_MN1 (XI1_I1390_I118_XP_n1 I1_I1390_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I118_XP_MN0 (I1_I1390_P22_19n I1_I1390_P22_21 XI1_I1390_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I116_XP_MN1 (XI1_I1390_I116_XP_n1 I1_I1390_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I116_XP_MN0 (I1_I1390_P20_17n I1_I1390_P20_19 XI1_I1390_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I168_XP_MN1 (XI1_I1390_I168_XP_n1 I1_I1390_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I168_XP_MN0 (I1_I1390_P17_2n I1_I1390_P17_10 XI1_I1390_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I105_XP_MN1 (XI1_I1390_I105_XP_n1 I1_I1390_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I105_XP_MN0 (I1_I1390_P9_6n I1_I1390_P9_8 XI1_I1390_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I103_XP_MN1 (XI1_I1390_I103_XP_n1 I1_I1390_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I103_XP_MN0 (I1_I1390_P7_4n I1_I1390_P7_6 XI1_I1390_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I6_MN1 (XI1_I1390_I6_n1 I1_b18_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I6_MN0 (I1_I1390_gn6 I1_p17_5 XI1_I1390_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I5_MN1 (XI1_I1390_I5_n1 I1_b18_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I5_MN0 (I1_I1390_gn5 I1_p17_4 XI1_I1390_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I1_MN1 (XI1_I1344_I1_n1 I1_b17_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I1_MN0 (I1_I1344_gn1 I1_p16_0 XI1_I1344_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I0_MN1 (XI1_I1298_I0_n1 I1_b16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I0_MN0 (I1_I1298_gn0 I1_aa15 XI1_I1298_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I31_MN1 (XI1_I1160_I31_n1 I1_b13_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I31_MN0 (I1_I1160_gn31 I1_p12_30 XI1_I1160_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I126_XP_MN1 (XI1_I1160_I126_XP_n1 I1_I1160_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I126_XP_MN0 (I1_I1160_P30_27n I1_I1160_P30_29 XI1_I1160_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I171_XP_MN1 (XI1_I1160_I171_XP_n1 I1_I1160_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I171_XP_MN0 (I1_I1160_P20_5n I1_I1160_P20_13 XI1_I1160_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I167_XP_MN1 (XI1_I1160_I167_XP_n1 I1_I1160_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I167_XP_MN0 (I1_I1160_P16_1n I1_I1160_P16_9 XI1_I1160_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I0_MN1 (XI1_I1206_I0_n1 I1_b14_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I0_MN0 (I1_I1206_gn0 I1_aa17 XI1_I1206_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I31_MN1 (XI1_I930_I31_n1 I1_b8_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I31_MN0 (I1_I930_gn31 I1_p7_30 XI1_I930_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I29_MN1 (XI1_I930_I29_n1 I1_b8_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I29_MN0 (I1_I930_gn29 I1_p7_28 XI1_I930_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I123_XP_MN1 (XI1_I930_I123_XP_n1 I1_I930_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I123_XP_MN0 (I1_I930_P27_24n I1_I930_P27_26 XI1_I930_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I121_XP_MN1 (XI1_I930_I121_XP_n1 I1_I930_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I121_XP_MN0 (I1_I930_P25_22n I1_I930_P25_24 XI1_I930_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I119_XP_MN1 (XI1_I930_I119_XP_n1 I1_I930_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I119_XP_MN0 (I1_I930_P23_20n I1_I930_P23_22 XI1_I930_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I117_XP_MN1 (XI1_I930_I117_XP_n1 I1_I930_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I117_XP_MN0 (I1_I930_P21_18n I1_I930_P21_20 XI1_I930_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I115_XP_MN1 (XI1_I930_I115_XP_n1 I1_I930_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I115_XP_MN0 (I1_I930_P19_16n I1_I930_P19_18 XI1_I930_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I113_XP_MN1 (XI1_I930_I113_XP_n1 I1_I930_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I113_XP_MN0 (I1_I930_P17_14n I1_I930_P17_16 XI1_I930_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I111_XP_MN1 (XI1_I930_I111_XP_n1 I1_I930_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I111_XP_MN0 (I1_I930_P15_12n I1_I930_P15_14 XI1_I930_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I8_MN1 (XI1_I930_I8_n1 I1_b8_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I8_MN0 (I1_I930_gn8 I1_p7_7 XI1_I930_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I6_MN1 (XI1_I930_I6_n1 I1_b8_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I6_MN0 (I1_I930_gn6 I1_p7_5 XI1_I930_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I0_MN1 (XI1_I838_I0_n1 I1_b6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I0_MN0 (I1_I838_gn0 I1_aa25 XI1_I838_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I1_MN1 (XI1_I700_I1_n1 I1_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I1_MN0 (I1_I700_gn1 I1_p2_0 XI1_I700_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I106_XP_MN1 (XI1_I700_I106_XP_n1 I1_I700_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I106_XP_MN0 (I1_I700_P10_7n I1_I700_P10_9 XI1_I700_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I108_XP_MN1 (XI1_I700_I108_XP_n1 I1_I700_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I108_XP_MN0 (I1_I700_P12_9n I1_I700_P12_11 XI1_I700_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I110_XP_MN1 (XI1_I700_I110_XP_n1 I1_I700_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I110_XP_MN0 (I1_I700_P14_11n I1_I700_P14_13 XI1_I700_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I112_XP_MN1 (XI1_I700_I112_XP_n1 I1_I700_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I112_XP_MN0 (I1_I700_P16_13n I1_I700_P16_15 XI1_I700_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I114_XP_MN1 (XI1_I700_I114_XP_n1 I1_I700_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I114_XP_MN0 (I1_I700_P18_15n I1_I700_P18_17 XI1_I700_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I116_XP_MN1 (XI1_I700_I116_XP_n1 I1_I700_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I116_XP_MN0 (I1_I700_P20_17n I1_I700_P20_19 XI1_I700_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I118_XP_MN1 (XI1_I700_I118_XP_n1 I1_I700_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I118_XP_MN0 (I1_I700_P22_19n I1_I700_P22_21 XI1_I700_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I120_XP_MN1 (XI1_I700_I120_XP_n1 I1_I700_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I120_XP_MN0 (I1_I700_P24_21n I1_I700_P24_23 XI1_I700_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I122_XP_MN1 (XI1_I700_I122_XP_n1 I1_I700_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I122_XP_MN0 (I1_I700_P26_23n I1_I700_P26_25 XI1_I700_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I124_XP_MN1 (XI1_I700_I124_XP_n1 I1_I700_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I124_XP_MN0 (I1_I700_P28_25n I1_I700_P28_27 XI1_I700_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I27_MN1 (XI1_I700_I27_n1 I1_b3_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I27_MN0 (I1_I700_gn27 I1_p2_26 XI1_I700_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I181_XP_MN1 (XI1_I1390_I181_XP_n1 I1_I1390_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I181_XP_MN0 (I1_I1390_P30_15n I1_I1390_P30_23 XI1_I1390_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I114_XP_MN1 (XI1_I1390_I114_XP_n1 I1_I1390_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I114_XP_MN0 (I1_I1390_P18_15n I1_I1390_P18_17 XI1_I1390_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I112_XP_MN1 (XI1_I1390_I112_XP_n1 I1_I1390_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I112_XP_MN0 (I1_I1390_P16_13n I1_I1390_P16_15 XI1_I1390_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I110_XP_MN1 (XI1_I1390_I110_XP_n1 I1_I1390_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I110_XP_MN0 (I1_I1390_P14_11n I1_I1390_P14_13 XI1_I1390_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I108_XP_MN1 (XI1_I1390_I108_XP_n1 I1_I1390_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I108_XP_MN0 (I1_I1390_P12_9n I1_I1390_P12_11 XI1_I1390_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I106_XP_MN1 (XI1_I1390_I106_XP_n1 I1_I1390_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I106_XP_MN0 (I1_I1390_P10_7n I1_I1390_P10_9 XI1_I1390_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I101_XP_MN1 (XI1_I1390_I101_XP_n1 I1_I1390_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I101_XP_MN0 (I1_I1390_P5_2n I1_I1390_P5_4 XI1_I1390_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I4_MN1 (XI1_I1390_I4_n1 I1_b18_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I4_MN0 (I1_I1390_gn4 I1_p17_3 XI1_I1390_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I3_MN1 (XI1_I1390_I3_n1 I1_b18_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I3_MN0 (I1_I1390_gn3 I1_p17_2 XI1_I1390_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I27_MN1 (XI1_I1160_I27_n1 I1_b13_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I27_MN0 (I1_I1160_gn27 I1_p12_26 XI1_I1160_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I29_MN1 (XI1_I1160_I29_n1 I1_b13_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I29_MN0 (I1_I1160_gn29 I1_p12_28 XI1_I1160_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I26_MN1 (XI1_I1160_I26_n1 I1_b13_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I26_MN0 (I1_I1160_gn26 I1_p12_25 XI1_I1160_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I30_MN1 (XI1_I1160_I30_n1 I1_b13_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I30_MN0 (I1_I1160_gn30 I1_p12_29 XI1_I1160_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I124_XP_MN1 (XI1_I1160_I124_XP_n1 I1_I1160_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I124_XP_MN0 (I1_I1160_P28_25n I1_I1160_P28_27 XI1_I1160_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I122_XP_MN1 (XI1_I1160_I122_XP_n1 I1_I1160_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I122_XP_MN0 (I1_I1160_P26_23n I1_I1160_P26_25 XI1_I1160_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I120_XP_MN1 (XI1_I1160_I120_XP_n1 I1_I1160_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I120_XP_MN0 (I1_I1160_P24_21n I1_I1160_P24_23 XI1_I1160_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I181_XP_MN1 (XI1_I1160_I181_XP_n1 I1_I1160_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I181_XP_MN0 (I1_I1160_P30_15n I1_I1160_P30_23 XI1_I1160_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I173_XP_MN1 (XI1_I1160_I173_XP_n1 I1_I1160_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I173_XP_MN0 (I1_I1160_P22_7n I1_I1160_P22_15 XI1_I1160_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I179_XP_MN1 (XI1_I1160_I179_XP_n1 I1_I1160_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I179_XP_MN0 (I1_I1160_P28_13n I1_I1160_P28_21 XI1_I1160_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I177_XP_MN1 (XI1_I1160_I177_XP_n1 I1_I1160_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I177_XP_MN0 (I1_I1160_P26_11n I1_I1160_P26_19 XI1_I1160_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I169_XP_MN1 (XI1_I1160_I169_XP_n1 I1_I1160_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I169_XP_MN0 (I1_I1160_P18_3n I1_I1160_P18_11 XI1_I1160_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I175_XP_MN1 (XI1_I1160_I175_XP_n1 I1_I1160_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I175_XP_MN0 (I1_I1160_P24_9n I1_I1160_P24_17 XI1_I1160_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I104_XP_MN1 (XI1_I1160_I104_XP_n1 I1_I1160_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I104_XP_MN0 (I1_I1160_P8_5n I1_I1160_P8_7 XI1_I1160_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I102_XP_MN1 (XI1_I1160_I102_XP_n1 I1_I1160_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I102_XP_MN0 (I1_I1160_P6_3n I1_I1160_P6_5 XI1_I1160_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I100_XP_MN1 (XI1_I1160_I100_XP_n1 I1_I1160_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I100_XP_MN0 (I1_I1160_P4_1n I1_I1160_P4_3 XI1_I1160_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I1_MN1 (XI1_I1160_I1_n1 I1_b13_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I1_MN0 (I1_I1160_gn1 I1_p12_0 XI1_I1160_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I30_MN1 (XI1_I930_I30_n1 I1_b8_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I30_MN0 (I1_I930_gn30 I1_p7_29 XI1_I930_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I127_XP_MN1 (XI1_I930_I127_XP_n1 I1_I930_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I127_XP_MN0 (I1_I930_P31_28n I1_I930_P31_30 XI1_I930_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I125_XP_MN1 (XI1_I930_I125_XP_n1 I1_I930_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I125_XP_MN0 (I1_I930_P29_26n I1_I930_P29_28 XI1_I930_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I182_XP_MN1 (XI1_I930_I182_XP_n1 I1_I930_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I182_XP_MN0 (I1_I930_P31_16n I1_I930_P31_24 XI1_I930_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I180_XP_MN1 (XI1_I930_I180_XP_n1 I1_I930_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I180_XP_MN0 (I1_I930_P29_14n I1_I930_P29_22 XI1_I930_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I178_XP_MN1 (XI1_I930_I178_XP_n1 I1_I930_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I178_XP_MN0 (I1_I930_P27_12n I1_I930_P27_20 XI1_I930_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I174_XP_MN1 (XI1_I930_I174_XP_n1 I1_I930_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I174_XP_MN0 (I1_I930_P23_8n I1_I930_P23_16 XI1_I930_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I176_XP_MN1 (XI1_I930_I176_XP_n1 I1_I930_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I176_XP_MN0 (I1_I930_P25_10n I1_I930_P25_18 XI1_I930_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I109_XP_MN1 (XI1_I930_I109_XP_n1 I1_I930_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I109_XP_MN0 (I1_I930_P13_10n I1_I930_P13_12 XI1_I930_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I107_XP_MN1 (XI1_I930_I107_XP_n1 I1_I930_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I107_XP_MN0 (I1_I930_P11_8n I1_I930_P11_10 XI1_I930_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I105_XP_MN1 (XI1_I930_I105_XP_n1 I1_I930_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I105_XP_MN0 (I1_I930_P9_6n I1_I930_P9_8 XI1_I930_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I5_MN1 (XI1_I930_I5_n1 I1_b8_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I5_MN0 (I1_I930_gn5 I1_p7_4 XI1_I930_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I2_MN1 (XI1_I700_I2_n1 I1_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I2_MN0 (I1_I700_gn2 I1_p2_1 XI1_I700_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I3_MN1 (XI1_I700_I3_n1 I1_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I3_MN0 (I1_I700_gn3 I1_p2_2 XI1_I700_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I6_MN1 (XI1_I700_I6_n1 I1_b3_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I6_MN0 (I1_I700_gn6 I1_p2_5 XI1_I700_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I7_MN1 (XI1_I700_I7_n1 I1_b3_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I7_MN0 (I1_I700_gn7 I1_p2_6 XI1_I700_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I8_MN1 (XI1_I700_I8_n1 I1_b3_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I8_MN0 (I1_I700_gn8 I1_p2_7 XI1_I700_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I15_MN1 (XI1_I700_I15_n1 I1_b3_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I15_MN0 (I1_I700_gn15 I1_p2_14 XI1_I700_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I19_MN1 (XI1_I700_I19_n1 I1_b3_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I19_MN0 (I1_I700_gn19 I1_p2_18 XI1_I700_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I23_MN1 (XI1_I700_I23_n1 I1_b3_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I23_MN0 (I1_I700_gn23 I1_p2_22 XI1_I700_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I26_MN1 (XI1_I700_I26_n1 I1_b3_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I26_MN0 (I1_I700_gn26 I1_p2_25 XI1_I700_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I28_MN1 (XI1_I700_I28_n1 I1_b3_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I28_MN0 (I1_I700_gn28 I1_p2_27 XI1_I700_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I179_XP_MN1 (XI1_I1390_I179_XP_n1 I1_I1390_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I179_XP_MN0 (I1_I1390_P28_13n I1_I1390_P28_21 XI1_I1390_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I173_XP_MN1 (XI1_I1390_I173_XP_n1 I1_I1390_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I173_XP_MN0 (I1_I1390_P22_7n I1_I1390_P22_15 XI1_I1390_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I177_XP_MN1 (XI1_I1390_I177_XP_n1 I1_I1390_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I177_XP_MN0 (I1_I1390_P26_11n I1_I1390_P26_19 XI1_I1390_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I175_XP_MN1 (XI1_I1390_I175_XP_n1 I1_I1390_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I175_XP_MN0 (I1_I1390_P24_9n I1_I1390_P24_17 XI1_I1390_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I171_XP_MN1 (XI1_I1390_I171_XP_n1 I1_I1390_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I171_XP_MN0 (I1_I1390_P20_5n I1_I1390_P20_13 XI1_I1390_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I169_XP_MN1 (XI1_I1390_I169_XP_n1 I1_I1390_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I169_XP_MN0 (I1_I1390_P18_3n I1_I1390_P18_11 XI1_I1390_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I104_XP_MN1 (XI1_I1390_I104_XP_n1 I1_I1390_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I104_XP_MN0 (I1_I1390_P8_5n I1_I1390_P8_7 XI1_I1390_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I102_XP_MN1 (XI1_I1390_I102_XP_n1 I1_I1390_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I102_XP_MN0 (I1_I1390_P6_3n I1_I1390_P6_5 XI1_I1390_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I2_MN1 (XI1_I1390_I2_n1 I1_b18_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I2_MN0 (I1_I1390_gn2 I1_p17_1 XI1_I1390_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I0_MN1 (XI1_I1344_I0_n1 I1_b17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I0_MN0 (I1_I1344_gn0 I1_aa14 XI1_I1344_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I23_MN1 (XI1_I1160_I23_n1 I1_b13_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I23_MN0 (I1_I1160_gn23 I1_p12_22 XI1_I1160_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I24_MN1 (XI1_I1160_I24_n1 I1_b13_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I24_MN0 (I1_I1160_gn24 I1_p12_23 XI1_I1160_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I118_XP_MN1 (XI1_I1160_I118_XP_n1 I1_I1160_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I118_XP_MN0 (I1_I1160_P22_19n I1_I1160_P22_21 XI1_I1160_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I116_XP_MN1 (XI1_I1160_I116_XP_n1 I1_I1160_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I116_XP_MN0 (I1_I1160_P20_17n I1_I1160_P20_19 XI1_I1160_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I114_XP_MN1 (XI1_I1160_I114_XP_n1 I1_I1160_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I114_XP_MN0 (I1_I1160_P18_15n I1_I1160_P18_17 XI1_I1160_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I112_XP_MN1 (XI1_I1160_I112_XP_n1 I1_I1160_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I112_XP_MN0 (I1_I1160_P16_13n I1_I1160_P16_15 XI1_I1160_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I110_XP_MN1 (XI1_I1160_I110_XP_n1 I1_I1160_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I110_XP_MN0 (I1_I1160_P14_11n I1_I1160_P14_13 XI1_I1160_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I106_XP_MN1 (XI1_I1160_I106_XP_n1 I1_I1160_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I106_XP_MN0 (I1_I1160_P10_7n I1_I1160_P10_9 XI1_I1160_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I4_MN1 (XI1_I1160_I4_n1 I1_b13_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I4_MN0 (I1_I1160_gn4 I1_p12_3 XI1_I1160_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I3_MN1 (XI1_I1160_I3_n1 I1_b13_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I3_MN0 (I1_I1160_gn3 I1_p12_2 XI1_I1160_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I2_MN1 (XI1_I1160_I2_n1 I1_b13_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I2_MN0 (I1_I1160_gn2 I1_p12_1 XI1_I1160_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I172_XP_MN1 (XI1_I930_I172_XP_n1 I1_I930_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I172_XP_MN0 (I1_I930_P21_6n I1_I930_P21_14 XI1_I930_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I170_XP_MN1 (XI1_I930_I170_XP_n1 I1_I930_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I170_XP_MN0 (I1_I930_P19_4n I1_I930_P19_12 XI1_I930_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I168_XP_MN1 (XI1_I930_I168_XP_n1 I1_I930_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I168_XP_MN0 (I1_I930_P17_2n I1_I930_P17_10 XI1_I930_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I103_XP_MN1 (XI1_I930_I103_XP_n1 I1_I930_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I103_XP_MN0 (I1_I930_P7_4n I1_I930_P7_6 XI1_I930_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I101_XP_MN1 (XI1_I930_I101_XP_n1 I1_I930_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I101_XP_MN0 (I1_I930_P5_2n I1_I930_P5_4 XI1_I930_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I4_MN1 (XI1_I930_I4_n1 I1_b8_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I4_MN0 (I1_I930_gn4 I1_p7_3 XI1_I930_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I0_MN1 (XI1_I746_I0_n1 I1_b4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I0_MN0 (I1_I746_gn0 I1_aa27 XI1_I746_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I4_MN1 (XI1_I700_I4_n1 I1_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I4_MN0 (I1_I700_gn4 I1_p2_3 XI1_I700_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I5_MN1 (XI1_I700_I5_n1 I1_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I5_MN0 (I1_I700_gn5 I1_p2_4 XI1_I700_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I9_MN1 (XI1_I700_I9_n1 I1_b3_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I9_MN0 (I1_I700_gn9 I1_p2_8 XI1_I700_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I11_MN1 (XI1_I700_I11_n1 I1_b3_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I11_MN0 (I1_I700_gn11 I1_p2_10 XI1_I700_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I10_MN1 (XI1_I700_I10_n1 I1_b3_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I10_MN0 (I1_I700_gn10 I1_p2_9 XI1_I700_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I12_MN1 (XI1_I700_I12_n1 I1_b3_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I12_MN0 (I1_I700_gn12 I1_p2_11 XI1_I700_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I13_MN1 (XI1_I700_I13_n1 I1_b3_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I13_MN0 (I1_I700_gn13 I1_p2_12 XI1_I700_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I14_MN1 (XI1_I700_I14_n1 I1_b3_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I14_MN0 (I1_I700_gn14 I1_p2_13 XI1_I700_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I16_MN1 (XI1_I700_I16_n1 I1_b3_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I16_MN0 (I1_I700_gn16 I1_p2_15 XI1_I700_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I18_MN1 (XI1_I700_I18_n1 I1_b3_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I18_MN0 (I1_I700_gn18 I1_p2_17 XI1_I700_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I20_MN1 (XI1_I700_I20_n1 I1_b3_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I20_MN0 (I1_I700_gn20 I1_p2_19 XI1_I700_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I21_MN1 (XI1_I700_I21_n1 I1_b3_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I21_MN0 (I1_I700_gn21 I1_p2_20 XI1_I700_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I22_MN1 (XI1_I700_I22_n1 I1_b3_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I22_MN0 (I1_I700_gn22 I1_p2_21 XI1_I700_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I24_MN1 (XI1_I700_I24_n1 I1_b3_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I24_MN0 (I1_I700_gn24 I1_p2_23 XI1_I700_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I25_MN1 (XI1_I700_I25_n1 I1_b3_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I25_MN0 (I1_I700_gn25 I1_p2_24 XI1_I700_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I29_MN1 (XI1_I700_I29_n1 I1_b3_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I29_MN0 (I1_I700_gn29 I1_p2_28 XI1_I700_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I27_MN1 (XI1_I1436_I27_n1 I1_b19_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I27_MN0 (I1_I1436_gn27 I1_p18_26 XI1_I1436_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I23_MN1 (XI1_I1436_I23_n1 I1_b19_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I23_MN0 (I1_I1436_gn23 I1_p18_22 XI1_I1436_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I19_MN1 (XI1_I1436_I19_n1 I1_b19_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I19_MN0 (I1_I1436_gn19 I1_p18_18 XI1_I1436_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I17_MN1 (XI1_I1436_I17_n1 I1_b19_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I17_MN0 (I1_I1436_gn17 I1_p18_16 XI1_I1436_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I16_MN1 (XI1_I1436_I16_n1 I1_b19_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I16_MN0 (I1_I1436_gn16 I1_p18_15 XI1_I1436_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I13_MN1 (XI1_I1436_I13_n1 I1_b19_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I13_MN0 (I1_I1436_gn13 I1_p18_12 XI1_I1436_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I167_XP_MN1 (XI1_I1390_I167_XP_n1 I1_I1390_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I167_XP_MN0 (I1_I1390_P16_1n I1_I1390_P16_9 XI1_I1390_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I100_XP_MN1 (XI1_I1390_I100_XP_n1 I1_I1390_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I100_XP_MN0 (I1_I1390_P4_1n I1_I1390_P4_3 XI1_I1390_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I1_MN1 (XI1_I1390_I1_n1 I1_b18_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I1_MN0 (I1_I1390_gn1 I1_p17_0 XI1_I1390_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I22_MN1 (XI1_I1160_I22_n1 I1_b13_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I22_MN0 (I1_I1160_gn22 I1_p12_21 XI1_I1160_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I21_MN1 (XI1_I1160_I21_n1 I1_b13_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I21_MN0 (I1_I1160_gn21 I1_p12_20 XI1_I1160_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I20_MN1 (XI1_I1160_I20_n1 I1_b13_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I20_MN0 (I1_I1160_gn20 I1_p12_19 XI1_I1160_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I18_MN1 (XI1_I1160_I18_n1 I1_b13_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I18_MN0 (I1_I1160_gn18 I1_p12_17 XI1_I1160_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I108_XP_MN1 (XI1_I1160_I108_XP_n1 I1_I1160_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I108_XP_MN0 (I1_I1160_P12_9n I1_I1160_P12_11 XI1_I1160_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I0_MN1 (XI1_I1160_I0_n1 I1_b13_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I0_MN0 (I1_I1160_gn0 I1_aa18 XI1_I1160_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I29_MN1 (XI1_I976_I29_n1 I1_b9_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I29_MN0 (I1_I976_gn29 I1_p8_28 XI1_I976_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I126_XP_MN1 (XI1_I930_I126_XP_n1 I1_I930_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I126_XP_MN0 (I1_I930_P30_27n I1_I930_P30_29 XI1_I930_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I124_XP_MN1 (XI1_I930_I124_XP_n1 I1_I930_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I124_XP_MN0 (I1_I930_P28_25n I1_I930_P28_27 XI1_I930_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I122_XP_MN1 (XI1_I930_I122_XP_n1 I1_I930_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I122_XP_MN0 (I1_I930_P26_23n I1_I930_P26_25 XI1_I930_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I120_XP_MN1 (XI1_I930_I120_XP_n1 I1_I930_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I120_XP_MN0 (I1_I930_P24_21n I1_I930_P24_23 XI1_I930_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I118_XP_MN1 (XI1_I930_I118_XP_n1 I1_I930_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I118_XP_MN0 (I1_I930_P22_19n I1_I930_P22_21 XI1_I930_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I116_XP_MN1 (XI1_I930_I116_XP_n1 I1_I930_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I116_XP_MN0 (I1_I930_P20_17n I1_I930_P20_19 XI1_I930_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I114_XP_MN1 (XI1_I930_I114_XP_n1 I1_I930_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I114_XP_MN0 (I1_I930_P18_15n I1_I930_P18_17 XI1_I930_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I112_XP_MN1 (XI1_I930_I112_XP_n1 I1_I930_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I112_XP_MN0 (I1_I930_P16_13n I1_I930_P16_15 XI1_I930_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I110_XP_MN1 (XI1_I930_I110_XP_n1 I1_I930_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I110_XP_MN0 (I1_I930_P14_11n I1_I930_P14_13 XI1_I930_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I108_XP_MN1 (XI1_I930_I108_XP_n1 I1_I930_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I108_XP_MN0 (I1_I930_P12_9n I1_I930_P12_11 XI1_I930_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I106_XP_MN1 (XI1_I930_I106_XP_n1 I1_I930_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I106_XP_MN0 (I1_I930_P10_7n I1_I930_P10_9 XI1_I930_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I3_MN1 (XI1_I930_I3_n1 I1_b8_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I3_MN0 (I1_I930_gn3 I1_p7_2 XI1_I930_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I0_MN1 (XI1_I700_I0_n1 I1_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I0_MN0 (I1_I700_gn0 I1_aa28 XI1_I700_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I170_XP_MN1 (XI1_I654_I170_XP_n1 I1_I654_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I170_XP_MN0 (I1_I654_P19_4n I1_I654_P19_12 XI1_I654_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I17_MN1 (XI1_I700_I17_n1 I1_b3_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I17_MN0 (I1_I700_gn17 I1_p2_16 XI1_I700_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I174_XP_MN1 (XI1_I654_I174_XP_n1 I1_I654_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I174_XP_MN0 (I1_I654_P23_8n I1_I654_P23_16 XI1_I654_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I30_MN1 (XI1_I700_I30_n1 I1_b3_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I30_MN0 (I1_I700_gn30 I1_p2_29 XI1_I700_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I28_MN1 (XI1_I1436_I28_n1 I1_b19_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I28_MN0 (I1_I1436_gn28 I1_p18_27 XI1_I1436_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I26_MN1 (XI1_I1436_I26_n1 I1_b19_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I26_MN0 (I1_I1436_gn26 I1_p18_25 XI1_I1436_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I25_MN1 (XI1_I1436_I25_n1 I1_b19_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I25_MN0 (I1_I1436_gn25 I1_p18_24 XI1_I1436_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I22_MN1 (XI1_I1436_I22_n1 I1_b19_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I22_MN0 (I1_I1436_gn22 I1_p18_21 XI1_I1436_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I21_MN1 (XI1_I1436_I21_n1 I1_b19_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I21_MN0 (I1_I1436_gn21 I1_p18_20 XI1_I1436_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I20_MN1 (XI1_I1436_I20_n1 I1_b19_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I20_MN0 (I1_I1436_gn20 I1_p18_19 XI1_I1436_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I18_MN1 (XI1_I1436_I18_n1 I1_b19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I18_MN0 (I1_I1436_gn18 I1_p18_17 XI1_I1436_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I15_MN1 (XI1_I1436_I15_n1 I1_b19_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I15_MN0 (I1_I1436_gn15 I1_p18_14 XI1_I1436_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I14_MN1 (XI1_I1436_I14_n1 I1_b19_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I14_MN0 (I1_I1436_gn14 I1_p18_13 XI1_I1436_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I12_MN1 (XI1_I1436_I12_n1 I1_b19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I12_MN0 (I1_I1436_gn12 I1_p18_11 XI1_I1436_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I10_MN1 (XI1_I1436_I10_n1 I1_b19_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I10_MN0 (I1_I1436_gn10 I1_p18_9 XI1_I1436_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I11_MN1 (XI1_I1436_I11_n1 I1_b19_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I11_MN0 (I1_I1436_gn11 I1_p18_10 XI1_I1436_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I9_MN1 (XI1_I1436_I9_n1 I1_b19_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I9_MN0 (I1_I1436_gn9 I1_p18_8 XI1_I1436_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I4_MN1 (XI1_I1436_I4_n1 I1_b19_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I4_MN0 (I1_I1436_gn4 I1_p18_3 XI1_I1436_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I28_MN1 (XI1_I1114_I28_n1 I1_b12_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I28_MN0 (I1_I1114_gn28 I1_p11_27 XI1_I1114_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I27_MN1 (XI1_I1114_I27_n1 I1_b12_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I27_MN0 (I1_I1114_gn27 I1_p11_26 XI1_I1114_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I29_MN1 (XI1_I1114_I29_n1 I1_b12_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I29_MN0 (I1_I1114_gn29 I1_p11_28 XI1_I1114_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I16_MN1 (XI1_I1160_I16_n1 I1_b13_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I16_MN0 (I1_I1160_gn16 I1_p12_15 XI1_I1160_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I14_MN1 (XI1_I1160_I14_n1 I1_b13_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I14_MN0 (I1_I1160_gn14 I1_p12_13 XI1_I1160_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I13_MN1 (XI1_I1160_I13_n1 I1_b13_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I13_MN0 (I1_I1160_gn13 I1_p12_12 XI1_I1160_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I10_MN1 (XI1_I1160_I10_n1 I1_b13_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I10_MN0 (I1_I1160_gn10 I1_p12_9 XI1_I1160_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I9_MN1 (XI1_I1160_I9_n1 I1_b13_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I9_MN0 (I1_I1160_gn9 I1_p12_8 XI1_I1160_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I7_MN1 (XI1_I1160_I7_n1 I1_b13_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I7_MN0 (I1_I1160_gn7 I1_p12_6 XI1_I1160_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I6_MN1 (XI1_I1160_I6_n1 I1_b13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I6_MN0 (I1_I1160_gn6 I1_p12_5 XI1_I1160_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I5_MN1 (XI1_I1160_I5_n1 I1_b13_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I5_MN0 (I1_I1160_gn5 I1_p12_4 XI1_I1160_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I181_XP_MN1 (XI1_I930_I181_XP_n1 I1_I930_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I181_XP_MN0 (I1_I930_P30_15n I1_I930_P30_23 XI1_I930_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I179_XP_MN1 (XI1_I930_I179_XP_n1 I1_I930_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I179_XP_MN0 (I1_I930_P28_13n I1_I930_P28_21 XI1_I930_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I173_XP_MN1 (XI1_I930_I173_XP_n1 I1_I930_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I173_XP_MN0 (I1_I930_P22_7n I1_I930_P22_15 XI1_I930_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I20_MN1 (XI1_I976_I20_n1 I1_b9_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I20_MN0 (I1_I976_gn20 I1_p8_19 XI1_I976_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I177_XP_MN1 (XI1_I930_I177_XP_n1 I1_I930_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I177_XP_MN0 (I1_I930_P26_11n I1_I930_P26_19 XI1_I930_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I171_XP_MN1 (XI1_I930_I171_XP_n1 I1_I930_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I171_XP_MN0 (I1_I930_P20_5n I1_I930_P20_13 XI1_I930_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I175_XP_MN1 (XI1_I930_I175_XP_n1 I1_I930_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I175_XP_MN0 (I1_I930_P24_9n I1_I930_P24_17 XI1_I930_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I169_XP_MN1 (XI1_I930_I169_XP_n1 I1_I930_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I169_XP_MN0 (I1_I930_P18_3n I1_I930_P18_11 XI1_I930_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I104_XP_MN1 (XI1_I930_I104_XP_n1 I1_I930_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I104_XP_MN0 (I1_I930_P8_5n I1_I930_P8_7 XI1_I930_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I102_XP_MN1 (XI1_I930_I102_XP_n1 I1_I930_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I102_XP_MN0 (I1_I930_P6_3n I1_I930_P6_5 XI1_I930_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I2_MN1 (XI1_I930_I2_n1 I1_b8_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I2_MN0 (I1_I930_gn2 I1_p7_1 XI1_I930_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I101_XP_MN1 (XI1_I654_I101_XP_n1 I1_I654_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I101_XP_MN0 (I1_I654_P5_2n I1_I654_P5_4 XI1_I654_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I103_XP_MN1 (XI1_I654_I103_XP_n1 I1_I654_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I103_XP_MN0 (I1_I654_P7_4n I1_I654_P7_6 XI1_I654_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I105_XP_MN1 (XI1_I654_I105_XP_n1 I1_I654_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I105_XP_MN0 (I1_I654_P9_6n I1_I654_P9_8 XI1_I654_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I168_XP_MN1 (XI1_I654_I168_XP_n1 I1_I654_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I168_XP_MN0 (I1_I654_P17_2n I1_I654_P17_10 XI1_I654_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I107_XP_MN1 (XI1_I654_I107_XP_n1 I1_I654_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I107_XP_MN0 (I1_I654_P11_8n I1_I654_P11_10 XI1_I654_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I109_XP_MN1 (XI1_I654_I109_XP_n1 I1_I654_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I109_XP_MN0 (I1_I654_P13_10n I1_I654_P13_12 XI1_I654_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I176_XP_MN1 (XI1_I654_I176_XP_n1 I1_I654_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I176_XP_MN0 (I1_I654_P25_10n I1_I654_P25_18 XI1_I654_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I111_XP_MN1 (XI1_I654_I111_XP_n1 I1_I654_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I111_XP_MN0 (I1_I654_P15_12n I1_I654_P15_14 XI1_I654_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I113_XP_MN1 (XI1_I654_I113_XP_n1 I1_I654_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I113_XP_MN0 (I1_I654_P17_14n I1_I654_P17_16 XI1_I654_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I172_XP_MN1 (XI1_I654_I172_XP_n1 I1_I654_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I172_XP_MN0 (I1_I654_P21_6n I1_I654_P21_14 XI1_I654_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I178_XP_MN1 (XI1_I654_I178_XP_n1 I1_I654_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I178_XP_MN0 (I1_I654_P27_12n I1_I654_P27_20 XI1_I654_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I180_XP_MN1 (XI1_I654_I180_XP_n1 I1_I654_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I180_XP_MN0 (I1_I654_P29_14n I1_I654_P29_22 XI1_I654_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I182_XP_MN1 (XI1_I654_I182_XP_n1 I1_I654_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I182_XP_MN0 (I1_I654_P31_16n I1_I654_P31_24 XI1_I654_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I31_MN1 (XI1_I700_I31_n1 I1_b3_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I31_MN0 (I1_I700_gn31 I1_p2_30 XI1_I700_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I24_MN1 (XI1_I1436_I24_n1 I1_b19_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I24_MN0 (I1_I1436_gn24 I1_p18_23 XI1_I1436_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I8_MN1 (XI1_I1436_I8_n1 I1_b19_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I8_MN0 (I1_I1436_gn8 I1_p18_7 XI1_I1436_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I7_MN1 (XI1_I1436_I7_n1 I1_b19_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I7_MN0 (I1_I1436_gn7 I1_p18_6 XI1_I1436_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I6_MN1 (XI1_I1436_I6_n1 I1_b19_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I6_MN0 (I1_I1436_gn6 I1_p18_5 XI1_I1436_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I5_MN1 (XI1_I1436_I5_n1 I1_b19_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I5_MN0 (I1_I1436_gn5 I1_p18_4 XI1_I1436_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I0_MN1 (XI1_I1390_I0_n1 I1_b18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I0_MN0 (I1_I1390_gn0 I1_aa13 XI1_I1390_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I127_XP_MN1 (XI1_I1114_I127_XP_n1 I1_I1114_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I127_XP_MN0 (I1_I1114_P31_28n I1_I1114_P31_30 XI1_I1114_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I125_XP_MN1 (XI1_I1114_I125_XP_n1 I1_I1114_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I125_XP_MN0 (I1_I1114_P29_26n I1_I1114_P29_28 XI1_I1114_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I26_MN1 (XI1_I1114_I26_n1 I1_b12_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I26_MN0 (I1_I1114_gn26 I1_p11_25 XI1_I1114_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I126_XP_MN1 (XI1_I1114_I126_XP_n1 I1_I1114_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I126_XP_MN0 (I1_I1114_P30_27n I1_I1114_P30_29 XI1_I1114_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I31_MN1 (XI1_I1114_I31_n1 I1_b12_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I31_MN0 (I1_I1114_gn31 I1_p11_30 XI1_I1114_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I30_MN1 (XI1_I1114_I30_n1 I1_b12_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I30_MN0 (I1_I1114_gn30 I1_p11_29 XI1_I1114_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I19_MN1 (XI1_I1160_I19_n1 I1_b13_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I19_MN0 (I1_I1160_gn19 I1_p12_18 XI1_I1160_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I17_MN1 (XI1_I1160_I17_n1 I1_b13_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I17_MN0 (I1_I1160_gn17 I1_p12_16 XI1_I1160_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I15_MN1 (XI1_I1160_I15_n1 I1_b13_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I15_MN0 (I1_I1160_gn15 I1_p12_14 XI1_I1160_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I12_MN1 (XI1_I1160_I12_n1 I1_b13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I12_MN0 (I1_I1160_gn12 I1_p12_11 XI1_I1160_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I11_MN1 (XI1_I1160_I11_n1 I1_b13_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I11_MN0 (I1_I1160_gn11 I1_p12_10 XI1_I1160_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I8_MN1 (XI1_I1160_I8_n1 I1_b13_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I8_MN0 (I1_I1160_gn8 I1_p12_7 XI1_I1160_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I28_MN1 (XI1_I1068_I28_n1 I1_b11_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I28_MN0 (I1_I1068_gn28 I1_p10_27 XI1_I1068_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I29_MN1 (XI1_I1068_I29_n1 I1_b11_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I29_MN0 (I1_I1068_gn29 I1_p10_28 XI1_I1068_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I27_MN1 (XI1_I1068_I27_n1 I1_b11_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I27_MN0 (I1_I1068_gn27 I1_p10_26 XI1_I1068_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I31_MN1 (XI1_I976_I31_n1 I1_b9_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I31_MN0 (I1_I976_gn31 I1_p8_30 XI1_I976_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I24_MN1 (XI1_I976_I24_n1 I1_b9_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I24_MN0 (I1_I976_gn24 I1_p8_23 XI1_I976_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I22_MN1 (XI1_I976_I22_n1 I1_b9_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I22_MN0 (I1_I976_gn22 I1_p8_21 XI1_I976_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I17_MN1 (XI1_I976_I17_n1 I1_b9_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I17_MN0 (I1_I976_gn17 I1_p8_16 XI1_I976_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I167_XP_MN1 (XI1_I930_I167_XP_n1 I1_I930_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I167_XP_MN0 (I1_I930_P16_1n I1_I930_P16_9 XI1_I930_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I100_XP_MN1 (XI1_I930_I100_XP_n1 I1_I930_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I100_XP_MN0 (I1_I930_P4_1n I1_I930_P4_3 XI1_I930_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I1_MN1 (XI1_I654_I1_n1 I1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I1_MN0 (I1_I654_gn1 I1_p1_0 XI1_I654_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I115_XP_MN1 (XI1_I654_I115_XP_n1 I1_I654_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I115_XP_MN0 (I1_I654_P19_16n I1_I654_P19_18 XI1_I654_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I117_XP_MN1 (XI1_I654_I117_XP_n1 I1_I654_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I117_XP_MN0 (I1_I654_P21_18n I1_I654_P21_20 XI1_I654_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I119_XP_MN1 (XI1_I654_I119_XP_n1 I1_I654_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I119_XP_MN0 (I1_I654_P23_20n I1_I654_P23_22 XI1_I654_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I121_XP_MN1 (XI1_I654_I121_XP_n1 I1_I654_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I121_XP_MN0 (I1_I654_P25_22n I1_I654_P25_24 XI1_I654_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I123_XP_MN1 (XI1_I654_I123_XP_n1 I1_I654_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I123_XP_MN0 (I1_I654_P27_24n I1_I654_P27_26 XI1_I654_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I125_XP_MN1 (XI1_I654_I125_XP_n1 I1_I654_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I125_XP_MN0 (I1_I654_P29_26n I1_I654_P29_28 XI1_I654_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I127_XP_MN1 (XI1_I654_I127_XP_n1 I1_I654_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I127_XP_MN0 (I1_I654_P31_28n I1_I654_P31_30 XI1_I654_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I29_MN1 (XI1_I1436_I29_n1 I1_b19_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I29_MN0 (I1_I1436_gn29 I1_p18_28 XI1_I1436_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I126_XP_MN1 (XI1_I1436_I126_XP_n1 I1_I1436_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I126_XP_MN0 (I1_I1436_P30_27n I1_I1436_P30_29 XI1_I1436_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I124_XP_MN1 (XI1_I1436_I124_XP_n1 I1_I1436_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I124_XP_MN0 (I1_I1436_P28_25n I1_I1436_P28_27 XI1_I1436_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I122_XP_MN1 (XI1_I1436_I122_XP_n1 I1_I1436_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I122_XP_MN0 (I1_I1436_P26_23n I1_I1436_P26_25 XI1_I1436_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I120_XP_MN1 (XI1_I1436_I120_XP_n1 I1_I1436_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I120_XP_MN0 (I1_I1436_P24_21n I1_I1436_P24_23 XI1_I1436_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I118_XP_MN1 (XI1_I1436_I118_XP_n1 I1_I1436_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I118_XP_MN0 (I1_I1436_P22_19n I1_I1436_P22_21 XI1_I1436_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I116_XP_MN1 (XI1_I1436_I116_XP_n1 I1_I1436_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I116_XP_MN0 (I1_I1436_P20_17n I1_I1436_P20_19 XI1_I1436_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I114_XP_MN1 (XI1_I1436_I114_XP_n1 I1_I1436_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I114_XP_MN0 (I1_I1436_P18_15n I1_I1436_P18_17 XI1_I1436_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I112_XP_MN1 (XI1_I1436_I112_XP_n1 I1_I1436_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I112_XP_MN0 (I1_I1436_P16_13n I1_I1436_P16_15 XI1_I1436_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I110_XP_MN1 (XI1_I1436_I110_XP_n1 I1_I1436_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I110_XP_MN0 (I1_I1436_P14_11n I1_I1436_P14_13 XI1_I1436_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I108_XP_MN1 (XI1_I1436_I108_XP_n1 I1_I1436_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I108_XP_MN0 (I1_I1436_P12_9n I1_I1436_P12_11 XI1_I1436_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I106_XP_MN1 (XI1_I1436_I106_XP_n1 I1_I1436_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I106_XP_MN0 (I1_I1436_P10_7n I1_I1436_P10_9 XI1_I1436_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I3_MN1 (XI1_I1436_I3_n1 I1_b19_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I3_MN0 (I1_I1436_gn3 I1_p18_2 XI1_I1436_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I2_MN1 (XI1_I1436_I2_n1 I1_b19_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I2_MN0 (I1_I1436_gn2 I1_p18_1 XI1_I1436_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I123_XP_MN1 (XI1_I1114_I123_XP_n1 I1_I1114_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I123_XP_MN0 (I1_I1114_P27_24n I1_I1114_P27_26 XI1_I1114_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I25_MN1 (XI1_I1114_I25_n1 I1_b12_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I25_MN0 (I1_I1114_gn25 I1_p11_24 XI1_I1114_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I24_MN1 (XI1_I1114_I24_n1 I1_b12_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I24_MN0 (I1_I1114_gn24 I1_p11_23 XI1_I1114_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I181_XP_MN1 (XI1_I1114_I181_XP_n1 I1_I1114_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I181_XP_MN0 (I1_I1114_P30_15n I1_I1114_P30_23 XI1_I1114_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I23_MN1 (XI1_I1114_I23_n1 I1_b12_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I23_MN0 (I1_I1114_gn23 I1_p11_22 XI1_I1114_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I126_XP_MN1 (XI1_I1068_I126_XP_n1 I1_I1068_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I126_XP_MN0 (I1_I1068_P30_27n I1_I1068_P30_29 XI1_I1068_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I127_XP_MN1 (XI1_I1068_I127_XP_n1 I1_I1068_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I127_XP_MN0 (I1_I1068_P31_28n I1_I1068_P31_30 XI1_I1068_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I26_MN1 (XI1_I1068_I26_n1 I1_b11_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I26_MN0 (I1_I1068_gn26 I1_p10_25 XI1_I1068_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I30_MN1 (XI1_I1068_I30_n1 I1_b11_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I30_MN0 (I1_I1068_gn30 I1_p10_29 XI1_I1068_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I28_MN1 (XI1_I1022_I28_n1 I1_b10_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I28_MN0 (I1_I1022_gn28 I1_p9_27 XI1_I1022_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I30_MN1 (XI1_I976_I30_n1 I1_b9_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I30_MN0 (I1_I976_gn30 I1_p8_29 XI1_I976_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I26_MN1 (XI1_I976_I26_n1 I1_b9_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I26_MN0 (I1_I976_gn26 I1_p8_25 XI1_I976_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I25_MN1 (XI1_I976_I25_n1 I1_b9_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I25_MN0 (I1_I976_gn25 I1_p8_24 XI1_I976_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I23_MN1 (XI1_I976_I23_n1 I1_b9_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I23_MN0 (I1_I976_gn23 I1_p8_22 XI1_I976_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I21_MN1 (XI1_I976_I21_n1 I1_b9_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I21_MN0 (I1_I976_gn21 I1_p8_20 XI1_I976_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I19_MN1 (XI1_I976_I19_n1 I1_b9_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I19_MN0 (I1_I976_gn19 I1_p8_18 XI1_I976_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I18_MN1 (XI1_I976_I18_n1 I1_b9_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I18_MN0 (I1_I976_gn18 I1_p8_17 XI1_I976_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I16_MN1 (XI1_I976_I16_n1 I1_b9_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I16_MN0 (I1_I976_gn16 I1_p8_15 XI1_I976_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I15_MN1 (XI1_I976_I15_n1 I1_b9_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I15_MN0 (I1_I976_gn15 I1_p8_14 XI1_I976_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I14_MN1 (XI1_I976_I14_n1 I1_b9_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I14_MN0 (I1_I976_gn14 I1_p8_13 XI1_I976_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I13_MN1 (XI1_I976_I13_n1 I1_b9_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I13_MN0 (I1_I976_gn13 I1_p8_12 XI1_I976_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I12_MN1 (XI1_I976_I12_n1 I1_b9_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I12_MN0 (I1_I976_gn12 I1_p8_11 XI1_I976_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I11_MN1 (XI1_I976_I11_n1 I1_b9_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I11_MN0 (I1_I976_gn11 I1_p8_10 XI1_I976_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I9_MN1 (XI1_I976_I9_n1 I1_b9_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I9_MN0 (I1_I976_gn9 I1_p8_8 XI1_I976_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I0_MN1 (XI1_I884_I0_n1 I1_b7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I0_MN0 (I1_I884_gn0 I1_aa24 XI1_I884_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I2_MN1 (XI1_I654_I2_n1 I1_b2_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I2_MN0 (I1_I654_gn2 I1_p1_1 XI1_I654_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I100_XP_MN1 (XI1_I654_I100_XP_n1 I1_I654_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I100_XP_MN0 (I1_I654_P4_1n I1_I654_P4_3 XI1_I654_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I102_XP_MN1 (XI1_I654_I102_XP_n1 I1_I654_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I102_XP_MN0 (I1_I654_P6_3n I1_I654_P6_5 XI1_I654_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I104_XP_MN1 (XI1_I654_I104_XP_n1 I1_I654_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I104_XP_MN0 (I1_I654_P8_5n I1_I654_P8_7 XI1_I654_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I167_XP_MN1 (XI1_I654_I167_XP_n1 I1_I654_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I167_XP_MN0 (I1_I654_P16_1n I1_I654_P16_9 XI1_I654_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I175_XP_MN1 (XI1_I654_I175_XP_n1 I1_I654_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I175_XP_MN0 (I1_I654_P24_9n I1_I654_P24_17 XI1_I654_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I169_XP_MN1 (XI1_I654_I169_XP_n1 I1_I654_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I169_XP_MN0 (I1_I654_P18_3n I1_I654_P18_11 XI1_I654_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I171_XP_MN1 (XI1_I654_I171_XP_n1 I1_I654_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I171_XP_MN0 (I1_I654_P20_5n I1_I654_P20_13 XI1_I654_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I177_XP_MN1 (XI1_I654_I177_XP_n1 I1_I654_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I177_XP_MN0 (I1_I654_P26_11n I1_I654_P26_19 XI1_I654_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I179_XP_MN1 (XI1_I654_I179_XP_n1 I1_I654_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I179_XP_MN0 (I1_I654_P28_13n I1_I654_P28_21 XI1_I654_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I173_XP_MN1 (XI1_I654_I173_XP_n1 I1_I654_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I173_XP_MN0 (I1_I654_P22_7n I1_I654_P22_15 XI1_I654_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I181_XP_MN1 (XI1_I654_I181_XP_n1 I1_I654_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I181_XP_MN0 (I1_I654_P30_15n I1_I654_P30_23 XI1_I654_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I126_XP_MN1 (XI1_I654_I126_XP_n1 I1_I654_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I126_XP_MN0 (I1_I654_P30_27n I1_I654_P30_29 XI1_I654_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I30_MN1 (XI1_I1436_I30_n1 I1_b19_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I30_MN0 (I1_I1436_gn30 I1_p18_29 XI1_I1436_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I181_XP_MN1 (XI1_I1436_I181_XP_n1 I1_I1436_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I181_XP_MN0 (I1_I1436_P30_15n I1_I1436_P30_23 XI1_I1436_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I179_XP_MN1 (XI1_I1436_I179_XP_n1 I1_I1436_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I179_XP_MN0 (I1_I1436_P28_13n I1_I1436_P28_21 XI1_I1436_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I173_XP_MN1 (XI1_I1436_I173_XP_n1 I1_I1436_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I173_XP_MN0 (I1_I1436_P22_7n I1_I1436_P22_15 XI1_I1436_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I177_XP_MN1 (XI1_I1436_I177_XP_n1 I1_I1436_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I177_XP_MN0 (I1_I1436_P26_11n I1_I1436_P26_19 XI1_I1436_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I171_XP_MN1 (XI1_I1436_I171_XP_n1 I1_I1436_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I171_XP_MN0 (I1_I1436_P20_5n I1_I1436_P20_13 XI1_I1436_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I169_XP_MN1 (XI1_I1436_I169_XP_n1 I1_I1436_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I169_XP_MN0 (I1_I1436_P18_3n I1_I1436_P18_11 XI1_I1436_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I104_XP_MN1 (XI1_I1436_I104_XP_n1 I1_I1436_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I104_XP_MN0 (I1_I1436_P8_5n I1_I1436_P8_7 XI1_I1436_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I102_XP_MN1 (XI1_I1436_I102_XP_n1 I1_I1436_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I102_XP_MN0 (I1_I1436_P6_3n I1_I1436_P6_5 XI1_I1436_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I1_MN1 (XI1_I1436_I1_n1 I1_b19_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I1_MN0 (I1_I1436_gn1 I1_p18_0 XI1_I1436_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I182_XP_MN1 (XI1_I1114_I182_XP_n1 I1_I1114_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I182_XP_MN0 (I1_I1114_P31_16n I1_I1114_P31_24 XI1_I1114_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I121_XP_MN1 (XI1_I1114_I121_XP_n1 I1_I1114_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I121_XP_MN0 (I1_I1114_P25_22n I1_I1114_P25_24 XI1_I1114_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I124_XP_MN1 (XI1_I1114_I124_XP_n1 I1_I1114_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I124_XP_MN0 (I1_I1114_P28_25n I1_I1114_P28_27 XI1_I1114_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I122_XP_MN1 (XI1_I1114_I122_XP_n1 I1_I1114_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I122_XP_MN0 (I1_I1114_P26_23n I1_I1114_P26_25 XI1_I1114_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I173_XP_MN1 (XI1_I1114_I173_XP_n1 I1_I1114_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I173_XP_MN0 (I1_I1114_P22_7n I1_I1114_P22_15 XI1_I1114_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I22_MN1 (XI1_I1114_I22_n1 I1_b12_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I22_MN0 (I1_I1114_gn22 I1_p11_21 XI1_I1114_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I181_XP_MN1 (XI1_I1068_I181_XP_n1 I1_I1068_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I181_XP_MN0 (I1_I1068_P30_15n I1_I1068_P30_23 XI1_I1068_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I122_XP_MN1 (XI1_I1068_I122_XP_n1 I1_I1068_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I122_XP_MN0 (I1_I1068_P26_23n I1_I1068_P26_25 XI1_I1068_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I124_XP_MN1 (XI1_I1068_I124_XP_n1 I1_I1068_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I124_XP_MN0 (I1_I1068_P28_25n I1_I1068_P28_27 XI1_I1068_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I125_XP_MN1 (XI1_I1068_I125_XP_n1 I1_I1068_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I125_XP_MN0 (I1_I1068_P29_26n I1_I1068_P29_28 XI1_I1068_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I24_MN1 (XI1_I1068_I24_n1 I1_b11_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I24_MN0 (I1_I1068_gn24 I1_p10_23 XI1_I1068_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I25_MN1 (XI1_I1068_I25_n1 I1_b11_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I25_MN0 (I1_I1068_gn25 I1_p10_24 XI1_I1068_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I31_MN1 (XI1_I1068_I31_n1 I1_b11_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I31_MN0 (I1_I1068_gn31 I1_p10_30 XI1_I1068_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I29_MN1 (XI1_I1022_I29_n1 I1_b10_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I29_MN0 (I1_I1022_gn29 I1_p9_28 XI1_I1022_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I125_XP_MN1 (XI1_I976_I125_XP_n1 I1_I976_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I125_XP_MN0 (I1_I976_P29_26n I1_I976_P29_28 XI1_I976_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I123_XP_MN1 (XI1_I976_I123_XP_n1 I1_I976_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I123_XP_MN0 (I1_I976_P27_24n I1_I976_P27_26 XI1_I976_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I121_XP_MN1 (XI1_I976_I121_XP_n1 I1_I976_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I121_XP_MN0 (I1_I976_P25_22n I1_I976_P25_24 XI1_I976_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I119_XP_MN1 (XI1_I976_I119_XP_n1 I1_I976_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I119_XP_MN0 (I1_I976_P23_20n I1_I976_P23_22 XI1_I976_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I117_XP_MN1 (XI1_I976_I117_XP_n1 I1_I976_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I117_XP_MN0 (I1_I976_P21_18n I1_I976_P21_20 XI1_I976_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I176_XP_MN1 (XI1_I976_I176_XP_n1 I1_I976_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I176_XP_MN0 (I1_I976_P25_10n I1_I976_P25_18 XI1_I976_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I10_MN1 (XI1_I976_I10_n1 I1_b9_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I10_MN0 (I1_I976_gn10 I1_p8_9 XI1_I976_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I8_MN1 (XI1_I976_I8_n1 I1_b9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I8_MN0 (I1_I976_gn8 I1_p8_7 XI1_I976_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I7_MN1 (XI1_I976_I7_n1 I1_b9_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I7_MN0 (I1_I976_gn7 I1_p8_6 XI1_I976_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I1_MN1 (XI1_I930_I1_n1 I1_b8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I1_MN0 (I1_I930_gn1 I1_p7_0 XI1_I930_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I3_MN1 (XI1_I654_I3_n1 I1_b2_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I3_MN0 (I1_I654_gn3 I1_p1_2 XI1_I654_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I4_MN1 (XI1_I654_I4_n1 I1_b2_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I4_MN0 (I1_I654_gn4 I1_p1_3 XI1_I654_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I106_XP_MN1 (XI1_I654_I106_XP_n1 I1_I654_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I106_XP_MN0 (I1_I654_P10_7n I1_I654_P10_9 XI1_I654_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I108_XP_MN1 (XI1_I654_I108_XP_n1 I1_I654_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I108_XP_MN0 (I1_I654_P12_9n I1_I654_P12_11 XI1_I654_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I110_XP_MN1 (XI1_I654_I110_XP_n1 I1_I654_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I110_XP_MN0 (I1_I654_P14_11n I1_I654_P14_13 XI1_I654_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I112_XP_MN1 (XI1_I654_I112_XP_n1 I1_I654_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I112_XP_MN0 (I1_I654_P16_13n I1_I654_P16_15 XI1_I654_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I114_XP_MN1 (XI1_I654_I114_XP_n1 I1_I654_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I114_XP_MN0 (I1_I654_P18_15n I1_I654_P18_17 XI1_I654_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I116_XP_MN1 (XI1_I654_I116_XP_n1 I1_I654_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I116_XP_MN0 (I1_I654_P20_17n I1_I654_P20_19 XI1_I654_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I118_XP_MN1 (XI1_I654_I118_XP_n1 I1_I654_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I118_XP_MN0 (I1_I654_P22_19n I1_I654_P22_21 XI1_I654_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I120_XP_MN1 (XI1_I654_I120_XP_n1 I1_I654_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I120_XP_MN0 (I1_I654_P24_21n I1_I654_P24_23 XI1_I654_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I122_XP_MN1 (XI1_I654_I122_XP_n1 I1_I654_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I122_XP_MN0 (I1_I654_P26_23n I1_I654_P26_25 XI1_I654_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I124_XP_MN1 (XI1_I654_I124_XP_n1 I1_I654_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I124_XP_MN0 (I1_I654_P28_25n I1_I654_P28_27 XI1_I654_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I121_XP_MN1 (XI1_I1436_I121_XP_n1 I1_I1436_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I121_XP_MN0 (I1_I1436_P25_22n I1_I1436_P25_24 XI1_I1436_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I119_XP_MN1 (XI1_I1436_I119_XP_n1 I1_I1436_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I119_XP_MN0 (I1_I1436_P23_20n I1_I1436_P23_22 XI1_I1436_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I117_XP_MN1 (XI1_I1436_I117_XP_n1 I1_I1436_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I117_XP_MN0 (I1_I1436_P21_18n I1_I1436_P21_20 XI1_I1436_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I175_XP_MN1 (XI1_I1436_I175_XP_n1 I1_I1436_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I175_XP_MN0 (I1_I1436_P24_9n I1_I1436_P24_17 XI1_I1436_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I167_XP_MN1 (XI1_I1436_I167_XP_n1 I1_I1436_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I167_XP_MN0 (I1_I1436_P16_1n I1_I1436_P16_9 XI1_I1436_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I100_XP_MN1 (XI1_I1436_I100_XP_n1 I1_I1436_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I100_XP_MN0 (I1_I1436_P4_1n I1_I1436_P4_3 XI1_I1436_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I119_XP_MN1 (XI1_I1114_I119_XP_n1 I1_I1114_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I119_XP_MN0 (I1_I1114_P23_20n I1_I1114_P23_22 XI1_I1114_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I180_XP_MN1 (XI1_I1114_I180_XP_n1 I1_I1114_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I180_XP_MN0 (I1_I1114_P29_14n I1_I1114_P29_22 XI1_I1114_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I120_XP_MN1 (XI1_I1114_I120_XP_n1 I1_I1114_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I120_XP_MN0 (I1_I1114_P24_21n I1_I1114_P24_23 XI1_I1114_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I118_XP_MN1 (XI1_I1114_I118_XP_n1 I1_I1114_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I118_XP_MN0 (I1_I1114_P22_19n I1_I1114_P22_21 XI1_I1114_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I21_MN1 (XI1_I1114_I21_n1 I1_b12_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I21_MN0 (I1_I1114_gn21 I1_p11_20 XI1_I1114_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I18_MN1 (XI1_I1114_I18_n1 I1_b12_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I18_MN0 (I1_I1114_gn18 I1_p11_17 XI1_I1114_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I20_MN1 (XI1_I1114_I20_n1 I1_b12_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I20_MN0 (I1_I1114_gn20 I1_p11_19 XI1_I1114_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I19_MN1 (XI1_I1114_I19_n1 I1_b12_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I19_MN0 (I1_I1114_gn19 I1_p11_18 XI1_I1114_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I179_XP_MN1 (XI1_I1068_I179_XP_n1 I1_I1068_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I179_XP_MN0 (I1_I1068_P28_13n I1_I1068_P28_21 XI1_I1068_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I120_XP_MN1 (XI1_I1068_I120_XP_n1 I1_I1068_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I120_XP_MN0 (I1_I1068_P24_21n I1_I1068_P24_23 XI1_I1068_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I180_XP_MN1 (XI1_I1068_I180_XP_n1 I1_I1068_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I180_XP_MN0 (I1_I1068_P29_14n I1_I1068_P29_22 XI1_I1068_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I182_XP_MN1 (XI1_I1068_I182_XP_n1 I1_I1068_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I182_XP_MN0 (I1_I1068_P31_16n I1_I1068_P31_24 XI1_I1068_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I123_XP_MN1 (XI1_I1068_I123_XP_n1 I1_I1068_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I123_XP_MN0 (I1_I1068_P27_24n I1_I1068_P27_26 XI1_I1068_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I23_MN1 (XI1_I1068_I23_n1 I1_b11_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I23_MN0 (I1_I1068_gn23 I1_p10_22 XI1_I1068_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I27_MN1 (XI1_I1022_I27_n1 I1_b10_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I27_MN0 (I1_I1022_gn27 I1_p9_26 XI1_I1022_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I30_MN1 (XI1_I1022_I30_n1 I1_b10_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I30_MN0 (I1_I1022_gn30 I1_p9_29 XI1_I1022_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I31_MN1 (XI1_I1022_I31_n1 I1_b10_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I31_MN0 (I1_I1022_gn31 I1_p9_30 XI1_I1022_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I127_XP_MN1 (XI1_I976_I127_XP_n1 I1_I976_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I127_XP_MN0 (I1_I976_P31_28n I1_I976_P31_30 XI1_I976_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I182_XP_MN1 (XI1_I976_I182_XP_n1 I1_I976_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I182_XP_MN0 (I1_I976_P31_16n I1_I976_P31_24 XI1_I976_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I174_XP_MN1 (XI1_I976_I174_XP_n1 I1_I976_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I174_XP_MN0 (I1_I976_P23_8n I1_I976_P23_16 XI1_I976_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I180_XP_MN1 (XI1_I976_I180_XP_n1 I1_I976_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I180_XP_MN0 (I1_I976_P29_14n I1_I976_P29_22 XI1_I976_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I115_XP_MN1 (XI1_I976_I115_XP_n1 I1_I976_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I115_XP_MN0 (I1_I976_P19_16n I1_I976_P19_18 XI1_I976_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I113_XP_MN1 (XI1_I976_I113_XP_n1 I1_I976_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I113_XP_MN0 (I1_I976_P17_14n I1_I976_P17_16 XI1_I976_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I111_XP_MN1 (XI1_I976_I111_XP_n1 I1_I976_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I111_XP_MN0 (I1_I976_P15_12n I1_I976_P15_14 XI1_I976_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I109_XP_MN1 (XI1_I976_I109_XP_n1 I1_I976_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I109_XP_MN0 (I1_I976_P13_10n I1_I976_P13_12 XI1_I976_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I6_MN1 (XI1_I976_I6_n1 I1_b9_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I6_MN0 (I1_I976_gn6 I1_p8_5 XI1_I976_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I5_MN1 (XI1_I654_I5_n1 I1_b2_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I5_MN0 (I1_I654_gn5 I1_p1_4 XI1_I654_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I7_MN1 (XI1_I654_I7_n1 I1_b2_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I7_MN0 (I1_I654_gn7 I1_p1_6 XI1_I654_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I8_MN1 (XI1_I654_I8_n1 I1_b2_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I8_MN0 (I1_I654_gn8 I1_p1_7 XI1_I654_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I9_MN1 (XI1_I654_I9_n1 I1_b2_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I9_MN0 (I1_I654_gn9 I1_p1_8 XI1_I654_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I17_MN1 (XI1_I654_I17_n1 I1_b2_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I17_MN0 (I1_I654_gn17 I1_p1_16 XI1_I654_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I24_MN1 (XI1_I654_I24_n1 I1_b2_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I24_MN0 (I1_I654_gn24 I1_p1_23 XI1_I654_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I25_MN1 (XI1_I654_I25_n1 I1_b2_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I25_MN0 (I1_I654_gn25 I1_p1_24 XI1_I654_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I27_MN1 (XI1_I654_I27_n1 I1_b2_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I27_MN0 (I1_I654_gn27 I1_p1_26 XI1_I654_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I28_MN1 (XI1_I654_I28_n1 I1_b2_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I28_MN0 (I1_I654_gn28 I1_p1_27 XI1_I654_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I29_MN1 (XI1_I654_I29_n1 I1_b2_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I29_MN0 (I1_I654_gn29 I1_p1_28 XI1_I654_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I31_MN1 (XI1_I1436_I31_n1 I1_b19_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I31_MN0 (I1_I1436_gn31 I1_p18_30 XI1_I1436_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I127_XP_MN1 (XI1_I1436_I127_XP_n1 I1_I1436_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I127_XP_MN0 (I1_I1436_P31_28n I1_I1436_P31_30 XI1_I1436_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I125_XP_MN1 (XI1_I1436_I125_XP_n1 I1_I1436_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I125_XP_MN0 (I1_I1436_P29_26n I1_I1436_P29_28 XI1_I1436_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I123_XP_MN1 (XI1_I1436_I123_XP_n1 I1_I1436_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I123_XP_MN0 (I1_I1436_P27_24n I1_I1436_P27_26 XI1_I1436_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I180_XP_MN1 (XI1_I1436_I180_XP_n1 I1_I1436_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I180_XP_MN0 (I1_I1436_P29_14n I1_I1436_P29_22 XI1_I1436_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I172_XP_MN1 (XI1_I1436_I172_XP_n1 I1_I1436_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I172_XP_MN0 (I1_I1436_P21_6n I1_I1436_P21_14 XI1_I1436_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I115_XP_MN1 (XI1_I1436_I115_XP_n1 I1_I1436_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I115_XP_MN0 (I1_I1436_P19_16n I1_I1436_P19_18 XI1_I1436_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I109_XP_MN1 (XI1_I1436_I109_XP_n1 I1_I1436_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I109_XP_MN0 (I1_I1436_P13_10n I1_I1436_P13_12 XI1_I1436_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I168_XP_MN1 (XI1_I1436_I168_XP_n1 I1_I1436_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I168_XP_MN0 (I1_I1436_P17_2n I1_I1436_P17_10 XI1_I1436_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I107_XP_MN1 (XI1_I1436_I107_XP_n1 I1_I1436_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I107_XP_MN0 (I1_I1436_P11_8n I1_I1436_P11_10 XI1_I1436_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I105_XP_MN1 (XI1_I1436_I105_XP_n1 I1_I1436_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I105_XP_MN0 (I1_I1436_P9_6n I1_I1436_P9_8 XI1_I1436_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I103_XP_MN1 (XI1_I1436_I103_XP_n1 I1_I1436_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I103_XP_MN0 (I1_I1436_P7_4n I1_I1436_P7_6 XI1_I1436_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I101_XP_MN1 (XI1_I1436_I101_XP_n1 I1_I1436_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I101_XP_MN0 (I1_I1436_P5_2n I1_I1436_P5_4 XI1_I1436_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I174_XP_MN1 (XI1_I1114_I174_XP_n1 I1_I1114_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I174_XP_MN0 (I1_I1114_P23_8n I1_I1114_P23_16 XI1_I1114_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I117_XP_MN1 (XI1_I1114_I117_XP_n1 I1_I1114_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I117_XP_MN0 (I1_I1114_P21_18n I1_I1114_P21_20 XI1_I1114_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I177_XP_MN1 (XI1_I1114_I177_XP_n1 I1_I1114_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I177_XP_MN0 (I1_I1114_P26_11n I1_I1114_P26_19 XI1_I1114_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I116_XP_MN1 (XI1_I1114_I116_XP_n1 I1_I1114_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I116_XP_MN0 (I1_I1114_P20_17n I1_I1114_P20_19 XI1_I1114_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I114_XP_MN1 (XI1_I1114_I114_XP_n1 I1_I1114_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I114_XP_MN0 (I1_I1114_P18_15n I1_I1114_P18_17 XI1_I1114_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I17_MN1 (XI1_I1114_I17_n1 I1_b12_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I17_MN0 (I1_I1114_gn17 I1_p11_16 XI1_I1114_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I173_XP_MN1 (XI1_I1068_I173_XP_n1 I1_I1068_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I173_XP_MN0 (I1_I1068_P22_7n I1_I1068_P22_15 XI1_I1068_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I118_XP_MN1 (XI1_I1068_I118_XP_n1 I1_I1068_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I118_XP_MN0 (I1_I1068_P22_19n I1_I1068_P22_21 XI1_I1068_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I174_XP_MN1 (XI1_I1068_I174_XP_n1 I1_I1068_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I174_XP_MN0 (I1_I1068_P23_8n I1_I1068_P23_16 XI1_I1068_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I121_XP_MN1 (XI1_I1068_I121_XP_n1 I1_I1068_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I121_XP_MN0 (I1_I1068_P25_22n I1_I1068_P25_24 XI1_I1068_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I119_XP_MN1 (XI1_I1068_I119_XP_n1 I1_I1068_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I119_XP_MN0 (I1_I1068_P23_20n I1_I1068_P23_22 XI1_I1068_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I22_MN1 (XI1_I1068_I22_n1 I1_b11_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I22_MN0 (I1_I1068_gn22 I1_p10_21 XI1_I1068_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I21_MN1 (XI1_I1068_I21_n1 I1_b11_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I21_MN0 (I1_I1068_gn21 I1_p10_20 XI1_I1068_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I26_MN1 (XI1_I1022_I26_n1 I1_b10_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I26_MN0 (I1_I1022_gn26 I1_p9_25 XI1_I1022_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I127_XP_MN1 (XI1_I1022_I127_XP_n1 I1_I1022_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I127_XP_MN0 (I1_I1022_P31_28n I1_I1022_P31_30 XI1_I1022_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I25_MN1 (XI1_I1022_I25_n1 I1_b10_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I25_MN0 (I1_I1022_gn25 I1_p9_24 XI1_I1022_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I24_MN1 (XI1_I1022_I24_n1 I1_b10_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I24_MN0 (I1_I1022_gn24 I1_p9_23 XI1_I1022_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I126_XP_MN1 (XI1_I976_I126_XP_n1 I1_I976_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I126_XP_MN0 (I1_I976_P30_27n I1_I976_P30_29 XI1_I976_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I124_XP_MN1 (XI1_I976_I124_XP_n1 I1_I976_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I124_XP_MN0 (I1_I976_P28_25n I1_I976_P28_27 XI1_I976_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I178_XP_MN1 (XI1_I976_I178_XP_n1 I1_I976_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I178_XP_MN0 (I1_I976_P27_12n I1_I976_P27_20 XI1_I976_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I172_XP_MN1 (XI1_I976_I172_XP_n1 I1_I976_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I172_XP_MN0 (I1_I976_P21_6n I1_I976_P21_14 XI1_I976_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I107_XP_MN1 (XI1_I976_I107_XP_n1 I1_I976_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I107_XP_MN0 (I1_I976_P11_8n I1_I976_P11_10 XI1_I976_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I105_XP_MN1 (XI1_I976_I105_XP_n1 I1_I976_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I105_XP_MN0 (I1_I976_P9_6n I1_I976_P9_8 XI1_I976_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I0_MN1 (XI1_I654_I0_n1 I1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I0_MN0 (I1_I654_gn0 I1_aa29 XI1_I654_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I6_MN1 (XI1_I654_I6_n1 I1_b2_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I6_MN0 (I1_I654_gn6 I1_p1_5 XI1_I654_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I10_MN1 (XI1_I654_I10_n1 I1_b2_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I10_MN0 (I1_I654_gn10 I1_p1_9 XI1_I654_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I11_MN1 (XI1_I654_I11_n1 I1_b2_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I11_MN0 (I1_I654_gn11 I1_p1_10 XI1_I654_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I12_MN1 (XI1_I654_I12_n1 I1_b2_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I12_MN0 (I1_I654_gn12 I1_p1_11 XI1_I654_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I13_MN1 (XI1_I654_I13_n1 I1_b2_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I13_MN0 (I1_I654_gn13 I1_p1_12 XI1_I654_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I14_MN1 (XI1_I654_I14_n1 I1_b2_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I14_MN0 (I1_I654_gn14 I1_p1_13 XI1_I654_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I15_MN1 (XI1_I654_I15_n1 I1_b2_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I15_MN0 (I1_I654_gn15 I1_p1_14 XI1_I654_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I16_MN1 (XI1_I654_I16_n1 I1_b2_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I16_MN0 (I1_I654_gn16 I1_p1_15 XI1_I654_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I19_MN1 (XI1_I654_I19_n1 I1_b2_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I19_MN0 (I1_I654_gn19 I1_p1_18 XI1_I654_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I20_MN1 (XI1_I654_I20_n1 I1_b2_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I20_MN0 (I1_I654_gn20 I1_p1_19 XI1_I654_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I21_MN1 (XI1_I654_I21_n1 I1_b2_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I21_MN0 (I1_I654_gn21 I1_p1_20 XI1_I654_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I22_MN1 (XI1_I654_I22_n1 I1_b2_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I22_MN0 (I1_I654_gn22 I1_p1_21 XI1_I654_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I23_MN1 (XI1_I654_I23_n1 I1_b2_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I23_MN0 (I1_I654_gn23 I1_p1_22 XI1_I654_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I26_MN1 (XI1_I654_I26_n1 I1_b2_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I26_MN0 (I1_I654_gn26 I1_p1_25 XI1_I654_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I30_MN1 (XI1_I654_I30_n1 I1_b2_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I30_MN0 (I1_I654_gn30 I1_p1_29 XI1_I654_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I182_XP_MN1 (XI1_I1436_I182_XP_n1 I1_I1436_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
