    I_MXI0_I1565_MP56 (VDD XI0_I1565_bcon I0_cm204_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1565_MP46 (XI0_I1565_bp3 XI0_I1565_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1565_MP48 (VDD I0_cm203_2 XI0_I1565_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1565_MP50_1 (XI0_I1565_bp4 XI0_I1565_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1565_MP26 (VDD XI0_I1565_asn XI0_I1565_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1565_MP18 (XI0_I1565_ap3 I0_cm129_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1565_MP21 (XI0_I1565_asn XI0_I1565_acon XI0_I1565_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1565_MP24 (XI0_I1565_ap5 I0_pp14_26 XI0_I1565_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1565_MP23 (XI0_I1565_ap4 I0_cm130_0 XI0_I1565_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1565_MP22 (VDD I0_cm129_1 XI0_I1565_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1565_MP22_1 (XI0_I1565_ap4 I0_cm129_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1565_MP23_1 (XI0_I1565_ap5 I0_cm130_0 XI0_I1565_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1565_MP24_1 (XI0_I1565_asn I0_pp14_26 XI0_I1565_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1565_MP17 (XI0_I1565_acon I0_pp14_26 XI0_I1565_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1565_MP14 (XI0_I1565_ap1 I0_cm130_0 XI0_I1565_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1565_MP13 (VDD I0_cm129_1 XI0_I1565_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1565_MP15 (XI0_I1565_ap2 I0_cm129_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1565_MP16 (VDD I0_cm130_0 XI0_I1565_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1565_MP28 (I0_cm204_2 XI0_I1565_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1565_MP19 (XI0_I1565_ap3 I0_cm130_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1565_MP20 (VDD I0_pp14_26 XI0_I1565_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1483_MP50 (VDD XI0_I1483_s1 XI0_I1483_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1483_MP47 (XI0_I1483_bp3 I0_pp15_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1483_MP49 (XI0_I1483_bsn XI0_I1483_bcon XI0_I1483_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1483_MP52 (XI0_I1483_bp5 I0_cm120_2 XI0_I1483_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1483_MP51 (XI0_I1483_bp4 I0_pp15_19 XI0_I1483_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1483_MP51_1 (XI0_I1483_bp5 I0_pp15_19 XI0_I1483_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1483_MP52_1 (XI0_I1483_bsn I0_cm120_2 XI0_I1483_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1483_MP54 (VDD XI0_I1483_bsn I0_cm122_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1483_MP41 (XI0_I1483_bp1 XI0_I1483_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1483_MP42 (XI0_I1483_bcon I0_pp15_19 XI0_I1483_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1483_MP45 (XI0_I1483_bp2 I0_cm120_2 XI0_I1483_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1483_MP43 (VDD XI0_I1483_s1 XI0_I1483_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1483_MP44 (XI0_I1483_bp2 I0_pp15_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1483_MP56 (VDD XI0_I1483_bcon I0_cm122_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1483_MP46 (XI0_I1483_bp3 XI0_I1483_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1483_MP48 (VDD I0_cm120_2 XI0_I1483_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1483_MP50_1 (XI0_I1483_bp4 XI0_I1483_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1483_MP26 (VDD XI0_I1483_asn XI0_I1483_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1483_MP18 (XI0_I1483_ap3 I0_pp12_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1483_MP21 (XI0_I1483_asn XI0_I1483_acon XI0_I1483_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1483_MP24 (XI0_I1483_ap5 I0_pp14_21 XI0_I1483_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1483_MP23 (XI0_I1483_ap4 I0_pp13_23 XI0_I1483_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1483_MP22 (VDD I0_pp12_25 XI0_I1483_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1483_MP22_1 (XI0_I1483_ap4 I0_pp12_25 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1483_MP23_1 (XI0_I1483_ap5 I0_pp13_23 XI0_I1483_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1483_MP24_1 (XI0_I1483_asn I0_pp14_21 XI0_I1483_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1483_MP17 (XI0_I1483_acon I0_pp14_21 XI0_I1483_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1483_MP14 (XI0_I1483_ap1 I0_pp13_23 XI0_I1483_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1483_MP13 (VDD I0_pp12_25 XI0_I1483_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1483_MP15 (XI0_I1483_ap2 I0_pp12_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1483_MP16 (VDD I0_pp13_23 XI0_I1483_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1483_MP28 (I0_cm122_2 XI0_I1483_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1483_MP19 (XI0_I1483_ap3 I0_pp13_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1483_MP20 (VDD I0_pp14_21 XI0_I1483_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1481_MP50 (VDD XI0_I1481_s1 XI0_I1481_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1481_MP47 (XI0_I1481_bp3 I0_pp14_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1481_MP49 (XI0_I1481_bsn XI0_I1481_bcon XI0_I1481_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1481_MP52 (XI0_I1481_bp5 I0_cm118_2 XI0_I1481_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1481_MP51 (XI0_I1481_bp4 I0_pp14_20 XI0_I1481_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1481_MP51_1 (XI0_I1481_bp5 I0_pp14_20 XI0_I1481_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1481_MP52_1 (XI0_I1481_bsn I0_cm118_2 XI0_I1481_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1481_MP54 (VDD XI0_I1481_bsn I0_cm120_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1481_MP41 (XI0_I1481_bp1 XI0_I1481_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1481_MP42 (XI0_I1481_bcon I0_pp14_20 XI0_I1481_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1481_MP45 (XI0_I1481_bp2 I0_cm118_2 XI0_I1481_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1481_MP43 (VDD XI0_I1481_s1 XI0_I1481_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1481_MP44 (XI0_I1481_bp2 I0_pp14_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1481_MP56 (VDD XI0_I1481_bcon I0_cm120_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1481_MP46 (XI0_I1481_bp3 XI0_I1481_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1481_MP48 (VDD I0_cm118_2 XI0_I1481_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1481_MP50_1 (XI0_I1481_bp4 XI0_I1481_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1481_MP26 (VDD XI0_I1481_asn XI0_I1481_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1481_MP18 (XI0_I1481_ap3 I0_pp11_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1481_MP21 (XI0_I1481_asn XI0_I1481_acon XI0_I1481_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1481_MP24 (XI0_I1481_ap5 I0_pp13_22 XI0_I1481_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1481_MP23 (XI0_I1481_ap4 I0_pp12_24 XI0_I1481_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1481_MP22 (VDD I0_pp11_26 XI0_I1481_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1481_MP22_1 (XI0_I1481_ap4 I0_pp11_26 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1481_MP23_1 (XI0_I1481_ap5 I0_pp12_24 XI0_I1481_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1481_MP24_1 (XI0_I1481_asn I0_pp13_22 XI0_I1481_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1481_MP17 (XI0_I1481_acon I0_pp13_22 XI0_I1481_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1481_MP14 (XI0_I1481_ap1 I0_pp12_24 XI0_I1481_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1481_MP13 (VDD I0_pp11_26 XI0_I1481_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1481_MP15 (XI0_I1481_ap2 I0_pp11_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1481_MP16 (VDD I0_pp12_24 XI0_I1481_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1481_MP28 (I0_cm120_2 XI0_I1481_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1481_MP19 (XI0_I1481_ap3 I0_pp12_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1481_MP20 (VDD I0_pp13_22 XI0_I1481_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1480_MP50 (VDD XI0_I1480_s1 XI0_I1480_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1480_MP47 (XI0_I1480_bp3 I0_pp10_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1480_MP49 (XI0_I1480_bsn XI0_I1480_bcon XI0_I1480_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1480_MP52 (XI0_I1480_bp5 I0_cm117_2 XI0_I1480_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1480_MP51 (XI0_I1480_bp4 I0_pp10_28 XI0_I1480_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1480_MP51_1 (XI0_I1480_bp5 I0_pp10_28 XI0_I1480_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1480_MP52_1 (XI0_I1480_bsn I0_cm117_2 XI0_I1480_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1480_MP54 (VDD XI0_I1480_bsn I0_cm119_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1480_MP41 (XI0_I1480_bp1 XI0_I1480_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1480_MP42 (XI0_I1480_bcon I0_pp10_28 XI0_I1480_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1480_MP45 (XI0_I1480_bp2 I0_cm117_2 XI0_I1480_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1480_MP43 (VDD XI0_I1480_s1 XI0_I1480_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1480_MP44 (XI0_I1480_bp2 I0_pp10_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1480_MP56 (VDD XI0_I1480_bcon I0_cm119_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1480_MP46 (XI0_I1480_bp3 XI0_I1480_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1480_MP48 (VDD I0_cm117_2 XI0_I1480_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1480_MP50_1 (XI0_I1480_bp4 XI0_I1480_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1480_MP26 (VDD XI0_I1480_asn XI0_I1480_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1480_MP18 (XI0_I1480_ap3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1480_MP21 (XI0_I1480_asn XI0_I1480_acon XI0_I1480_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1480_MP24 (XI0_I1480_ap5 I0_pp9_30 XI0_I1480_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1480_MP23 (XI0_I1480_ap4 I0_pp8_32 XI0_I1480_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1480_MP22 (VDD VDD XI0_I1480_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1480_MP22_1 (XI0_I1480_ap4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1480_MP23_1 (XI0_I1480_ap5 I0_pp8_32 XI0_I1480_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1480_MP24_1 (XI0_I1480_asn I0_pp9_30 XI0_I1480_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1480_MP17 (XI0_I1480_acon I0_pp9_30 XI0_I1480_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1480_MP14 (XI0_I1480_ap1 I0_pp8_32 XI0_I1480_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1480_MP13 (VDD VDD XI0_I1480_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1480_MP15 (XI0_I1480_ap2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1480_MP16 (VDD I0_pp8_32 XI0_I1480_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1480_MP28 (I0_cm119_2 XI0_I1480_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1480_MP19 (XI0_I1480_ap3 I0_pp8_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1480_MP20 (VDD I0_pp9_30 XI0_I1480_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1564_MP50 (VDD XI0_I1564_s1 XI0_I1564_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1564_MP47 (XI0_I1564_bp3 I0_pp14_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1564_MP49 (XI0_I1564_bsn XI0_I1564_bcon XI0_I1564_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1564_MP52 (XI0_I1564_bp5 I0_cm202_2 XI0_I1564_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1564_MP51 (XI0_I1564_bp4 I0_pp14_25 XI0_I1564_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1564_MP51_1 (XI0_I1564_bp5 I0_pp14_25 XI0_I1564_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1564_MP52_1 (XI0_I1564_bsn I0_cm202_2 XI0_I1564_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1564_MP54 (VDD XI0_I1564_bsn I0_cm203_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1564_MP41 (XI0_I1564_bp1 XI0_I1564_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1564_MP42 (XI0_I1564_bcon I0_pp14_25 XI0_I1564_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1564_MP45 (XI0_I1564_bp2 I0_cm202_2 XI0_I1564_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1564_MP43 (VDD XI0_I1564_s1 XI0_I1564_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1564_MP44 (XI0_I1564_bp2 I0_pp14_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1564_MP56 (VDD XI0_I1564_bcon I0_cm203_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1564_MP46 (XI0_I1564_bp3 XI0_I1564_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1564_MP48 (VDD I0_cm202_2 XI0_I1564_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1564_MP50_1 (XI0_I1564_bp4 XI0_I1564_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1564_MP26 (VDD XI0_I1564_asn XI0_I1564_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1564_MP18 (XI0_I1564_ap3 I0_cm127_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1564_MP21 (XI0_I1564_asn XI0_I1564_acon XI0_I1564_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1564_MP24 (XI0_I1564_ap5 I0_cm129_0 XI0_I1564_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1564_MP23 (XI0_I1564_ap4 I0_fa128_1 XI0_I1564_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1564_MP22 (VDD I0_cm127_1 XI0_I1564_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1564_MP22_1 (XI0_I1564_ap4 I0_cm127_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1564_MP23_1 (XI0_I1564_ap5 I0_fa128_1 XI0_I1564_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1564_MP24_1 (XI0_I1564_asn I0_cm129_0 XI0_I1564_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1564_MP17 (XI0_I1564_acon I0_cm129_0 XI0_I1564_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1564_MP14 (XI0_I1564_ap1 I0_fa128_1 XI0_I1564_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1564_MP13 (VDD I0_cm127_1 XI0_I1564_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1564_MP15 (XI0_I1564_ap2 I0_cm127_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1564_MP16 (VDD I0_fa128_1 XI0_I1564_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1564_MP28 (I0_cm203_2 XI0_I1564_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1564_MP19 (XI0_I1564_ap3 I0_fa128_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1564_MP20 (VDD I0_cm129_0 XI0_I1564_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1488_MP50 (VDD XI0_I1488_s1 XI0_I1488_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1488_MP47 (XI0_I1488_bp3 I0_pp12_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1488_MP49 (XI0_I1488_bsn XI0_I1488_bcon XI0_I1488_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1488_MP52 (XI0_I1488_bp5 I0_cm125_2 XI0_I1488_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1488_MP51 (XI0_I1488_bp4 I0_pp12_28 XI0_I1488_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1488_MP51_1 (XI0_I1488_bp5 I0_pp12_28 XI0_I1488_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1488_MP52_1 (XI0_I1488_bsn I0_cm125_2 XI0_I1488_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1488_MP54 (VDD XI0_I1488_bsn I0_cm127_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1488_MP41 (XI0_I1488_bp1 XI0_I1488_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1488_MP42 (XI0_I1488_bcon I0_pp12_28 XI0_I1488_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1488_MP45 (XI0_I1488_bp2 I0_cm125_2 XI0_I1488_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1488_MP43 (VDD XI0_I1488_s1 XI0_I1488_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1488_MP44 (XI0_I1488_bp2 I0_pp12_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1488_MP56 (VDD XI0_I1488_bcon I0_cm127_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1488_MP46 (XI0_I1488_bp3 XI0_I1488_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1488_MP48 (VDD I0_cm125_2 XI0_I1488_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1488_MP50_1 (XI0_I1488_bp4 XI0_I1488_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1488_MP26 (VDD XI0_I1488_asn XI0_I1488_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1488_MP18 (XI0_I1488_ap3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1488_MP21 (XI0_I1488_asn XI0_I1488_acon XI0_I1488_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1488_MP24 (XI0_I1488_ap5 I0_pp11_30 XI0_I1488_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1488_MP23 (XI0_I1488_ap4 I0_pp10_32 XI0_I1488_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1488_MP22 (VDD VDD XI0_I1488_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1488_MP22_1 (XI0_I1488_ap4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1488_MP23_1 (XI0_I1488_ap5 I0_pp10_32 XI0_I1488_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1488_MP24_1 (XI0_I1488_asn I0_pp11_30 XI0_I1488_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1488_MP17 (XI0_I1488_acon I0_pp11_30 XI0_I1488_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1488_MP14 (XI0_I1488_ap1 I0_pp10_32 XI0_I1488_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1488_MP13 (VDD VDD XI0_I1488_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1488_MP15 (XI0_I1488_ap2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1488_MP16 (VDD I0_pp10_32 XI0_I1488_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1488_MP28 (I0_cm127_2 XI0_I1488_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1488_MP19 (XI0_I1488_ap3 I0_pp10_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1488_MP20 (VDD I0_pp11_30 XI0_I1488_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1485_MP50 (VDD XI0_I1485_s1 XI0_I1485_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1485_MP47 (XI0_I1485_bp3 I0_pp15_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1485_MP49 (XI0_I1485_bsn XI0_I1485_bcon XI0_I1485_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1485_MP52 (XI0_I1485_bp5 I0_cm122_2 XI0_I1485_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1485_MP51 (XI0_I1485_bp4 I0_pp15_20 XI0_I1485_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1485_MP51_1 (XI0_I1485_bp5 I0_pp15_20 XI0_I1485_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1485_MP52_1 (XI0_I1485_bsn I0_cm122_2 XI0_I1485_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1485_MP54 (VDD XI0_I1485_bsn I0_cm124_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1485_MP41 (XI0_I1485_bp1 XI0_I1485_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1485_MP42 (XI0_I1485_bcon I0_pp15_20 XI0_I1485_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1485_MP45 (XI0_I1485_bp2 I0_cm122_2 XI0_I1485_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1485_MP43 (VDD XI0_I1485_s1 XI0_I1485_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1485_MP44 (XI0_I1485_bp2 I0_pp15_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1485_MP56 (VDD XI0_I1485_bcon I0_cm124_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1485_MP46 (XI0_I1485_bp3 XI0_I1485_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1485_MP48 (VDD I0_cm122_2 XI0_I1485_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1485_MP50_1 (XI0_I1485_bp4 XI0_I1485_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1485_MP26 (VDD XI0_I1485_asn XI0_I1485_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1485_MP18 (XI0_I1485_ap3 I0_pp12_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1485_MP21 (XI0_I1485_asn XI0_I1485_acon XI0_I1485_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1485_MP24 (XI0_I1485_ap5 I0_pp14_22 XI0_I1485_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1485_MP23 (XI0_I1485_ap4 I0_pp13_24 XI0_I1485_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1485_MP22 (VDD I0_pp12_26 XI0_I1485_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1485_MP22_1 (XI0_I1485_ap4 I0_pp12_26 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1485_MP23_1 (XI0_I1485_ap5 I0_pp13_24 XI0_I1485_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1485_MP24_1 (XI0_I1485_asn I0_pp14_22 XI0_I1485_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1485_MP17 (XI0_I1485_acon I0_pp14_22 XI0_I1485_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1485_MP14 (XI0_I1485_ap1 I0_pp13_24 XI0_I1485_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1485_MP13 (VDD I0_pp12_26 XI0_I1485_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1485_MP15 (XI0_I1485_ap2 I0_pp12_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1485_MP16 (VDD I0_pp13_24 XI0_I1485_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1485_MP28 (I0_cm124_2 XI0_I1485_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1485_MP19 (XI0_I1485_ap3 I0_pp13_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1485_MP20 (VDD I0_pp14_22 XI0_I1485_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1560_MP50 (VDD XI0_I1560_s1 XI0_I1560_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1560_MP47 (XI0_I1560_bp3 I0_cm122_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1560_MP49 (XI0_I1560_bsn XI0_I1560_bcon XI0_I1560_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1560_MP52 (XI0_I1560_bp5 I0_cm198_2 XI0_I1560_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1560_MP51 (XI0_I1560_bp4 I0_cm122_0 XI0_I1560_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1560_MP51_1 (XI0_I1560_bp5 I0_cm122_0 XI0_I1560_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1560_MP52_1 (XI0_I1560_bsn I0_cm198_2 XI0_I1560_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1560_MP54 (VDD XI0_I1560_bsn I0_cm199_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1560_MP41 (XI0_I1560_bp1 XI0_I1560_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1560_MP42 (XI0_I1560_bcon I0_cm122_0 XI0_I1560_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1560_MP45 (XI0_I1560_bp2 I0_cm198_2 XI0_I1560_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1560_MP43 (VDD XI0_I1560_s1 XI0_I1560_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1560_MP44 (XI0_I1560_bp2 I0_cm122_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1560_MP56 (VDD XI0_I1560_bcon I0_cm199_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1560_MP46 (XI0_I1560_bp3 XI0_I1560_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1560_MP48 (VDD I0_cm198_2 XI0_I1560_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1560_MP50_1 (XI0_I1560_bp4 XI0_I1560_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1560_MP26 (VDD XI0_I1560_asn XI0_I1560_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1560_MP18 (XI0_I1560_ap3 I0_cm119_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1560_MP21 (XI0_I1560_asn XI0_I1560_acon XI0_I1560_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1560_MP24 (XI0_I1560_ap5 I0_cm121_0 XI0_I1560_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1560_MP23 (XI0_I1560_ap4 I0_cm120_1 XI0_I1560_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1560_MP22 (VDD I0_cm119_1 XI0_I1560_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1560_MP22_1 (XI0_I1560_ap4 I0_cm119_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1560_MP23_1 (XI0_I1560_ap5 I0_cm120_1 XI0_I1560_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1560_MP24_1 (XI0_I1560_asn I0_cm121_0 XI0_I1560_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1560_MP17 (XI0_I1560_acon I0_cm121_0 XI0_I1560_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1560_MP14 (XI0_I1560_ap1 I0_cm120_1 XI0_I1560_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1560_MP13 (VDD I0_cm119_1 XI0_I1560_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1560_MP15 (XI0_I1560_ap2 I0_cm119_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1560_MP16 (VDD I0_cm120_1 XI0_I1560_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1560_MP28 (I0_cm199_2 XI0_I1560_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1560_MP19 (XI0_I1560_ap3 I0_cm120_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1560_MP20 (VDD I0_cm121_0 XI0_I1560_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1561_MP50 (VDD XI0_I1561_s1 XI0_I1561_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1561_MP47 (XI0_I1561_bp3 I0_cm124_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1561_MP49 (XI0_I1561_bsn XI0_I1561_bcon XI0_I1561_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1561_MP52 (XI0_I1561_bp5 I0_cm199_2 XI0_I1561_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1561_MP51 (XI0_I1561_bp4 I0_cm124_0 XI0_I1561_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1561_MP51_1 (XI0_I1561_bp5 I0_cm124_0 XI0_I1561_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1561_MP52_1 (XI0_I1561_bsn I0_cm199_2 XI0_I1561_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1561_MP54 (VDD XI0_I1561_bsn I0_cm200_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1561_MP41 (XI0_I1561_bp1 XI0_I1561_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1561_MP42 (XI0_I1561_bcon I0_cm124_0 XI0_I1561_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1561_MP45 (XI0_I1561_bp2 I0_cm199_2 XI0_I1561_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1561_MP43 (VDD XI0_I1561_s1 XI0_I1561_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1561_MP44 (XI0_I1561_bp2 I0_cm124_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1561_MP56 (VDD XI0_I1561_bcon I0_cm200_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1561_MP46 (XI0_I1561_bp3 XI0_I1561_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1561_MP48 (VDD I0_cm199_2 XI0_I1561_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1561_MP50_1 (XI0_I1561_bp4 XI0_I1561_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1561_MP26 (VDD XI0_I1561_asn XI0_I1561_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1561_MP18 (XI0_I1561_ap3 I0_cm121_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1561_MP21 (XI0_I1561_asn XI0_I1561_acon XI0_I1561_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1561_MP24 (XI0_I1561_ap5 I0_cm123_0 XI0_I1561_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1561_MP23 (XI0_I1561_ap4 I0_cm122_1 XI0_I1561_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1561_MP22 (VDD I0_cm121_1 XI0_I1561_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1561_MP22_1 (XI0_I1561_ap4 I0_cm121_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1561_MP23_1 (XI0_I1561_ap5 I0_cm122_1 XI0_I1561_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1561_MP24_1 (XI0_I1561_asn I0_cm123_0 XI0_I1561_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1561_MP17 (XI0_I1561_acon I0_cm123_0 XI0_I1561_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1561_MP14 (XI0_I1561_ap1 I0_cm122_1 XI0_I1561_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1561_MP13 (VDD I0_cm121_1 XI0_I1561_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1561_MP15 (XI0_I1561_ap2 I0_cm121_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1561_MP16 (VDD I0_cm122_1 XI0_I1561_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1561_MP28 (I0_cm200_2 XI0_I1561_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1561_MP19 (XI0_I1561_ap3 I0_cm122_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1561_MP20 (VDD I0_cm123_0 XI0_I1561_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1482_MP50 (VDD XI0_I1482_s1 XI0_I1482_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1482_MP47 (XI0_I1482_bp3 I0_pp11_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1482_MP49 (XI0_I1482_bsn XI0_I1482_bcon XI0_I1482_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1482_MP52 (XI0_I1482_bp5 I0_cm119_2 XI0_I1482_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1482_MP51 (XI0_I1482_bp4 I0_pp11_27 XI0_I1482_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1482_MP51_1 (XI0_I1482_bp5 I0_pp11_27 XI0_I1482_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1482_MP52_1 (XI0_I1482_bsn I0_cm119_2 XI0_I1482_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1482_MP54 (VDD XI0_I1482_bsn I0_cm121_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1482_MP41 (XI0_I1482_bp1 XI0_I1482_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1482_MP42 (XI0_I1482_bcon I0_pp11_27 XI0_I1482_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1482_MP45 (XI0_I1482_bp2 I0_cm119_2 XI0_I1482_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1482_MP43 (VDD XI0_I1482_s1 XI0_I1482_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1482_MP44 (XI0_I1482_bp2 I0_pp11_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1482_MP56 (VDD XI0_I1482_bcon I0_cm121_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1482_MP46 (XI0_I1482_bp3 XI0_I1482_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1482_MP48 (VDD I0_cm119_2 XI0_I1482_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1482_MP50_1 (XI0_I1482_bp4 XI0_I1482_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1482_MP26 (VDD XI0_I1482_asn XI0_I1482_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1482_MP18 (XI0_I1482_ap3 I0_sn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1482_MP21 (XI0_I1482_asn XI0_I1482_acon XI0_I1482_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1482_MP24 (XI0_I1482_ap5 I0_pp10_29 XI0_I1482_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1482_MP23 (XI0_I1482_ap4 I0_pp9_31 XI0_I1482_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1482_MP22 (VDD I0_sn8 XI0_I1482_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1482_MP22_1 (XI0_I1482_ap4 I0_sn8 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1482_MP23_1 (XI0_I1482_ap5 I0_pp9_31 XI0_I1482_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1482_MP24_1 (XI0_I1482_asn I0_pp10_29 XI0_I1482_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1482_MP17 (XI0_I1482_acon I0_pp10_29 XI0_I1482_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1482_MP14 (XI0_I1482_ap1 I0_pp9_31 XI0_I1482_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1482_MP13 (VDD I0_sn8 XI0_I1482_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1482_MP15 (XI0_I1482_ap2 I0_sn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1482_MP16 (VDD I0_pp9_31 XI0_I1482_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1482_MP28 (I0_cm121_2 XI0_I1482_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1482_MP19 (XI0_I1482_ap3 I0_pp9_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1482_MP20 (VDD I0_pp10_29 XI0_I1482_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1563_MP50 (VDD XI0_I1563_s1 XI0_I1563_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1563_MP47 (XI0_I1563_bp3 I0_fa128_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1563_MP49 (XI0_I1563_bsn XI0_I1563_bcon XI0_I1563_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1563_MP52 (XI0_I1563_bp5 I0_cm201_2 XI0_I1563_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1563_MP51 (XI0_I1563_bp4 I0_fa128_0 XI0_I1563_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1563_MP51_1 (XI0_I1563_bp5 I0_fa128_0 XI0_I1563_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1563_MP52_1 (XI0_I1563_bsn I0_cm201_2 XI0_I1563_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1563_MP54 (VDD XI0_I1563_bsn I0_cm202_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1563_MP41 (XI0_I1563_bp1 XI0_I1563_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1563_MP42 (XI0_I1563_bcon I0_fa128_0 XI0_I1563_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1563_MP45 (XI0_I1563_bp2 I0_cm201_2 XI0_I1563_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1563_MP43 (VDD XI0_I1563_s1 XI0_I1563_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1563_MP44 (XI0_I1563_bp2 I0_fa128_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1563_MP56 (VDD XI0_I1563_bcon I0_cm202_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1563_MP46 (XI0_I1563_bp3 XI0_I1563_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1563_MP48 (VDD I0_cm201_2 XI0_I1563_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1563_MP50_1 (XI0_I1563_bp4 XI0_I1563_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1563_MP26 (VDD XI0_I1563_asn XI0_I1563_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1563_MP18 (XI0_I1563_ap3 I0_cm125_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1563_MP21 (XI0_I1563_asn XI0_I1563_acon XI0_I1563_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1563_MP24 (XI0_I1563_ap5 I0_cm127_0 XI0_I1563_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1563_MP23 (XI0_I1563_ap4 I0_fa126_1 XI0_I1563_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1563_MP22 (VDD I0_cm125_1 XI0_I1563_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1563_MP22_1 (XI0_I1563_ap4 I0_cm125_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1563_MP23_1 (XI0_I1563_ap5 I0_fa126_1 XI0_I1563_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1563_MP24_1 (XI0_I1563_asn I0_cm127_0 XI0_I1563_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1563_MP17 (XI0_I1563_acon I0_cm127_0 XI0_I1563_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1563_MP14 (XI0_I1563_ap1 I0_fa126_1 XI0_I1563_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1563_MP13 (VDD I0_cm125_1 XI0_I1563_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1563_MP15 (XI0_I1563_ap2 I0_cm125_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1563_MP16 (VDD I0_fa126_1 XI0_I1563_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1563_MP28 (I0_cm202_2 XI0_I1563_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1563_MP19 (XI0_I1563_ap3 I0_fa126_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1563_MP20 (VDD I0_cm127_0 XI0_I1563_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1486_MP50 (VDD XI0_I1486_s1 XI0_I1486_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1486_MP47 (XI0_I1486_bp3 I0_pp12_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1486_MP49 (XI0_I1486_bsn XI0_I1486_bcon XI0_I1486_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1486_MP52 (XI0_I1486_bp5 I0_cm123_2 XI0_I1486_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1486_MP51 (XI0_I1486_bp4 I0_pp12_27 XI0_I1486_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1486_MP51_1 (XI0_I1486_bp5 I0_pp12_27 XI0_I1486_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1486_MP52_1 (XI0_I1486_bsn I0_cm123_2 XI0_I1486_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1486_MP54 (VDD XI0_I1486_bsn I0_cm125_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1486_MP41 (XI0_I1486_bp1 XI0_I1486_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1486_MP42 (XI0_I1486_bcon I0_pp12_27 XI0_I1486_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1486_MP45 (XI0_I1486_bp2 I0_cm123_2 XI0_I1486_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1486_MP43 (VDD XI0_I1486_s1 XI0_I1486_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1486_MP44 (XI0_I1486_bp2 I0_pp12_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1486_MP56 (VDD XI0_I1486_bcon I0_cm125_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1486_MP46 (XI0_I1486_bp3 XI0_I1486_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1486_MP48 (VDD I0_cm123_2 XI0_I1486_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1486_MP50_1 (XI0_I1486_bp4 XI0_I1486_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1486_MP26 (VDD XI0_I1486_asn XI0_I1486_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1486_MP18 (XI0_I1486_ap3 I0_sn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1486_MP21 (XI0_I1486_asn XI0_I1486_acon XI0_I1486_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1486_MP24 (XI0_I1486_ap5 I0_pp11_29 XI0_I1486_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1486_MP23 (XI0_I1486_ap4 I0_pp10_31 XI0_I1486_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1486_MP22 (VDD I0_sn9 XI0_I1486_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1486_MP22_1 (XI0_I1486_ap4 I0_sn9 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1486_MP23_1 (XI0_I1486_ap5 I0_pp10_31 XI0_I1486_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1486_MP24_1 (XI0_I1486_asn I0_pp11_29 XI0_I1486_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1486_MP17 (XI0_I1486_acon I0_pp11_29 XI0_I1486_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1486_MP14 (XI0_I1486_ap1 I0_pp10_31 XI0_I1486_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1486_MP13 (VDD I0_sn9 XI0_I1486_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1486_MP15 (XI0_I1486_ap2 I0_sn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1486_MP16 (VDD I0_pp10_31 XI0_I1486_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1486_MP28 (I0_cm125_2 XI0_I1486_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1486_MP19 (XI0_I1486_ap3 I0_pp10_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1486_MP20 (VDD I0_pp11_29 XI0_I1486_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1562_MP50 (VDD XI0_I1562_s1 XI0_I1562_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1562_MP47 (XI0_I1562_bp3 I0_fa126_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1562_MP49 (XI0_I1562_bsn XI0_I1562_bcon XI0_I1562_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1562_MP52 (XI0_I1562_bp5 I0_cm200_2 XI0_I1562_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1562_MP51 (XI0_I1562_bp4 I0_fa126_0 XI0_I1562_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1562_MP51_1 (XI0_I1562_bp5 I0_fa126_0 XI0_I1562_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1562_MP52_1 (XI0_I1562_bsn I0_cm200_2 XI0_I1562_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1562_MP54 (VDD XI0_I1562_bsn I0_cm201_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1562_MP41 (XI0_I1562_bp1 XI0_I1562_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1562_MP42 (XI0_I1562_bcon I0_fa126_0 XI0_I1562_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1562_MP45 (XI0_I1562_bp2 I0_cm200_2 XI0_I1562_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1562_MP43 (VDD XI0_I1562_s1 XI0_I1562_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1562_MP44 (XI0_I1562_bp2 I0_fa126_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1562_MP56 (VDD XI0_I1562_bcon I0_cm201_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1562_MP46 (XI0_I1562_bp3 XI0_I1562_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1562_MP48 (VDD I0_cm200_2 XI0_I1562_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1562_MP50_1 (XI0_I1562_bp4 XI0_I1562_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1562_MP26 (VDD XI0_I1562_asn XI0_I1562_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1562_MP18 (XI0_I1562_ap3 I0_cm123_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1562_MP21 (XI0_I1562_asn XI0_I1562_acon XI0_I1562_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1562_MP24 (XI0_I1562_ap5 I0_cm125_0 XI0_I1562_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1562_MP23 (XI0_I1562_ap4 I0_cm124_1 XI0_I1562_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1562_MP22 (VDD I0_cm123_1 XI0_I1562_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1562_MP22_1 (XI0_I1562_ap4 I0_cm123_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1562_MP23_1 (XI0_I1562_ap5 I0_cm124_1 XI0_I1562_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1562_MP24_1 (XI0_I1562_asn I0_cm125_0 XI0_I1562_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1562_MP17 (XI0_I1562_acon I0_cm125_0 XI0_I1562_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1562_MP14 (XI0_I1562_ap1 I0_cm124_1 XI0_I1562_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1562_MP13 (VDD I0_cm123_1 XI0_I1562_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1562_MP15 (XI0_I1562_ap2 I0_cm123_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1562_MP16 (VDD I0_cm124_1 XI0_I1562_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1562_MP28 (I0_cm201_2 XI0_I1562_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1562_MP19 (XI0_I1562_ap3 I0_cm124_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1562_MP20 (VDD I0_cm125_0 XI0_I1562_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1484_MP50 (VDD XI0_I1484_s1 XI0_I1484_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1484_MP47 (XI0_I1484_bp3 I0_pp11_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1484_MP49 (XI0_I1484_bsn XI0_I1484_bcon XI0_I1484_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1484_MP52 (XI0_I1484_bp5 I0_cm121_2 XI0_I1484_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1484_MP51 (XI0_I1484_bp4 I0_pp11_28 XI0_I1484_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1484_MP51_1 (XI0_I1484_bp5 I0_pp11_28 XI0_I1484_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1484_MP52_1 (XI0_I1484_bsn I0_cm121_2 XI0_I1484_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1484_MP54 (VDD XI0_I1484_bsn I0_cm123_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1484_MP41 (XI0_I1484_bp1 XI0_I1484_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1484_MP42 (XI0_I1484_bcon I0_pp11_28 XI0_I1484_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1484_MP45 (XI0_I1484_bp2 I0_cm121_2 XI0_I1484_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1484_MP43 (VDD XI0_I1484_s1 XI0_I1484_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1484_MP44 (XI0_I1484_bp2 I0_pp11_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1484_MP56 (VDD XI0_I1484_bcon I0_cm123_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1484_MP46 (XI0_I1484_bp3 XI0_I1484_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1484_MP48 (VDD I0_cm121_2 XI0_I1484_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1484_MP50_1 (XI0_I1484_bp4 XI0_I1484_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1484_MP26 (VDD XI0_I1484_asn XI0_I1484_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1484_MP18 (XI0_I1484_ap3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1484_MP21 (XI0_I1484_asn XI0_I1484_acon XI0_I1484_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1484_MP24 (XI0_I1484_ap5 I0_pp10_30 XI0_I1484_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1484_MP23 (XI0_I1484_ap4 I0_pp9_32 XI0_I1484_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1484_MP22 (VDD VDD XI0_I1484_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1484_MP22_1 (XI0_I1484_ap4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1484_MP23_1 (XI0_I1484_ap5 I0_pp9_32 XI0_I1484_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1484_MP24_1 (XI0_I1484_asn I0_pp10_30 XI0_I1484_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1484_MP17 (XI0_I1484_acon I0_pp10_30 XI0_I1484_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1484_MP14 (XI0_I1484_ap1 I0_pp9_32 XI0_I1484_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1484_MP13 (VDD VDD XI0_I1484_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1484_MP15 (XI0_I1484_ap2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1484_MP16 (VDD I0_pp9_32 XI0_I1484_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1484_MP28 (I0_cm123_2 XI0_I1484_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1484_MP19 (XI0_I1484_ap3 I0_pp9_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1484_MP20 (VDD I0_pp10_30 XI0_I1484_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI1_I838_I193_MP0 (I1_I838_G7_0n I1_I838_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I189_MP0 (I1_I838_G5_0n I1_I838_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I161_MP0 (I1_I838_G3_0np I1_I838_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I796_MP0 (I1_qu26_b0 I1_qu26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I193_MP0 (I1_I1344_G7_0n I1_I1344_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1348_MP0 (I1_qu14_b0 I1_qu14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1302_MP0 (I1_qu15_b0 I1_qu15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1256_MP0 (I1_qu16_b0 I1_qu16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I842_MP0 (I1_qu25_b0 I1_qu25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I193_MP0 (I1_I792_G7_0n I1_I792_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I161_MP0 (I1_I1344_G3_0np I1_I1344_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I129_MP0 (I1_I838_G1_0n I1_I838_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I189_MP0 (I1_I792_G5_0n I1_I792_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I191_MP0 (I1_I792_G6_0n I1_I792_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I161_MP0 (I1_I792_G3_0np I1_I792_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I187_MP0 (I1_I792_G4_0n I1_I792_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I191_MP0 (I1_I746_G6_0n I1_I746_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I189_MP0 (I1_I1344_G5_0n I1_I1344_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I193_MP0 (I1_I1298_G7_0n I1_I1298_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I191_MP0 (I1_I1252_G6_0n I1_I1252_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I193_MP0 (I1_I1252_G7_0n I1_I1252_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I189_MP0 (I1_I1298_G5_0n I1_I1298_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I191_MP0 (I1_I1298_G6_0n I1_I1298_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I189_MP0 (I1_I1252_G5_0n I1_I1252_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I191_MP0 (I1_I838_G6_0n I1_I838_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I159_MP0 (I1_I792_G2_0np I1_I792_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I159_MP0 (I1_I746_G2_0np I1_I746_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I187_MP0 (I1_I746_G4_0n I1_I746_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I129_MP0 (I1_I1344_G1_0n I1_I1344_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I187_MP0 (I1_I1298_G4_0n I1_I1298_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I193_MP0 (I1_I1206_G7_0n I1_I1206_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I189_MP0 (I1_I1206_G5_0n I1_I1206_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I187_MP0 (I1_I838_G4_0n I1_I838_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I159_MP0 (I1_I838_G2_0np I1_I838_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I129_MP0 (I1_I792_G1_0n I1_I792_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I161_MP0 (I1_I1298_G3_0np I1_I1298_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I187_MP0 (I1_I1252_G4_0n I1_I1252_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I191_MP0 (I1_I1206_G6_0n I1_I1206_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I66_MP0 (I1_I838_G0_0n I1_I838_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I189_MP0 (I1_I746_G5_0n I1_I746_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I159_MP0 (I1_I1252_G2_0np I1_I1252_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I161_MP0 (I1_I1252_G3_0np I1_I1252_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I161_MP0 (I1_I1206_G3_0np I1_I1206_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I159_MP0 (I1_I1206_G2_0np I1_I1206_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I187_MP0 (I1_I1206_G4_0n I1_I1206_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I66_MP0 (I1_I792_G0_0n I1_I792_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I66_MP0 (I1_I746_G0_0n I1_I746_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I129_MP0 (I1_I746_G1_0n I1_I746_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I161_MP0 (I1_I746_G3_0np I1_I746_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I191_MP0 (I1_I1344_G6_0n I1_I1344_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I187_MP0 (I1_I1344_G4_0n I1_I1344_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I159_MP0 (I1_I1298_G2_0np I1_I1298_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I129_MP0 (I1_I1206_G1_0n I1_I1206_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I193_MP0 (I1_I746_G7_0n I1_I746_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I159_MP0 (I1_I1344_G2_0np I1_I1344_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I129_MP0 (I1_I1298_G1_0n I1_I1298_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I129_MP0 (I1_I1252_G1_0n I1_I1252_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I750_MP0 (I1_qu27_b0 I1_qu27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I704_MP0 (I1_qu28_b0 I1_qu28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1164_MP0 (I1_qu18_b0 I1_qu18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1210_MP0 (I1_qu17_b0 I1_qu17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I193_MP0 (I1_I884_G7_0n I1_I884_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I189_MP0 (I1_I884_G5_0n I1_I884_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I161_MP0 (I1_I884_G3_0np I1_I884_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I193_MP0 (I1_I700_G7_0n I1_I700_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I161_MP0 (I1_I1160_G3_0np I1_I1160_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I66_MP0 (I1_I1206_G0_0n I1_I1206_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I129_MP0 (I1_I884_G1_0n I1_I884_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I161_MP0 (I1_I700_G3_0np I1_I700_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I189_MP0 (I1_I700_G5_0n I1_I700_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I66_MP0 (I1_I1252_G0_0n I1_I1252_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I193_MP0 (I1_I1160_G7_0n I1_I1160_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I189_MP0 (I1_I1160_G5_0n I1_I1160_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I888_MP0 (I1_qu24_b0 I1_qu24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I191_MP0 (I1_I884_G6_0n I1_I884_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I187_MP0 (I1_I884_G4_0n I1_I884_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I159_MP0 (I1_I884_G2_0np I1_I884_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I129_MP0 (I1_I700_G1_0n I1_I700_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I66_MP0 (I1_I1298_G0_0n I1_I1298_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I129_MP0 (I1_I1160_G1_0n I1_I1160_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I66_MP0 (I1_I884_G0_0n I1_I884_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I64_MP0 (I1_I792_cinn I1_qu27_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I159_MP0 (I1_I700_G2_0np I1_I700_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I187_MP0 (I1_I700_G4_0n I1_I700_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I191_MP0 (I1_I700_G6_0n I1_I700_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I193_MP0 (I1_I1390_G7_0n I1_I1390_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I189_MP0 (I1_I1390_G5_0n I1_I1390_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I161_MP0 (I1_I1390_G3_0np I1_I1390_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I66_MP0 (I1_I1344_G0_0n I1_I1344_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I64_MP0 (I1_I1252_cinn I1_qu17_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I64_MP0 (I1_I1206_cinn I1_qu18_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I66_MP0 (I1_I700_G0_0n I1_I700_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I129_MP0 (I1_I1390_G1_0n I1_I1390_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I64_MP0 (I1_I1298_cinn I1_qu16_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I191_MP0 (I1_I1160_G6_0n I1_I1160_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I187_MP0 (I1_I1160_G4_0n I1_I1160_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I66_MP0 (I1_I1160_G0_0n I1_I1160_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I64_MP0 (I1_I838_cinn I1_qu26_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I159_MP0 (I1_I1160_G2_0np I1_I1160_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I64_MP0 (I1_I1160_cinn I1_qu19_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I64_MP0 (I1_I746_cinn I1_qu28_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1394_MP0 (I1_qu13_b0 I1_qu13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I191_MP0 (I1_I1390_G6_0n I1_I1390_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I187_MP0 (I1_I1390_G4_0n I1_I1390_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I159_MP0 (I1_I1390_G2_0np I1_I1390_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I193_MP0 (I1_I930_G7_0n I1_I930_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I189_MP0 (I1_I930_G5_0n I1_I930_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I161_MP0 (I1_I930_G3_0np I1_I930_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I129_MP0 (I1_I930_G1_0n I1_I930_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I66_MP0 (I1_I1390_G0_0n I1_I1390_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I64_MP0 (I1_I1344_cinn I1_qu15_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I934_MP0 (I1_qu23_b0 I1_qu23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I64_MP0 (I1_I700_cinn I1_qu29_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I129_MP0 (I1_I654_G1_0n I1_I654_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I161_MP0 (I1_I654_G3_0np I1_I654_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I189_MP0 (I1_I654_G5_0n I1_I654_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I193_MP0 (I1_I654_G7_0n I1_I654_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I658_MP0 (I1_qu29_b0 I1_qu29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I64_MP0 (I1_I1390_cinn I1_qu14_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I191_MP0 (I1_I930_G6_0n I1_I930_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I187_MP0 (I1_I930_G4_0n I1_I930_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I159_MP0 (I1_I930_G2_0np I1_I930_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I66_MP0 (I1_I654_G0_0n I1_I654_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I187_MP0 (I1_I654_G4_0n I1_I654_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I191_MP0 (I1_I1114_G6_0n I1_I1114_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1118_MP0 (I1_qu19_b0 I1_qu19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I64_MP0 (I1_I884_cinn I1_qu25_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I66_MP0 (I1_I930_G0_0n I1_I930_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I159_MP0 (I1_I654_G2_0np I1_I654_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I191_MP0 (I1_I654_G6_0n I1_I654_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I191_MP0 (I1_I1436_G6_0n I1_I1436_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I159_MP0 (I1_I1436_G2_0np I1_I1436_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1072_MP0 (I1_qu20_b0 I1_qu20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I187_MP0 (I1_I1436_G4_0n I1_I1436_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I66_MP0 (I1_I1436_G0_0n I1_I1436_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I189_MP0 (I1_I1436_G5_0n I1_I1436_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I64_MP0 (I1_I1436_cinn I1_qu13_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I193_MP0 (I1_I1114_G7_0n I1_I1114_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I191_MP0 (I1_I1068_G6_0n I1_I1068_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I193_MP0 (I1_I1068_G7_0n I1_I1068_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I980_MP0 (I1_qu22_b0 I1_qu22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I193_MP0 (I1_I976_G7_0n I1_I976_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I189_MP0 (I1_I976_G5_0n I1_I976_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I64_MP0 (I1_I654_cinn I1_qu30_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I161_MP0 (I1_I1436_G3_0np I1_I1436_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I129_MP0 (I1_I1436_G1_0n I1_I1436_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I189_MP0 (I1_I1114_G5_0n I1_I1114_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I159_MP0 (I1_I1114_G2_0np I1_I1114_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I161_MP0 (I1_I976_G3_0np I1_I976_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I129_MP0 (I1_I976_G1_0n I1_I976_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I66_MP0 (I1_I608_G0_0n I1_I608_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I159_MP0 (I1_I608_G2_0np I1_I608_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I187_MP0 (I1_I608_G4_0n I1_I608_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I191_MP0 (I1_I608_G6_0n I1_I608_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I193_MP0 (I1_I1436_G7_0n I1_I1436_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I187_MP0 (I1_I1114_G4_0n I1_I1114_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I187_MP0 (I1_I1068_G4_0n I1_I1068_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I189_MP0 (I1_I1068_G5_0n I1_I1068_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I612_MP0 (I1_qu30_b0 I1_qu30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1440_MP0 (I1_qu12_b0 I1_qu12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I161_MP0 (I1_I1114_G3_0np I1_I1114_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I161_MP0 (I1_I1068_G3_0np I1_I1068_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1026_MP0 (I1_qu21_b0 I1_qu21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I191_MP0 (I1_I976_G6_0n I1_I976_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I129_MP0 (I1_I1114_G1_0n I1_I1114_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I159_MP0 (I1_I1068_G2_0np I1_I1068_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I187_MP0 (I1_I976_G4_0n I1_I976_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I159_MP0 (I1_I976_G2_0np I1_I976_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I64_MP0 (I1_I608_cinn I1_qu31_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I129_MP0 (I1_I608_G1_0n I1_I608_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I161_MP0 (I1_I608_G3_0np I1_I608_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I189_MP0 (I1_I608_G5_0n I1_I608_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I193_MP0 (I1_I608_G7_0n I1_I608_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I193_MP0 (I1_I1482_G7_0n I1_I1482_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I189_MP0 (I1_I1482_G5_0n I1_I1482_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I161_MP0 (I1_I1482_G3_0np I1_I1482_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I129_MP0 (I1_I1482_G1_0n I1_I1482_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I66_MP0 (I1_I1114_G0_0n I1_I1114_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I191_MP0 (I1_I1022_G6_0n I1_I1022_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I193_MP0 (I1_I1022_G7_0n I1_I1022_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I66_MP0 (I1_I976_G0_0n I1_I976_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I64_MP0 (I1_I930_cinn I1_qu24_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1486_MP0 (I1_qu11_b0 I1_qu11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I66_MP0 (I1_I1482_G0_0n I1_I1482_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I64_MP0 (I1_I1482_cinn I1_qu12_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I129_MP0 (I1_I1068_G1_0n I1_I1068_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I64_MP0 (I1_I1114_cinn I1_qu20_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I161_MP0 (I1_I1022_G3_0np I1_I1022_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I187_MP0 (I1_I1482_G4_0n I1_I1482_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I159_MP0 (I1_I1482_G2_0np I1_I1482_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I66_MP0 (I1_I1068_G0_0n I1_I1068_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I64_MP0 (I1_I1068_cinn I1_qu21_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I159_MP0 (I1_I1022_G2_0np I1_I1022_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I187_MP0 (I1_I1022_G4_0n I1_I1022_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I189_MP0 (I1_I1022_G5_0n I1_I1022_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I64_MP0 (I1_I976_cinn I1_qu23_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1482_I191_MP0 (I1_I1482_G6_0n I1_I1482_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I66_MP0 (I1_I1022_G0_0n I1_I1022_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I129_MP0 (I1_I1022_G1_0n I1_I1022_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2158_MP0 (I1_nqk27 I1_nqkn27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2161_MP0 (I1_nqk28 I1_nqkn28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2164_MP0 (I1_nqk29 I1_nqkn29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2167_MP0 (I1_nqk30 I1_nqkn30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I66_MP0 (I1_I562_G0_0n I1_I562_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I159_MP0 (I1_I1528_G2_0np I1_I1528_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2125_MP0 (I1_nqk16 I1_nqkn16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2128_MP0 (I1_nqk17 I1_nqkn17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2131_MP0 (I1_nqk18 I1_nqkn18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2134_MP0 (I1_nqk19 I1_nqkn19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2137_MP0 (I1_nqk20 I1_nqkn20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2140_MP0 (I1_nqk21 I1_nqkn21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I364_MP0 (I1_dd19_b0 I1_dd19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I377_MP0 (I1_dd20_b0 I1_dd20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1022_I64_MP0 (I1_I1022_cinn I1_qu22_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I494_MP0 (I1_dd29_b0 I1_dd29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2143_MP0 (I1_nqk22 I1_nqkn22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2146_MP0 (I1_nqk23 I1_nqkn23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2149_MP0 (I1_nqk24 I1_nqkn24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2152_MP0 (I1_nqk25 I1_nqkn25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2155_MP0 (I1_nqk26 I1_nqkn26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2293_MP0 (I1_sqn I1_sq_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I104_MP0 (I1_nak23 I1_nakn23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I125_MP0 (I1_nak30 I1_nakn30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I122_MP0 (I1_nak29 I1_nakn29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I64_MP0 (I1_I562_cinn VDD VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I159_MP0 (I1_I562_G2_0np I1_I562_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I187_MP0 (I1_I562_G4_0n I1_I562_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I191_MP0 (I1_I562_G6_0n I1_I562_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I191_MP0 (I1_I1528_G6_0n I1_I1528_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I187_MP0 (I1_I1528_G4_0n I1_I1528_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I66_MP0 (I1_I1528_G0_0n I1_I1528_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I64_MP0 (I1_I1528_cinn I1_qu11_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2119_MP0 (I1_nqk14 I1_nqkn14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2122_MP0 (I1_nqk15 I1_nqkn15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I260_MP0 (I1_dd11_b0 I1_dd11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I221_MP0 (I1_dd8_b0 I1_dd8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I273_MP0 (I1_dd12_b0 I1_dd12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I208_MP0 (I1_dd7_b0 I1_dd7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I195_MP0 (I1_dd6_b0 I1_dd6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I169_MP0 (I1_dd4_b0 I1_dd4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I286_MP0 (I1_dd13_b0 I1_dd13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I299_MP0 (I1_dd14_b0 I1_dd14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I143_MP0 (I1_dd2_b0 I1_dd2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I130_MP0 (I1_dd1_b0 I1_dd1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I312_MP0 (I1_dd15_b0 I1_dd15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I403_MP0 (I1_dd22_b0 I1_dd22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I89_MP0 (I1_nak18 I1_nakn18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I507_MP0 (I1_dd30_b0 I1_dd30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I92_MP0 (I1_nak19 I1_nakn19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I390_MP0 (I1_dd21_b0 I1_dd21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I520_MP0 (I1_dd31_b0 I1_dd31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I95_MP0 (I1_nak20 I1_nakn20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2068_MP0 (I1_sq_b0 I1_sq VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I481_MP0 (I1_dd28_b0 I1_dd28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I98_MP0 (I1_nak21 I1_nakn21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I517_MP0 (I1_nbk30 I1_nbkn30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I504_MP0 (I1_nbk29 I1_nbkn29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I491_MP0 (I1_nbk28 I1_nbkn28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I117_MP0 (I2_OR_19 I2_I2_nor19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I101_MP0 (I1_nak22 I1_nakn22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I119_MP0 (I2_NOT_19 A_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I113_MP0 (I2_NOT_18 A_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I125_MP0 (I2_NOT_20 A_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I107_MP0 (I1_nak24 I1_nakn24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I110_MP0 (I1_nak25 I1_nakn25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I113_MP0 (I1_nak26 I1_nakn26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I119_MP0 (I1_nak28 I1_nakn28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I77_MP0 (I1_nak14 I1_nakn14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I80_MP0 (I1_nak15 I1_nakn15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2116_MP0 (I1_nqk13 I1_nqkn13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I247_MP0 (I1_dd10_b0 I1_dd10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I234_MP0 (I1_dd9_b0 I1_dd9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I83_MP0 (I1_nak16 I1_nakn16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I182_MP0 (I1_dd5_b0 I1_dd5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I156_MP0 (I1_dd3_b0 I1_dd3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I309_MP0 (I1_nbk14 I1_nbkn14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I322_MP0 (I1_nbk15 I1_nbkn15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I325_MP0 (I1_dd16_b0 I1_dd16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I86_MP0 (I1_nak17 I1_nakn17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I338_MP0 (I1_dd17_b0 I1_dd17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I351_MP0 (I1_dd18_b0 I1_dd18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I416_MP0 (I1_dd23_b0 I1_dd23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I361_MP0 (I1_nbk18 I1_nbkn18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I374_MP0 (I1_nbk19 I1_nbkn19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I387_MP0 (I1_nbk20 I1_nbkn20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I400_MP0 (I1_nbk21 I1_nbkn21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I413_MP0 (I1_nbk22 I1_nbkn22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I442_MP0 (I1_dd25_b0 I1_dd25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I426_MP0 (I1_nbk23 I1_nbkn23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I455_MP0 (I1_dd26_b0 I1_dd26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I468_MP0 (I1_dd27_b0 I1_dd27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I478_MP0 (I1_nbk27 I1_nbkn27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I115_MP0 (I2_AND_19 I2_I2_nand19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I109_MP0 (I2_AND_18 I2_I2_nand18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I121_MP0 (I2_AND_20 I2_I2_nand20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I116_MP0 (I1_nak27 I1_nakn27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I133_MP0 (I2_AND_22 I2_I2_nand22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I129_MP0 (I1_I1528_G1_0n I1_I1528_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I161_MP0 (I1_I1574_G3_0np I1_I1574_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I74_MP0 (I1_nak13 I1_nakn13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I71_MP0 (I1_nak12 I1_nakn12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2113_MP0 (I1_nqk12 I1_nqkn12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I257_MP0 (I1_nbk10 I1_nbkn10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I270_MP0 (I1_nbk11 I1_nbkn11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I192_MP0 (I1_nbk5 I1_nbkn5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I283_MP0 (I1_nbk12 I1_nbkn12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I179_MP0 (I1_nbk4 I1_nbkn4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I296_MP0 (I1_nbk13 I1_nbkn13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I335_MP0 (I1_nbk16 I1_nbkn16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I348_MP0 (I1_nbk17 I1_nbkn17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I429_MP0 (I1_dd24_b0 I1_dd24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I439_MP0 (I1_nbk24 I1_nbkn24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I452_MP0 (I1_nbk25 I1_nbkn25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I465_MP0 (I1_nbk26 I1_nbkn26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I127_MP0 (I2_AND_21 I2_I2_nand21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I129_MP0 (I2_OR_21 I2_I2_nor21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I131_MP0 (I2_NOT_21 A_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I111_MP0 (I2_OR_18 I2_I2_nor18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I101_MP0 (I2_NOT_16 A_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I123_MP0 (I2_OR_20 I2_I2_nor20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I139_MP0 (I2_AND_23 I2_I2_nand23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I143_MP0 (I2_NOT_23 A_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I137_MP0 (I2_NOT_22 A_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I193_MP0 (I1_I1712_G7_0n I1_I1712_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I193_MP0 (I1_I1574_G7_0n I1_I1574_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2110_MP0 (I1_nqk11 I1_nqkn11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I244_MP0 (I1_nbk9 I1_nbkn9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I231_MP0 (I1_nbk8 I1_nbkn8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I218_MP0 (I1_nbk7 I1_nbkn7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I205_MP0 (I1_nbk6 I1_nbkn6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I166_MP0 (I1_nbk3 I1_nbkn3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I153_MP0 (I1_nbk2 I1_nbkn2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I140_MP0 (I1_nbk1 I1_nbkn1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I103_MP0 (I2_AND_17 I2_I2_nand17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I141_MP0 (I2_OR_23 I2_I2_nor23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I155_MP0 (I2_NOT_25 A_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I135_MP0 (I2_OR_22 I2_I2_nor22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I163_MP0 (I2_AND_27 I2_I2_nand27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I175_MP0 (I2_AND_29 I2_I2_nand29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I129_MP0 (I1_I562_G1_0n I1_I562_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I189_MP0 (I1_I562_G5_0n I1_I562_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I161_MP0 (I1_I1712_G3_0np I1_I1712_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I193_MP0 (I1_I1528_G7_0n I1_I1528_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I189_MP0 (I1_I1528_G5_0n I1_I1528_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1528_I161_MP0 (I1_I1528_G3_0np I1_I1528_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I68_MP0 (I1_nak11 I1_nakn11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I65_MP0 (I1_nak10 I1_nakn10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I83_MP0 (I2_NOT_13 A_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I95_MP0 (I2_NOT_15 A_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I187_MP0 (I2_I1_I42_G4_0n I2_I1_I42_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I16_MP0 (I1_B_31_b0 B_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I105_MP0 (I2_OR_17 I2_I2_nor17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I107_MP0 (I2_NOT_17 A_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I99_MP0 (I2_OR_16 I2_I2_nor16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I97_MP0 (I2_AND_16 I2_I2_nand16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I151_MP0 (I2_AND_25 I2_I2_nand25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I153_MP0 (I2_OR_25 I2_I2_nor25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I149_MP0 (I2_NOT_24 A_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I161_MP0 (I2_NOT_26 A_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I165_MP0 (I2_OR_27 I2_I2_nor27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I177_MP0 (I2_OR_29 I2_I2_nor29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I179_MP0 (I2_NOT_29 A_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I161_MP0 (I1_I562_G3_0np I1_I562_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I129_MP0 (I1_I1712_G1_0n I1_I1712_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1532_MP0 (I1_qu10_b0 I1_qu10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I189_MP0 (I1_I1574_G5_0n I1_I1574_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I129_MP0 (I1_I1574_G1_0n I1_I1574_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I81_MP0 (I2_OR_13 I2_I2_nor13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I93_MP0 (I2_OR_15 I2_I2_nor15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I89_MP0 (I2_NOT_14 A_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I191_MP0 (I2_I1_I42_G6_0n I2_I1_I42_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I145_MP0 (I2_AND_24 I2_I2_nand24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I185_MP0 (I2_NOT_30 A_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I167_MP0 (I2_NOT_27 A_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I169_MP0 (I2_AND_28 I2_I2_nand28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I173_MP0 (I2_NOT_28 A_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I452_MP0 (I0_B_27_b0 B_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I442_MP0 (I0_B_25_b0 B_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I432_MP0 (I0_B_23_b0 B_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I190_MP0 (I0_A_18_b0 A_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I180_MP0 (I0_A_17_b0 A_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I200_MP0 (I0_A_19_b0 A_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I220_MP0 (I0_A_21_b0 A_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I210_MP0 (I0_A_20_b0 A_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I230_MP0 (I0_A_22_b0 A_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I566_MP0 (I1_qu31_b0 I1_qu31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I402_MP0 (I0_B_17_b0 B_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I412_MP0 (I0_B_19_b0 B_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I4_I71_MP0 (DZ I2_I4_dzn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I189_MP0 (I1_I1712_G5_0n I1_I1712_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I187_MP0 (I1_I1712_G4_0n I1_I1712_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I79_MP0 (I2_AND_13 I2_I2_nand13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I77_MP0 (I2_NOT_12 A_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I91_MP0 (I2_AND_15 I2_I2_nand15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I0_MP0 (I2_I1_SUB_b0 OP_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I3_I10_MP0 (I2_I3_SEL_OR_b0 I2_SEL_OR VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I3_I30_MP0 (I2_I3_SEL_NOT_b0 I2_SEL_NOT VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I3_I20_MP0 (I2_I3_SEL_XOR_b0 I2_SEL_XOR VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I3_I0_MP0 (I2_I3_SEL_AND_b0 I2_SEL_AND VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I147_MP0 (I2_OR_24 I2_I2_nor24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I157_MP0 (I2_AND_26 I2_I2_nand26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I171_MP0 (I2_OR_28 I2_I2_nor28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I462_MP0 (I0_B_29_b0 B_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I170_MP0 (I0_A_16_b0 A_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I260_MP0 (I0_A_25_b0 A_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I240_MP0 (I0_A_23_b0 A_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I280_MP0 (I0_A_27_b0 A_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I562_I193_MP0 (I1_I562_G7_0n I1_I562_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I250_MP0 (I0_A_24_b0 A_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I422_MP0 (I0_B_21_b0 B_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I290_MP0 (I0_A_28_b0 A_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I159_MP0 (I1_I1712_G2_0np I1_I1712_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I66_MP0 (I1_I1712_G0_0n I1_I1712_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I71_MP0 (I2_NOT_11 A_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I87_MP0 (I2_OR_14 I2_I2_nor14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I160_MP0 (I0_A_15_b0 A_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I3_I72_MP0 (I2_I3_SEL_AS_b0 I2_SEL_AS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I0_I1_MP0 (I2_I0_opn1 OP_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I0_I0_MP0 (I2_I0_opn0 OP_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I0_I3_MP0 (I2_I0_opn3 OP_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I0_I2_MP0 (I2_I0_opn2 OP_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I159_MP0 (I2_OR_26 I2_I2_nor26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I4_I65_MP0 (C I2_I4_cn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I183_MP0 (I2_OR_30 I2_I2_nor30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I181_MP0 (I2_AND_30 I2_I2_nand30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I189_MP0 (I2_OR_31 I2_I2_nor31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I187_MP0 (I2_AND_31 I2_I2_nand31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I191_MP0 (I2_NOT_31 A_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I591_MP0 (I0_sn1 I0_pp1_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I270_MP0 (I0_A_26_b0 A_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I310_MP0 (I0_A_30_b0 A_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I300_MP0 (I0_A_29_b0 A_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I187_MP0 (I1_I1574_G4_0n I1_I1574_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I66_MP0 (I1_I1574_G0_0n I1_I1574_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I75_MP0 (I2_OR_12 I2_I2_nor12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I69_MP0 (I2_OR_11 I2_I2_nor11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I85_MP0 (I2_AND_14 I2_I2_nand14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I159_MP0 (I2_I1_I42_G2_0np I2_I1_I42_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I189_MP0 (I2_I1_I42_G5_0n I2_I1_I42_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I150_MP0 (I0_A_14_b0 A_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I392_MP0 (I0_B_15_b0 B_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I382_MP0 (I0_B_13_b0 B_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I3_I56_MP0 (I2_I3_SEL_DIV_b0 I2_SEL_DIV VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I472_MP0 (I0_B_31_b0 B_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I536_MP0 (I0_sn0 I0_pp0_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I320_MP0 (I0_A_31_b0 A_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I191_MP0 (I1_I1712_G6_0n I1_I1712_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I64_MP0 (I1_I1666_cinn I1_qu8_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I159_MP0 (I1_I1574_G2_0np I1_I1574_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I73_MP0 (I2_AND_12 I2_I2_nand12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I67_MP0 (I2_AND_11 I2_I2_nand11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I372_MP0 (I0_B_11_b0 B_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I120_MP0 (I0_A_11_b0 A_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I161_MP0 (I2_I1_I42_G3_0np I2_I1_I42_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I140_MP0 (I0_A_13_b0 A_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I193_MP0 (I2_I1_I42_G7_0n I2_I1_I42_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I130_MP0 (I0_A_12_b0 A_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I3_I40_MP0 (I2_I3_SEL_MUL_b0 I2_SEL_MUL VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I0_MP0 (I1_A_31_b0 A_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1712_I64_MP0 (I1_I1712_cinn I1_qu7_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1578_MP0 (I1_qu9_b0 I1_qu9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I191_MP0 (I1_I1574_G6_0n I1_I1574_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1574_I64_MP0 (I1_I1574_cinn I1_qu10_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I62_MP0 (I1_nak9 I1_nakn9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I593_MP0 (I0_one2_b0 I0_one2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I603_MP0 (I0_two2_b0 I0_two2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I758_MP0 (I0_one5_b0 I0_one5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I648_MP0 (I0_one3_b0 I0_one3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I658_MP0 (I0_two3_b0 I0_two3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I813_MP0 (I0_one6_b0 I0_one6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I823_MP0 (I0_two6_b0 I0_two6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I646_MP0 (I0_sn2 I0_pp2_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I66_MP0 (I1_I1666_G0_0n I1_I1666_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I53_MP0 (I1_nak6 I1_nakn6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I56_MP0 (I1_nak7 I1_nakn7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I59_MP0 (I1_nak8 I1_nakn8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I342_MP0 (I0_B_5_b0 B_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I352_MP0 (I0_B_7_b0 B_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I332_MP0 (I0_B_3_b0 B_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I0_MP0 (I0_B_1_b0 B_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I548_MP0 (I0_two1_b0 I0_two1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I538_MP0 (I0_one1_b0 I0_one1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I129_MP0 (I2_I1_I42_G1_0n I2_I1_I42_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I768_MP0 (I0_two5_b0 I0_two5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I701_MP0 (I0_sn3 I0_pp3_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I159_MP0 (I1_I1666_G2_0np I1_I1666_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I129_MP0 (I1_I1666_G1_0n I1_I1666_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I64_MP0 (I1_I1620_cinn I1_qu9_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I703_MP0 (I0_one4_b0 I0_one4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1716_MP0 (I1_qu6_b0 I1_qu6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I57_MP0 (I2_OR_9 I2_I2_nor9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I49_MP0 (I2_AND_8 I2_I2_nand8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I51_MP0 (I2_OR_8 I2_I2_nor8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I26_MP0 (I1_B_0_b0 B_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I66_MP0 (I2_I1_I42_G0_0n I2_I1_I42_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I362_MP0 (I0_B_9_b0 B_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I483_MP0 (I0_one0_b0 I0_one0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I493_MP0 (I0_two0_b0 I0_two0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I868_MP0 (I0_one7_b0 I0_one7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I878_MP0 (I0_two7_b0 I0_two7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1670_MP0 (I1_qu7_b0 I1_qu7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I187_MP0 (I1_I1666_G4_0n I1_I1666_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I161_MP0 (I1_I1666_G3_0np I1_I1666_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I55_MP0 (I2_AND_9 I2_I2_nand9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I61_MP0 (I2_AND_10 I2_I2_nand10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I43_MP0 (I2_AND_7 I2_I2_nand7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I713_MP0 (I0_two4_b0 I0_two4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I756_MP0 (I0_sn4 I0_pp4_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I189_MP0 (I1_I1666_G5_0n I1_I1666_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1624_MP0 (I1_qu8_b0 I1_qu8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I66_MP0 (I1_I1620_G0_0n I1_I1620_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I63_MP0 (I2_OR_10 I2_I2_nor10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I47_MP0 (I2_NOT_7 A_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I45_MP0 (I2_OR_7 I2_I2_nor7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I37_MP0 (I2_AND_6 I2_I2_nand6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I39_MP0 (I2_OR_6 I2_I2_nor6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I159_MP0 (I1_I1620_G2_0np I1_I1620_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I65_MP0 (I2_NOT_10 A_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I110_MP0 (I0_A_10_b0 A_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I191_MP0 (I1_I1666_G6_0n I1_I1666_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I191_MP0 (I1_I1620_G6_0n I1_I1620_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2107_MP0 (I1_nqk10 I1_nqkn10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I59_MP0 (I2_NOT_9 A_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I53_MP0 (I2_NOT_8 A_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I41_MP0 (I2_NOT_6 A_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I1_I42_I64_MP0 (I2_I1_I42_cinn I2_I1_SUB_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I811_MP0 (I0_sn5 I0_pp5_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1758_I193_MP0 (I1_I1758_G7_0n I1_I1758_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1666_I193_MP0 (I1_I1666_G7_0n I1_I1666_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I187_MP0 (I1_I1620_G4_0n I1_I1620_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I129_MP0 (I1_I1620_G1_0n I1_I1620_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2104_MP0 (I1_nqk9 I1_nqkn9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I80_MP0 (I0_A_7_b0 A_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1758_I189_MP0 (I1_I1758_G5_0n I1_I1758_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1758_I161_MP0 (I1_I1758_G3_0np I1_I1758_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I161_MP0 (I1_I1620_G3_0np I1_I1620_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2101_MP0 (I1_nqk8 I1_nqkn8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I33_MP0 (I2_OR_5 I2_I2_nor5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I31_MP0 (I2_AND_5 I2_I2_nand5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I100_MP0 (I0_A_9_b0 A_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I90_MP0 (I0_A_8_b0 A_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I70_MP0 (I0_A_6_b0 A_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1758_I129_MP0 (I1_I1758_G1_0n I1_I1758_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I189_MP0 (I1_I1620_G5_0n I1_I1620_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2098_MP0 (I1_nqk7 I1_nqkn7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I3_MP0 (I2_OR_0 I2_I2_nor0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1762_MP0 (I1_qu5_b0 I1_qu5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2095_MP0 (I1_nqk6 I1_nqkn6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I35_MP0 (I2_NOT_5 A_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I7_MP0 (I2_AND_1 I2_I2_nand1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I19_MP0 (I2_AND_3 I2_I2_nand3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I5_MP0 (I2_NOT_0 A_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I13_MP0 (I2_AND_2 I2_I2_nand2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I25_MP0 (I2_AND_4 I2_I2_nand4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I1_MP0 (I2_AND_0 I2_I2_nand0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1758_I191_MP0 (I1_I1758_G6_0n I1_I1758_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1758_I187_MP0 (I1_I1758_G4_0n I1_I1758_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1758_I159_MP0 (I1_I1758_G2_0np I1_I1758_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1620_I193_MP0 (I1_I1620_G7_0n I1_I1620_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I50_MP0 (I1_nak5 I1_nakn5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I9_MP0 (I2_OR_1 I2_I2_nor1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I15_MP0 (I2_OR_2 I2_I2_nor2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I27_MP0 (I2_OR_4 I2_I2_nor4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I60_MP0 (I0_A_5_b0 A_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I933_MP0 (I0_two8_b0 I0_two8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I923_MP0 (I0_one8_b0 I0_one8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1758_I66_MP0 (I1_I1758_G0_0n I1_I1758_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1758_I64_MP0 (I1_I1758_cinn I1_qu6_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I47_MP0 (I1_nak4 I1_nakn4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2092_MP0 (I1_nqk5 I1_nqkn5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I21_MP0 (I2_OR_3 I2_I2_nor3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I23_MP0 (I2_NOT_3 A_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I17_MP0 (I2_NOT_2 A_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I29_MP0 (I2_NOT_4 A_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I50_MP0 (I0_A_4_b0 A_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I20_MP0 (I0_A_1_b0 A_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1033_MP0 (I0_one10_b0 I0_one10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I41_MP0 (I1_nak2 I1_nakn2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I44_MP0 (I1_nak3 I1_nakn3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I2_I11_MP0 (I2_NOT_1 A_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I40_MP0 (I0_A_3_b0 A_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1660_I128_MP0 (I0_I1660_cinn VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I988_MP0 (I0_two9_b0 I0_two9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1043_MP0 (I0_two10_b0 I0_two10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1804_I64_MP0 (I1_I1804_cinn I1_qu5_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1896_I64_MP0 (I1_I1896_cinn I1_qu3_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I38_MP0 (I1_nak1 I1_nakn1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2089_MP0 (I1_nqk4 I1_nqkn4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2086_MP0 (I1_nqk3 I1_nqkn3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2083_MP0 (I1_nqk2 I1_nqkn2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2080_MP0 (I1_nqk1 I1_nqkn1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I10_MP0 (I0_A_0_b0 A_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I30_MP0 (I0_A_2_b0 A_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I978_MP0 (I0_one9_b0 I0_one9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1850_I64_MP0 (I1_I1850_cinn I1_qu4_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1942_I64_MP0 (I1_I1942_cinn I1_qu2_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2001_MP0 (DIVQ_0 I1_p31_32_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2005_MP0 (I1_dm1 I1_dmn1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1804_I66_MP0 (I1_I1804_G0_0n I1_I1804_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2007_MP0 (I1_dm2 I1_dmn2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1988_I64_MP0 (I1_I1988_cinn I1_qu1_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2003_MP0 (I1_dm0 I1_dmn0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2066_I64_MP0 (I1_I2066_cinn VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1804_I191_MP0 (I1_I1804_G6_0n I1_I1804_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1804_I187_MP0 (I1_I1804_G4_0n I1_I1804_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1804_I159_MP0 (I1_I1804_G2_0np I1_I1804_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1896_I66_MP0 (I1_I1896_G0_0n I1_I1896_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1942_I66_MP0 (I1_I1942_G0_0n I1_I1942_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2011_MP0 (I1_dm4 I1_dmn4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2009_MP0 (I1_dm3 I1_dmn3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1942_I129_MP0 (I1_I1942_G1_0n I1_I1942_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1988_I66_MP0 (I1_I1988_G0_0n I1_I1988_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2015_MP0 (I1_dm6 I1_dmn6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2013_MP0 (I1_dm5 I1_dmn5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1660_I385_MP0 (I0_I1660_G7_0n I0_I1660_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1804_I129_MP0 (I1_I1804_G1_0n I1_I1804_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1942_I159_MP0 (I1_I1942_G2_0np I1_I1942_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1988_I129_MP0 (I1_I1988_G1_0n I1_I1988_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2021_MP0 (I1_dm9 I1_dmn9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2019_MP0 (I1_dm8 I1_dmn8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2017_MP0 (I1_dm7 I1_dmn7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1660_I257_MP0 (I0_I1660_G1_0n I0_I1660_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1660_I321_MP0 (I0_I1660_G3_0np I0_I1660_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1660_I381_MP0 (I0_I1660_G5_0n I0_I1660_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1088_MP0 (I0_one11_b0 I0_one11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1804_I189_MP0 (I1_I1804_G5_0n I1_I1804_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1896_I129_MP0 (I1_I1896_G1_0n I1_I1896_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1942_I161_MP0 (I1_I1942_G3_0np I1_I1942_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1988_I159_MP0 (I1_I1988_G2_0np I1_I1988_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2023_MP0 (I1_dm10 I1_dmn10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1660_I130_MP0 (I0_I1660_G0_0n I0_I1660_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2172_MP0 (I1_nrk1 I1_nrkn1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1660_I441_MP0 (I0_I1660_G11_0np I0_I1660_G11_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1208_MP0 (I0_two13_b0 I0_two13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1198_MP0 (I0_one13_b0 I0_one13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1153_MP0 (I0_two12_b0 I0_two12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1143_MP0 (I0_one12_b0 I0_one12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1098_MP0 (I0_two11_b0 I0_two11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1804_I161_MP0 (I1_I1804_G3_0np I1_I1804_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1988_I161_MP0 (I1_I1988_G3_0np I1_I1988_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2025_MP0 (I1_dm11 I1_dmn11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2066_I66_MP0 (I1_I2066_G0_0n I1_I2066_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1660_I379_MP0 (I0_I1660_G4_0n I0_I1660_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1660_I437_MP0 (I0_I1660_G9_0np I0_I1660_G9_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1660_I449_MP0 (I0_I1660_G15_0np I0_I1660_G15_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1253_MP0 (I0_one14_b0 I0_one14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1263_MP0 (I0_two14_b0 I0_two14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1308_MP0 (I0_one15_b0 I0_one15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1318_MP0 (I0_two15_b0 I0_two15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1808_MP0 (I1_qu4_b0 I1_qu4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1804_I193_MP0 (I1_I1804_G7_0n I1_I1804_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1850_I66_MP0 (I1_I1850_G0_0n I1_I1850_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1896_I159_MP0 (I1_I1896_G2_0np I1_I1896_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2027_MP0 (I1_dm12 I1_dmn12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2066_I129_MP0 (I1_I2066_G1_0n I1_I2066_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2175_MP0 (I1_nrk2 I1_nrkn2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2178_MP0 (I1_nrk3 I1_nrkn3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2181_MP0 (I1_nrk4 I1_nrkn4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1660_I319_MP0 (I0_I1660_G2_0np I0_I1660_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1660_I435_MP0 (I0_I1660_G8_0np I0_I1660_G8_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1660_I445_MP0 (I0_I1660_G13_0np I0_I1660_G13_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1850_I161_MP0 (I1_I1850_G3_0np I1_I1850_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1850_I129_MP0 (I1_I1850_G1_0n I1_I1850_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1896_I161_MP0 (I1_I1896_G3_0np I1_I1896_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1942_I189_MP0 (I1_I1942_G5_0n I1_I1942_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1942_I187_MP0 (I1_I1942_G4_0n I1_I1942_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1988_I189_MP0 (I1_I1988_G5_0n I1_I1988_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2031_MP0 (I1_dm14 I1_dmn14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1988_I187_MP0 (I1_I1988_G4_0n I1_I1988_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2029_MP0 (I1_dm13 I1_dmn13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2187_MP0 (I1_nrk6 I1_nrkn6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2184_MP0 (I1_nrk5 I1_nrkn5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1660_I443_MP0 (I0_I1660_G12_0np I0_I1660_G12_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1660_I532_MP0 (I0_kco I0_I1660_G63_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1854_MP0 (I1_qu3_b0 I1_qu3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1896_I187_MP0 (I1_I1896_G4_0n I1_I1896_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2033_MP0 (I1_dm15 I1_dmn15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2066_I159_MP0 (I1_I2066_G2_0np I1_I2066_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2190_MP0 (I1_nrk7 I1_nrkn7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2196_MP0 (I1_nrk9 I1_nrkn9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I866_MP0 (I0_sn6 I0_pp6_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1850_I189_MP0 (I1_I1850_G5_0n I1_I1850_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1942_I191_MP0 (I1_I1942_G6_0n I1_I1942_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2035_MP0 (I1_dm16 I1_dmn16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2037_MP0 (I1_dm17 I1_dmn17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1988_I191_MP0 (I1_I1988_G6_0n I1_I1988_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2066_I161_MP0 (I1_I2066_G3_0np I1_I2066_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2193_MP0 (I1_nrk8 I1_nrkn8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2199_MP0 (I1_nrk10 I1_nrkn10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1660_I383_MP0 (I0_I1660_G6_0n I0_I1660_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1660_I439_MP0 (I0_I1660_G10_0np I0_I1660_G10_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1196_MP0 (I0_sn12 I0_pp12_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1850_I193_MP0 (I1_I1850_G7_0n I1_I1850_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1850_I187_MP0 (I1_I1850_G4_0n I1_I1850_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1850_I159_MP0 (I1_I1850_G2_0np I1_I1850_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1896_I189_MP0 (I1_I1896_G5_0n I1_I1896_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1942_I193_MP0 (I1_I1942_G7_0n I1_I1942_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1988_I193_MP0 (I1_I1988_G7_0n I1_I1988_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2039_MP0 (I1_dm18 I1_dmn18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2066_I187_MP0 (I1_I2066_G4_0n I1_I2066_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2202_MP0 (I1_nrk11 I1_nrkn11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2208_MP0 (I1_nrk13 I1_nrkn13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2205_MP0 (I1_nrk12 I1_nrkn12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1141_MP0 (I0_sn11 I0_pp11_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1086_MP0 (I0_sn10 I0_pp10_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I921_MP0 (I0_sn7 I0_pp7_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2041_MP0 (I1_dm19 I1_dmn19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2043_MP0 (I1_dm20 I1_dmn20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2066_I189_MP0 (I1_I2066_G5_0n I1_I2066_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2211_MP0 (I1_nrk14 I1_nrkn14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2226_MP0 (I1_nrk19 I1_nrkn19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2223_MP0 (I1_nrk18 I1_nrkn18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2220_MP0 (I1_nrk17 I1_nrkn17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1660_I447_MP0 (I0_I1660_G14_0np I0_I1660_G14_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1850_I191_MP0 (I1_I1850_G6_0n I1_I1850_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1896_I193_MP0 (I1_I1896_G7_0n I1_I1896_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1896_I191_MP0 (I1_I1896_G6_0n I1_I1896_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1991_MP0 (I1_p31_32_b0 I1_p31_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2045_MP0 (I1_dm21 I1_dmn21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2066_I193_MP0 (I1_I2066_G7_0n I1_I2066_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2229_MP0 (I1_nrk20 I1_nrkn20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2214_MP0 (I1_nrk15 I1_nrkn15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2217_MP0 (I1_nrk16 I1_nrkn16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2047_MP0 (I1_dm22 I1_dmn22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2049_MP0 (I1_dm23 I1_dmn23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2066_I191_MP0 (I1_I2066_G6_0n I1_I2066_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2232_MP0 (I1_nrk21 I1_nrkn21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2241_MP0 (I1_nrk24 I1_nrkn24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1251_MP0 (I0_sn13 I0_pp13_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1946_MP0 (I1_qu1_b0 I1_qu1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2051_MP0 (I1_dm24 I1_dmn24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2055_MP0 (I1_dm26 I1_dmn26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2053_MP0 (I1_dm25 I1_dmn25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2235_MP0 (I1_nrk22 I1_nrkn22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2238_MP0 (I1_nrk23 I1_nrkn23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2244_MP0 (I1_nrk25 I1_nrkn25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1900_MP0 (I1_qu2_b0 I1_qu2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2057_MP0 (I1_dm27 I1_dmn27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2059_MP0 (I1_dm28 I1_dmn28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2259_MP0 (I1_nrk30 I1_nrkn30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2256_MP0 (I1_nrk29 I1_nrkn29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2247_MP0 (I1_nrk26 I1_nrkn26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1660_I531_MP0 (I0_kcm I0_I1660_G62_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I976_MP0 (I0_sn8 I0_pp8_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2065_MP0 (I1_dm31 I1_dmn31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2063_MP0 (I1_dm30 I1_dmn30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2061_MP0 (I1_dm29 I1_dmn29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2250_MP0 (I1_nrk27 I1_nrkn27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I2253_MP0 (I1_nrk28 I1_nrkn28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI2_I4_I63_MP0 (Z I2_I4_z5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1361_MP0 (I0_sn15 I0_pp15_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1306_MP0 (I0_sn14 I0_pp14_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1031_MP0 (I0_sn9 I0_pp9_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I647_MP9 (XI0_I647_ap1 B_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I647_MP11 (I0_one3 XI0_I647_aan XI0_I647_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I647_MP12 (XI0_I647_ap1 XI0_I647_abn I0_one3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I647_MP10 (VDD I0_B_5_b3_5 XI0_I647_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I647_MP2 (VDD B_6 XI0_I647_aan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I647_MP4 (XI0_I647_abn I0_B_5_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I647_MP16 (XI0_I647_bbn B_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I647_MP14 (XI0_I647_ban I0_B_7_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I647_MP23 (XI0_I647_e XI0_I647_ban XI0_I647_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I647_MP24 (XI0_I647_bp1 B_6 XI0_I647_e VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I647_MP22 (VDD XI0_I647_bbn XI0_I647_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I647_MP21 (XI0_I647_bp1 I0_B_7_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I647_MP28 (XI0_I647_cp I0_one3 I0_two3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I647_MP27 (VDD XI0_I647_e XI0_I647_cp VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I812_MP9 (XI0_I812_ap1 B_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I812_MP11 (I0_one6 XI0_I812_aan XI0_I812_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I812_MP12 (XI0_I812_ap1 XI0_I812_abn I0_one6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I812_MP10 (VDD I0_B_11_b3_5 XI0_I812_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I812_MP2 (VDD B_12 XI0_I812_aan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I812_MP4 (XI0_I812_abn I0_B_11_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I812_MP16 (XI0_I812_bbn B_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I812_MP14 (XI0_I812_ban I0_B_13_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I812_MP23 (XI0_I812_e XI0_I812_ban XI0_I812_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I812_MP24 (XI0_I812_bp1 B_12 XI0_I812_e VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I812_MP22 (VDD XI0_I812_bbn XI0_I812_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I812_MP21 (XI0_I812_bp1 I0_B_13_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I812_MP28 (XI0_I812_cp I0_one6 I0_two6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I812_MP27 (VDD XI0_I812_e XI0_I812_cp VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I757_MP9 (XI0_I757_ap1 B_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I757_MP11 (I0_one5 XI0_I757_aan XI0_I757_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I757_MP12 (XI0_I757_ap1 XI0_I757_abn I0_one5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I757_MP10 (VDD I0_B_9_b3_5 XI0_I757_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I757_MP2 (VDD B_10 XI0_I757_aan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I757_MP4 (XI0_I757_abn I0_B_9_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I757_MP16 (XI0_I757_bbn B_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I757_MP14 (XI0_I757_ban I0_B_11_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I757_MP23 (XI0_I757_e XI0_I757_ban XI0_I757_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I757_MP24 (XI0_I757_bp1 B_10 XI0_I757_e VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I757_MP22 (VDD XI0_I757_bbn XI0_I757_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I757_MP21 (XI0_I757_bp1 I0_B_11_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I757_MP28 (XI0_I757_cp I0_one5 I0_two5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I757_MP27 (VDD XI0_I757_e XI0_I757_cp VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I592_MP9 (XI0_I592_ap1 B_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I592_MP11 (I0_one2 XI0_I592_aan XI0_I592_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I592_MP12 (XI0_I592_ap1 XI0_I592_abn I0_one2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I592_MP10 (VDD I0_B_3_b3_5 XI0_I592_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I592_MP2 (VDD B_4 XI0_I592_aan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I592_MP4 (XI0_I592_abn I0_B_3_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I592_MP16 (XI0_I592_bbn B_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I592_MP14 (XI0_I592_ban I0_B_5_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I592_MP23 (XI0_I592_e XI0_I592_ban XI0_I592_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I592_MP24 (XI0_I592_bp1 B_4 XI0_I592_e VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I592_MP22 (VDD XI0_I592_bbn XI0_I592_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I592_MP21 (XI0_I592_bp1 I0_B_5_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I592_MP28 (XI0_I592_cp I0_one2 I0_two2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I592_MP27 (VDD XI0_I592_e XI0_I592_cp VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I537_MP9 (XI0_I537_ap1 B_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I537_MP11 (I0_one1 XI0_I537_aan XI0_I537_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I537_MP12 (XI0_I537_ap1 XI0_I537_abn I0_one1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I537_MP10 (VDD I0_B_1_b3_5 XI0_I537_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I537_MP2 (VDD B_2 XI0_I537_aan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I537_MP4 (XI0_I537_abn I0_B_1_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I537_MP16 (XI0_I537_bbn B_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I537_MP14 (XI0_I537_ban I0_B_3_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I537_MP23 (XI0_I537_e XI0_I537_ban XI0_I537_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I537_MP24 (XI0_I537_bp1 B_2 XI0_I537_e VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I537_MP22 (VDD XI0_I537_bbn XI0_I537_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I537_MP21 (XI0_I537_bp1 I0_B_3_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I537_MP28 (XI0_I537_cp I0_one1 I0_two1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I537_MP27 (VDD XI0_I537_e XI0_I537_cp VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I482_MP9 (XI0_I482_ap1 B_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I482_MP11 (I0_one0 XI0_I482_aan XI0_I482_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I482_MP12 (XI0_I482_ap1 XI0_I482_abn I0_one0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I482_MP10 (VDD VSS XI0_I482_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I482_MP2 (VDD B_0 XI0_I482_aan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I482_MP4 (XI0_I482_abn VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I482_MP16 (XI0_I482_bbn B_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I482_MP14 (XI0_I482_ban I0_B_1_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I482_MP23 (XI0_I482_e XI0_I482_ban XI0_I482_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I482_MP24 (XI0_I482_bp1 B_0 XI0_I482_e VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I482_MP22 (VDD XI0_I482_bbn XI0_I482_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I482_MP21 (XI0_I482_bp1 I0_B_1_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I482_MP28 (XI0_I482_cp I0_one0 I0_two0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I482_MP27 (VDD XI0_I482_e XI0_I482_cp VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I702_MP9 (XI0_I702_ap1 B_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I702_MP11 (I0_one4 XI0_I702_aan XI0_I702_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I702_MP12 (XI0_I702_ap1 XI0_I702_abn I0_one4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I702_MP10 (VDD I0_B_7_b3_5 XI0_I702_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I702_MP2 (VDD B_8 XI0_I702_aan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I702_MP4 (XI0_I702_abn I0_B_7_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I702_MP16 (XI0_I702_bbn B_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I702_MP14 (XI0_I702_ban I0_B_9_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I702_MP23 (XI0_I702_e XI0_I702_ban XI0_I702_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I702_MP24 (XI0_I702_bp1 B_8 XI0_I702_e VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I702_MP22 (VDD XI0_I702_bbn XI0_I702_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I702_MP21 (XI0_I702_bp1 I0_B_9_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I702_MP28 (XI0_I702_cp I0_one4 I0_two4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I702_MP27 (VDD XI0_I702_e XI0_I702_cp VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I867_MP9 (XI0_I867_ap1 B_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I867_MP11 (I0_one7 XI0_I867_aan XI0_I867_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I867_MP12 (XI0_I867_ap1 XI0_I867_abn I0_one7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I867_MP10 (VDD I0_B_13_b3_5 XI0_I867_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I867_MP2 (VDD B_14 XI0_I867_aan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I867_MP4 (XI0_I867_abn I0_B_13_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I867_MP16 (XI0_I867_bbn B_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I867_MP14 (XI0_I867_ban I0_B_15_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I867_MP23 (XI0_I867_e XI0_I867_ban XI0_I867_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I867_MP24 (XI0_I867_bp1 B_14 XI0_I867_e VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I867_MP22 (VDD XI0_I867_bbn XI0_I867_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I867_MP21 (XI0_I867_bp1 I0_B_15_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I867_MP28 (XI0_I867_cp I0_one7 I0_two7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I867_MP27 (VDD XI0_I867_e XI0_I867_cp VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I922_MP9 (XI0_I922_ap1 B_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I922_MP11 (I0_one8 XI0_I922_aan XI0_I922_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I922_MP12 (XI0_I922_ap1 XI0_I922_abn I0_one8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I922_MP10 (VDD I0_B_15_b3_5 XI0_I922_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I922_MP2 (VDD B_16 XI0_I922_aan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I922_MP4 (XI0_I922_abn I0_B_15_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I922_MP16 (XI0_I922_bbn B_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I922_MP14 (XI0_I922_ban I0_B_17_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I922_MP23 (XI0_I922_e XI0_I922_ban XI0_I922_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I922_MP24 (XI0_I922_bp1 B_16 XI0_I922_e VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I922_MP22 (VDD XI0_I922_bbn XI0_I922_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I922_MP21 (XI0_I922_bp1 I0_B_17_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I922_MP28 (XI0_I922_cp I0_one8 I0_two8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I922_MP27 (VDD XI0_I922_e XI0_I922_cp VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1032_MP9 (XI0_I1032_ap1 B_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1032_MP11 (I0_one10 XI0_I1032_aan XI0_I1032_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1032_MP12 (XI0_I1032_ap1 XI0_I1032_abn I0_one10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1032_MP10 (VDD I0_B_19_b3_5 XI0_I1032_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1032_MP2 (VDD B_20 XI0_I1032_aan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1032_MP4 (XI0_I1032_abn I0_B_19_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1032_MP16 (XI0_I1032_bbn B_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1032_MP14 (XI0_I1032_ban I0_B_21_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1032_MP23 (XI0_I1032_e XI0_I1032_ban XI0_I1032_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1032_MP24 (XI0_I1032_bp1 B_20 XI0_I1032_e VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1032_MP22 (VDD XI0_I1032_bbn XI0_I1032_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1032_MP21 (XI0_I1032_bp1 I0_B_21_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1032_MP28 (XI0_I1032_cp I0_one10 I0_two10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1032_MP27 (VDD XI0_I1032_e XI0_I1032_cp VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I977_MP9 (XI0_I977_ap1 B_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I977_MP11 (I0_one9 XI0_I977_aan XI0_I977_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I977_MP12 (XI0_I977_ap1 XI0_I977_abn I0_one9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I977_MP10 (VDD I0_B_17_b3_5 XI0_I977_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I977_MP2 (VDD B_18 XI0_I977_aan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I977_MP4 (XI0_I977_abn I0_B_17_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I977_MP16 (XI0_I977_bbn B_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I977_MP14 (XI0_I977_ban I0_B_19_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I977_MP23 (XI0_I977_e XI0_I977_ban XI0_I977_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I977_MP24 (XI0_I977_bp1 B_18 XI0_I977_e VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I977_MP22 (VDD XI0_I977_bbn XI0_I977_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I977_MP21 (XI0_I977_bp1 I0_B_19_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I977_MP28 (XI0_I977_cp I0_one9 I0_two9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I977_MP27 (VDD XI0_I977_e XI0_I977_cp VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1197_MP9 (XI0_I1197_ap1 B_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1197_MP11 (I0_one13 XI0_I1197_aan XI0_I1197_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1197_MP12 (XI0_I1197_ap1 XI0_I1197_abn I0_one13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1197_MP10 (VDD I0_B_25_b3_5 XI0_I1197_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1197_MP2 (VDD B_26 XI0_I1197_aan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1197_MP4 (XI0_I1197_abn I0_B_25_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1197_MP16 (XI0_I1197_bbn B_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1197_MP14 (XI0_I1197_ban I0_B_27_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1197_MP23 (XI0_I1197_e XI0_I1197_ban XI0_I1197_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1197_MP24 (XI0_I1197_bp1 B_26 XI0_I1197_e VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1197_MP22 (VDD XI0_I1197_bbn XI0_I1197_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1197_MP21 (XI0_I1197_bp1 I0_B_27_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1197_MP28 (XI0_I1197_cp I0_one13 I0_two13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1197_MP27 (VDD XI0_I1197_e XI0_I1197_cp VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1142_MP9 (XI0_I1142_ap1 B_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1142_MP11 (I0_one12 XI0_I1142_aan XI0_I1142_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1142_MP12 (XI0_I1142_ap1 XI0_I1142_abn I0_one12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1142_MP10 (VDD I0_B_23_b3_5 XI0_I1142_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1142_MP2 (VDD B_24 XI0_I1142_aan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1142_MP4 (XI0_I1142_abn I0_B_23_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1142_MP16 (XI0_I1142_bbn B_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1142_MP14 (XI0_I1142_ban I0_B_25_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1142_MP23 (XI0_I1142_e XI0_I1142_ban XI0_I1142_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1142_MP24 (XI0_I1142_bp1 B_24 XI0_I1142_e VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1142_MP22 (VDD XI0_I1142_bbn XI0_I1142_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1142_MP21 (XI0_I1142_bp1 I0_B_25_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1142_MP28 (XI0_I1142_cp I0_one12 I0_two12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1142_MP27 (VDD XI0_I1142_e XI0_I1142_cp VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1087_MP9 (XI0_I1087_ap1 B_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1087_MP11 (I0_one11 XI0_I1087_aan XI0_I1087_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1087_MP12 (XI0_I1087_ap1 XI0_I1087_abn I0_one11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1087_MP10 (VDD I0_B_21_b3_5 XI0_I1087_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1087_MP2 (VDD B_22 XI0_I1087_aan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1087_MP4 (XI0_I1087_abn I0_B_21_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1087_MP16 (XI0_I1087_bbn B_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1087_MP14 (XI0_I1087_ban I0_B_23_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1087_MP23 (XI0_I1087_e XI0_I1087_ban XI0_I1087_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1087_MP24 (XI0_I1087_bp1 B_22 XI0_I1087_e VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1087_MP22 (VDD XI0_I1087_bbn XI0_I1087_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1087_MP21 (XI0_I1087_bp1 I0_B_23_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1087_MP28 (XI0_I1087_cp I0_one11 I0_two11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1087_MP27 (VDD XI0_I1087_e XI0_I1087_cp VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1307_MP9 (XI0_I1307_ap1 B_30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1307_MP11 (I0_one15 XI0_I1307_aan XI0_I1307_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1307_MP12 (XI0_I1307_ap1 XI0_I1307_abn I0_one15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1307_MP10 (VDD I0_B_29_b3_5 XI0_I1307_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1307_MP2 (VDD B_30 XI0_I1307_aan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1307_MP4 (XI0_I1307_abn I0_B_29_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1307_MP16 (XI0_I1307_bbn B_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1307_MP14 (XI0_I1307_ban I0_B_31_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1307_MP23 (XI0_I1307_e XI0_I1307_ban XI0_I1307_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1307_MP24 (XI0_I1307_bp1 B_30 XI0_I1307_e VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1307_MP22 (VDD XI0_I1307_bbn XI0_I1307_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1307_MP21 (XI0_I1307_bp1 I0_B_31_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1307_MP28 (XI0_I1307_cp I0_one15 I0_two15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1307_MP27 (VDD XI0_I1307_e XI0_I1307_cp VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1252_MP9 (XI0_I1252_ap1 B_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1252_MP11 (I0_one14 XI0_I1252_aan XI0_I1252_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1252_MP12 (XI0_I1252_ap1 XI0_I1252_abn I0_one14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1252_MP10 (VDD I0_B_27_b3_5 XI0_I1252_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1252_MP2 (VDD B_28 XI0_I1252_aan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1252_MP4 (XI0_I1252_abn I0_B_27_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1252_MP16 (XI0_I1252_bbn B_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1252_MP14 (XI0_I1252_ban I0_B_29_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1252_MP23 (XI0_I1252_e XI0_I1252_ban XI0_I1252_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1252_MP24 (XI0_I1252_bp1 B_28 XI0_I1252_e VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1252_MP22 (VDD XI0_I1252_bbn XI0_I1252_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1252_MP21 (XI0_I1252_bp1 I0_B_29_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1252_MP28 (XI0_I1252_cp I0_one14 I0_two14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1252_MP27 (VDD XI0_I1252_e XI0_I1252_cp VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1346_MP1 (VDD I1_c17_o XI1_I1346_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1346_MP5 (I1_p17_32 XI1_I1346_Bn XI1_I1346_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1346_MP4 (XI1_I1346_p1 XI1_I1346_An I1_p17_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1346_MP2 (VDD I1_h17 XI1_I1346_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1346_MP3 (XI1_I1346_p1 I1_c17_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1346_MP0 (VDD I1_h17 XI1_I1346_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1345_MP1 (VDD I1_qu15_b3_5 XI1_I1345_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1345_MP5 (I1_h17 XI1_I1345_Bn XI1_I1345_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1345_MP4 (XI1_I1345_p1 XI1_I1345_An I1_h17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1345_MP2 (VDD I1_p16_31 XI1_I1345_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1345_MP3 (XI1_I1345_p1 I1_qu15_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1345_MP0 (VDD I1_p16_31 XI1_I1345_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1300_MP1 (VDD I1_c16_o XI1_I1300_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1300_MP5 (I1_p16_32 XI1_I1300_Bn XI1_I1300_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1300_MP4 (XI1_I1300_p1 XI1_I1300_An I1_p16_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1300_MP2 (VDD I1_h16 XI1_I1300_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1300_MP3 (XI1_I1300_p1 I1_c16_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1300_MP0 (VDD I1_h16 XI1_I1300_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1295_MP1 (VDD I1_qu16_b3_4 XI1_I1295_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1295_MP5 (I1_b16_29 XI1_I1295_Bn XI1_I1295_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1295_MP4 (XI1_I1295_p1 XI1_I1295_An I1_b16_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1295_MP2 (VDD I1_dd29_b3_2 XI1_I1295_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1295_MP3 (XI1_I1295_p1 I1_qu16_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1295_MP0 (VDD I1_dd29_b3_2 XI1_I1295_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1299_MP1 (VDD I1_qu16_b3_5 XI1_I1299_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1299_MP5 (I1_h16 XI1_I1299_Bn XI1_I1299_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1299_MP4 (XI1_I1299_p1 XI1_I1299_An I1_h16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1299_MP2 (VDD I1_p15_31 XI1_I1299_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1299_MP3 (XI1_I1299_p1 I1_qu16_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1299_MP0 (VDD I1_p15_31 XI1_I1299_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1297_MP1 (VDD I1_qu16_b3_5 XI1_I1297_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1297_MP5 (I1_b16_31 XI1_I1297_Bn XI1_I1297_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1297_MP4 (XI1_I1297_p1 XI1_I1297_An I1_b16_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1297_MP2 (VDD I1_dd31_b3_2 XI1_I1297_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1297_MP3 (XI1_I1297_p1 I1_qu16_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1297_MP0 (VDD I1_dd31_b3_2 XI1_I1297_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1296_MP1 (VDD I1_qu16_b3_5 XI1_I1296_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1296_MP5 (I1_b16_30 XI1_I1296_Bn XI1_I1296_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1296_MP4 (XI1_I1296_p1 XI1_I1296_An I1_b16_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1296_MP2 (VDD I1_dd30_b3_2 XI1_I1296_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1296_MP3 (XI1_I1296_p1 I1_qu16_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1296_MP0 (VDD I1_dd30_b3_2 XI1_I1296_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1249_MP1 (VDD I1_qu17_b3_4 XI1_I1249_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1249_MP5 (I1_b15_29 XI1_I1249_Bn XI1_I1249_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1249_MP4 (XI1_I1249_p1 XI1_I1249_An I1_b15_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1249_MP2 (VDD I1_dd29_b3_2 XI1_I1249_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1249_MP3 (XI1_I1249_p1 I1_qu17_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1249_MP0 (VDD I1_dd29_b3_2 XI1_I1249_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1250_MP1 (VDD I1_qu17_b3_5 XI1_I1250_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1250_MP5 (I1_b15_30 XI1_I1250_Bn XI1_I1250_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1250_MP4 (XI1_I1250_p1 XI1_I1250_An I1_b15_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1250_MP2 (VDD I1_dd30_b3_2 XI1_I1250_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1250_MP3 (XI1_I1250_p1 I1_qu17_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1250_MP0 (VDD I1_dd30_b3_2 XI1_I1250_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1203_MP1 (VDD I1_qu18_b3_4 XI1_I1203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1203_MP5 (I1_b14_29 XI1_I1203_Bn XI1_I1203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1203_MP4 (XI1_I1203_p1 XI1_I1203_An I1_b14_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1203_MP2 (VDD I1_dd29_b3_2 XI1_I1203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1203_MP3 (XI1_I1203_p1 I1_qu18_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1203_MP0 (VDD I1_dd29_b3_2 XI1_I1203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I840_MP1 (VDD I1_c6_o XI1_I840_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I840_MP5 (I1_p6_32 XI1_I840_Bn XI1_I840_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I840_MP4 (XI1_I840_p1 XI1_I840_An I1_p6_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I840_MP2 (VDD I1_h6 XI1_I840_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I840_MP3 (XI1_I840_p1 I1_c6_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I840_MP0 (VDD I1_h6 XI1_I840_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I839_MP1 (VDD I1_qu26_b3_5 XI1_I839_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I839_MP5 (I1_h6 XI1_I839_Bn XI1_I839_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I839_MP4 (XI1_I839_p1 XI1_I839_An I1_h6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I839_MP2 (VDD I1_p5_31 XI1_I839_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I839_MP3 (XI1_I839_p1 I1_qu26_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I839_MP0 (VDD I1_p5_31 XI1_I839_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I794_MP1 (VDD I1_c5_o XI1_I794_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I794_MP5 (I1_p5_32 XI1_I794_Bn XI1_I794_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I794_MP4 (XI1_I794_p1 XI1_I794_An I1_p5_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I794_MP2 (VDD I1_h5 XI1_I794_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I794_MP3 (XI1_I794_p1 I1_c5_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I794_MP0 (VDD I1_h5 XI1_I794_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1343_MP1 (VDD I1_qu15_b3_5 XI1_I1343_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1343_MP5 (I1_b17_31 XI1_I1343_Bn XI1_I1343_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1343_MP4 (XI1_I1343_p1 XI1_I1343_An I1_b17_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1343_MP2 (VDD I1_dd31_b3_3 XI1_I1343_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1343_MP3 (XI1_I1343_p1 I1_qu15_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1343_MP0 (VDD I1_dd31_b3_3 XI1_I1343_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1342_MP1 (VDD I1_qu15_b3_5 XI1_I1342_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1342_MP5 (I1_b17_30 XI1_I1342_Bn XI1_I1342_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1342_MP4 (XI1_I1342_p1 XI1_I1342_An I1_b17_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1342_MP2 (VDD I1_dd30_b3_3 XI1_I1342_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1342_MP3 (XI1_I1342_p1 I1_qu15_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1342_MP0 (VDD I1_dd30_b3_3 XI1_I1342_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1293_MP1 (VDD I1_qu16_b3_4 XI1_I1293_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1293_MP5 (I1_b16_27 XI1_I1293_Bn XI1_I1293_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1293_MP4 (XI1_I1293_p1 XI1_I1293_An I1_b16_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1293_MP2 (VDD I1_dd27_b3_2 XI1_I1293_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1293_MP3 (XI1_I1293_p1 I1_qu16_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1293_MP0 (VDD I1_dd27_b3_2 XI1_I1293_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1294_MP1 (VDD I1_qu16_b3_4 XI1_I1294_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1294_MP5 (I1_b16_28 XI1_I1294_Bn XI1_I1294_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1294_MP4 (XI1_I1294_p1 XI1_I1294_An I1_b16_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1294_MP2 (VDD I1_dd28_b3_2 XI1_I1294_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1294_MP3 (XI1_I1294_p1 I1_qu16_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1294_MP0 (VDD I1_dd28_b3_2 XI1_I1294_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1292_MP1 (VDD I1_qu16_b3_4 XI1_I1292_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1292_MP5 (I1_b16_26 XI1_I1292_Bn XI1_I1292_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1292_MP4 (XI1_I1292_p1 XI1_I1292_An I1_b16_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1292_MP2 (VDD I1_dd26_b3_2 XI1_I1292_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1292_MP3 (XI1_I1292_p1 I1_qu16_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1292_MP0 (VDD I1_dd26_b3_2 XI1_I1292_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1254_MP1 (VDD I1_c15_o XI1_I1254_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1254_MP5 (I1_p15_32 XI1_I1254_Bn XI1_I1254_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1254_MP4 (XI1_I1254_p1 XI1_I1254_An I1_p15_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1254_MP2 (VDD I1_h15 XI1_I1254_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1254_MP3 (XI1_I1254_p1 I1_c15_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1254_MP0 (VDD I1_h15 XI1_I1254_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1246_MP1 (VDD I1_qu17_b3_4 XI1_I1246_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1246_MP5 (I1_b15_26 XI1_I1246_Bn XI1_I1246_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1246_MP4 (XI1_I1246_p1 XI1_I1246_An I1_b15_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1246_MP2 (VDD I1_dd26_b3_2 XI1_I1246_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1246_MP3 (XI1_I1246_p1 I1_qu17_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1246_MP0 (VDD I1_dd26_b3_2 XI1_I1246_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1248_MP1 (VDD I1_qu17_b3_4 XI1_I1248_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1248_MP5 (I1_b15_28 XI1_I1248_Bn XI1_I1248_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1248_MP4 (XI1_I1248_p1 XI1_I1248_An I1_b15_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1248_MP2 (VDD I1_dd28_b3_2 XI1_I1248_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1248_MP3 (XI1_I1248_p1 I1_qu17_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1248_MP0 (VDD I1_dd28_b3_2 XI1_I1248_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1247_MP1 (VDD I1_qu17_b3_4 XI1_I1247_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1247_MP5 (I1_b15_27 XI1_I1247_Bn XI1_I1247_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1247_MP4 (XI1_I1247_p1 XI1_I1247_An I1_b15_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1247_MP2 (VDD I1_dd27_b3_2 XI1_I1247_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1247_MP3 (XI1_I1247_p1 I1_qu17_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1247_MP0 (VDD I1_dd27_b3_2 XI1_I1247_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1253_MP1 (VDD I1_qu17_b3_5 XI1_I1253_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1253_MP5 (I1_h15 XI1_I1253_Bn XI1_I1253_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1253_MP4 (XI1_I1253_p1 XI1_I1253_An I1_h15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1253_MP2 (VDD I1_p14_31 XI1_I1253_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1253_MP3 (XI1_I1253_p1 I1_qu17_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1253_MP0 (VDD I1_p14_31 XI1_I1253_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1251_MP1 (VDD I1_qu17_b3_5 XI1_I1251_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1251_MP5 (I1_b15_31 XI1_I1251_Bn XI1_I1251_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1251_MP4 (XI1_I1251_p1 XI1_I1251_An I1_b15_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1251_MP2 (VDD I1_dd31_b3_2 XI1_I1251_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1251_MP3 (XI1_I1251_p1 I1_qu17_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1251_MP0 (VDD I1_dd31_b3_2 XI1_I1251_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1202_MP1 (VDD I1_qu18_b3_4 XI1_I1202_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1202_MP5 (I1_b14_28 XI1_I1202_Bn XI1_I1202_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1202_MP4 (XI1_I1202_p1 XI1_I1202_An I1_b14_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1202_MP2 (VDD I1_dd28_b3_2 XI1_I1202_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1202_MP3 (XI1_I1202_p1 I1_qu18_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1202_MP0 (VDD I1_dd28_b3_2 XI1_I1202_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1201_MP1 (VDD I1_qu18_b3_4 XI1_I1201_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1201_MP5 (I1_b14_27 XI1_I1201_Bn XI1_I1201_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1201_MP4 (XI1_I1201_p1 XI1_I1201_An I1_b14_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1201_MP2 (VDD I1_dd27_b3_2 XI1_I1201_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1201_MP3 (XI1_I1201_p1 I1_qu18_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1201_MP0 (VDD I1_dd27_b3_2 XI1_I1201_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I786_MP1 (VDD I1_qu27_b3_4 XI1_I786_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I786_MP5 (I1_b5_26 XI1_I786_Bn XI1_I786_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I786_MP4 (XI1_I786_p1 XI1_I786_An I1_b5_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I786_MP2 (VDD I1_dd26_b3_0 XI1_I786_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I786_MP3 (XI1_I786_p1 I1_qu27_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I786_MP0 (VDD I1_dd26_b3_0 XI1_I786_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I784_MP1 (VDD I1_qu27_b3_4 XI1_I784_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I784_MP5 (I1_b5_24 XI1_I784_Bn XI1_I784_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I784_MP4 (XI1_I784_p1 XI1_I784_An I1_b5_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I784_MP2 (VDD I1_dd24_b3_0 XI1_I784_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I784_MP3 (XI1_I784_p1 I1_qu27_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I784_MP0 (VDD I1_dd24_b3_0 XI1_I784_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I788_MP1 (VDD I1_qu27_b3_4 XI1_I788_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I788_MP5 (I1_b5_28 XI1_I788_Bn XI1_I788_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I788_MP4 (XI1_I788_p1 XI1_I788_An I1_b5_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I788_MP2 (VDD I1_dd28_b3_0 XI1_I788_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I788_MP3 (XI1_I788_p1 I1_qu27_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I788_MP0 (VDD I1_dd28_b3_0 XI1_I788_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I787_MP1 (VDD I1_qu27_b3_4 XI1_I787_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I787_MP5 (I1_b5_27 XI1_I787_Bn XI1_I787_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I787_MP4 (XI1_I787_p1 XI1_I787_An I1_b5_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I787_MP2 (VDD I1_dd27_b3_0 XI1_I787_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I787_MP3 (XI1_I787_p1 I1_qu27_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I787_MP0 (VDD I1_dd27_b3_0 XI1_I787_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I789_MP1 (VDD I1_qu27_b3_4 XI1_I789_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I789_MP5 (I1_b5_29 XI1_I789_Bn XI1_I789_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I789_MP4 (XI1_I789_p1 XI1_I789_An I1_b5_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I789_MP2 (VDD I1_dd29_b3_0 XI1_I789_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I789_MP3 (XI1_I789_p1 I1_qu27_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I789_MP0 (VDD I1_dd29_b3_0 XI1_I789_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I740_MP1 (VDD I1_qu28_b3_4 XI1_I740_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I740_MP5 (I1_b4_26 XI1_I740_Bn XI1_I740_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I740_MP4 (XI1_I740_p1 XI1_I740_An I1_b4_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I740_MP2 (VDD I1_dd26_b3_0 XI1_I740_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I740_MP3 (XI1_I740_p1 I1_qu28_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I740_MP0 (VDD I1_dd26_b3_0 XI1_I740_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1291_MP1 (VDD I1_qu16_b3_4 XI1_I1291_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1291_MP5 (I1_b16_25 XI1_I1291_Bn XI1_I1291_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1291_MP4 (XI1_I1291_p1 XI1_I1291_An I1_b16_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1291_MP2 (VDD I1_dd25_b3_2 XI1_I1291_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1291_MP3 (XI1_I1291_p1 I1_qu16_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1291_MP0 (VDD I1_dd25_b3_2 XI1_I1291_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1290_MP1 (VDD I1_qu16_b3_4 XI1_I1290_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1290_MP5 (I1_b16_24 XI1_I1290_Bn XI1_I1290_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1290_MP4 (XI1_I1290_p1 XI1_I1290_An I1_b16_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1290_MP2 (VDD I1_dd24_b3_2 XI1_I1290_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1290_MP3 (XI1_I1290_p1 I1_qu16_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1290_MP0 (VDD I1_dd24_b3_2 XI1_I1290_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1245_MP1 (VDD I1_qu17_b3_4 XI1_I1245_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1245_MP5 (I1_b15_25 XI1_I1245_Bn XI1_I1245_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1245_MP4 (XI1_I1245_p1 XI1_I1245_An I1_b15_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1245_MP2 (VDD I1_dd25_b3_2 XI1_I1245_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1245_MP3 (XI1_I1245_p1 I1_qu17_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1245_MP0 (VDD I1_dd25_b3_2 XI1_I1245_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1205_MP1 (VDD I1_qu18_b3_5 XI1_I1205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1205_MP5 (I1_b14_31 XI1_I1205_Bn XI1_I1205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1205_MP4 (XI1_I1205_p1 XI1_I1205_An I1_b14_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1205_MP2 (VDD I1_dd31_b3_2 XI1_I1205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1205_MP3 (XI1_I1205_p1 I1_qu18_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1205_MP0 (VDD I1_dd31_b3_2 XI1_I1205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1204_MP1 (VDD I1_qu18_b3_5 XI1_I1204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1204_MP5 (I1_b14_30 XI1_I1204_Bn XI1_I1204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1204_MP4 (XI1_I1204_p1 XI1_I1204_An I1_b14_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1204_MP2 (VDD I1_dd30_b3_2 XI1_I1204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1204_MP3 (XI1_I1204_p1 I1_qu18_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1204_MP0 (VDD I1_dd30_b3_2 XI1_I1204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1198_MP1 (VDD I1_qu18_b3_4 XI1_I1198_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1198_MP5 (I1_b14_24 XI1_I1198_Bn XI1_I1198_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1198_MP4 (XI1_I1198_p1 XI1_I1198_An I1_b14_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1198_MP2 (VDD I1_dd24_b3_2 XI1_I1198_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1198_MP3 (XI1_I1198_p1 I1_qu18_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1198_MP0 (VDD I1_dd24_b3_2 XI1_I1198_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1200_MP1 (VDD I1_qu18_b3_4 XI1_I1200_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1200_MP5 (I1_b14_26 XI1_I1200_Bn XI1_I1200_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1200_MP4 (XI1_I1200_p1 XI1_I1200_An I1_b14_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1200_MP2 (VDD I1_dd26_b3_2 XI1_I1200_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1200_MP3 (XI1_I1200_p1 I1_qu18_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1200_MP0 (VDD I1_dd26_b3_2 XI1_I1200_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I219_MP1 (VDD I1_I838_G15_0n XI1_I838_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I219_MP5 (I1_p6_16 XI1_I838_I219_Bn XI1_I838_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I219_MP4 (XI1_I838_I219_p1 XI1_I838_I219_An I1_p6_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I219_MP2 (VDD I1_I838_pn16 XI1_I838_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I219_MP3 (XI1_I838_I219_p1 I1_I838_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I219_MP0 (VDD I1_I838_pn16 XI1_I838_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I217_MP1 (VDD I1_I838_G13_0n XI1_I838_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I217_MP5 (I1_p6_14 XI1_I838_I217_Bn XI1_I838_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I217_MP4 (XI1_I838_I217_p1 XI1_I838_I217_An I1_p6_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I217_MP2 (VDD I1_I838_pn14 XI1_I838_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I217_MP3 (XI1_I838_I217_p1 I1_I838_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I217_MP0 (VDD I1_I838_pn14 XI1_I838_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I219_MP1 (VDD I1_I792_G15_0n XI1_I792_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I219_MP5 (I1_p5_16 XI1_I792_I219_Bn XI1_I792_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I219_MP4 (XI1_I792_I219_p1 XI1_I792_I219_An I1_p5_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I219_MP2 (VDD I1_I792_pn16 XI1_I792_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I219_MP3 (XI1_I792_I219_p1 I1_I792_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I219_MP0 (VDD I1_I792_pn16 XI1_I792_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I793_MP1 (VDD I1_qu27_b3_5 XI1_I793_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I793_MP5 (I1_h5 XI1_I793_Bn XI1_I793_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I793_MP4 (XI1_I793_p1 XI1_I793_An I1_h5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I793_MP2 (VDD I1_p4_31 XI1_I793_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I793_MP3 (XI1_I793_p1 I1_qu27_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I793_MP0 (VDD I1_p4_31 XI1_I793_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I790_MP1 (VDD I1_qu27_b3_5 XI1_I790_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I790_MP5 (I1_b5_30 XI1_I790_Bn XI1_I790_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I790_MP4 (XI1_I790_p1 XI1_I790_An I1_b5_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I790_MP2 (VDD I1_dd30_b3_0 XI1_I790_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I790_MP3 (XI1_I790_p1 I1_qu27_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I790_MP0 (VDD I1_dd30_b3_0 XI1_I790_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I791_MP1 (VDD I1_qu27_b3_5 XI1_I791_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I791_MP5 (I1_b5_31 XI1_I791_Bn XI1_I791_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I791_MP4 (XI1_I791_p1 XI1_I791_An I1_b5_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I791_MP2 (VDD I1_dd31_b3_0 XI1_I791_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I791_MP3 (XI1_I791_p1 I1_qu27_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I791_MP0 (VDD I1_dd31_b3_0 XI1_I791_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I785_MP1 (VDD I1_qu27_b3_4 XI1_I785_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I785_MP5 (I1_b5_25 XI1_I785_Bn XI1_I785_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I785_MP4 (XI1_I785_p1 XI1_I785_An I1_b5_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I785_MP2 (VDD I1_dd25_b3_0 XI1_I785_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I785_MP3 (XI1_I785_p1 I1_qu27_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I785_MP0 (VDD I1_dd25_b3_0 XI1_I785_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I741_MP1 (VDD I1_qu28_b3_4 XI1_I741_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I741_MP5 (I1_b4_27 XI1_I741_Bn XI1_I741_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I741_MP4 (XI1_I741_p1 XI1_I741_An I1_b4_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I741_MP2 (VDD I1_dd27_b3_0 XI1_I741_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I741_MP3 (XI1_I741_p1 I1_qu28_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I741_MP0 (VDD I1_dd27_b3_0 XI1_I741_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1289_MP1 (VDD I1_qu16_b3_3 XI1_I1289_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1289_MP5 (I1_b16_23 XI1_I1289_Bn XI1_I1289_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1289_MP4 (XI1_I1289_p1 XI1_I1289_An I1_b16_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1289_MP2 (VDD I1_dd23_b3_2 XI1_I1289_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1289_MP3 (XI1_I1289_p1 I1_qu16_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1289_MP0 (VDD I1_dd23_b3_2 XI1_I1289_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1244_MP1 (VDD I1_qu17_b3_4 XI1_I1244_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1244_MP5 (I1_b15_24 XI1_I1244_Bn XI1_I1244_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1244_MP4 (XI1_I1244_p1 XI1_I1244_An I1_b15_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1244_MP2 (VDD I1_dd24_b3_2 XI1_I1244_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1244_MP3 (XI1_I1244_p1 I1_qu17_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1244_MP0 (VDD I1_dd24_b3_2 XI1_I1244_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1243_MP1 (VDD I1_qu17_b3_3 XI1_I1243_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1243_MP5 (I1_b15_23 XI1_I1243_Bn XI1_I1243_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1243_MP4 (XI1_I1243_p1 XI1_I1243_An I1_b15_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1243_MP2 (VDD I1_dd23_b3_2 XI1_I1243_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1243_MP3 (XI1_I1243_p1 I1_qu17_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1243_MP0 (VDD I1_dd23_b3_2 XI1_I1243_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1242_MP1 (VDD I1_qu17_b3_3 XI1_I1242_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1242_MP5 (I1_b15_22 XI1_I1242_Bn XI1_I1242_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1242_MP4 (XI1_I1242_p1 XI1_I1242_An I1_b15_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1242_MP2 (VDD I1_dd22_b3_2 XI1_I1242_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1242_MP3 (XI1_I1242_p1 I1_qu17_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1242_MP0 (VDD I1_dd22_b3_2 XI1_I1242_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1197_MP1 (VDD I1_qu18_b3_3 XI1_I1197_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1197_MP5 (I1_b14_23 XI1_I1197_Bn XI1_I1197_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1197_MP4 (XI1_I1197_p1 XI1_I1197_An I1_b14_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1197_MP2 (VDD I1_dd23_b3_2 XI1_I1197_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1197_MP3 (XI1_I1197_p1 I1_qu18_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1197_MP0 (VDD I1_dd23_b3_2 XI1_I1197_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1196_MP1 (VDD I1_qu18_b3_3 XI1_I1196_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1196_MP5 (I1_b14_22 XI1_I1196_Bn XI1_I1196_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1196_MP4 (XI1_I1196_p1 XI1_I1196_An I1_b14_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1196_MP2 (VDD I1_dd22_b3_2 XI1_I1196_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1196_MP3 (XI1_I1196_p1 I1_qu18_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1196_MP0 (VDD I1_dd22_b3_2 XI1_I1196_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1199_MP1 (VDD I1_qu18_b3_4 XI1_I1199_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1199_MP5 (I1_b14_25 XI1_I1199_Bn XI1_I1199_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1199_MP4 (XI1_I1199_p1 XI1_I1199_An I1_b14_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1199_MP2 (VDD I1_dd25_b3_2 XI1_I1199_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1199_MP3 (XI1_I1199_p1 I1_qu18_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1199_MP0 (VDD I1_dd25_b3_2 XI1_I1199_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I836_MP1 (VDD I1_qu26_b3_5 XI1_I836_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I836_MP5 (I1_b6_30 XI1_I836_Bn XI1_I836_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I836_MP4 (XI1_I836_p1 XI1_I836_An I1_b6_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I836_MP2 (VDD I1_dd30_b3_1 XI1_I836_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I836_MP3 (XI1_I836_p1 I1_qu26_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I836_MP0 (VDD I1_dd30_b3_1 XI1_I836_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I215_MP1 (VDD I1_I838_G11_0n XI1_I838_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I215_MP5 (I1_p6_12 XI1_I838_I215_Bn XI1_I838_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I215_MP4 (XI1_I838_I215_p1 XI1_I838_I215_An I1_p6_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I215_MP2 (VDD I1_I838_pn12 XI1_I838_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I215_MP3 (XI1_I838_I215_p1 I1_I838_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I215_MP0 (VDD I1_I838_pn12 XI1_I838_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I213_MP1 (VDD I1_I838_G9_0n XI1_I838_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I213_MP5 (I1_p6_10 XI1_I838_I213_Bn XI1_I838_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I213_MP4 (XI1_I838_I213_p1 XI1_I838_I213_An I1_p6_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I213_MP2 (VDD I1_I838_pn10 XI1_I838_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I213_MP3 (XI1_I838_I213_p1 I1_I838_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I213_MP0 (VDD I1_I838_pn10 XI1_I838_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I217_MP1 (VDD I1_I792_G13_0n XI1_I792_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I217_MP5 (I1_p5_14 XI1_I792_I217_Bn XI1_I792_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I217_MP4 (XI1_I792_I217_p1 XI1_I792_I217_An I1_p5_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I217_MP2 (VDD I1_I792_pn14 XI1_I792_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I217_MP3 (XI1_I792_I217_p1 I1_I792_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I217_MP0 (VDD I1_I792_pn14 XI1_I792_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I215_MP1 (VDD I1_I792_G11_0n XI1_I792_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I215_MP5 (I1_p5_12 XI1_I792_I215_Bn XI1_I792_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I215_MP4 (XI1_I792_I215_p1 XI1_I792_I215_An I1_p5_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I215_MP2 (VDD I1_I792_pn12 XI1_I792_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I215_MP3 (XI1_I792_I215_p1 I1_I792_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I215_MP0 (VDD I1_I792_pn12 XI1_I792_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I218_MP1 (VDD I1_I792_G14_0n XI1_I792_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I218_MP5 (I1_p5_15 XI1_I792_I218_Bn XI1_I792_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I218_MP4 (XI1_I792_I218_p1 XI1_I792_I218_An I1_p5_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I218_MP2 (VDD I1_I792_pn15 XI1_I792_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I218_MP3 (XI1_I792_I218_p1 I1_I792_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I218_MP0 (VDD I1_I792_pn15 XI1_I792_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I781_MP1 (VDD I1_qu27_b3_3 XI1_I781_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I781_MP5 (I1_b5_21 XI1_I781_Bn XI1_I781_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I781_MP4 (XI1_I781_p1 XI1_I781_An I1_b5_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I781_MP2 (VDD I1_dd21_b3_0 XI1_I781_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I781_MP3 (XI1_I781_p1 I1_qu27_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I781_MP0 (VDD I1_dd21_b3_0 XI1_I781_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I782_MP1 (VDD I1_qu27_b3_3 XI1_I782_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I782_MP5 (I1_b5_22 XI1_I782_Bn XI1_I782_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I782_MP4 (XI1_I782_p1 XI1_I782_An I1_b5_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I782_MP2 (VDD I1_dd22_b3_0 XI1_I782_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I782_MP3 (XI1_I782_p1 I1_qu27_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I782_MP0 (VDD I1_dd22_b3_0 XI1_I782_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I742_MP1 (VDD I1_qu28_b3_4 XI1_I742_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I742_MP5 (I1_b4_28 XI1_I742_Bn XI1_I742_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I742_MP4 (XI1_I742_p1 XI1_I742_An I1_b4_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I742_MP2 (VDD I1_dd28_b3_0 XI1_I742_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I742_MP3 (XI1_I742_p1 I1_qu28_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I742_MP0 (VDD I1_dd28_b3_0 XI1_I742_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I219_MP1 (VDD I1_I1298_G15_0n XI1_I1298_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I219_MP5 (I1_p16_16 XI1_I1298_I219_Bn XI1_I1298_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I219_MP4 (XI1_I1298_I219_p1 XI1_I1298_I219_An I1_p16_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I219_MP2 (VDD I1_I1298_pn16 XI1_I1298_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I219_MP3 (XI1_I1298_I219_p1 I1_I1298_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I219_MP0 (VDD I1_I1298_pn16 XI1_I1298_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1288_MP1 (VDD I1_qu16_b3_3 XI1_I1288_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1288_MP5 (I1_b16_22 XI1_I1288_Bn XI1_I1288_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1288_MP4 (XI1_I1288_p1 XI1_I1288_An I1_b16_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1288_MP2 (VDD I1_dd22_b3_2 XI1_I1288_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1288_MP3 (XI1_I1288_p1 I1_qu16_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1288_MP0 (VDD I1_dd22_b3_2 XI1_I1288_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1287_MP1 (VDD I1_qu16_b3_3 XI1_I1287_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1287_MP5 (I1_b16_21 XI1_I1287_Bn XI1_I1287_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1287_MP4 (XI1_I1287_p1 XI1_I1287_An I1_b16_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1287_MP2 (VDD I1_dd21_b3_2 XI1_I1287_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1287_MP3 (XI1_I1287_p1 I1_qu16_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1287_MP0 (VDD I1_dd21_b3_2 XI1_I1287_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1241_MP1 (VDD I1_qu17_b3_3 XI1_I1241_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1241_MP5 (I1_b15_21 XI1_I1241_Bn XI1_I1241_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1241_MP4 (XI1_I1241_p1 XI1_I1241_An I1_b15_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1241_MP2 (VDD I1_dd21_b3_2 XI1_I1241_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1241_MP3 (XI1_I1241_p1 I1_qu17_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1241_MP0 (VDD I1_dd21_b3_2 XI1_I1241_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I834_MP1 (VDD I1_qu26_b3_4 XI1_I834_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I834_MP5 (I1_b6_28 XI1_I834_Bn XI1_I834_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I834_MP4 (XI1_I834_p1 XI1_I834_An I1_b6_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I834_MP2 (VDD I1_dd28_b3_1 XI1_I834_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I834_MP3 (XI1_I834_p1 I1_qu26_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I834_MP0 (VDD I1_dd28_b3_1 XI1_I834_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I835_MP1 (VDD I1_qu26_b3_4 XI1_I835_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I835_MP5 (I1_b6_29 XI1_I835_Bn XI1_I835_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I835_MP4 (XI1_I835_p1 XI1_I835_An I1_b6_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I835_MP2 (VDD I1_dd29_b3_1 XI1_I835_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I835_MP3 (XI1_I835_p1 I1_qu26_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I835_MP0 (VDD I1_dd29_b3_1 XI1_I835_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I833_MP1 (VDD I1_qu26_b3_4 XI1_I833_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I833_MP5 (I1_b6_27 XI1_I833_Bn XI1_I833_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I833_MP4 (XI1_I833_p1 XI1_I833_An I1_b6_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I833_MP2 (VDD I1_dd27_b3_1 XI1_I833_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I833_MP3 (XI1_I833_p1 I1_qu26_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I833_MP0 (VDD I1_dd27_b3_1 XI1_I833_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I837_MP1 (VDD I1_qu26_b3_5 XI1_I837_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I837_MP5 (I1_b6_31 XI1_I837_Bn XI1_I837_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I837_MP4 (XI1_I837_p1 XI1_I837_An I1_b6_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I837_MP2 (VDD I1_dd31_b3_1 XI1_I837_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I837_MP3 (XI1_I837_p1 I1_qu26_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I837_MP0 (VDD I1_dd31_b3_1 XI1_I837_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I832_MP1 (VDD I1_qu26_b3_4 XI1_I832_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I832_MP5 (I1_b6_26 XI1_I832_Bn XI1_I832_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I832_MP4 (XI1_I832_p1 XI1_I832_An I1_b6_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I832_MP2 (VDD I1_dd26_b3_1 XI1_I832_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I832_MP3 (XI1_I832_p1 I1_qu26_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I832_MP0 (VDD I1_dd26_b3_1 XI1_I832_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I831_MP1 (VDD I1_qu26_b3_4 XI1_I831_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I831_MP5 (I1_b6_25 XI1_I831_Bn XI1_I831_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I831_MP4 (XI1_I831_p1 XI1_I831_An I1_b6_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I831_MP2 (VDD I1_dd25_b3_1 XI1_I831_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I831_MP3 (XI1_I831_p1 I1_qu26_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I831_MP0 (VDD I1_dd25_b3_1 XI1_I831_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I830_MP1 (VDD I1_qu26_b3_4 XI1_I830_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I830_MP5 (I1_b6_24 XI1_I830_Bn XI1_I830_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I830_MP4 (XI1_I830_p1 XI1_I830_An I1_b6_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I830_MP2 (VDD I1_dd24_b3_1 XI1_I830_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I830_MP3 (XI1_I830_p1 I1_qu26_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I830_MP0 (VDD I1_dd24_b3_1 XI1_I830_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I213_MP1 (VDD I1_I792_G9_0n XI1_I792_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I213_MP5 (I1_p5_10 XI1_I792_I213_Bn XI1_I792_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I213_MP4 (XI1_I792_I213_p1 XI1_I792_I213_An I1_p5_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I213_MP2 (VDD I1_I792_pn10 XI1_I792_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I213_MP3 (XI1_I792_I213_p1 I1_I792_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I213_MP0 (VDD I1_I792_pn10 XI1_I792_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I216_MP1 (VDD I1_I792_G12_0n XI1_I792_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I216_MP5 (I1_p5_13 XI1_I792_I216_Bn XI1_I792_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I216_MP4 (XI1_I792_I216_p1 XI1_I792_I216_An I1_p5_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I216_MP2 (VDD I1_I792_pn13 XI1_I792_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I216_MP3 (XI1_I792_I216_p1 I1_I792_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I216_MP0 (VDD I1_I792_pn13 XI1_I792_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I780_MP1 (VDD I1_qu27_b3_3 XI1_I780_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I780_MP5 (I1_b5_20 XI1_I780_Bn XI1_I780_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I780_MP4 (XI1_I780_p1 XI1_I780_An I1_b5_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I780_MP2 (VDD I1_dd20_b3_0 XI1_I780_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I780_MP3 (XI1_I780_p1 I1_qu27_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I780_MP0 (VDD I1_dd20_b3_0 XI1_I780_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I778_MP1 (VDD I1_qu27_b3_3 XI1_I778_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I778_MP5 (I1_b5_18 XI1_I778_Bn XI1_I778_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I778_MP4 (XI1_I778_p1 XI1_I778_An I1_b5_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I778_MP2 (VDD I1_dd18_b3_0 XI1_I778_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I778_MP3 (XI1_I778_p1 I1_qu27_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I778_MP0 (VDD I1_dd18_b3_0 XI1_I778_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I783_MP1 (VDD I1_qu27_b3_3 XI1_I783_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I783_MP5 (I1_b5_23 XI1_I783_Bn XI1_I783_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I783_MP4 (XI1_I783_p1 XI1_I783_An I1_b5_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I783_MP2 (VDD I1_dd23_b3_0 XI1_I783_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I783_MP3 (XI1_I783_p1 I1_qu27_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I783_MP0 (VDD I1_dd23_b3_0 XI1_I783_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I218_MP1 (VDD I1_I746_G14_0n XI1_I746_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I218_MP5 (I1_p4_15 XI1_I746_I218_Bn XI1_I746_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I218_MP4 (XI1_I746_I218_p1 XI1_I746_I218_An I1_p4_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I218_MP2 (VDD I1_I746_pn15 XI1_I746_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I218_MP3 (XI1_I746_I218_p1 I1_I746_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I218_MP0 (VDD I1_I746_pn15 XI1_I746_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I743_MP1 (VDD I1_qu28_b3_4 XI1_I743_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I743_MP5 (I1_b4_29 XI1_I743_Bn XI1_I743_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I743_MP4 (XI1_I743_p1 XI1_I743_An I1_b4_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I743_MP2 (VDD I1_dd29_b3_0 XI1_I743_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I743_MP3 (XI1_I743_p1 I1_qu28_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I743_MP0 (VDD I1_dd29_b3_0 XI1_I743_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1338_MP1 (VDD I1_qu15_b3_4 XI1_I1338_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1338_MP5 (I1_b17_26 XI1_I1338_Bn XI1_I1338_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1338_MP4 (XI1_I1338_p1 XI1_I1338_An I1_b17_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1338_MP2 (VDD I1_dd26_b3_3 XI1_I1338_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1338_MP3 (XI1_I1338_p1 I1_qu15_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1338_MP0 (VDD I1_dd26_b3_3 XI1_I1338_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1341_MP1 (VDD I1_qu15_b3_4 XI1_I1341_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1341_MP5 (I1_b17_29 XI1_I1341_Bn XI1_I1341_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1341_MP4 (XI1_I1341_p1 XI1_I1341_An I1_b17_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1341_MP2 (VDD I1_dd29_b3_3 XI1_I1341_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1341_MP3 (XI1_I1341_p1 I1_qu15_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1341_MP0 (VDD I1_dd29_b3_3 XI1_I1341_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1336_MP1 (VDD I1_qu15_b3_4 XI1_I1336_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1336_MP5 (I1_b17_24 XI1_I1336_Bn XI1_I1336_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1336_MP4 (XI1_I1336_p1 XI1_I1336_An I1_b17_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1336_MP2 (VDD I1_dd24_b3_3 XI1_I1336_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1336_MP3 (XI1_I1336_p1 I1_qu15_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1336_MP0 (VDD I1_dd24_b3_3 XI1_I1336_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I219_MP1 (VDD I1_I1344_G15_0n XI1_I1344_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I219_MP5 (I1_p17_16 XI1_I1344_I219_Bn XI1_I1344_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I219_MP4 (XI1_I1344_I219_p1 XI1_I1344_I219_An I1_p17_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I219_MP2 (VDD I1_I1344_pn16 XI1_I1344_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I219_MP3 (XI1_I1344_I219_p1 I1_I1344_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I219_MP0 (VDD I1_I1344_pn16 XI1_I1344_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1286_MP1 (VDD I1_qu16_b3_3 XI1_I1286_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1286_MP5 (I1_b16_20 XI1_I1286_Bn XI1_I1286_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1286_MP4 (XI1_I1286_p1 XI1_I1286_An I1_b16_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1286_MP2 (VDD I1_dd20_b3_2 XI1_I1286_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1286_MP3 (XI1_I1286_p1 I1_qu16_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1286_MP0 (VDD I1_dd20_b3_2 XI1_I1286_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1285_MP1 (VDD I1_qu16_b3_3 XI1_I1285_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1285_MP5 (I1_b16_19 XI1_I1285_Bn XI1_I1285_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1285_MP4 (XI1_I1285_p1 XI1_I1285_An I1_b16_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1285_MP2 (VDD I1_dd19_b3_2 XI1_I1285_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1285_MP3 (XI1_I1285_p1 I1_qu16_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1285_MP0 (VDD I1_dd19_b3_2 XI1_I1285_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1240_MP1 (VDD I1_qu17_b3_3 XI1_I1240_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1240_MP5 (I1_b15_20 XI1_I1240_Bn XI1_I1240_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1240_MP4 (XI1_I1240_p1 XI1_I1240_An I1_b15_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1240_MP2 (VDD I1_dd20_b3_2 XI1_I1240_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1240_MP3 (XI1_I1240_p1 I1_qu17_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1240_MP0 (VDD I1_dd20_b3_2 XI1_I1240_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1238_MP1 (VDD I1_qu17_b3_3 XI1_I1238_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1238_MP5 (I1_b15_18 XI1_I1238_Bn XI1_I1238_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1238_MP4 (XI1_I1238_p1 XI1_I1238_An I1_b15_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1238_MP2 (VDD I1_dd18_b3_2 XI1_I1238_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1238_MP3 (XI1_I1238_p1 I1_qu17_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1238_MP0 (VDD I1_dd18_b3_2 XI1_I1238_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1195_MP1 (VDD I1_qu18_b3_3 XI1_I1195_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1195_MP5 (I1_b14_21 XI1_I1195_Bn XI1_I1195_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1195_MP4 (XI1_I1195_p1 XI1_I1195_An I1_b14_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1195_MP2 (VDD I1_dd21_b3_2 XI1_I1195_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1195_MP3 (XI1_I1195_p1 I1_qu18_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1195_MP0 (VDD I1_dd21_b3_2 XI1_I1195_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1192_MP1 (VDD I1_qu18_b3_3 XI1_I1192_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1192_MP5 (I1_b14_18 XI1_I1192_Bn XI1_I1192_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1192_MP4 (XI1_I1192_p1 XI1_I1192_An I1_b14_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1192_MP2 (VDD I1_dd18_b3_2 XI1_I1192_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1192_MP3 (XI1_I1192_p1 I1_qu18_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1192_MP0 (VDD I1_dd18_b3_2 XI1_I1192_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1194_MP1 (VDD I1_qu18_b3_3 XI1_I1194_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1194_MP5 (I1_b14_20 XI1_I1194_Bn XI1_I1194_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1194_MP4 (XI1_I1194_p1 XI1_I1194_An I1_b14_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1194_MP2 (VDD I1_dd20_b3_2 XI1_I1194_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1194_MP3 (XI1_I1194_p1 I1_qu18_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1194_MP0 (VDD I1_dd20_b3_2 XI1_I1194_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I829_MP1 (VDD I1_qu26_b3_3 XI1_I829_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I829_MP5 (I1_b6_23 XI1_I829_Bn XI1_I829_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I829_MP4 (XI1_I829_p1 XI1_I829_An I1_b6_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I829_MP2 (VDD I1_dd23_b3_1 XI1_I829_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I829_MP3 (XI1_I829_p1 I1_qu26_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I829_MP0 (VDD I1_dd23_b3_1 XI1_I829_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I827_MP1 (VDD I1_qu26_b3_3 XI1_I827_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I827_MP5 (I1_b6_21 XI1_I827_Bn XI1_I827_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I827_MP4 (XI1_I827_p1 XI1_I827_An I1_b6_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I827_MP2 (VDD I1_dd21_b3_1 XI1_I827_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I827_MP3 (XI1_I827_p1 I1_qu26_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I827_MP0 (VDD I1_dd21_b3_1 XI1_I827_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I825_MP1 (VDD I1_qu26_b3_3 XI1_I825_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I825_MP5 (I1_b6_19 XI1_I825_Bn XI1_I825_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I825_MP4 (XI1_I825_p1 XI1_I825_An I1_b6_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I825_MP2 (VDD I1_dd19_b3_1 XI1_I825_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I825_MP3 (XI1_I825_p1 I1_qu26_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I825_MP0 (VDD I1_dd19_b3_1 XI1_I825_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I218_MP1 (VDD I1_I838_G14_0n XI1_I838_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I218_MP5 (I1_p6_15 XI1_I838_I218_Bn XI1_I838_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I218_MP4 (XI1_I838_I218_p1 XI1_I838_I218_An I1_p6_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I218_MP2 (VDD I1_I838_pn15 XI1_I838_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I218_MP3 (XI1_I838_I218_p1 I1_I838_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I218_MP0 (VDD I1_I838_pn15 XI1_I838_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I214_MP1 (VDD I1_I838_G10_0n XI1_I838_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I214_MP5 (I1_p6_11 XI1_I838_I214_Bn XI1_I838_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I214_MP4 (XI1_I838_I214_p1 XI1_I838_I214_An I1_p6_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I214_MP2 (VDD I1_I838_pn11 XI1_I838_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I214_MP3 (XI1_I838_I214_p1 I1_I838_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I214_MP0 (VDD I1_I838_pn11 XI1_I838_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I212_MP1 (VDD I1_I792_G8_0n XI1_I792_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I212_MP5 (I1_p5_9 XI1_I792_I212_Bn XI1_I792_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I212_MP4 (XI1_I792_I212_p1 XI1_I792_I212_An I1_p5_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I212_MP2 (VDD I1_I792_pn9 XI1_I792_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I212_MP3 (XI1_I792_I212_p1 I1_I792_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I212_MP0 (VDD I1_I792_pn9 XI1_I792_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I214_MP1 (VDD I1_I792_G10_0n XI1_I792_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I214_MP5 (I1_p5_11 XI1_I792_I214_Bn XI1_I792_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I214_MP4 (XI1_I792_I214_p1 XI1_I792_I214_An I1_p5_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I214_MP2 (VDD I1_I792_pn11 XI1_I792_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I214_MP3 (XI1_I792_I214_p1 I1_I792_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I214_MP0 (VDD I1_I792_pn11 XI1_I792_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I779_MP1 (VDD I1_qu27_b3_3 XI1_I779_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I779_MP5 (I1_b5_19 XI1_I779_Bn XI1_I779_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I779_MP4 (XI1_I779_p1 XI1_I779_An I1_b5_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I779_MP2 (VDD I1_dd19_b3_0 XI1_I779_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I779_MP3 (XI1_I779_p1 I1_qu27_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I779_MP0 (VDD I1_dd19_b3_0 XI1_I779_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I739_MP1 (VDD I1_qu28_b3_4 XI1_I739_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I739_MP5 (I1_b4_25 XI1_I739_Bn XI1_I739_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I739_MP4 (XI1_I739_p1 XI1_I739_An I1_b4_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I739_MP2 (VDD I1_dd25_b3_0 XI1_I739_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I739_MP3 (XI1_I739_p1 I1_qu28_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I739_MP0 (VDD I1_dd25_b3_0 XI1_I739_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1339_MP1 (VDD I1_qu15_b3_4 XI1_I1339_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1339_MP5 (I1_b17_27 XI1_I1339_Bn XI1_I1339_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1339_MP4 (XI1_I1339_p1 XI1_I1339_An I1_b17_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1339_MP2 (VDD I1_dd27_b3_3 XI1_I1339_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1339_MP3 (XI1_I1339_p1 I1_qu15_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1339_MP0 (VDD I1_dd27_b3_3 XI1_I1339_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1340_MP1 (VDD I1_qu15_b3_4 XI1_I1340_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1340_MP5 (I1_b17_28 XI1_I1340_Bn XI1_I1340_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1340_MP4 (XI1_I1340_p1 XI1_I1340_An I1_b17_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1340_MP2 (VDD I1_dd28_b3_3 XI1_I1340_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1340_MP3 (XI1_I1340_p1 I1_qu15_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1340_MP0 (VDD I1_dd28_b3_3 XI1_I1340_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1337_MP1 (VDD I1_qu15_b3_4 XI1_I1337_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1337_MP5 (I1_b17_25 XI1_I1337_Bn XI1_I1337_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1337_MP4 (XI1_I1337_p1 XI1_I1337_An I1_b17_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1337_MP2 (VDD I1_dd25_b3_3 XI1_I1337_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1337_MP3 (XI1_I1337_p1 I1_qu15_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1337_MP0 (VDD I1_dd25_b3_3 XI1_I1337_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I217_MP1 (VDD I1_I1344_G13_0n XI1_I1344_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I217_MP5 (I1_p17_14 XI1_I1344_I217_Bn XI1_I1344_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I217_MP4 (XI1_I1344_I217_p1 XI1_I1344_I217_An I1_p17_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I217_MP2 (VDD I1_I1344_pn14 XI1_I1344_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I217_MP3 (XI1_I1344_I217_p1 I1_I1344_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I217_MP0 (VDD I1_I1344_pn14 XI1_I1344_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I217_MP1 (VDD I1_I1298_G13_0n XI1_I1298_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I217_MP5 (I1_p16_14 XI1_I1298_I217_Bn XI1_I1298_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I217_MP4 (XI1_I1298_I217_p1 XI1_I1298_I217_An I1_p16_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I217_MP2 (VDD I1_I1298_pn14 XI1_I1298_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I217_MP3 (XI1_I1298_I217_p1 I1_I1298_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I217_MP0 (VDD I1_I1298_pn14 XI1_I1298_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I218_MP1 (VDD I1_I1298_G14_0n XI1_I1298_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I218_MP5 (I1_p16_15 XI1_I1298_I218_Bn XI1_I1298_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I218_MP4 (XI1_I1298_I218_p1 XI1_I1298_I218_An I1_p16_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I218_MP2 (VDD I1_I1298_pn15 XI1_I1298_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I218_MP3 (XI1_I1298_I218_p1 I1_I1298_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I218_MP0 (VDD I1_I1298_pn15 XI1_I1298_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1284_MP1 (VDD I1_qu16_b3_3 XI1_I1284_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1284_MP5 (I1_b16_18 XI1_I1284_Bn XI1_I1284_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1284_MP4 (XI1_I1284_p1 XI1_I1284_An I1_b16_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1284_MP2 (VDD I1_dd18_b3_2 XI1_I1284_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1284_MP3 (XI1_I1284_p1 I1_qu16_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1284_MP0 (VDD I1_dd18_b3_2 XI1_I1284_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I218_MP1 (VDD I1_I1252_G14_0n XI1_I1252_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I218_MP5 (I1_p15_15 XI1_I1252_I218_Bn XI1_I1252_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I218_MP4 (XI1_I1252_I218_p1 XI1_I1252_I218_An I1_p15_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I218_MP2 (VDD I1_I1252_pn15 XI1_I1252_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I218_MP3 (XI1_I1252_I218_p1 I1_I1252_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I218_MP0 (VDD I1_I1252_pn15 XI1_I1252_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I219_MP1 (VDD I1_I1252_G15_0n XI1_I1252_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I219_MP5 (I1_p15_16 XI1_I1252_I219_Bn XI1_I1252_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I219_MP4 (XI1_I1252_I219_p1 XI1_I1252_I219_An I1_p15_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I219_MP2 (VDD I1_I1252_pn16 XI1_I1252_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I219_MP3 (XI1_I1252_I219_p1 I1_I1252_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I219_MP0 (VDD I1_I1252_pn16 XI1_I1252_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1239_MP1 (VDD I1_qu17_b3_3 XI1_I1239_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1239_MP5 (I1_b15_19 XI1_I1239_Bn XI1_I1239_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1239_MP4 (XI1_I1239_p1 XI1_I1239_An I1_b15_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1239_MP2 (VDD I1_dd19_b3_2 XI1_I1239_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1239_MP3 (XI1_I1239_p1 I1_qu17_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1239_MP0 (VDD I1_dd19_b3_2 XI1_I1239_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1193_MP1 (VDD I1_qu18_b3_3 XI1_I1193_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1193_MP5 (I1_b14_19 XI1_I1193_Bn XI1_I1193_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1193_MP4 (XI1_I1193_p1 XI1_I1193_An I1_b14_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1193_MP2 (VDD I1_dd19_b3_2 XI1_I1193_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1193_MP3 (XI1_I1193_p1 I1_qu18_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1193_MP0 (VDD I1_dd19_b3_2 XI1_I1193_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I881_MP1 (VDD I1_qu25_b3_4 XI1_I881_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I881_MP5 (I1_b7_29 XI1_I881_Bn XI1_I881_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I881_MP4 (XI1_I881_p1 XI1_I881_An I1_b7_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I881_MP2 (VDD I1_dd29_b3_1 XI1_I881_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I881_MP3 (XI1_I881_p1 I1_qu25_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I881_MP0 (VDD I1_dd29_b3_1 XI1_I881_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I880_MP1 (VDD I1_qu25_b3_4 XI1_I880_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I880_MP5 (I1_b7_28 XI1_I880_Bn XI1_I880_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I880_MP4 (XI1_I880_p1 XI1_I880_An I1_b7_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I880_MP2 (VDD I1_dd28_b3_1 XI1_I880_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I880_MP3 (XI1_I880_p1 I1_qu25_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I880_MP0 (VDD I1_dd28_b3_1 XI1_I880_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I879_MP1 (VDD I1_qu25_b3_4 XI1_I879_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I879_MP5 (I1_b7_27 XI1_I879_Bn XI1_I879_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I879_MP4 (XI1_I879_p1 XI1_I879_An I1_b7_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I879_MP2 (VDD I1_dd27_b3_1 XI1_I879_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I879_MP3 (XI1_I879_p1 I1_qu25_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I879_MP0 (VDD I1_dd27_b3_1 XI1_I879_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I877_MP1 (VDD I1_qu25_b3_4 XI1_I877_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I877_MP5 (I1_b7_25 XI1_I877_Bn XI1_I877_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I877_MP4 (XI1_I877_p1 XI1_I877_An I1_b7_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I877_MP2 (VDD I1_dd25_b3_1 XI1_I877_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I877_MP3 (XI1_I877_p1 I1_qu25_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I877_MP0 (VDD I1_dd25_b3_1 XI1_I877_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I878_MP1 (VDD I1_qu25_b3_4 XI1_I878_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I878_MP5 (I1_b7_26 XI1_I878_Bn XI1_I878_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I878_MP4 (XI1_I878_p1 XI1_I878_An I1_b7_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I878_MP2 (VDD I1_dd26_b3_1 XI1_I878_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I878_MP3 (XI1_I878_p1 I1_qu25_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I878_MP0 (VDD I1_dd26_b3_1 XI1_I878_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I876_MP1 (VDD I1_qu25_b3_4 XI1_I876_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I876_MP5 (I1_b7_24 XI1_I876_Bn XI1_I876_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I876_MP4 (XI1_I876_p1 XI1_I876_An I1_b7_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I876_MP2 (VDD I1_dd24_b3_1 XI1_I876_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I876_MP3 (XI1_I876_p1 I1_qu25_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I876_MP0 (VDD I1_dd24_b3_1 XI1_I876_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I875_MP1 (VDD I1_qu25_b3_3 XI1_I875_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I875_MP5 (I1_b7_23 XI1_I875_Bn XI1_I875_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I875_MP4 (XI1_I875_p1 XI1_I875_An I1_b7_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I875_MP2 (VDD I1_dd23_b3_1 XI1_I875_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I875_MP3 (XI1_I875_p1 I1_qu25_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I875_MP0 (VDD I1_dd23_b3_1 XI1_I875_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I828_MP1 (VDD I1_qu26_b3_3 XI1_I828_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I828_MP5 (I1_b6_22 XI1_I828_Bn XI1_I828_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I828_MP4 (XI1_I828_p1 XI1_I828_An I1_b6_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I828_MP2 (VDD I1_dd22_b3_1 XI1_I828_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I828_MP3 (XI1_I828_p1 I1_qu26_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I828_MP0 (VDD I1_dd22_b3_1 XI1_I828_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I824_MP1 (VDD I1_qu26_b3_3 XI1_I824_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I824_MP5 (I1_b6_18 XI1_I824_Bn XI1_I824_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I824_MP4 (XI1_I824_p1 XI1_I824_An I1_b6_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I824_MP2 (VDD I1_dd18_b3_1 XI1_I824_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I824_MP3 (XI1_I824_p1 I1_qu26_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I824_MP0 (VDD I1_dd18_b3_1 XI1_I824_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I826_MP1 (VDD I1_qu26_b3_3 XI1_I826_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I826_MP5 (I1_b6_20 XI1_I826_Bn XI1_I826_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I826_MP4 (XI1_I826_p1 XI1_I826_An I1_b6_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I826_MP2 (VDD I1_dd20_b3_1 XI1_I826_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I826_MP3 (XI1_I826_p1 I1_qu26_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I826_MP0 (VDD I1_dd20_b3_1 XI1_I826_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I216_MP1 (VDD I1_I838_G12_0n XI1_I838_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I216_MP5 (I1_p6_13 XI1_I838_I216_Bn XI1_I838_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I216_MP4 (XI1_I838_I216_p1 XI1_I838_I216_An I1_p6_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I216_MP2 (VDD I1_I838_pn13 XI1_I838_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I216_MP3 (XI1_I838_I216_p1 I1_I838_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I216_MP0 (VDD I1_I838_pn13 XI1_I838_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I823_MP1 (VDD I1_qu26_b3_2 XI1_I823_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I823_MP5 (I1_b6_17 XI1_I823_Bn XI1_I823_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I823_MP4 (XI1_I823_p1 XI1_I823_An I1_b6_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I823_MP2 (VDD I1_dd17_b3_1 XI1_I823_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I823_MP3 (XI1_I823_p1 I1_qu26_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I823_MP0 (VDD I1_dd17_b3_1 XI1_I823_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I212_MP1 (VDD I1_I838_G8_0n XI1_I838_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I212_MP5 (I1_p6_9 XI1_I838_I212_Bn XI1_I838_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I212_MP4 (XI1_I838_I212_p1 XI1_I838_I212_An I1_p6_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I212_MP2 (VDD I1_I838_pn9 XI1_I838_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I212_MP3 (XI1_I838_I212_p1 I1_I838_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I212_MP0 (VDD I1_I838_pn9 XI1_I838_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I738_MP1 (VDD I1_qu28_b3_4 XI1_I738_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I738_MP5 (I1_b4_24 XI1_I738_Bn XI1_I738_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I738_MP4 (XI1_I738_p1 XI1_I738_An I1_b4_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I738_MP2 (VDD I1_dd24_b3_0 XI1_I738_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I738_MP3 (XI1_I738_p1 I1_qu28_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I738_MP0 (VDD I1_dd24_b3_0 XI1_I738_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1385_MP1 (VDD I1_qu14_b3_4 XI1_I1385_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1385_MP5 (I1_b18_27 XI1_I1385_Bn XI1_I1385_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1385_MP4 (XI1_I1385_p1 XI1_I1385_An I1_b18_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1385_MP2 (VDD I1_dd27_b3_3 XI1_I1385_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1385_MP3 (XI1_I1385_p1 I1_qu14_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1385_MP0 (VDD I1_dd27_b3_3 XI1_I1385_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I218_MP1 (VDD I1_I1344_G14_0n XI1_I1344_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I218_MP5 (I1_p17_15 XI1_I1344_I218_Bn XI1_I1344_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I218_MP4 (XI1_I1344_I218_p1 XI1_I1344_I218_An I1_p17_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I218_MP2 (VDD I1_I1344_pn15 XI1_I1344_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I218_MP3 (XI1_I1344_I218_p1 I1_I1344_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I218_MP0 (VDD I1_I1344_pn15 XI1_I1344_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I215_MP1 (VDD I1_I1298_G11_0n XI1_I1298_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I215_MP5 (I1_p16_12 XI1_I1298_I215_Bn XI1_I1298_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I215_MP4 (XI1_I1298_I215_p1 XI1_I1298_I215_An I1_p16_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I215_MP2 (VDD I1_I1298_pn12 XI1_I1298_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I215_MP3 (XI1_I1298_I215_p1 I1_I1298_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I215_MP0 (VDD I1_I1298_pn12 XI1_I1298_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I216_MP1 (VDD I1_I1298_G12_0n XI1_I1298_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I216_MP5 (I1_p16_13 XI1_I1298_I216_Bn XI1_I1298_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I216_MP4 (XI1_I1298_I216_p1 XI1_I1298_I216_An I1_p16_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I216_MP2 (VDD I1_I1298_pn13 XI1_I1298_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I216_MP3 (XI1_I1298_I216_p1 I1_I1298_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I216_MP0 (VDD I1_I1298_pn13 XI1_I1298_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I217_MP1 (VDD I1_I1252_G13_0n XI1_I1252_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I217_MP5 (I1_p15_14 XI1_I1252_I217_Bn XI1_I1252_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I217_MP4 (XI1_I1252_I217_p1 XI1_I1252_I217_An I1_p15_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I217_MP2 (VDD I1_I1252_pn14 XI1_I1252_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I217_MP3 (XI1_I1252_I217_p1 I1_I1252_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I217_MP0 (VDD I1_I1252_pn14 XI1_I1252_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I219_MP1 (VDD I1_I1206_G15_0n XI1_I1206_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I219_MP5 (I1_p14_16 XI1_I1206_I219_Bn XI1_I1206_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I219_MP4 (XI1_I1206_I219_p1 XI1_I1206_I219_An I1_p14_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I219_MP2 (VDD I1_I1206_pn16 XI1_I1206_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I219_MP3 (XI1_I1206_I219_p1 I1_I1206_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I219_MP0 (VDD I1_I1206_pn16 XI1_I1206_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I217_MP1 (VDD I1_I1206_G13_0n XI1_I1206_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I217_MP5 (I1_p14_14 XI1_I1206_I217_Bn XI1_I1206_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I217_MP4 (XI1_I1206_I217_p1 XI1_I1206_I217_An I1_p14_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I217_MP2 (VDD I1_I1206_pn14 XI1_I1206_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I217_MP3 (XI1_I1206_I217_p1 I1_I1206_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I217_MP0 (VDD I1_I1206_pn14 XI1_I1206_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I218_MP1 (VDD I1_I1206_G14_0n XI1_I1206_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I218_MP5 (I1_p14_15 XI1_I1206_I218_Bn XI1_I1206_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I218_MP4 (XI1_I1206_I218_p1 XI1_I1206_I218_An I1_p14_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I218_MP2 (VDD I1_I1206_pn15 XI1_I1206_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I218_MP3 (XI1_I1206_I218_p1 I1_I1206_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I218_MP0 (VDD I1_I1206_pn15 XI1_I1206_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I883_MP1 (VDD I1_qu25_b3_5 XI1_I883_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I883_MP5 (I1_b7_31 XI1_I883_Bn XI1_I883_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I883_MP4 (XI1_I883_p1 XI1_I883_An I1_b7_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I883_MP2 (VDD I1_dd31_b3_1 XI1_I883_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I883_MP3 (XI1_I883_p1 I1_qu25_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I883_MP0 (VDD I1_dd31_b3_1 XI1_I883_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I885_MP1 (VDD I1_qu25_b3_5 XI1_I885_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I885_MP5 (I1_h7 XI1_I885_Bn XI1_I885_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I885_MP4 (XI1_I885_p1 XI1_I885_An I1_h7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I885_MP2 (VDD I1_p6_31 XI1_I885_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I885_MP3 (XI1_I885_p1 I1_qu25_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I885_MP0 (VDD I1_p6_31 XI1_I885_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I874_MP1 (VDD I1_qu25_b3_3 XI1_I874_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I874_MP5 (I1_b7_22 XI1_I874_Bn XI1_I874_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I874_MP4 (XI1_I874_p1 XI1_I874_An I1_b7_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I874_MP2 (VDD I1_dd22_b3_1 XI1_I874_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I874_MP3 (XI1_I874_p1 I1_qu25_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I874_MP0 (VDD I1_dd22_b3_1 XI1_I874_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I872_MP1 (VDD I1_qu25_b3_3 XI1_I872_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I872_MP5 (I1_b7_20 XI1_I872_Bn XI1_I872_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I872_MP4 (XI1_I872_p1 XI1_I872_An I1_b7_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I872_MP2 (VDD I1_dd20_b3_1 XI1_I872_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I872_MP3 (XI1_I872_p1 I1_qu25_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I872_MP0 (VDD I1_dd20_b3_1 XI1_I872_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I873_MP1 (VDD I1_qu25_b3_3 XI1_I873_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I873_MP5 (I1_b7_21 XI1_I873_Bn XI1_I873_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I873_MP4 (XI1_I873_p1 XI1_I873_An I1_b7_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I873_MP2 (VDD I1_dd21_b3_1 XI1_I873_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I873_MP3 (XI1_I873_p1 I1_qu25_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I873_MP0 (VDD I1_dd21_b3_1 XI1_I873_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I870_MP1 (VDD I1_qu25_b3_3 XI1_I870_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I870_MP5 (I1_b7_18 XI1_I870_Bn XI1_I870_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I870_MP4 (XI1_I870_p1 XI1_I870_An I1_b7_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I870_MP2 (VDD I1_dd18_b3_1 XI1_I870_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I870_MP3 (XI1_I870_p1 I1_qu25_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I870_MP0 (VDD I1_dd18_b3_1 XI1_I870_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I871_MP1 (VDD I1_qu25_b3_3 XI1_I871_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I871_MP5 (I1_b7_19 XI1_I871_Bn XI1_I871_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I871_MP4 (XI1_I871_p1 XI1_I871_An I1_b7_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I871_MP2 (VDD I1_dd19_b3_1 XI1_I871_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I871_MP3 (XI1_I871_p1 I1_qu25_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I871_MP0 (VDD I1_dd19_b3_1 XI1_I871_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I869_MP1 (VDD I1_qu25_b3_2 XI1_I869_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I869_MP5 (I1_b7_17 XI1_I869_Bn XI1_I869_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I869_MP4 (XI1_I869_p1 XI1_I869_An I1_b7_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I869_MP2 (VDD I1_dd17_b3_1 XI1_I869_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I869_MP3 (XI1_I869_p1 I1_qu25_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I869_MP0 (VDD I1_dd17_b3_1 XI1_I869_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I867_MP1 (VDD I1_qu25_b3_2 XI1_I867_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I867_MP5 (I1_b7_15 XI1_I867_Bn XI1_I867_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I867_MP4 (XI1_I867_p1 XI1_I867_An I1_b7_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I867_MP2 (VDD I1_dd15_b3_1 XI1_I867_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I867_MP3 (XI1_I867_p1 I1_qu25_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I867_MP0 (VDD I1_dd15_b3_1 XI1_I867_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I822_MP1 (VDD I1_qu26_b3_2 XI1_I822_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I822_MP5 (I1_b6_16 XI1_I822_Bn XI1_I822_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I822_MP4 (XI1_I822_p1 XI1_I822_An I1_b6_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I822_MP2 (VDD I1_dd16_b3_1 XI1_I822_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I822_MP3 (XI1_I822_p1 I1_qu26_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I822_MP0 (VDD I1_dd16_b3_1 XI1_I822_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I820_MP1 (VDD I1_qu26_b3_2 XI1_I820_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I820_MP5 (I1_b6_14 XI1_I820_Bn XI1_I820_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I820_MP4 (XI1_I820_p1 XI1_I820_An I1_b6_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I820_MP2 (VDD I1_dd14_b3_1 XI1_I820_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I820_MP3 (XI1_I820_p1 I1_qu26_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I820_MP0 (VDD I1_dd14_b3_1 XI1_I820_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I821_MP1 (VDD I1_qu26_b3_2 XI1_I821_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I821_MP5 (I1_b6_15 XI1_I821_Bn XI1_I821_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I821_MP4 (XI1_I821_p1 XI1_I821_An I1_b6_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I821_MP2 (VDD I1_dd15_b3_1 XI1_I821_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I821_MP3 (XI1_I821_p1 I1_qu26_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I821_MP0 (VDD I1_dd15_b3_1 XI1_I821_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I819_MP1 (VDD I1_qu26_b3_2 XI1_I819_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I819_MP5 (I1_b6_13 XI1_I819_Bn XI1_I819_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I819_MP4 (XI1_I819_p1 XI1_I819_An I1_b6_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I819_MP2 (VDD I1_dd13_b3_1 XI1_I819_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I819_MP3 (XI1_I819_p1 I1_qu26_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I819_MP0 (VDD I1_dd13_b3_1 XI1_I819_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I818_MP1 (VDD I1_qu26_b3_2 XI1_I818_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I818_MP5 (I1_b6_12 XI1_I818_Bn XI1_I818_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I818_MP4 (XI1_I818_p1 XI1_I818_An I1_b6_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I818_MP2 (VDD I1_dd12_b3_1 XI1_I818_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I818_MP3 (XI1_I818_p1 I1_qu26_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I818_MP0 (VDD I1_dd12_b3_1 XI1_I818_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I207_MP1 (VDD I1_I838_G3_0n XI1_I838_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I207_MP5 (I1_p6_4 XI1_I838_I207_Bn XI1_I838_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I207_MP4 (XI1_I838_I207_p1 XI1_I838_I207_An I1_p6_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I207_MP2 (VDD I1_I838_pn4 XI1_I838_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I207_MP3 (XI1_I838_I207_p1 I1_I838_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I207_MP0 (VDD I1_I838_pn4 XI1_I838_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I207_MP1 (VDD I1_I792_G3_0n XI1_I792_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I207_MP5 (I1_p5_4 XI1_I792_I207_Bn XI1_I792_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I207_MP4 (XI1_I792_I207_p1 XI1_I792_I207_An I1_p5_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I207_MP2 (VDD I1_I792_pn4 XI1_I792_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I207_MP3 (XI1_I792_I207_p1 I1_I792_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I207_MP0 (VDD I1_I792_pn4 XI1_I792_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I212_MP1 (VDD I1_I746_G8_0n XI1_I746_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I212_MP5 (I1_p4_9 XI1_I746_I212_Bn XI1_I746_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I212_MP4 (XI1_I746_I212_p1 XI1_I746_I212_An I1_p4_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I212_MP2 (VDD I1_I746_pn9 XI1_I746_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I212_MP3 (XI1_I746_I212_p1 I1_I746_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I212_MP0 (VDD I1_I746_pn9 XI1_I746_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I214_MP1 (VDD I1_I746_G10_0n XI1_I746_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I214_MP5 (I1_p4_11 XI1_I746_I214_Bn XI1_I746_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I214_MP4 (XI1_I746_I214_p1 XI1_I746_I214_An I1_p4_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I214_MP2 (VDD I1_I746_pn11 XI1_I746_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I214_MP3 (XI1_I746_I214_p1 I1_I746_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I214_MP0 (VDD I1_I746_pn11 XI1_I746_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I216_MP1 (VDD I1_I746_G12_0n XI1_I746_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I216_MP5 (I1_p4_13 XI1_I746_I216_Bn XI1_I746_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I216_MP4 (XI1_I746_I216_p1 XI1_I746_I216_An I1_p4_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I216_MP2 (VDD I1_I746_pn13 XI1_I746_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I216_MP3 (XI1_I746_I216_p1 I1_I746_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I216_MP0 (VDD I1_I746_pn13 XI1_I746_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I217_MP1 (VDD I1_I746_G13_0n XI1_I746_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I217_MP5 (I1_p4_14 XI1_I746_I217_Bn XI1_I746_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I217_MP4 (XI1_I746_I217_p1 XI1_I746_I217_An I1_p4_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I217_MP2 (VDD I1_I746_pn14 XI1_I746_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I217_MP3 (XI1_I746_I217_p1 I1_I746_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I217_MP0 (VDD I1_I746_pn14 XI1_I746_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I219_MP1 (VDD I1_I746_G15_0n XI1_I746_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I219_MP5 (I1_p4_16 XI1_I746_I219_Bn XI1_I746_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I219_MP4 (XI1_I746_I219_p1 XI1_I746_I219_An I1_p4_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I219_MP2 (VDD I1_I746_pn16 XI1_I746_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I219_MP3 (XI1_I746_I219_p1 I1_I746_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I219_MP0 (VDD I1_I746_pn16 XI1_I746_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1387_MP1 (VDD I1_qu14_b3_4 XI1_I1387_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1387_MP5 (I1_b18_29 XI1_I1387_Bn XI1_I1387_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1387_MP4 (XI1_I1387_p1 XI1_I1387_An I1_b18_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1387_MP2 (VDD I1_dd29_b3_3 XI1_I1387_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1387_MP3 (XI1_I1387_p1 I1_qu14_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1387_MP0 (VDD I1_dd29_b3_3 XI1_I1387_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1386_MP1 (VDD I1_qu14_b3_4 XI1_I1386_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1386_MP5 (I1_b18_28 XI1_I1386_Bn XI1_I1386_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1386_MP4 (XI1_I1386_p1 XI1_I1386_An I1_b18_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1386_MP2 (VDD I1_dd28_b3_3 XI1_I1386_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1386_MP3 (XI1_I1386_p1 I1_qu14_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1386_MP0 (VDD I1_dd28_b3_3 XI1_I1386_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1383_MP1 (VDD I1_qu14_b3_4 XI1_I1383_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1383_MP5 (I1_b18_25 XI1_I1383_Bn XI1_I1383_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1383_MP4 (XI1_I1383_p1 XI1_I1383_An I1_b18_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1383_MP2 (VDD I1_dd25_b3_3 XI1_I1383_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1383_MP3 (XI1_I1383_p1 I1_qu14_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1383_MP0 (VDD I1_dd25_b3_3 XI1_I1383_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I215_MP1 (VDD I1_I1344_G11_0n XI1_I1344_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I215_MP5 (I1_p17_12 XI1_I1344_I215_Bn XI1_I1344_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I215_MP4 (XI1_I1344_I215_p1 XI1_I1344_I215_An I1_p17_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I215_MP2 (VDD I1_I1344_pn12 XI1_I1344_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I215_MP3 (XI1_I1344_I215_p1 I1_I1344_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I215_MP0 (VDD I1_I1344_pn12 XI1_I1344_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I214_MP1 (VDD I1_I1298_G10_0n XI1_I1298_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I214_MP5 (I1_p16_11 XI1_I1298_I214_Bn XI1_I1298_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I214_MP4 (XI1_I1298_I214_p1 XI1_I1298_I214_An I1_p16_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I214_MP2 (VDD I1_I1298_pn11 XI1_I1298_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I214_MP3 (XI1_I1298_I214_p1 I1_I1298_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I214_MP0 (VDD I1_I1298_pn11 XI1_I1298_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1283_MP1 (VDD I1_qu16_b3_2 XI1_I1283_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1283_MP5 (I1_b16_17 XI1_I1283_Bn XI1_I1283_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1283_MP4 (XI1_I1283_p1 XI1_I1283_An I1_b16_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1283_MP2 (VDD I1_dd17_b3_2 XI1_I1283_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1283_MP3 (XI1_I1283_p1 I1_qu16_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1283_MP0 (VDD I1_dd17_b3_2 XI1_I1283_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1282_MP1 (VDD I1_qu16_b3_2 XI1_I1282_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1282_MP5 (I1_b16_16 XI1_I1282_Bn XI1_I1282_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1282_MP4 (XI1_I1282_p1 XI1_I1282_An I1_b16_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1282_MP2 (VDD I1_dd16_b3_2 XI1_I1282_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1282_MP3 (XI1_I1282_p1 I1_qu16_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1282_MP0 (VDD I1_dd16_b3_2 XI1_I1282_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1281_MP1 (VDD I1_qu16_b3_2 XI1_I1281_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1281_MP5 (I1_b16_15 XI1_I1281_Bn XI1_I1281_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1281_MP4 (XI1_I1281_p1 XI1_I1281_An I1_b16_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1281_MP2 (VDD I1_dd15_b3_2 XI1_I1281_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1281_MP3 (XI1_I1281_p1 I1_qu16_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1281_MP0 (VDD I1_dd15_b3_2 XI1_I1281_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I216_MP1 (VDD I1_I1252_G12_0n XI1_I1252_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I216_MP5 (I1_p15_13 XI1_I1252_I216_Bn XI1_I1252_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I216_MP4 (XI1_I1252_I216_p1 XI1_I1252_I216_An I1_p15_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I216_MP2 (VDD I1_I1252_pn13 XI1_I1252_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I216_MP3 (XI1_I1252_I216_p1 I1_I1252_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I216_MP0 (VDD I1_I1252_pn13 XI1_I1252_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I215_MP1 (VDD I1_I1252_G11_0n XI1_I1252_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I215_MP5 (I1_p15_12 XI1_I1252_I215_Bn XI1_I1252_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I215_MP4 (XI1_I1252_I215_p1 XI1_I1252_I215_An I1_p15_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I215_MP2 (VDD I1_I1252_pn12 XI1_I1252_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I215_MP3 (XI1_I1252_I215_p1 I1_I1252_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I215_MP0 (VDD I1_I1252_pn12 XI1_I1252_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1235_MP1 (VDD I1_qu17_b3_2 XI1_I1235_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1235_MP5 (I1_b15_15 XI1_I1235_Bn XI1_I1235_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1235_MP4 (XI1_I1235_p1 XI1_I1235_An I1_b15_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1235_MP2 (VDD I1_dd15_b3_2 XI1_I1235_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1235_MP3 (XI1_I1235_p1 I1_qu17_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1235_MP0 (VDD I1_dd15_b3_2 XI1_I1235_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I216_MP1 (VDD I1_I1206_G12_0n XI1_I1206_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I216_MP5 (I1_p14_13 XI1_I1206_I216_Bn XI1_I1206_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I216_MP4 (XI1_I1206_I216_p1 XI1_I1206_I216_An I1_p14_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I216_MP2 (VDD I1_I1206_pn13 XI1_I1206_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I216_MP3 (XI1_I1206_I216_p1 I1_I1206_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I216_MP0 (VDD I1_I1206_pn13 XI1_I1206_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I215_MP1 (VDD I1_I1206_G11_0n XI1_I1206_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I215_MP5 (I1_p14_12 XI1_I1206_I215_Bn XI1_I1206_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I215_MP4 (XI1_I1206_I215_p1 XI1_I1206_I215_An I1_p14_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I215_MP2 (VDD I1_I1206_pn12 XI1_I1206_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I215_MP3 (XI1_I1206_I215_p1 I1_I1206_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I215_MP0 (VDD I1_I1206_pn12 XI1_I1206_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I868_MP1 (VDD I1_qu25_b3_2 XI1_I868_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I868_MP5 (I1_b7_16 XI1_I868_Bn XI1_I868_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I868_MP4 (XI1_I868_p1 XI1_I868_An I1_b7_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I868_MP2 (VDD I1_dd16_b3_1 XI1_I868_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I868_MP3 (XI1_I868_p1 I1_qu25_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I868_MP0 (VDD I1_dd16_b3_1 XI1_I868_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I866_MP1 (VDD I1_qu25_b3_2 XI1_I866_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I866_MP5 (I1_b7_14 XI1_I866_Bn XI1_I866_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I866_MP4 (XI1_I866_p1 XI1_I866_An I1_b7_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I866_MP2 (VDD I1_dd14_b3_1 XI1_I866_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I866_MP3 (XI1_I866_p1 I1_qu25_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I866_MP0 (VDD I1_dd14_b3_1 XI1_I866_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I864_MP1 (VDD I1_qu25_b3_2 XI1_I864_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I864_MP5 (I1_b7_12 XI1_I864_Bn XI1_I864_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I864_MP4 (XI1_I864_p1 XI1_I864_An I1_b7_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I864_MP2 (VDD I1_dd12_b3_1 XI1_I864_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I864_MP3 (XI1_I864_p1 I1_qu25_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I864_MP0 (VDD I1_dd12_b3_1 XI1_I864_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I865_MP1 (VDD I1_qu25_b3_2 XI1_I865_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I865_MP5 (I1_b7_13 XI1_I865_Bn XI1_I865_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I865_MP4 (XI1_I865_p1 XI1_I865_An I1_b7_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I865_MP2 (VDD I1_dd13_b3_1 XI1_I865_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I865_MP3 (XI1_I865_p1 I1_qu25_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I865_MP0 (VDD I1_dd13_b3_1 XI1_I865_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I863_MP1 (VDD I1_qu25_b3_1 XI1_I863_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I863_MP5 (I1_b7_11 XI1_I863_Bn XI1_I863_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I863_MP4 (XI1_I863_p1 XI1_I863_An I1_b7_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I863_MP2 (VDD I1_dd11_b3_1 XI1_I863_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I863_MP3 (XI1_I863_p1 I1_qu25_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I863_MP0 (VDD I1_dd11_b3_1 XI1_I863_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I816_MP1 (VDD I1_qu26_b3_1 XI1_I816_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I816_MP5 (I1_b6_10 XI1_I816_Bn XI1_I816_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I816_MP4 (XI1_I816_p1 XI1_I816_An I1_b6_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I816_MP2 (VDD I1_dd10_b3_1 XI1_I816_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I816_MP3 (XI1_I816_p1 I1_qu26_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I816_MP0 (VDD I1_dd10_b3_1 XI1_I816_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I817_MP1 (VDD I1_qu26_b3_1 XI1_I817_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I817_MP5 (I1_b6_11 XI1_I817_Bn XI1_I817_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I817_MP4 (XI1_I817_p1 XI1_I817_An I1_b6_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I817_MP2 (VDD I1_dd11_b3_1 XI1_I817_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I817_MP3 (XI1_I817_p1 I1_qu26_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I817_MP0 (VDD I1_dd11_b3_1 XI1_I817_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I815_MP1 (VDD I1_qu26_b3_1 XI1_I815_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I815_MP5 (I1_b6_9 XI1_I815_Bn XI1_I815_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I815_MP4 (XI1_I815_p1 XI1_I815_An I1_b6_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I815_MP2 (VDD I1_dd9_b3_1 XI1_I815_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I815_MP3 (XI1_I815_p1 I1_qu26_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I815_MP0 (VDD I1_dd9_b3_1 XI1_I815_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I206_MP1 (VDD I1_I838_G2_0n XI1_I838_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I838_I206_MP5 (I1_p6_3 XI1_I838_I206_Bn XI1_I838_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I838_I206_MP4 (XI1_I838_I206_p1 XI1_I838_I206_An I1_p6_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I206_MP2 (VDD I1_I838_pn3 XI1_I838_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I838_I206_MP3 (XI1_I838_I206_p1 I1_I838_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I838_I206_MP0 (VDD I1_I838_pn3 XI1_I838_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I206_MP1 (VDD I1_I792_G2_0n XI1_I792_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I792_I206_MP5 (I1_p5_3 XI1_I792_I206_Bn XI1_I792_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I792_I206_MP4 (XI1_I792_I206_p1 XI1_I792_I206_An I1_p5_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I206_MP2 (VDD I1_I792_pn3 XI1_I792_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I792_I206_MP3 (XI1_I792_I206_p1 I1_I792_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I792_I206_MP0 (VDD I1_I792_pn3 XI1_I792_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I213_MP1 (VDD I1_I746_G9_0n XI1_I746_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I213_MP5 (I1_p4_10 XI1_I746_I213_Bn XI1_I746_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I213_MP4 (XI1_I746_I213_p1 XI1_I746_I213_An I1_p4_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I213_MP2 (VDD I1_I746_pn10 XI1_I746_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I213_MP3 (XI1_I746_I213_p1 I1_I746_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I213_MP0 (VDD I1_I746_pn10 XI1_I746_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I215_MP1 (VDD I1_I746_G11_0n XI1_I746_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I215_MP5 (I1_p4_12 XI1_I746_I215_Bn XI1_I746_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I215_MP4 (XI1_I746_I215_p1 XI1_I746_I215_An I1_p4_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I215_MP2 (VDD I1_I746_pn12 XI1_I746_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I215_MP3 (XI1_I746_I215_p1 I1_I746_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I215_MP0 (VDD I1_I746_pn12 XI1_I746_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I745_MP1 (VDD I1_qu28_b3_5 XI1_I745_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I745_MP5 (I1_b4_31 XI1_I745_Bn XI1_I745_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I745_MP4 (XI1_I745_p1 XI1_I745_An I1_b4_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I745_MP2 (VDD I1_dd31_b3_0 XI1_I745_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I745_MP3 (XI1_I745_p1 I1_qu28_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I745_MP0 (VDD I1_dd31_b3_0 XI1_I745_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1384_MP1 (VDD I1_qu14_b3_4 XI1_I1384_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1384_MP5 (I1_b18_26 XI1_I1384_Bn XI1_I1384_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1384_MP4 (XI1_I1384_p1 XI1_I1384_An I1_b18_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1384_MP2 (VDD I1_dd26_b3_3 XI1_I1384_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1384_MP3 (XI1_I1384_p1 I1_qu14_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1384_MP0 (VDD I1_dd26_b3_3 XI1_I1384_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1382_MP1 (VDD I1_qu14_b3_4 XI1_I1382_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1382_MP5 (I1_b18_24 XI1_I1382_Bn XI1_I1382_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1382_MP4 (XI1_I1382_p1 XI1_I1382_An I1_b18_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1382_MP2 (VDD I1_dd24_b3_3 XI1_I1382_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1382_MP3 (XI1_I1382_p1 I1_qu14_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1382_MP0 (VDD I1_dd24_b3_3 XI1_I1382_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1332_MP1 (VDD I1_qu15_b3_3 XI1_I1332_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1332_MP5 (I1_b17_20 XI1_I1332_Bn XI1_I1332_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1332_MP4 (XI1_I1332_p1 XI1_I1332_An I1_b17_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1332_MP2 (VDD I1_dd20_b3_3 XI1_I1332_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1332_MP3 (XI1_I1332_p1 I1_qu15_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1332_MP0 (VDD I1_dd20_b3_3 XI1_I1332_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1335_MP1 (VDD I1_qu15_b3_3 XI1_I1335_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1335_MP5 (I1_b17_23 XI1_I1335_Bn XI1_I1335_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1335_MP4 (XI1_I1335_p1 XI1_I1335_An I1_b17_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1335_MP2 (VDD I1_dd23_b3_3 XI1_I1335_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1335_MP3 (XI1_I1335_p1 I1_qu15_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1335_MP0 (VDD I1_dd23_b3_3 XI1_I1335_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1330_MP1 (VDD I1_qu15_b3_3 XI1_I1330_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1330_MP5 (I1_b17_18 XI1_I1330_Bn XI1_I1330_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1330_MP4 (XI1_I1330_p1 XI1_I1330_An I1_b17_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1330_MP2 (VDD I1_dd18_b3_3 XI1_I1330_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1330_MP3 (XI1_I1330_p1 I1_qu15_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1330_MP0 (VDD I1_dd18_b3_3 XI1_I1330_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I216_MP1 (VDD I1_I1344_G12_0n XI1_I1344_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I216_MP5 (I1_p17_13 XI1_I1344_I216_Bn XI1_I1344_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I216_MP4 (XI1_I1344_I216_p1 XI1_I1344_I216_An I1_p17_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I216_MP2 (VDD I1_I1344_pn13 XI1_I1344_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I216_MP3 (XI1_I1344_I216_p1 I1_I1344_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I216_MP0 (VDD I1_I1344_pn13 XI1_I1344_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I214_MP1 (VDD I1_I1344_G10_0n XI1_I1344_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I214_MP5 (I1_p17_11 XI1_I1344_I214_Bn XI1_I1344_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I214_MP4 (XI1_I1344_I214_p1 XI1_I1344_I214_An I1_p17_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I214_MP2 (VDD I1_I1344_pn11 XI1_I1344_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I214_MP3 (XI1_I1344_I214_p1 I1_I1344_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I214_MP0 (VDD I1_I1344_pn11 XI1_I1344_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I213_MP1 (VDD I1_I1344_G9_0n XI1_I1344_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I213_MP5 (I1_p17_10 XI1_I1344_I213_Bn XI1_I1344_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I213_MP4 (XI1_I1344_I213_p1 XI1_I1344_I213_An I1_p17_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I213_MP2 (VDD I1_I1344_pn10 XI1_I1344_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I213_MP3 (XI1_I1344_I213_p1 I1_I1344_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I213_MP0 (VDD I1_I1344_pn10 XI1_I1344_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I213_MP1 (VDD I1_I1298_G9_0n XI1_I1298_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I213_MP5 (I1_p16_10 XI1_I1298_I213_Bn XI1_I1298_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I213_MP4 (XI1_I1298_I213_p1 XI1_I1298_I213_An I1_p16_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I213_MP2 (VDD I1_I1298_pn10 XI1_I1298_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I213_MP3 (XI1_I1298_I213_p1 I1_I1298_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I213_MP0 (VDD I1_I1298_pn10 XI1_I1298_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1278_MP1 (VDD I1_qu16_b3_2 XI1_I1278_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1278_MP5 (I1_b16_12 XI1_I1278_Bn XI1_I1278_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1278_MP4 (XI1_I1278_p1 XI1_I1278_An I1_b16_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1278_MP2 (VDD I1_dd12_b3_2 XI1_I1278_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1278_MP3 (XI1_I1278_p1 I1_qu16_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1278_MP0 (VDD I1_dd12_b3_2 XI1_I1278_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1280_MP1 (VDD I1_qu16_b3_2 XI1_I1280_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1280_MP5 (I1_b16_14 XI1_I1280_Bn XI1_I1280_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1280_MP4 (XI1_I1280_p1 XI1_I1280_An I1_b16_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1280_MP2 (VDD I1_dd14_b3_2 XI1_I1280_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1280_MP3 (XI1_I1280_p1 I1_qu16_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1280_MP0 (VDD I1_dd14_b3_2 XI1_I1280_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I214_MP1 (VDD I1_I1252_G10_0n XI1_I1252_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I214_MP5 (I1_p15_11 XI1_I1252_I214_Bn XI1_I1252_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I214_MP4 (XI1_I1252_I214_p1 XI1_I1252_I214_An I1_p15_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I214_MP2 (VDD I1_I1252_pn11 XI1_I1252_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I214_MP3 (XI1_I1252_I214_p1 I1_I1252_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I214_MP0 (VDD I1_I1252_pn11 XI1_I1252_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I213_MP1 (VDD I1_I1252_G9_0n XI1_I1252_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I213_MP5 (I1_p15_10 XI1_I1252_I213_Bn XI1_I1252_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I213_MP4 (XI1_I1252_I213_p1 XI1_I1252_I213_An I1_p15_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I213_MP2 (VDD I1_I1252_pn10 XI1_I1252_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I213_MP3 (XI1_I1252_I213_p1 I1_I1252_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I213_MP0 (VDD I1_I1252_pn10 XI1_I1252_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1234_MP1 (VDD I1_qu17_b3_2 XI1_I1234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1234_MP5 (I1_b15_14 XI1_I1234_Bn XI1_I1234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1234_MP4 (XI1_I1234_p1 XI1_I1234_An I1_b15_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1234_MP2 (VDD I1_dd14_b3_2 XI1_I1234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1234_MP3 (XI1_I1234_p1 I1_qu17_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1234_MP0 (VDD I1_dd14_b3_2 XI1_I1234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1237_MP1 (VDD I1_qu17_b3_2 XI1_I1237_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1237_MP5 (I1_b15_17 XI1_I1237_Bn XI1_I1237_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1237_MP4 (XI1_I1237_p1 XI1_I1237_An I1_b15_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1237_MP2 (VDD I1_dd17_b3_2 XI1_I1237_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1237_MP3 (XI1_I1237_p1 I1_qu17_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1237_MP0 (VDD I1_dd17_b3_2 XI1_I1237_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1236_MP1 (VDD I1_qu17_b3_2 XI1_I1236_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1236_MP5 (I1_b15_16 XI1_I1236_Bn XI1_I1236_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1236_MP4 (XI1_I1236_p1 XI1_I1236_An I1_b15_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1236_MP2 (VDD I1_dd16_b3_2 XI1_I1236_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1236_MP3 (XI1_I1236_p1 I1_qu17_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1236_MP0 (VDD I1_dd16_b3_2 XI1_I1236_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1191_MP1 (VDD I1_qu18_b3_2 XI1_I1191_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1191_MP5 (I1_b14_17 XI1_I1191_Bn XI1_I1191_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1191_MP4 (XI1_I1191_p1 XI1_I1191_An I1_b14_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1191_MP2 (VDD I1_dd17_b3_2 XI1_I1191_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1191_MP3 (XI1_I1191_p1 I1_qu18_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1191_MP0 (VDD I1_dd17_b3_2 XI1_I1191_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1189_MP1 (VDD I1_qu18_b3_2 XI1_I1189_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1189_MP5 (I1_b14_15 XI1_I1189_Bn XI1_I1189_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1189_MP4 (XI1_I1189_p1 XI1_I1189_An I1_b14_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1189_MP2 (VDD I1_dd15_b3_2 XI1_I1189_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1189_MP3 (XI1_I1189_p1 I1_qu18_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1189_MP0 (VDD I1_dd15_b3_2 XI1_I1189_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I214_MP1 (VDD I1_I1206_G10_0n XI1_I1206_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I214_MP5 (I1_p14_11 XI1_I1206_I214_Bn XI1_I1206_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I214_MP4 (XI1_I1206_I214_p1 XI1_I1206_I214_An I1_p14_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I214_MP2 (VDD I1_I1206_pn11 XI1_I1206_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I214_MP3 (XI1_I1206_I214_p1 I1_I1206_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I214_MP0 (VDD I1_I1206_pn11 XI1_I1206_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I213_MP1 (VDD I1_I1206_G9_0n XI1_I1206_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I213_MP5 (I1_p14_10 XI1_I1206_I213_Bn XI1_I1206_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I213_MP4 (XI1_I1206_I213_p1 XI1_I1206_I213_An I1_p14_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I213_MP2 (VDD I1_I1206_pn10 XI1_I1206_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I213_MP3 (XI1_I1206_I213_p1 I1_I1206_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I213_MP0 (VDD I1_I1206_pn10 XI1_I1206_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I862_MP1 (VDD I1_qu25_b3_1 XI1_I862_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I862_MP5 (I1_b7_10 XI1_I862_Bn XI1_I862_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I862_MP4 (XI1_I862_p1 XI1_I862_An I1_b7_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I862_MP2 (VDD I1_dd10_b3_1 XI1_I862_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I862_MP3 (XI1_I862_p1 I1_qu25_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I862_MP0 (VDD I1_dd10_b3_1 XI1_I862_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I861_MP1 (VDD I1_qu25_b3_1 XI1_I861_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I861_MP5 (I1_b7_9 XI1_I861_Bn XI1_I861_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I861_MP4 (XI1_I861_p1 XI1_I861_An I1_b7_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I861_MP2 (VDD I1_dd9_b3_1 XI1_I861_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I861_MP3 (XI1_I861_p1 I1_qu25_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I861_MP0 (VDD I1_dd9_b3_1 XI1_I861_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I859_MP1 (VDD I1_qu25_b3_1 XI1_I859_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I859_MP5 (I1_b7_7 XI1_I859_Bn XI1_I859_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I859_MP4 (XI1_I859_p1 XI1_I859_An I1_b7_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I859_MP2 (VDD I1_dd7_b3_1 XI1_I859_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I859_MP3 (XI1_I859_p1 I1_qu25_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I859_MP0 (VDD I1_dd7_b3_1 XI1_I859_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I814_MP1 (VDD I1_qu26_b3_1 XI1_I814_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I814_MP5 (I1_b6_8 XI1_I814_Bn XI1_I814_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I814_MP4 (XI1_I814_p1 XI1_I814_An I1_b6_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I814_MP2 (VDD I1_dd8_b3_1 XI1_I814_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I814_MP3 (XI1_I814_p1 I1_qu26_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I814_MP0 (VDD I1_dd8_b3_1 XI1_I814_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I813_MP1 (VDD I1_qu26_b3_1 XI1_I813_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I813_MP5 (I1_b6_7 XI1_I813_Bn XI1_I813_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I813_MP4 (XI1_I813_p1 XI1_I813_An I1_b6_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I813_MP2 (VDD I1_dd7_b3_1 XI1_I813_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I813_MP3 (XI1_I813_p1 I1_qu26_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I813_MP0 (VDD I1_dd7_b3_1 XI1_I813_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I744_MP1 (VDD I1_qu28_b3_5 XI1_I744_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I744_MP5 (I1_b4_30 XI1_I744_Bn XI1_I744_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I744_MP4 (XI1_I744_p1 XI1_I744_An I1_b4_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I744_MP2 (VDD I1_dd30_b3_0 XI1_I744_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I744_MP3 (XI1_I744_p1 I1_qu28_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I744_MP0 (VDD I1_dd30_b3_0 XI1_I744_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1389_MP1 (VDD I1_qu14_b3_5 XI1_I1389_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1389_MP5 (I1_b18_31 XI1_I1389_Bn XI1_I1389_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1389_MP4 (XI1_I1389_p1 XI1_I1389_An I1_b18_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1389_MP2 (VDD I1_dd31_b3_3 XI1_I1389_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1389_MP3 (XI1_I1389_p1 I1_qu14_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1389_MP0 (VDD I1_dd31_b3_3 XI1_I1389_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1391_MP1 (VDD I1_qu14_b3_5 XI1_I1391_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1391_MP5 (I1_h18 XI1_I1391_Bn XI1_I1391_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1391_MP4 (XI1_I1391_p1 XI1_I1391_An I1_h18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1391_MP2 (VDD I1_p17_31 XI1_I1391_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1391_MP3 (XI1_I1391_p1 I1_qu14_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1391_MP0 (VDD I1_p17_31 XI1_I1391_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1380_MP1 (VDD I1_qu14_b3_3 XI1_I1380_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1380_MP5 (I1_b18_22 XI1_I1380_Bn XI1_I1380_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1380_MP4 (XI1_I1380_p1 XI1_I1380_An I1_b18_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1380_MP2 (VDD I1_dd22_b3_3 XI1_I1380_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1380_MP3 (XI1_I1380_p1 I1_qu14_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1380_MP0 (VDD I1_dd22_b3_3 XI1_I1380_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1334_MP1 (VDD I1_qu15_b3_3 XI1_I1334_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1334_MP5 (I1_b17_22 XI1_I1334_Bn XI1_I1334_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1334_MP4 (XI1_I1334_p1 XI1_I1334_An I1_b17_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1334_MP2 (VDD I1_dd22_b3_3 XI1_I1334_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1334_MP3 (XI1_I1334_p1 I1_qu15_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1334_MP0 (VDD I1_dd22_b3_3 XI1_I1334_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1333_MP1 (VDD I1_qu15_b3_3 XI1_I1333_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1333_MP5 (I1_b17_21 XI1_I1333_Bn XI1_I1333_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1333_MP4 (XI1_I1333_p1 XI1_I1333_An I1_b17_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1333_MP2 (VDD I1_dd21_b3_3 XI1_I1333_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1333_MP3 (XI1_I1333_p1 I1_qu15_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1333_MP0 (VDD I1_dd21_b3_3 XI1_I1333_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1331_MP1 (VDD I1_qu15_b3_3 XI1_I1331_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1331_MP5 (I1_b17_19 XI1_I1331_Bn XI1_I1331_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1331_MP4 (XI1_I1331_p1 XI1_I1331_An I1_b17_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1331_MP2 (VDD I1_dd19_b3_3 XI1_I1331_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1331_MP3 (XI1_I1331_p1 I1_qu15_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1331_MP0 (VDD I1_dd19_b3_3 XI1_I1331_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I212_MP1 (VDD I1_I1344_G8_0n XI1_I1344_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I212_MP5 (I1_p17_9 XI1_I1344_I212_Bn XI1_I1344_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I212_MP4 (XI1_I1344_I212_p1 XI1_I1344_I212_An I1_p17_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I212_MP2 (VDD I1_I1344_pn9 XI1_I1344_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I212_MP3 (XI1_I1344_I212_p1 I1_I1344_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I212_MP0 (VDD I1_I1344_pn9 XI1_I1344_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I212_MP1 (VDD I1_I1298_G8_0n XI1_I1298_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I212_MP5 (I1_p16_9 XI1_I1298_I212_Bn XI1_I1298_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I212_MP4 (XI1_I1298_I212_p1 XI1_I1298_I212_An I1_p16_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I212_MP2 (VDD I1_I1298_pn9 XI1_I1298_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I212_MP3 (XI1_I1298_I212_p1 I1_I1298_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I212_MP0 (VDD I1_I1298_pn9 XI1_I1298_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1279_MP1 (VDD I1_qu16_b3_2 XI1_I1279_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1279_MP5 (I1_b16_13 XI1_I1279_Bn XI1_I1279_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1279_MP4 (XI1_I1279_p1 XI1_I1279_An I1_b16_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1279_MP2 (VDD I1_dd13_b3_2 XI1_I1279_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1279_MP3 (XI1_I1279_p1 I1_qu16_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1279_MP0 (VDD I1_dd13_b3_2 XI1_I1279_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I212_MP1 (VDD I1_I1252_G8_0n XI1_I1252_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I212_MP5 (I1_p15_9 XI1_I1252_I212_Bn XI1_I1252_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I212_MP4 (XI1_I1252_I212_p1 XI1_I1252_I212_An I1_p15_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I212_MP2 (VDD I1_I1252_pn9 XI1_I1252_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I212_MP3 (XI1_I1252_I212_p1 I1_I1252_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I212_MP0 (VDD I1_I1252_pn9 XI1_I1252_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1233_MP1 (VDD I1_qu17_b3_2 XI1_I1233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1233_MP5 (I1_b15_13 XI1_I1233_Bn XI1_I1233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1233_MP4 (XI1_I1233_p1 XI1_I1233_An I1_b15_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1233_MP2 (VDD I1_dd13_b3_2 XI1_I1233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1233_MP3 (XI1_I1233_p1 I1_qu17_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1233_MP0 (VDD I1_dd13_b3_2 XI1_I1233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1232_MP1 (VDD I1_qu17_b3_2 XI1_I1232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1232_MP5 (I1_b15_12 XI1_I1232_Bn XI1_I1232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1232_MP4 (XI1_I1232_p1 XI1_I1232_An I1_b15_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1232_MP2 (VDD I1_dd12_b3_2 XI1_I1232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1232_MP3 (XI1_I1232_p1 I1_qu17_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1232_MP0 (VDD I1_dd12_b3_2 XI1_I1232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1190_MP1 (VDD I1_qu18_b3_2 XI1_I1190_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1190_MP5 (I1_b14_16 XI1_I1190_Bn XI1_I1190_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1190_MP4 (XI1_I1190_p1 XI1_I1190_An I1_b14_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1190_MP2 (VDD I1_dd16_b3_2 XI1_I1190_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1190_MP3 (XI1_I1190_p1 I1_qu18_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1190_MP0 (VDD I1_dd16_b3_2 XI1_I1190_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1187_MP1 (VDD I1_qu18_b3_2 XI1_I1187_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1187_MP5 (I1_b14_13 XI1_I1187_Bn XI1_I1187_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1187_MP4 (XI1_I1187_p1 XI1_I1187_An I1_b14_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1187_MP2 (VDD I1_dd13_b3_2 XI1_I1187_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1187_MP3 (XI1_I1187_p1 I1_qu18_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1187_MP0 (VDD I1_dd13_b3_2 XI1_I1187_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1188_MP1 (VDD I1_qu18_b3_2 XI1_I1188_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1188_MP5 (I1_b14_14 XI1_I1188_Bn XI1_I1188_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1188_MP4 (XI1_I1188_p1 XI1_I1188_An I1_b14_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1188_MP2 (VDD I1_dd14_b3_2 XI1_I1188_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1188_MP3 (XI1_I1188_p1 I1_qu18_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1188_MP0 (VDD I1_dd14_b3_2 XI1_I1188_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I212_MP1 (VDD I1_I1206_G8_0n XI1_I1206_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I212_MP5 (I1_p14_9 XI1_I1206_I212_Bn XI1_I1206_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I212_MP4 (XI1_I1206_I212_p1 XI1_I1206_I212_An I1_p14_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I212_MP2 (VDD I1_I1206_pn9 XI1_I1206_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I212_MP3 (XI1_I1206_I212_p1 I1_I1206_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I212_MP0 (VDD I1_I1206_pn9 XI1_I1206_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I886_MP1 (VDD I1_c7_o XI1_I886_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I886_MP5 (I1_p7_32 XI1_I886_Bn XI1_I886_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I886_MP4 (XI1_I886_p1 XI1_I886_An I1_p7_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I886_MP2 (VDD I1_h7 XI1_I886_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I886_MP3 (XI1_I886_p1 I1_c7_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I886_MP0 (VDD I1_h7 XI1_I886_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I860_MP1 (VDD I1_qu25_b3_1 XI1_I860_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I860_MP5 (I1_b7_8 XI1_I860_Bn XI1_I860_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I860_MP4 (XI1_I860_p1 XI1_I860_An I1_b7_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I860_MP2 (VDD I1_dd8_b3_1 XI1_I860_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I860_MP3 (XI1_I860_p1 I1_qu25_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I860_MP0 (VDD I1_dd8_b3_1 XI1_I860_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I858_MP1 (VDD I1_qu25_b3_1 XI1_I858_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I858_MP5 (I1_b7_6 XI1_I858_Bn XI1_I858_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I858_MP4 (XI1_I858_p1 XI1_I858_An I1_b7_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I858_MP2 (VDD I1_dd6_b3_1 XI1_I858_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I858_MP3 (XI1_I858_p1 I1_qu25_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I858_MP0 (VDD I1_dd6_b3_1 XI1_I858_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I812_MP1 (VDD I1_qu26_b3_1 XI1_I812_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I812_MP5 (I1_b6_6 XI1_I812_Bn XI1_I812_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I812_MP4 (XI1_I812_p1 XI1_I812_An I1_b6_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I812_MP2 (VDD I1_dd6_b3_1 XI1_I812_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I812_MP3 (XI1_I812_p1 I1_qu26_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I812_MP0 (VDD I1_dd6_b3_1 XI1_I812_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I811_MP1 (VDD I1_qu26_b3_0 XI1_I811_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I811_MP5 (I1_b6_5 XI1_I811_Bn XI1_I811_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I811_MP4 (XI1_I811_p1 XI1_I811_An I1_b6_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I811_MP2 (VDD I1_dd5_b3_1 XI1_I811_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I811_MP3 (XI1_I811_p1 I1_qu26_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I811_MP0 (VDD I1_dd5_b3_1 XI1_I811_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I206_MP1 (VDD I1_I746_G2_0n XI1_I746_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I206_MP5 (I1_p4_3 XI1_I746_I206_Bn XI1_I746_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I206_MP4 (XI1_I746_I206_p1 XI1_I746_I206_An I1_p4_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I206_MP2 (VDD I1_I746_pn3 XI1_I746_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I206_MP3 (XI1_I746_I206_p1 I1_I746_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I206_MP0 (VDD I1_I746_pn3 XI1_I746_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I207_MP1 (VDD I1_I746_G3_0n XI1_I746_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I746_I207_MP5 (I1_p4_4 XI1_I746_I207_Bn XI1_I746_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I746_I207_MP4 (XI1_I746_I207_p1 XI1_I746_I207_An I1_p4_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I207_MP2 (VDD I1_I746_pn4 XI1_I746_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I746_I207_MP3 (XI1_I746_I207_p1 I1_I746_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I746_I207_MP0 (VDD I1_I746_pn4 XI1_I746_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I772_MP1 (VDD I1_qu27_b3_2 XI1_I772_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I772_MP5 (I1_b5_12 XI1_I772_Bn XI1_I772_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I772_MP4 (XI1_I772_p1 XI1_I772_An I1_b5_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I772_MP2 (VDD I1_dd12_b3_0 XI1_I772_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I772_MP3 (XI1_I772_p1 I1_qu27_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I772_MP0 (VDD I1_dd12_b3_0 XI1_I772_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I773_MP1 (VDD I1_qu27_b3_2 XI1_I773_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I773_MP5 (I1_b5_13 XI1_I773_Bn XI1_I773_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I773_MP4 (XI1_I773_p1 XI1_I773_An I1_b5_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I773_MP2 (VDD I1_dd13_b3_0 XI1_I773_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I773_MP3 (XI1_I773_p1 I1_qu27_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I773_MP0 (VDD I1_dd13_b3_0 XI1_I773_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I774_MP1 (VDD I1_qu27_b3_2 XI1_I774_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I774_MP5 (I1_b5_14 XI1_I774_Bn XI1_I774_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I774_MP4 (XI1_I774_p1 XI1_I774_An I1_b5_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I774_MP2 (VDD I1_dd14_b3_0 XI1_I774_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I774_MP3 (XI1_I774_p1 I1_qu27_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I774_MP0 (VDD I1_dd14_b3_0 XI1_I774_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I775_MP1 (VDD I1_qu27_b3_2 XI1_I775_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I775_MP5 (I1_b5_15 XI1_I775_Bn XI1_I775_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I775_MP4 (XI1_I775_p1 XI1_I775_An I1_b5_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I775_MP2 (VDD I1_dd15_b3_0 XI1_I775_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I775_MP3 (XI1_I775_p1 I1_qu27_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I775_MP0 (VDD I1_dd15_b3_0 XI1_I775_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I776_MP1 (VDD I1_qu27_b3_2 XI1_I776_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I776_MP5 (I1_b5_16 XI1_I776_Bn XI1_I776_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I776_MP4 (XI1_I776_p1 XI1_I776_An I1_b5_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I776_MP2 (VDD I1_dd16_b3_0 XI1_I776_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I776_MP3 (XI1_I776_p1 I1_qu27_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I776_MP0 (VDD I1_dd16_b3_0 XI1_I776_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I777_MP1 (VDD I1_qu27_b3_2 XI1_I777_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I777_MP5 (I1_b5_17 XI1_I777_Bn XI1_I777_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I777_MP4 (XI1_I777_p1 XI1_I777_An I1_b5_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I777_MP2 (VDD I1_dd17_b3_0 XI1_I777_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I777_MP3 (XI1_I777_p1 I1_qu27_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I777_MP0 (VDD I1_dd17_b3_0 XI1_I777_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I728_MP1 (VDD I1_qu28_b3_2 XI1_I728_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I728_MP5 (I1_b4_14 XI1_I728_Bn XI1_I728_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I728_MP4 (XI1_I728_p1 XI1_I728_An I1_b4_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I728_MP2 (VDD I1_dd14_b3_0 XI1_I728_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I728_MP3 (XI1_I728_p1 I1_qu28_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I728_MP0 (VDD I1_dd14_b3_0 XI1_I728_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I732_MP1 (VDD I1_qu28_b3_3 XI1_I732_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I732_MP5 (I1_b4_18 XI1_I732_Bn XI1_I732_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I732_MP4 (XI1_I732_p1 XI1_I732_An I1_b4_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I732_MP2 (VDD I1_dd18_b3_0 XI1_I732_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I732_MP3 (XI1_I732_p1 I1_qu28_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I732_MP0 (VDD I1_dd18_b3_0 XI1_I732_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I735_MP1 (VDD I1_qu28_b3_3 XI1_I735_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I735_MP5 (I1_b4_21 XI1_I735_Bn XI1_I735_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I735_MP4 (XI1_I735_p1 XI1_I735_An I1_b4_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I735_MP2 (VDD I1_dd21_b3_0 XI1_I735_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I735_MP3 (XI1_I735_p1 I1_qu28_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I735_MP0 (VDD I1_dd21_b3_0 XI1_I735_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I737_MP1 (VDD I1_qu28_b3_3 XI1_I737_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I737_MP5 (I1_b4_23 XI1_I737_Bn XI1_I737_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I737_MP4 (XI1_I737_p1 XI1_I737_An I1_b4_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I737_MP2 (VDD I1_dd23_b3_0 XI1_I737_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I737_MP3 (XI1_I737_p1 I1_qu28_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I737_MP0 (VDD I1_dd23_b3_0 XI1_I737_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I748_MP1 (VDD I1_c4_o XI1_I748_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I748_MP5 (I1_p4_32 XI1_I748_Bn XI1_I748_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I748_MP4 (XI1_I748_p1 XI1_I748_An I1_p4_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I748_MP2 (VDD I1_h4 XI1_I748_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I748_MP3 (XI1_I748_p1 I1_c4_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I748_MP0 (VDD I1_h4 XI1_I748_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I747_MP1 (VDD I1_qu28_b3_5 XI1_I747_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I747_MP5 (I1_h4 XI1_I747_Bn XI1_I747_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I747_MP4 (XI1_I747_p1 XI1_I747_An I1_h4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I747_MP2 (VDD I1_p3_31 XI1_I747_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I747_MP3 (XI1_I747_p1 I1_qu28_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I747_MP0 (VDD I1_p3_31 XI1_I747_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1388_MP1 (VDD I1_qu14_b3_5 XI1_I1388_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1388_MP5 (I1_b18_30 XI1_I1388_Bn XI1_I1388_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1388_MP4 (XI1_I1388_p1 XI1_I1388_An I1_b18_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1388_MP2 (VDD I1_dd30_b3_3 XI1_I1388_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1388_MP3 (XI1_I1388_p1 I1_qu14_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1388_MP0 (VDD I1_dd30_b3_3 XI1_I1388_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1381_MP1 (VDD I1_qu14_b3_3 XI1_I1381_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1381_MP5 (I1_b18_23 XI1_I1381_Bn XI1_I1381_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1381_MP4 (XI1_I1381_p1 XI1_I1381_An I1_b18_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1381_MP2 (VDD I1_dd23_b3_3 XI1_I1381_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1381_MP3 (XI1_I1381_p1 I1_qu14_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1381_MP0 (VDD I1_dd23_b3_3 XI1_I1381_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1379_MP1 (VDD I1_qu14_b3_3 XI1_I1379_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1379_MP5 (I1_b18_21 XI1_I1379_Bn XI1_I1379_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1379_MP4 (XI1_I1379_p1 XI1_I1379_An I1_b18_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1379_MP2 (VDD I1_dd21_b3_3 XI1_I1379_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1379_MP3 (XI1_I1379_p1 I1_qu14_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1379_MP0 (VDD I1_dd21_b3_3 XI1_I1379_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1378_MP1 (VDD I1_qu14_b3_3 XI1_I1378_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1378_MP5 (I1_b18_20 XI1_I1378_Bn XI1_I1378_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1378_MP4 (XI1_I1378_p1 XI1_I1378_An I1_b18_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1378_MP2 (VDD I1_dd20_b3_3 XI1_I1378_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1378_MP3 (XI1_I1378_p1 I1_qu14_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
