    I_MXI1_I1559_MN0 (XI1_I1559_An I1_dd17_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1558_MN1 (XI1_I1558_Bn I1_qu10_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1558_MN5 (XI1_I1558_n2 XI1_I1558_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1558_MN4 (I1_b22_16 XI1_I1558_An XI1_I1558_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1558_MN2 (XI1_I1558_n1 I1_dd16_b3_4 I1_b22_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1558_MN3 (VSS I1_qu10_b3_2 XI1_I1558_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1558_MN0 (XI1_I1558_An I1_dd16_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1557_MN1 (XI1_I1557_Bn I1_qu10_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1557_MN5 (XI1_I1557_n2 XI1_I1557_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1557_MN4 (I1_b22_15 XI1_I1557_An XI1_I1557_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1557_MN2 (XI1_I1557_n1 I1_dd15_b3_4 I1_b22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1557_MN3 (VSS I1_qu10_b3_2 XI1_I1557_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1557_MN0 (XI1_I1557_An I1_dd15_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1554_MN1 (XI1_I1554_Bn I1_qu10_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1554_MN5 (XI1_I1554_n2 XI1_I1554_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1554_MN4 (I1_b22_12 XI1_I1554_An XI1_I1554_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1554_MN2 (XI1_I1554_n1 I1_dd12_b3_4 I1_b22_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1554_MN3 (VSS I1_qu10_b3_2 XI1_I1554_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1554_MN0 (XI1_I1554_An I1_dd12_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1556_MN1 (XI1_I1556_Bn I1_qu10_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1556_MN5 (XI1_I1556_n2 XI1_I1556_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1556_MN4 (I1_b22_14 XI1_I1556_An XI1_I1556_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1556_MN2 (XI1_I1556_n1 I1_dd14_b3_4 I1_b22_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1556_MN3 (VSS I1_qu10_b3_2 XI1_I1556_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1556_MN0 (XI1_I1556_An I1_dd14_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I218_MN1 (XI1_I1574_I218_Bn I1_I1574_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I218_MN5 (XI1_I1574_I218_n2 XI1_I1574_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1574_I218_MN4 (I1_p22_15 XI1_I1574_I218_An XI1_I1574_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1574_I218_MN2 (XI1_I1574_I218_n1 I1_I1574_pn15 I1_p22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1574_I218_MN3 (VSS I1_I1574_G14_0n XI1_I1574_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1574_I218_MN0 (XI1_I1574_I218_An I1_I1574_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1553_MN1 (XI1_I1553_Bn I1_qu10_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1553_MN5 (XI1_I1553_n2 XI1_I1553_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1553_MN4 (I1_b22_11 XI1_I1553_An XI1_I1553_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1553_MN2 (XI1_I1553_n1 I1_dd11_b3_4 I1_b22_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1553_MN3 (VSS I1_qu10_b3_1 XI1_I1553_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1553_MN0 (XI1_I1553_An I1_dd11_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1551_MN1 (XI1_I1551_Bn I1_qu10_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1551_MN5 (XI1_I1551_n2 XI1_I1551_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1551_MN4 (I1_b22_9 XI1_I1551_An XI1_I1551_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1551_MN2 (XI1_I1551_n1 I1_dd9_b3_4 I1_b22_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1551_MN3 (VSS I1_qu10_b3_1 XI1_I1551_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1551_MN0 (XI1_I1551_An I1_dd9_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1597_MN1 (XI1_I1597_Bn I1_qu9_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1597_MN5 (XI1_I1597_n2 XI1_I1597_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1597_MN4 (I1_b23_9 XI1_I1597_An XI1_I1597_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1597_MN2 (XI1_I1597_n1 I1_dd9_b3_4 I1_b23_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1597_MN3 (VSS I1_qu9_b3_1 XI1_I1597_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1597_MN0 (XI1_I1597_An I1_dd9_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1596_MN1 (XI1_I1596_Bn I1_qu9_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1596_MN5 (XI1_I1596_n2 XI1_I1596_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1596_MN4 (I1_b23_8 XI1_I1596_An XI1_I1596_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1596_MN2 (XI1_I1596_n1 I1_dd8_b3_4 I1_b23_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1596_MN3 (VSS I1_qu9_b3_1 XI1_I1596_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1596_MN0 (XI1_I1596_An I1_dd8_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1593_MN1 (XI1_I1593_Bn I1_qu9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1593_MN5 (XI1_I1593_n2 XI1_I1593_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1593_MN4 (I1_b23_5 XI1_I1593_An XI1_I1593_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1593_MN2 (XI1_I1593_n1 I1_dd5_b3_4 I1_b23_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1593_MN3 (VSS I1_qu9_b3_0 XI1_I1593_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1593_MN0 (XI1_I1593_An I1_dd5_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1589_MN1 (XI1_I1589_Bn I1_qu9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1589_MN5 (XI1_I1589_n2 XI1_I1589_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1589_MN4 (I1_b23_1 XI1_I1589_An XI1_I1589_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1589_MN2 (XI1_I1589_n1 I1_dd1_b3_4 I1_b23_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1589_MN3 (VSS I1_qu9_b3_0 XI1_I1589_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1589_MN0 (XI1_I1589_An I1_dd1_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I17_MN1 (XI2_I1_I17_Bn I2_I1_SUB_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I17_MN5 (XI2_I1_I17_n2 XI2_I1_I17_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I17_MN4 (I2_I1_bx7 XI2_I1_I17_An XI2_I1_I17_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I17_MN2 (XI2_I1_I17_n1 B_7 I2_I1_bx7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I17_MN3 (VSS I2_I1_SUB_b3_1 XI2_I1_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I17_MN0 (XI2_I1_I17_An B_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1753_MN1 (XI1_I1753_Bn I1_qu6_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1753_MN5 (XI1_I1753_n2 XI1_I1753_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1753_MN4 (I1_b26_27 XI1_I1753_An XI1_I1753_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1753_MN2 (XI1_I1753_n1 I1_dd27_b3_4 I1_b26_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1753_MN3 (VSS I1_qu6_b3_4 XI1_I1753_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1753_MN0 (XI1_I1753_An I1_dd27_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1751_MN1 (XI1_I1751_Bn I1_qu6_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1751_MN5 (XI1_I1751_n2 XI1_I1751_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1751_MN4 (I1_b26_25 XI1_I1751_An XI1_I1751_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1751_MN2 (XI1_I1751_n1 I1_dd25_b3_4 I1_b26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1751_MN3 (VSS I1_qu6_b3_4 XI1_I1751_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1751_MN0 (XI1_I1751_An I1_dd25_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1750_MN1 (XI1_I1750_Bn I1_qu6_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1750_MN5 (XI1_I1750_n2 XI1_I1750_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1750_MN4 (I1_b26_24 XI1_I1750_An XI1_I1750_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1750_MN2 (XI1_I1750_n1 I1_dd24_b3_4 I1_b26_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1750_MN3 (VSS I1_qu6_b3_4 XI1_I1750_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1750_MN0 (XI1_I1750_An I1_dd24_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1701_MN1 (XI1_I1701_Bn I1_qu7_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1701_MN5 (XI1_I1701_n2 XI1_I1701_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1701_MN4 (I1_b25_21 XI1_I1701_An XI1_I1701_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1701_MN2 (XI1_I1701_n1 I1_dd21_b3_4 I1_b25_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1701_MN3 (VSS I1_qu7_b3_3 XI1_I1701_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1701_MN0 (XI1_I1701_An I1_dd21_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1700_MN1 (XI1_I1700_Bn I1_qu7_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1700_MN5 (XI1_I1700_n2 XI1_I1700_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1700_MN4 (I1_b25_20 XI1_I1700_An XI1_I1700_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1700_MN2 (XI1_I1700_n1 I1_dd20_b3_4 I1_b25_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1700_MN3 (VSS I1_qu7_b3_3 XI1_I1700_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1700_MN0 (XI1_I1700_An I1_dd20_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1698_MN1 (XI1_I1698_Bn I1_qu7_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1698_MN5 (XI1_I1698_n2 XI1_I1698_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1698_MN4 (I1_b25_18 XI1_I1698_An XI1_I1698_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1698_MN2 (XI1_I1698_n1 I1_dd18_b3_4 I1_b25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1698_MN3 (VSS I1_qu7_b3_3 XI1_I1698_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1698_MN0 (XI1_I1698_An I1_dd18_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I218_MN1 (XI1_I1712_I218_Bn I1_I1712_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I218_MN5 (XI1_I1712_I218_n2 XI1_I1712_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1712_I218_MN4 (I1_p25_15 XI1_I1712_I218_An XI1_I1712_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1712_I218_MN2 (XI1_I1712_I218_n1 I1_I1712_pn15 I1_p25_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1712_I218_MN3 (VSS I1_I1712_G14_0n XI1_I1712_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1712_I218_MN0 (XI1_I1712_I218_An I1_I1712_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I219_MN1 (XI1_I1712_I219_Bn I1_I1712_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I219_MN5 (XI1_I1712_I219_n2 XI1_I1712_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1712_I219_MN4 (I1_p25_16 XI1_I1712_I219_An XI1_I1712_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1712_I219_MN2 (XI1_I1712_I219_n1 I1_I1712_pn16 I1_p25_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1712_I219_MN3 (VSS I1_I1712_G15_0n XI1_I1712_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1712_I219_MN0 (XI1_I1712_I219_An I1_I1712_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I216_MN1 (XI1_I1712_I216_Bn I1_I1712_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I216_MN5 (XI1_I1712_I216_n2 XI1_I1712_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1712_I216_MN4 (I1_p25_13 XI1_I1712_I216_An XI1_I1712_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1712_I216_MN2 (XI1_I1712_I216_n1 I1_I1712_pn13 I1_p25_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1712_I216_MN3 (VSS I1_I1712_G12_0n XI1_I1712_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1712_I216_MN0 (XI1_I1712_I216_An I1_I1712_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1695_MN1 (XI1_I1695_Bn I1_qu7_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1695_MN5 (XI1_I1695_n2 XI1_I1695_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1695_MN4 (I1_b25_15 XI1_I1695_An XI1_I1695_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1695_MN2 (XI1_I1695_n1 I1_dd15_b3_4 I1_b25_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1695_MN3 (VSS I1_qu7_b3_2 XI1_I1695_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1695_MN0 (XI1_I1695_An I1_dd15_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1696_MN1 (XI1_I1696_Bn I1_qu7_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1696_MN5 (XI1_I1696_n2 XI1_I1696_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1696_MN4 (I1_b25_16 XI1_I1696_An XI1_I1696_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1696_MN2 (XI1_I1696_n1 I1_dd16_b3_4 I1_b25_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1696_MN3 (VSS I1_qu7_b3_2 XI1_I1696_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1696_MN0 (XI1_I1696_An I1_dd16_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1692_MN1 (XI1_I1692_Bn I1_qu7_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1692_MN5 (XI1_I1692_n2 XI1_I1692_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1692_MN4 (I1_b25_12 XI1_I1692_An XI1_I1692_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1692_MN2 (XI1_I1692_n1 I1_dd12_b3_4 I1_b25_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1692_MN3 (VSS I1_qu7_b3_2 XI1_I1692_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1692_MN0 (XI1_I1692_An I1_dd12_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I213_MN1 (XI1_I1666_I213_Bn I1_I1666_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I213_MN5 (XI1_I1666_I213_n2 XI1_I1666_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1666_I213_MN4 (I1_p24_10 XI1_I1666_I213_An XI1_I1666_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1666_I213_MN2 (XI1_I1666_I213_n1 I1_I1666_pn10 I1_p24_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1666_I213_MN3 (VSS I1_I1666_G9_0n XI1_I1666_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1666_I213_MN0 (XI1_I1666_I213_An I1_I1666_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1640_MN1 (XI1_I1640_Bn I1_qu8_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1640_MN5 (XI1_I1640_n2 XI1_I1640_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1640_MN4 (I1_b24_6 XI1_I1640_An XI1_I1640_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1640_MN2 (XI1_I1640_n1 I1_dd6_b3_4 I1_b24_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1640_MN3 (VSS I1_qu8_b3_1 XI1_I1640_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1640_MN0 (XI1_I1640_An I1_dd6_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1643_MN1 (XI1_I1643_Bn I1_qu8_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1643_MN5 (XI1_I1643_n2 XI1_I1643_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1643_MN4 (I1_b24_9 XI1_I1643_An XI1_I1643_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1643_MN2 (XI1_I1643_n1 I1_dd9_b3_4 I1_b24_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1643_MN3 (VSS I1_qu8_b3_1 XI1_I1643_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1643_MN0 (XI1_I1643_An I1_dd9_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1642_MN1 (XI1_I1642_Bn I1_qu8_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1642_MN5 (XI1_I1642_n2 XI1_I1642_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1642_MN4 (I1_b24_8 XI1_I1642_An XI1_I1642_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1642_MN2 (XI1_I1642_n1 I1_dd8_b3_4 I1_b24_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1642_MN3 (VSS I1_qu8_b3_1 XI1_I1642_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1642_MN0 (XI1_I1642_An I1_dd8_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1621_MN1 (XI1_I1621_Bn I1_qu9_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1621_MN5 (XI1_I1621_n2 XI1_I1621_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1621_MN4 (I1_h23 XI1_I1621_An XI1_I1621_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1621_MN2 (XI1_I1621_n1 I1_p22_31 I1_h23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1621_MN3 (VSS I1_qu9_b3_5 XI1_I1621_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1621_MN0 (XI1_I1621_An I1_p22_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1555_MN1 (XI1_I1555_Bn I1_qu10_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1555_MN5 (XI1_I1555_n2 XI1_I1555_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1555_MN4 (I1_b22_13 XI1_I1555_An XI1_I1555_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1555_MN2 (XI1_I1555_n1 I1_dd13_b3_4 I1_b22_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1555_MN3 (VSS I1_qu10_b3_2 XI1_I1555_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1555_MN0 (XI1_I1555_An I1_dd13_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1599_MN1 (XI1_I1599_Bn I1_qu9_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1599_MN5 (XI1_I1599_n2 XI1_I1599_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1599_MN4 (I1_b23_11 XI1_I1599_An XI1_I1599_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1599_MN2 (XI1_I1599_n1 I1_dd11_b3_4 I1_b23_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1599_MN3 (VSS I1_qu9_b3_1 XI1_I1599_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1599_MN0 (XI1_I1599_An I1_dd11_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1598_MN1 (XI1_I1598_Bn I1_qu9_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1598_MN5 (XI1_I1598_n2 XI1_I1598_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1598_MN4 (I1_b23_10 XI1_I1598_An XI1_I1598_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1598_MN2 (XI1_I1598_n1 I1_dd10_b3_4 I1_b23_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1598_MN3 (VSS I1_qu9_b3_1 XI1_I1598_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1598_MN0 (XI1_I1598_An I1_dd10_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1594_MN1 (XI1_I1594_Bn I1_qu9_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1594_MN5 (XI1_I1594_n2 XI1_I1594_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1594_MN4 (I1_b23_6 XI1_I1594_An XI1_I1594_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1594_MN2 (XI1_I1594_n1 I1_dd6_b3_4 I1_b23_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1594_MN3 (VSS I1_qu9_b3_1 XI1_I1594_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1594_MN0 (XI1_I1594_An I1_dd6_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1595_MN1 (XI1_I1595_Bn I1_qu9_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1595_MN5 (XI1_I1595_n2 XI1_I1595_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1595_MN4 (I1_b23_7 XI1_I1595_An XI1_I1595_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1595_MN2 (XI1_I1595_n1 I1_dd7_b3_4 I1_b23_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1595_MN3 (VSS I1_qu9_b3_1 XI1_I1595_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1595_MN0 (XI1_I1595_An I1_dd7_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I206_MN1 (XI1_I1620_I206_Bn I1_I1620_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I206_MN5 (XI1_I1620_I206_n2 XI1_I1620_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1620_I206_MN4 (I1_p23_3 XI1_I1620_I206_An XI1_I1620_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1620_I206_MN2 (XI1_I1620_I206_n1 I1_I1620_pn3 I1_p23_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1620_I206_MN3 (VSS I1_I1620_G2_0n XI1_I1620_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1620_I206_MN0 (XI1_I1620_I206_An I1_I1620_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1590_MN1 (XI1_I1590_Bn I1_qu9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1590_MN5 (XI1_I1590_n2 XI1_I1590_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1590_MN4 (I1_b23_2 XI1_I1590_An XI1_I1590_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1590_MN2 (XI1_I1590_n1 I1_dd2_b3_4 I1_b23_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1590_MN3 (VSS I1_qu9_b3_0 XI1_I1590_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1590_MN0 (XI1_I1590_An I1_dd2_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1588_MN1 (XI1_I1588_Bn I1_qu9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1588_MN5 (XI1_I1588_n2 XI1_I1588_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1588_MN4 (I1_b23_0 XI1_I1588_An XI1_I1588_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1588_MN2 (XI1_I1588_n1 I1_B_0_b3_4 I1_b23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1588_MN3 (VSS I1_qu9_b3_0 XI1_I1588_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1588_MN0 (XI1_I1588_An I1_B_0_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I16_MN1 (XI2_I1_I16_Bn I2_I1_SUB_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I16_MN5 (XI2_I1_I16_n2 XI2_I1_I16_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I16_MN4 (I2_I1_bx6 XI2_I1_I16_An XI2_I1_I16_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I16_MN2 (XI2_I1_I16_n1 B_6 I2_I1_bx6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I16_MN3 (VSS I2_I1_SUB_b3_1 XI2_I1_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I16_MN0 (XI2_I1_I16_An B_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1755_MN1 (XI1_I1755_Bn I1_qu6_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1755_MN5 (XI1_I1755_n2 XI1_I1755_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1755_MN4 (I1_b26_29 XI1_I1755_An XI1_I1755_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1755_MN2 (XI1_I1755_n1 I1_dd29_b3_4 I1_b26_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1755_MN3 (VSS I1_qu6_b3_4 XI1_I1755_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1755_MN0 (XI1_I1755_An I1_dd29_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1759_MN1 (XI1_I1759_Bn I1_qu6_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1759_MN5 (XI1_I1759_n2 XI1_I1759_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1759_MN4 (I1_h26 XI1_I1759_An XI1_I1759_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1759_MN2 (XI1_I1759_n1 I1_p25_31 I1_h26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1759_MN3 (VSS I1_qu6_b3_5 XI1_I1759_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1759_MN0 (XI1_I1759_An I1_p25_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1752_MN1 (XI1_I1752_Bn I1_qu6_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1752_MN5 (XI1_I1752_n2 XI1_I1752_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1752_MN4 (I1_b26_26 XI1_I1752_An XI1_I1752_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1752_MN2 (XI1_I1752_n1 I1_dd26_b3_4 I1_b26_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1752_MN3 (VSS I1_qu6_b3_4 XI1_I1752_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1752_MN0 (XI1_I1752_An I1_dd26_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1747_MN1 (XI1_I1747_Bn I1_qu6_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1747_MN5 (XI1_I1747_n2 XI1_I1747_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1747_MN4 (I1_b26_21 XI1_I1747_An XI1_I1747_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1747_MN2 (XI1_I1747_n1 I1_dd21_b3_4 I1_b26_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1747_MN3 (VSS I1_qu6_b3_3 XI1_I1747_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1747_MN0 (XI1_I1747_An I1_dd21_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1703_MN1 (XI1_I1703_Bn I1_qu7_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1703_MN5 (XI1_I1703_n2 XI1_I1703_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1703_MN4 (I1_b25_23 XI1_I1703_An XI1_I1703_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1703_MN2 (XI1_I1703_n1 I1_dd23_b3_4 I1_b25_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1703_MN3 (VSS I1_qu7_b3_3 XI1_I1703_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1703_MN0 (XI1_I1703_An I1_dd23_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1699_MN1 (XI1_I1699_Bn I1_qu7_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1699_MN5 (XI1_I1699_n2 XI1_I1699_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1699_MN4 (I1_b25_19 XI1_I1699_An XI1_I1699_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1699_MN2 (XI1_I1699_n1 I1_dd19_b3_4 I1_b25_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1699_MN3 (VSS I1_qu7_b3_3 XI1_I1699_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1699_MN0 (XI1_I1699_An I1_dd19_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1744_MN1 (XI1_I1744_Bn I1_qu6_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1744_MN5 (XI1_I1744_n2 XI1_I1744_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1744_MN4 (I1_b26_18 XI1_I1744_An XI1_I1744_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1744_MN2 (XI1_I1744_n1 I1_dd18_b3_4 I1_b26_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1744_MN3 (VSS I1_qu6_b3_3 XI1_I1744_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1744_MN0 (XI1_I1744_An I1_dd18_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1714_MN1 (XI1_I1714_Bn I1_c25_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1714_MN5 (XI1_I1714_n2 XI1_I1714_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1714_MN4 (I1_p25_32 XI1_I1714_An XI1_I1714_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1714_MN2 (XI1_I1714_n1 I1_h25 I1_p25_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1714_MN3 (VSS I1_c25_o XI1_I1714_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1714_MN0 (XI1_I1714_An I1_h25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1697_MN1 (XI1_I1697_Bn I1_qu7_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1697_MN5 (XI1_I1697_n2 XI1_I1697_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1697_MN4 (I1_b25_17 XI1_I1697_An XI1_I1697_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1697_MN2 (XI1_I1697_n1 I1_dd17_b3_4 I1_b25_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1697_MN3 (VSS I1_qu7_b3_2 XI1_I1697_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1697_MN0 (XI1_I1697_An I1_dd17_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1741_MN1 (XI1_I1741_Bn I1_qu6_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1741_MN5 (XI1_I1741_n2 XI1_I1741_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1741_MN4 (I1_b26_15 XI1_I1741_An XI1_I1741_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1741_MN2 (XI1_I1741_n1 I1_dd15_b3_4 I1_b26_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1741_MN3 (VSS I1_qu6_b3_2 XI1_I1741_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1741_MN0 (XI1_I1741_An I1_dd15_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1694_MN1 (XI1_I1694_Bn I1_qu7_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1694_MN5 (XI1_I1694_n2 XI1_I1694_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1694_MN4 (I1_b25_14 XI1_I1694_An XI1_I1694_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1694_MN2 (XI1_I1694_n1 I1_dd14_b3_4 I1_b25_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1694_MN3 (VSS I1_qu7_b3_2 XI1_I1694_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1694_MN0 (XI1_I1694_An I1_dd14_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1713_MN1 (XI1_I1713_Bn I1_qu7_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1713_MN5 (XI1_I1713_n2 XI1_I1713_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1713_MN4 (I1_h25 XI1_I1713_An XI1_I1713_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1713_MN2 (XI1_I1713_n1 I1_p24_31 I1_h25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1713_MN3 (VSS I1_qu7_b3_5 XI1_I1713_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1713_MN0 (XI1_I1713_An I1_p24_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1693_MN1 (XI1_I1693_Bn I1_qu7_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1693_MN5 (XI1_I1693_n2 XI1_I1693_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1693_MN4 (I1_b25_13 XI1_I1693_An XI1_I1693_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1693_MN2 (XI1_I1693_n1 I1_dd13_b3_4 I1_b25_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1693_MN3 (VSS I1_qu7_b3_2 XI1_I1693_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1693_MN0 (XI1_I1693_An I1_dd13_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I214_MN1 (XI1_I1666_I214_Bn I1_I1666_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I214_MN5 (XI1_I1666_I214_n2 XI1_I1666_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1666_I214_MN4 (I1_p24_11 XI1_I1666_I214_An XI1_I1666_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1666_I214_MN2 (XI1_I1666_I214_n1 I1_I1666_pn11 I1_p24_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1666_I214_MN3 (VSS I1_I1666_G10_0n XI1_I1666_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1666_I214_MN0 (XI1_I1666_I214_An I1_I1666_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I212_MN1 (XI1_I1666_I212_Bn I1_I1666_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I212_MN5 (XI1_I1666_I212_n2 XI1_I1666_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1666_I212_MN4 (I1_p24_9 XI1_I1666_I212_An XI1_I1666_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1666_I212_MN2 (XI1_I1666_I212_n1 I1_I1666_pn9 I1_p24_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1666_I212_MN3 (VSS I1_I1666_G8_0n XI1_I1666_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1666_I212_MN0 (XI1_I1666_I212_An I1_I1666_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1644_MN1 (XI1_I1644_Bn I1_qu8_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1644_MN5 (XI1_I1644_n2 XI1_I1644_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1644_MN4 (I1_b24_10 XI1_I1644_An XI1_I1644_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1644_MN2 (XI1_I1644_n1 I1_dd10_b3_4 I1_b24_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1644_MN3 (VSS I1_qu8_b3_1 XI1_I1644_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1644_MN0 (XI1_I1644_An I1_dd10_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1641_MN1 (XI1_I1641_Bn I1_qu8_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1641_MN5 (XI1_I1641_n2 XI1_I1641_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1641_MN4 (I1_b24_7 XI1_I1641_An XI1_I1641_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1641_MN2 (XI1_I1641_n1 I1_dd7_b3_4 I1_b24_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1641_MN3 (VSS I1_qu8_b3_1 XI1_I1641_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1641_MN0 (XI1_I1641_An I1_dd7_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1602_MN1 (XI1_I1602_Bn I1_qu9_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1602_MN5 (XI1_I1602_n2 XI1_I1602_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1602_MN4 (I1_b23_14 XI1_I1602_An XI1_I1602_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1602_MN2 (XI1_I1602_n1 I1_dd14_b3_4 I1_b23_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1602_MN3 (VSS I1_qu9_b3_2 XI1_I1602_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1602_MN0 (XI1_I1602_An I1_dd14_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1600_MN1 (XI1_I1600_Bn I1_qu9_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1600_MN5 (XI1_I1600_n2 XI1_I1600_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1600_MN4 (I1_b23_12 XI1_I1600_An XI1_I1600_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1600_MN2 (XI1_I1600_n1 I1_dd12_b3_4 I1_b23_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1600_MN3 (VSS I1_qu9_b3_2 XI1_I1600_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1600_MN0 (XI1_I1600_An I1_dd12_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1601_MN1 (XI1_I1601_Bn I1_qu9_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1601_MN5 (XI1_I1601_n2 XI1_I1601_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1601_MN4 (I1_b23_13 XI1_I1601_An XI1_I1601_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1601_MN2 (XI1_I1601_n1 I1_dd13_b3_4 I1_b23_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1601_MN3 (VSS I1_qu9_b3_2 XI1_I1601_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1601_MN0 (XI1_I1601_An I1_dd13_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I207_MN1 (XI1_I1620_I207_Bn I1_I1620_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I207_MN5 (XI1_I1620_I207_n2 XI1_I1620_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1620_I207_MN4 (I1_p23_4 XI1_I1620_I207_An XI1_I1620_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1620_I207_MN2 (XI1_I1620_I207_n1 I1_I1620_pn4 I1_p23_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1620_I207_MN3 (VSS I1_I1620_G3_0n XI1_I1620_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1620_I207_MN0 (XI1_I1620_I207_An I1_I1620_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I15_MN1 (XI2_I1_I15_Bn I2_I1_SUB_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I15_MN5 (XI2_I1_I15_n2 XI2_I1_I15_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I15_MN4 (I2_I1_bx5 XI2_I1_I15_An XI2_I1_I15_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I15_MN2 (XI2_I1_I15_n1 B_5 I2_I1_bx5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I15_MN3 (VSS I2_I1_SUB_b3_0 XI2_I1_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I15_MN0 (XI2_I1_I15_An B_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I207_MN1 (XI2_I1_I42_I207_Bn I2_I1_I42_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I207_MN5 (XI2_I1_I42_I207_n2 XI2_I1_I42_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I42_I207_MN4 (I2_S_4 XI2_I1_I42_I207_An XI2_I1_I42_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I42_I207_MN2 (XI2_I1_I42_I207_n1 I2_I1_I42_pn4 I2_S_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I42_I207_MN3 (VSS I2_I1_I42_G3_0n XI2_I1_I42_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I42_I207_MN0 (XI2_I1_I42_I207_An I2_I1_I42_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1757_MN1 (XI1_I1757_Bn I1_qu6_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1757_MN5 (XI1_I1757_n2 XI1_I1757_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1757_MN4 (I1_b26_31 XI1_I1757_An XI1_I1757_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1757_MN2 (XI1_I1757_n1 I1_dd31_b3_4 I1_b26_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1757_MN3 (VSS I1_qu6_b3_5 XI1_I1757_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1757_MN0 (XI1_I1757_An I1_dd31_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1749_MN1 (XI1_I1749_Bn I1_qu6_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1749_MN5 (XI1_I1749_n2 XI1_I1749_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1749_MN4 (I1_b26_23 XI1_I1749_An XI1_I1749_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1749_MN2 (XI1_I1749_n1 I1_dd23_b3_4 I1_b26_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1749_MN3 (VSS I1_qu6_b3_3 XI1_I1749_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1749_MN0 (XI1_I1749_An I1_dd23_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1748_MN1 (XI1_I1748_Bn I1_qu6_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1748_MN5 (XI1_I1748_n2 XI1_I1748_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1748_MN4 (I1_b26_22 XI1_I1748_An XI1_I1748_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1748_MN2 (XI1_I1748_n1 I1_dd22_b3_4 I1_b26_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1748_MN3 (VSS I1_qu6_b3_3 XI1_I1748_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1748_MN0 (XI1_I1748_An I1_dd22_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1746_MN1 (XI1_I1746_Bn I1_qu6_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1746_MN5 (XI1_I1746_n2 XI1_I1746_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1746_MN4 (I1_b26_20 XI1_I1746_An XI1_I1746_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1746_MN2 (XI1_I1746_n1 I1_dd20_b3_4 I1_b26_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1746_MN3 (VSS I1_qu6_b3_3 XI1_I1746_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1746_MN0 (XI1_I1746_An I1_dd20_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1745_MN1 (XI1_I1745_Bn I1_qu6_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1745_MN5 (XI1_I1745_n2 XI1_I1745_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1745_MN4 (I1_b26_19 XI1_I1745_An XI1_I1745_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1745_MN2 (XI1_I1745_n1 I1_dd19_b3_4 I1_b26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1745_MN3 (VSS I1_qu6_b3_3 XI1_I1745_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1745_MN0 (XI1_I1745_An I1_dd19_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1739_MN1 (XI1_I1739_Bn I1_qu6_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1739_MN5 (XI1_I1739_n2 XI1_I1739_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1739_MN4 (I1_b26_13 XI1_I1739_An XI1_I1739_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1739_MN2 (XI1_I1739_n1 I1_dd13_b3_4 I1_b26_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1739_MN3 (VSS I1_qu6_b3_2 XI1_I1739_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1739_MN0 (XI1_I1739_An I1_dd13_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1743_MN1 (XI1_I1743_Bn I1_qu6_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1743_MN5 (XI1_I1743_n2 XI1_I1743_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1743_MN4 (I1_b26_17 XI1_I1743_An XI1_I1743_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1743_MN2 (XI1_I1743_n1 I1_dd17_b3_4 I1_b26_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1743_MN3 (VSS I1_qu6_b3_2 XI1_I1743_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1743_MN0 (XI1_I1743_An I1_dd17_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1742_MN1 (XI1_I1742_Bn I1_qu6_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1742_MN5 (XI1_I1742_n2 XI1_I1742_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1742_MN4 (I1_b26_16 XI1_I1742_An XI1_I1742_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1742_MN2 (XI1_I1742_n1 I1_dd16_b3_4 I1_b26_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1742_MN3 (VSS I1_qu6_b3_2 XI1_I1742_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1742_MN0 (XI1_I1742_An I1_dd16_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1738_MN1 (XI1_I1738_Bn I1_qu6_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1738_MN5 (XI1_I1738_n2 XI1_I1738_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1738_MN4 (I1_b26_12 XI1_I1738_An XI1_I1738_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1738_MN2 (XI1_I1738_n1 I1_dd12_b3_4 I1_b26_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1738_MN3 (VSS I1_qu6_b3_2 XI1_I1738_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1738_MN0 (XI1_I1738_An I1_dd12_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I216_MN1 (XI1_I1666_I216_Bn I1_I1666_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I216_MN5 (XI1_I1666_I216_n2 XI1_I1666_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1666_I216_MN4 (I1_p24_13 XI1_I1666_I216_An XI1_I1666_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1666_I216_MN2 (XI1_I1666_I216_n1 I1_I1666_pn13 I1_p24_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1666_I216_MN3 (VSS I1_I1666_G12_0n XI1_I1666_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1666_I216_MN0 (XI1_I1666_I216_An I1_I1666_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I215_MN1 (XI1_I1666_I215_Bn I1_I1666_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I215_MN5 (XI1_I1666_I215_n2 XI1_I1666_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1666_I215_MN4 (I1_p24_12 XI1_I1666_I215_An XI1_I1666_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1666_I215_MN2 (XI1_I1666_I215_n1 I1_I1666_pn12 I1_p24_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1666_I215_MN3 (VSS I1_I1666_G11_0n XI1_I1666_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1666_I215_MN0 (XI1_I1666_I215_An I1_I1666_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1645_MN1 (XI1_I1645_Bn I1_qu8_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1645_MN5 (XI1_I1645_n2 XI1_I1645_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1645_MN4 (I1_b24_11 XI1_I1645_An XI1_I1645_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1645_MN2 (XI1_I1645_n1 I1_dd11_b3_4 I1_b24_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1645_MN3 (VSS I1_qu8_b3_1 XI1_I1645_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1645_MN0 (XI1_I1645_An I1_dd11_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1646_MN1 (XI1_I1646_Bn I1_qu8_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1646_MN5 (XI1_I1646_n2 XI1_I1646_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1646_MN4 (I1_b24_12 XI1_I1646_An XI1_I1646_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1646_MN2 (XI1_I1646_n1 I1_dd12_b3_4 I1_b24_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1646_MN3 (VSS I1_qu8_b3_2 XI1_I1646_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1646_MN0 (XI1_I1646_An I1_dd12_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1647_MN1 (XI1_I1647_Bn I1_qu8_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1647_MN5 (XI1_I1647_n2 XI1_I1647_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1647_MN4 (I1_b24_13 XI1_I1647_An XI1_I1647_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1647_MN2 (XI1_I1647_n1 I1_dd13_b3_4 I1_b24_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1647_MN3 (VSS I1_qu8_b3_2 XI1_I1647_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1647_MN0 (XI1_I1647_An I1_dd13_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1603_MN1 (XI1_I1603_Bn I1_qu9_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1603_MN5 (XI1_I1603_n2 XI1_I1603_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1603_MN4 (I1_b23_15 XI1_I1603_An XI1_I1603_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1603_MN2 (XI1_I1603_n1 I1_dd15_b3_4 I1_b23_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1603_MN3 (VSS I1_qu9_b3_2 XI1_I1603_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1603_MN0 (XI1_I1603_An I1_dd15_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1604_MN1 (XI1_I1604_Bn I1_qu9_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1604_MN5 (XI1_I1604_n2 XI1_I1604_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1604_MN4 (I1_b23_16 XI1_I1604_An XI1_I1604_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1604_MN2 (XI1_I1604_n1 I1_dd16_b3_4 I1_b23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1604_MN3 (VSS I1_qu9_b3_2 XI1_I1604_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1604_MN0 (XI1_I1604_An I1_dd16_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I212_MN1 (XI1_I1620_I212_Bn I1_I1620_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I212_MN5 (XI1_I1620_I212_n2 XI1_I1620_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1620_I212_MN4 (I1_p23_9 XI1_I1620_I212_An XI1_I1620_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1620_I212_MN2 (XI1_I1620_I212_n1 I1_I1620_pn9 I1_p23_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1620_I212_MN3 (VSS I1_I1620_G8_0n XI1_I1620_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1620_I212_MN0 (XI1_I1620_I212_An I1_I1620_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I213_MN1 (XI1_I1620_I213_Bn I1_I1620_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I213_MN5 (XI1_I1620_I213_n2 XI1_I1620_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1620_I213_MN4 (I1_p23_10 XI1_I1620_I213_An XI1_I1620_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1620_I213_MN2 (XI1_I1620_I213_n1 I1_I1620_pn10 I1_p23_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1620_I213_MN3 (VSS I1_I1620_G9_0n XI1_I1620_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1620_I213_MN0 (XI1_I1620_I213_An I1_I1620_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I14_MN1 (XI2_I1_I14_Bn I2_I1_SUB_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I14_MN5 (XI2_I1_I14_n2 XI2_I1_I14_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I14_MN4 (I2_I1_bx4 XI2_I1_I14_An XI2_I1_I14_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I14_MN2 (XI2_I1_I14_n1 B_4 I2_I1_bx4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I14_MN3 (VSS I2_I1_SUB_b3_0 XI2_I1_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I14_MN0 (XI2_I1_I14_An B_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I206_MN1 (XI2_I1_I42_I206_Bn I2_I1_I42_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I206_MN5 (XI2_I1_I42_I206_n2 XI2_I1_I42_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I42_I206_MN4 (I2_S_3 XI2_I1_I42_I206_An XI2_I1_I42_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I42_I206_MN2 (XI2_I1_I42_I206_n1 I2_I1_I42_pn3 I2_S_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I42_I206_MN3 (VSS I2_I1_I42_G2_0n XI2_I1_I42_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I42_I206_MN0 (XI2_I1_I42_I206_An I2_I1_I42_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1756_MN1 (XI1_I1756_Bn I1_qu6_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1756_MN5 (XI1_I1756_n2 XI1_I1756_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1756_MN4 (I1_b26_30 XI1_I1756_An XI1_I1756_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1756_MN2 (XI1_I1756_n1 I1_dd30_b3_4 I1_b26_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1756_MN3 (VSS I1_qu6_b3_5 XI1_I1756_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1756_MN0 (XI1_I1756_An I1_dd30_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1740_MN1 (XI1_I1740_Bn I1_qu6_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1740_MN5 (XI1_I1740_n2 XI1_I1740_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1740_MN4 (I1_b26_14 XI1_I1740_An XI1_I1740_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1740_MN2 (XI1_I1740_n1 I1_dd14_b3_4 I1_b26_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1740_MN3 (VSS I1_qu6_b3_2 XI1_I1740_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1740_MN0 (XI1_I1740_An I1_dd14_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1785_MN1 (XI1_I1785_Bn I1_qu5_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1785_MN5 (XI1_I1785_n2 XI1_I1785_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1785_MN4 (I1_b27_13 XI1_I1785_An XI1_I1785_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1785_MN2 (XI1_I1785_n1 I1_dd13_b3_4 I1_b27_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1785_MN3 (VSS I1_qu5_b3_2 XI1_I1785_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1785_MN0 (XI1_I1785_An I1_dd13_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1786_MN1 (XI1_I1786_Bn I1_qu5_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1786_MN5 (XI1_I1786_n2 XI1_I1786_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1786_MN4 (I1_b27_14 XI1_I1786_An XI1_I1786_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1786_MN2 (XI1_I1786_n1 I1_dd14_b3_4 I1_b27_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1786_MN3 (VSS I1_qu5_b3_2 XI1_I1786_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1786_MN0 (XI1_I1786_An I1_dd14_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1784_MN1 (XI1_I1784_Bn I1_qu5_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1784_MN5 (XI1_I1784_n2 XI1_I1784_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1784_MN4 (I1_b27_12 XI1_I1784_An XI1_I1784_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1784_MN2 (XI1_I1784_n1 I1_dd12_b3_4 I1_b27_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1784_MN3 (VSS I1_qu5_b3_2 XI1_I1784_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1784_MN0 (XI1_I1784_An I1_dd12_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1736_MN1 (XI1_I1736_Bn I1_qu6_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1736_MN5 (XI1_I1736_n2 XI1_I1736_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1736_MN4 (I1_b26_10 XI1_I1736_An XI1_I1736_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1736_MN2 (XI1_I1736_n1 I1_dd10_b3_4 I1_b26_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1736_MN3 (VSS I1_qu6_b3_1 XI1_I1736_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1736_MN0 (XI1_I1736_An I1_dd10_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1737_MN1 (XI1_I1737_Bn I1_qu6_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1737_MN5 (XI1_I1737_n2 XI1_I1737_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1737_MN4 (I1_b26_11 XI1_I1737_An XI1_I1737_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1737_MN2 (XI1_I1737_n1 I1_dd11_b3_4 I1_b26_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1737_MN3 (VSS I1_qu6_b3_1 XI1_I1737_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1737_MN0 (XI1_I1737_An I1_dd11_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I217_MN1 (XI1_I1666_I217_Bn I1_I1666_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I217_MN5 (XI1_I1666_I217_n2 XI1_I1666_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1666_I217_MN4 (I1_p24_14 XI1_I1666_I217_An XI1_I1666_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1666_I217_MN2 (XI1_I1666_I217_n1 I1_I1666_pn14 I1_p24_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1666_I217_MN3 (VSS I1_I1666_G13_0n XI1_I1666_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1666_I217_MN0 (XI1_I1666_I217_An I1_I1666_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1648_MN1 (XI1_I1648_Bn I1_qu8_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1648_MN5 (XI1_I1648_n2 XI1_I1648_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1648_MN4 (I1_b24_14 XI1_I1648_An XI1_I1648_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1648_MN2 (XI1_I1648_n1 I1_dd14_b3_4 I1_b24_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1648_MN3 (VSS I1_qu8_b3_2 XI1_I1648_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1648_MN0 (XI1_I1648_An I1_dd14_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1605_MN1 (XI1_I1605_Bn I1_qu9_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1605_MN5 (XI1_I1605_n2 XI1_I1605_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1605_MN4 (I1_b23_17 XI1_I1605_An XI1_I1605_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1605_MN2 (XI1_I1605_n1 I1_dd17_b3_4 I1_b23_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1605_MN3 (VSS I1_qu9_b3_2 XI1_I1605_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1605_MN0 (XI1_I1605_An I1_dd17_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I214_MN1 (XI1_I1620_I214_Bn I1_I1620_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I214_MN5 (XI1_I1620_I214_n2 XI1_I1620_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1620_I214_MN4 (I1_p23_11 XI1_I1620_I214_An XI1_I1620_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1620_I214_MN2 (XI1_I1620_I214_n1 I1_I1620_pn11 I1_p23_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1620_I214_MN3 (VSS I1_I1620_G10_0n XI1_I1620_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1620_I214_MN0 (XI1_I1620_I214_An I1_I1620_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I216_MN1 (XI1_I1620_I216_Bn I1_I1620_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I216_MN5 (XI1_I1620_I216_n2 XI1_I1620_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1620_I216_MN4 (I1_p23_13 XI1_I1620_I216_An XI1_I1620_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1620_I216_MN2 (XI1_I1620_I216_n1 I1_I1620_pn13 I1_p23_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1620_I216_MN3 (VSS I1_I1620_G12_0n XI1_I1620_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1620_I216_MN0 (XI1_I1620_I216_An I1_I1620_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I215_MN1 (XI1_I1620_I215_Bn I1_I1620_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I215_MN5 (XI1_I1620_I215_n2 XI1_I1620_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1620_I215_MN4 (I1_p23_12 XI1_I1620_I215_An XI1_I1620_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1620_I215_MN2 (XI1_I1620_I215_n1 I1_I1620_pn12 I1_p23_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1620_I215_MN3 (VSS I1_I1620_G11_0n XI1_I1620_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1620_I215_MN0 (XI1_I1620_I215_An I1_I1620_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I13_MN1 (XI2_I1_I13_Bn I2_I1_SUB_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I13_MN5 (XI2_I1_I13_n2 XI2_I1_I13_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I13_MN4 (I2_I1_bx3 XI2_I1_I13_An XI2_I1_I13_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I13_MN2 (XI2_I1_I13_n1 B_3 I2_I1_bx3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I13_MN3 (VSS I2_I1_SUB_b3_0 XI2_I1_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I13_MN0 (XI2_I1_I13_An B_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I12_MN1 (XI2_I1_I12_Bn I2_I1_SUB_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I12_MN5 (XI2_I1_I12_n2 XI2_I1_I12_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I12_MN4 (I2_I1_bx2 XI2_I1_I12_An XI2_I1_I12_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I12_MN2 (XI2_I1_I12_n1 B_2 I2_I1_bx2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I12_MN3 (VSS I2_I1_SUB_b3_0 XI2_I1_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I12_MN0 (XI2_I1_I12_An B_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1788_MN1 (XI1_I1788_Bn I1_qu5_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1788_MN5 (XI1_I1788_n2 XI1_I1788_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1788_MN4 (I1_b27_16 XI1_I1788_An XI1_I1788_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1788_MN2 (XI1_I1788_n1 I1_dd16_b3_4 I1_b27_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1788_MN3 (VSS I1_qu5_b3_2 XI1_I1788_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1788_MN0 (XI1_I1788_An I1_dd16_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1787_MN1 (XI1_I1787_Bn I1_qu5_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1787_MN5 (XI1_I1787_n2 XI1_I1787_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1787_MN4 (I1_b27_15 XI1_I1787_An XI1_I1787_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1787_MN2 (XI1_I1787_n1 I1_dd15_b3_4 I1_b27_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1787_MN3 (VSS I1_qu5_b3_2 XI1_I1787_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1787_MN0 (XI1_I1787_An I1_dd15_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1734_MN1 (XI1_I1734_Bn I1_qu6_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1734_MN5 (XI1_I1734_n2 XI1_I1734_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1734_MN4 (I1_b26_8 XI1_I1734_An XI1_I1734_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1734_MN2 (XI1_I1734_n1 I1_dd8_b3_4 I1_b26_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1734_MN3 (VSS I1_qu6_b3_1 XI1_I1734_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1734_MN0 (XI1_I1734_An I1_dd8_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1735_MN1 (XI1_I1735_Bn I1_qu6_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1735_MN5 (XI1_I1735_n2 XI1_I1735_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1735_MN4 (I1_b26_9 XI1_I1735_An XI1_I1735_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1735_MN2 (XI1_I1735_n1 I1_dd9_b3_4 I1_b26_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1735_MN3 (VSS I1_qu6_b3_1 XI1_I1735_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1735_MN0 (XI1_I1735_An I1_dd9_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I218_MN1 (XI1_I1666_I218_Bn I1_I1666_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I218_MN5 (XI1_I1666_I218_n2 XI1_I1666_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1666_I218_MN4 (I1_p24_15 XI1_I1666_I218_An XI1_I1666_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1666_I218_MN2 (XI1_I1666_I218_n1 I1_I1666_pn15 I1_p24_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1666_I218_MN3 (VSS I1_I1666_G14_0n XI1_I1666_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1666_I218_MN0 (XI1_I1666_I218_An I1_I1666_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I219_MN1 (XI1_I1666_I219_Bn I1_I1666_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I219_MN5 (XI1_I1666_I219_n2 XI1_I1666_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1666_I219_MN4 (I1_p24_16 XI1_I1666_I219_An XI1_I1666_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1666_I219_MN2 (XI1_I1666_I219_n1 I1_I1666_pn16 I1_p24_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1666_I219_MN3 (VSS I1_I1666_G15_0n XI1_I1666_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1666_I219_MN0 (XI1_I1666_I219_An I1_I1666_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1650_MN1 (XI1_I1650_Bn I1_qu8_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1650_MN5 (XI1_I1650_n2 XI1_I1650_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1650_MN4 (I1_b24_16 XI1_I1650_An XI1_I1650_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1650_MN2 (XI1_I1650_n1 I1_dd16_b3_4 I1_b24_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1650_MN3 (VSS I1_qu8_b3_2 XI1_I1650_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1650_MN0 (XI1_I1650_An I1_dd16_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1649_MN1 (XI1_I1649_Bn I1_qu8_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1649_MN5 (XI1_I1649_n2 XI1_I1649_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1649_MN4 (I1_b24_15 XI1_I1649_An XI1_I1649_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1649_MN2 (XI1_I1649_n1 I1_dd15_b3_4 I1_b24_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1649_MN3 (VSS I1_qu8_b3_2 XI1_I1649_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1649_MN0 (XI1_I1649_An I1_dd15_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I218_MN1 (XI1_I1620_I218_Bn I1_I1620_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I218_MN5 (XI1_I1620_I218_n2 XI1_I1620_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1620_I218_MN4 (I1_p23_15 XI1_I1620_I218_An XI1_I1620_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1620_I218_MN2 (XI1_I1620_I218_n1 I1_I1620_pn15 I1_p23_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1620_I218_MN3 (VSS I1_I1620_G14_0n XI1_I1620_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1620_I218_MN0 (XI1_I1620_I218_An I1_I1620_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1622_MN1 (XI1_I1622_Bn I1_c23_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1622_MN5 (XI1_I1622_n2 XI1_I1622_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1622_MN4 (I1_p23_32 XI1_I1622_An XI1_I1622_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1622_MN2 (XI1_I1622_n1 I1_h23 I1_p23_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1622_MN3 (VSS I1_c23_o XI1_I1622_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1622_MN0 (XI1_I1622_An I1_h23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I217_MN1 (XI1_I1620_I217_Bn I1_I1620_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I217_MN5 (XI1_I1620_I217_n2 XI1_I1620_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1620_I217_MN4 (I1_p23_14 XI1_I1620_I217_An XI1_I1620_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1620_I217_MN2 (XI1_I1620_I217_n1 I1_I1620_pn14 I1_p23_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1620_I217_MN3 (VSS I1_I1620_G13_0n XI1_I1620_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1620_I217_MN0 (XI1_I1620_I217_An I1_I1620_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I64_MN1 (XI2_I2_I64_Bn B_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I64_MN5 (XI2_I2_I64_n2 XI2_I2_I64_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I64_MN4 (I2_XOR_10 XI2_I2_I64_An XI2_I2_I64_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I64_MN2 (XI2_I2_I64_n1 A_10 I2_XOR_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I64_MN3 (VSS B_10 XI2_I2_I64_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I64_MN0 (XI2_I2_I64_An A_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I40_MN1 (XI2_I2_I40_Bn B_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I40_MN5 (XI2_I2_I40_n2 XI2_I2_I40_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I40_MN4 (I2_XOR_6 XI2_I2_I40_An XI2_I2_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I40_MN2 (XI2_I2_I40_n1 A_6 I2_XOR_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I40_MN3 (VSS B_6 XI2_I2_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I40_MN0 (XI2_I2_I40_An A_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I10_MN1 (XI2_I1_I10_Bn I2_I1_SUB_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I10_MN5 (XI2_I1_I10_n2 XI2_I1_I10_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I10_MN4 (I2_I1_bx0 XI2_I1_I10_An XI2_I1_I10_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I10_MN2 (XI2_I1_I10_n1 B_0 I2_I1_bx0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I10_MN3 (VSS I2_I1_SUB_b3_0 XI2_I1_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I10_MN0 (XI2_I1_I10_An B_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I11_MN1 (XI2_I1_I11_Bn I2_I1_SUB_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I11_MN5 (XI2_I1_I11_n2 XI2_I1_I11_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I1_I11_MN4 (I2_I1_bx1 XI2_I1_I11_An XI2_I1_I11_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I11_MN2 (XI2_I1_I11_n1 B_1 I2_I1_bx1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I1_I11_MN3 (VSS I2_I1_SUB_b3_0 XI2_I1_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I1_I11_MN0 (XI2_I1_I11_An B_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1789_MN1 (XI1_I1789_Bn I1_qu5_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1789_MN5 (XI1_I1789_n2 XI1_I1789_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1789_MN4 (I1_b27_17 XI1_I1789_An XI1_I1789_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1789_MN2 (XI1_I1789_n1 I1_dd17_b3_4 I1_b27_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1789_MN3 (VSS I1_qu5_b3_2 XI1_I1789_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1789_MN0 (XI1_I1789_An I1_dd17_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1733_MN1 (XI1_I1733_Bn I1_qu6_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1733_MN5 (XI1_I1733_n2 XI1_I1733_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1733_MN4 (I1_b26_7 XI1_I1733_An XI1_I1733_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1733_MN2 (XI1_I1733_n1 I1_dd7_b3_4 I1_b26_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1733_MN3 (VSS I1_qu6_b3_1 XI1_I1733_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1733_MN0 (XI1_I1733_An I1_dd7_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1732_MN1 (XI1_I1732_Bn I1_qu6_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1732_MN5 (XI1_I1732_n2 XI1_I1732_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1732_MN4 (I1_b26_6 XI1_I1732_An XI1_I1732_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1732_MN2 (XI1_I1732_n1 I1_dd6_b3_4 I1_b26_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1732_MN3 (VSS I1_qu6_b3_1 XI1_I1732_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1732_MN0 (XI1_I1732_An I1_dd6_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1651_MN1 (XI1_I1651_Bn I1_qu8_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1651_MN5 (XI1_I1651_n2 XI1_I1651_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1651_MN4 (I1_b24_17 XI1_I1651_An XI1_I1651_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1651_MN2 (XI1_I1651_n1 I1_dd17_b3_4 I1_b24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1651_MN3 (VSS I1_qu8_b3_2 XI1_I1651_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1651_MN0 (XI1_I1651_An I1_dd17_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I219_MN1 (XI1_I1620_I219_Bn I1_I1620_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I219_MN5 (XI1_I1620_I219_n2 XI1_I1620_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1620_I219_MN4 (I1_p23_16 XI1_I1620_I219_An XI1_I1620_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1620_I219_MN2 (XI1_I1620_I219_n1 I1_I1620_pn16 I1_p23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1620_I219_MN3 (VSS I1_I1620_G15_0n XI1_I1620_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1620_I219_MN0 (XI1_I1620_I219_An I1_I1620_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I46_MN1 (XI2_I2_I46_Bn B_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I46_MN5 (XI2_I2_I46_n2 XI2_I2_I46_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I46_MN4 (I2_XOR_7 XI2_I2_I46_An XI2_I2_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I46_MN2 (XI2_I2_I46_n1 A_7 I2_XOR_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I46_MN3 (VSS B_7 XI2_I2_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I46_MN0 (XI2_I2_I46_An A_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1760_MN1 (XI1_I1760_Bn I1_c26_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1760_MN5 (XI1_I1760_n2 XI1_I1760_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1760_MN4 (I1_p26_32 XI1_I1760_An XI1_I1760_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1760_MN2 (XI1_I1760_n1 I1_h26 I1_p26_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1760_MN3 (VSS I1_c26_o XI1_I1760_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1760_MN0 (XI1_I1760_An I1_h26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1780_MN1 (XI1_I1780_Bn I1_qu5_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1780_MN5 (XI1_I1780_n2 XI1_I1780_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1780_MN4 (I1_b27_8 XI1_I1780_An XI1_I1780_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1780_MN2 (XI1_I1780_n1 I1_dd8_b3_4 I1_b27_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1780_MN3 (VSS I1_qu5_b3_1 XI1_I1780_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1780_MN0 (XI1_I1780_An I1_dd8_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1778_MN1 (XI1_I1778_Bn I1_qu5_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1778_MN5 (XI1_I1778_n2 XI1_I1778_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1778_MN4 (I1_b27_6 XI1_I1778_An XI1_I1778_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1778_MN2 (XI1_I1778_n1 I1_dd6_b3_4 I1_b27_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1778_MN3 (VSS I1_qu5_b3_1 XI1_I1778_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1778_MN0 (XI1_I1778_An I1_dd6_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1653_MN1 (XI1_I1653_Bn I1_qu8_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1653_MN5 (XI1_I1653_n2 XI1_I1653_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1653_MN4 (I1_b24_19 XI1_I1653_An XI1_I1653_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1653_MN2 (XI1_I1653_n1 I1_dd19_b3_4 I1_b24_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1653_MN3 (VSS I1_qu8_b3_3 XI1_I1653_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1653_MN0 (XI1_I1653_An I1_dd19_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1652_MN1 (XI1_I1652_Bn I1_qu8_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1652_MN5 (XI1_I1652_n2 XI1_I1652_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1652_MN4 (I1_b24_18 XI1_I1652_An XI1_I1652_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1652_MN2 (XI1_I1652_n1 I1_dd18_b3_4 I1_b24_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1652_MN3 (VSS I1_qu8_b3_3 XI1_I1652_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1652_MN0 (XI1_I1652_An I1_dd18_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I58_MN1 (XI2_I2_I58_Bn B_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I58_MN5 (XI2_I2_I58_n2 XI2_I2_I58_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I58_MN4 (I2_XOR_9 XI2_I2_I58_An XI2_I2_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I58_MN2 (XI2_I2_I58_n1 A_9 I2_XOR_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I58_MN3 (VSS B_9 XI2_I2_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I58_MN0 (XI2_I2_I58_An A_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I52_MN1 (XI2_I2_I52_Bn B_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I52_MN5 (XI2_I2_I52_n2 XI2_I2_I52_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I52_MN4 (I2_XOR_8 XI2_I2_I52_An XI2_I2_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I52_MN2 (XI2_I2_I52_n1 A_8 I2_XOR_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I52_MN3 (VSS B_8 XI2_I2_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I52_MN0 (XI2_I2_I52_An A_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I219_MN1 (XI1_I1758_I219_Bn I1_I1758_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I219_MN5 (XI1_I1758_I219_n2 XI1_I1758_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1758_I219_MN4 (I1_p26_16 XI1_I1758_I219_An XI1_I1758_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1758_I219_MN2 (XI1_I1758_I219_n1 I1_I1758_pn16 I1_p26_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1758_I219_MN3 (VSS I1_I1758_G15_0n XI1_I1758_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1758_I219_MN0 (XI1_I1758_I219_An I1_I1758_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I217_MN1 (XI1_I1758_I217_Bn I1_I1758_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I217_MN5 (XI1_I1758_I217_n2 XI1_I1758_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1758_I217_MN4 (I1_p26_14 XI1_I1758_I217_An XI1_I1758_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1758_I217_MN2 (XI1_I1758_I217_n1 I1_I1758_pn14 I1_p26_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1758_I217_MN3 (VSS I1_I1758_G13_0n XI1_I1758_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1758_I217_MN0 (XI1_I1758_I217_An I1_I1758_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1782_MN1 (XI1_I1782_Bn I1_qu5_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1782_MN5 (XI1_I1782_n2 XI1_I1782_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1782_MN4 (I1_b27_10 XI1_I1782_An XI1_I1782_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1782_MN2 (XI1_I1782_n1 I1_dd10_b3_4 I1_b27_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1782_MN3 (VSS I1_qu5_b3_1 XI1_I1782_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1782_MN0 (XI1_I1782_An I1_dd10_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1783_MN1 (XI1_I1783_Bn I1_qu5_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1783_MN5 (XI1_I1783_n2 XI1_I1783_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1783_MN4 (I1_b27_11 XI1_I1783_An XI1_I1783_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1783_MN2 (XI1_I1783_n1 I1_dd11_b3_4 I1_b27_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1783_MN3 (VSS I1_qu5_b3_1 XI1_I1783_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1783_MN0 (XI1_I1783_An I1_dd11_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1781_MN1 (XI1_I1781_Bn I1_qu5_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1781_MN5 (XI1_I1781_n2 XI1_I1781_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1781_MN4 (I1_b27_9 XI1_I1781_An XI1_I1781_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1781_MN2 (XI1_I1781_n1 I1_dd9_b3_4 I1_b27_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1781_MN3 (VSS I1_qu5_b3_1 XI1_I1781_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1781_MN0 (XI1_I1781_An I1_dd9_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1779_MN1 (XI1_I1779_Bn I1_qu5_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1779_MN5 (XI1_I1779_n2 XI1_I1779_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1779_MN4 (I1_b27_7 XI1_I1779_An XI1_I1779_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1779_MN2 (XI1_I1779_n1 I1_dd7_b3_4 I1_b27_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1779_MN3 (VSS I1_qu5_b3_1 XI1_I1779_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1779_MN0 (XI1_I1779_An I1_dd7_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1654_MN1 (XI1_I1654_Bn I1_qu8_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1654_MN5 (XI1_I1654_n2 XI1_I1654_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1654_MN4 (I1_b24_20 XI1_I1654_An XI1_I1654_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1654_MN2 (XI1_I1654_n1 I1_dd20_b3_4 I1_b24_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1654_MN3 (VSS I1_qu8_b3_3 XI1_I1654_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1654_MN0 (XI1_I1654_An I1_dd20_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1608_MN1 (XI1_I1608_Bn I1_qu9_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1608_MN5 (XI1_I1608_n2 XI1_I1608_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1608_MN4 (I1_b23_20 XI1_I1608_An XI1_I1608_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1608_MN2 (XI1_I1608_n1 I1_dd20_b3_4 I1_b23_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1608_MN3 (VSS I1_qu9_b3_3 XI1_I1608_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1608_MN0 (XI1_I1608_An I1_dd20_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1606_MN1 (XI1_I1606_Bn I1_qu9_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1606_MN5 (XI1_I1606_n2 XI1_I1606_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1606_MN4 (I1_b23_18 XI1_I1606_An XI1_I1606_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1606_MN2 (XI1_I1606_n1 I1_dd18_b3_4 I1_b23_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1606_MN3 (VSS I1_qu9_b3_3 XI1_I1606_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1606_MN0 (XI1_I1606_An I1_dd18_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1607_MN1 (XI1_I1607_Bn I1_qu9_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1607_MN5 (XI1_I1607_n2 XI1_I1607_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1607_MN4 (I1_b23_19 XI1_I1607_An XI1_I1607_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1607_MN2 (XI1_I1607_n1 I1_dd19_b3_4 I1_b23_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1607_MN3 (VSS I1_qu9_b3_3 XI1_I1607_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1607_MN0 (XI1_I1607_An I1_dd19_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I215_MN1 (XI1_I1758_I215_Bn I1_I1758_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I215_MN5 (XI1_I1758_I215_n2 XI1_I1758_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1758_I215_MN4 (I1_p26_12 XI1_I1758_I215_An XI1_I1758_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1758_I215_MN2 (XI1_I1758_I215_n1 I1_I1758_pn12 I1_p26_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1758_I215_MN3 (VSS I1_I1758_G11_0n XI1_I1758_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1758_I215_MN0 (XI1_I1758_I215_An I1_I1758_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I213_MN1 (XI1_I1758_I213_Bn I1_I1758_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I213_MN5 (XI1_I1758_I213_n2 XI1_I1758_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1758_I213_MN4 (I1_p26_10 XI1_I1758_I213_An XI1_I1758_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1758_I213_MN2 (XI1_I1758_I213_n1 I1_I1758_pn10 I1_p26_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1758_I213_MN3 (VSS I1_I1758_G9_0n XI1_I1758_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1758_I213_MN0 (XI1_I1758_I213_An I1_I1758_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1731_MN1 (XI1_I1731_Bn I1_qu6_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1731_MN5 (XI1_I1731_n2 XI1_I1731_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1731_MN4 (I1_b26_5 XI1_I1731_An XI1_I1731_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1731_MN2 (XI1_I1731_n1 I1_dd5_b3_4 I1_b26_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1731_MN3 (VSS I1_qu6_b3_0 XI1_I1731_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1731_MN0 (XI1_I1731_An I1_dd5_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1730_MN1 (XI1_I1730_Bn I1_qu6_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1730_MN5 (XI1_I1730_n2 XI1_I1730_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1730_MN4 (I1_b26_4 XI1_I1730_An XI1_I1730_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1730_MN2 (XI1_I1730_n1 I1_dd4_b3_4 I1_b26_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1730_MN3 (VSS I1_qu6_b3_0 XI1_I1730_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1730_MN0 (XI1_I1730_An I1_dd4_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1668_MN1 (XI1_I1668_Bn I1_c24_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1668_MN5 (XI1_I1668_n2 XI1_I1668_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1668_MN4 (I1_p24_32 XI1_I1668_An XI1_I1668_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1668_MN2 (XI1_I1668_n1 I1_h24 I1_p24_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1668_MN3 (VSS I1_c24_o XI1_I1668_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1668_MN0 (XI1_I1668_An I1_h24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1656_MN1 (XI1_I1656_Bn I1_qu8_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1656_MN5 (XI1_I1656_n2 XI1_I1656_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1656_MN4 (I1_b24_22 XI1_I1656_An XI1_I1656_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1656_MN2 (XI1_I1656_n1 I1_dd22_b3_4 I1_b24_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1656_MN3 (VSS I1_qu8_b3_3 XI1_I1656_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1656_MN0 (XI1_I1656_An I1_dd22_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1655_MN1 (XI1_I1655_Bn I1_qu8_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1655_MN5 (XI1_I1655_n2 XI1_I1655_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1655_MN4 (I1_b24_21 XI1_I1655_An XI1_I1655_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1655_MN2 (XI1_I1655_n1 I1_dd21_b3_4 I1_b24_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1655_MN3 (VSS I1_qu8_b3_3 XI1_I1655_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1655_MN0 (XI1_I1655_An I1_dd21_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1609_MN1 (XI1_I1609_Bn I1_qu9_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1609_MN5 (XI1_I1609_n2 XI1_I1609_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1609_MN4 (I1_b23_21 XI1_I1609_An XI1_I1609_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1609_MN2 (XI1_I1609_n1 I1_dd21_b3_4 I1_b23_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1609_MN3 (VSS I1_qu9_b3_3 XI1_I1609_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1609_MN0 (XI1_I1609_An I1_dd21_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I34_MN1 (XI2_I2_I34_Bn B_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I34_MN5 (XI2_I2_I34_n2 XI2_I2_I34_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I34_MN4 (I2_XOR_5 XI2_I2_I34_An XI2_I2_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I34_MN2 (XI2_I2_I34_n1 A_5 I2_XOR_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I34_MN3 (VSS B_5 XI2_I2_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I34_MN0 (XI2_I2_I34_An A_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I4_MN1 (XI2_I2_I4_Bn B_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I4_MN5 (XI2_I2_I4_n2 XI2_I2_I4_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I4_MN4 (I2_XOR_0 XI2_I2_I4_An XI2_I2_I4_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I4_MN2 (XI2_I2_I4_n1 A_0 I2_XOR_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I4_MN3 (VSS B_0 XI2_I2_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I4_MN0 (XI2_I2_I4_An A_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I218_MN1 (XI1_I1758_I218_Bn I1_I1758_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I218_MN5 (XI1_I1758_I218_n2 XI1_I1758_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1758_I218_MN4 (I1_p26_15 XI1_I1758_I218_An XI1_I1758_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1758_I218_MN2 (XI1_I1758_I218_n1 I1_I1758_pn15 I1_p26_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1758_I218_MN3 (VSS I1_I1758_G14_0n XI1_I1758_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1758_I218_MN0 (XI1_I1758_I218_An I1_I1758_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I207_MN1 (XI1_I1758_I207_Bn I1_I1758_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I207_MN5 (XI1_I1758_I207_n2 XI1_I1758_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1758_I207_MN4 (I1_p26_4 XI1_I1758_I207_An XI1_I1758_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1758_I207_MN2 (XI1_I1758_I207_n1 I1_I1758_pn4 I1_p26_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1758_I207_MN3 (VSS I1_I1758_G3_0n XI1_I1758_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1758_I207_MN0 (XI1_I1758_I207_An I1_I1758_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1729_MN1 (XI1_I1729_Bn I1_qu6_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1729_MN5 (XI1_I1729_n2 XI1_I1729_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1729_MN4 (I1_b26_3 XI1_I1729_An XI1_I1729_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1729_MN2 (XI1_I1729_n1 I1_dd3_b3_4 I1_b26_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1729_MN3 (VSS I1_qu6_b3_0 XI1_I1729_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1729_MN0 (XI1_I1729_An I1_dd3_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1728_MN1 (XI1_I1728_Bn I1_qu6_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1728_MN5 (XI1_I1728_n2 XI1_I1728_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1728_MN4 (I1_b26_2 XI1_I1728_An XI1_I1728_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1728_MN2 (XI1_I1728_n1 I1_dd2_b3_4 I1_b26_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1728_MN3 (VSS I1_qu6_b3_0 XI1_I1728_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1728_MN0 (XI1_I1728_An I1_dd2_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1667_MN1 (XI1_I1667_Bn I1_qu8_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1667_MN5 (XI1_I1667_n2 XI1_I1667_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1667_MN4 (I1_h24 XI1_I1667_An XI1_I1667_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1667_MN2 (XI1_I1667_n1 I1_p23_31 I1_h24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1667_MN3 (VSS I1_qu8_b3_5 XI1_I1667_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1667_MN0 (XI1_I1667_An I1_p23_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1657_MN1 (XI1_I1657_Bn I1_qu8_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1657_MN5 (XI1_I1657_n2 XI1_I1657_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1657_MN4 (I1_b24_23 XI1_I1657_An XI1_I1657_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1657_MN2 (XI1_I1657_n1 I1_dd23_b3_4 I1_b24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1657_MN3 (VSS I1_qu8_b3_3 XI1_I1657_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1657_MN0 (XI1_I1657_An I1_dd23_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1611_MN1 (XI1_I1611_Bn I1_qu9_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1611_MN5 (XI1_I1611_n2 XI1_I1611_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1611_MN4 (I1_b23_23 XI1_I1611_An XI1_I1611_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1611_MN2 (XI1_I1611_n1 I1_dd23_b3_4 I1_b23_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1611_MN3 (VSS I1_qu9_b3_3 XI1_I1611_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1611_MN0 (XI1_I1611_An I1_dd23_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1610_MN1 (XI1_I1610_Bn I1_qu9_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1610_MN5 (XI1_I1610_n2 XI1_I1610_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1610_MN4 (I1_b23_22 XI1_I1610_An XI1_I1610_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1610_MN2 (XI1_I1610_n1 I1_dd22_b3_4 I1_b23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1610_MN3 (VSS I1_qu9_b3_3 XI1_I1610_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1610_MN0 (XI1_I1610_An I1_dd22_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1805_MN1 (XI1_I1805_Bn I1_qu5_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1805_MN5 (XI1_I1805_n2 XI1_I1805_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1805_MN4 (I1_h27 XI1_I1805_An XI1_I1805_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1805_MN2 (XI1_I1805_n1 I1_p26_31 I1_h27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1805_MN3 (VSS I1_qu5_b3_5 XI1_I1805_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1805_MN0 (XI1_I1805_An I1_p26_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1790_MN1 (XI1_I1790_Bn I1_qu5_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1790_MN5 (XI1_I1790_n2 XI1_I1790_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1790_MN4 (I1_b27_18 XI1_I1790_An XI1_I1790_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1790_MN2 (XI1_I1790_n1 I1_dd18_b3_4 I1_b27_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1790_MN3 (VSS I1_qu5_b3_3 XI1_I1790_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1790_MN0 (XI1_I1790_An I1_dd18_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I216_MN1 (XI1_I1758_I216_Bn I1_I1758_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I216_MN5 (XI1_I1758_I216_n2 XI1_I1758_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1758_I216_MN4 (I1_p26_13 XI1_I1758_I216_An XI1_I1758_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1758_I216_MN2 (XI1_I1758_I216_n1 I1_I1758_pn13 I1_p26_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1758_I216_MN3 (VSS I1_I1758_G12_0n XI1_I1758_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1758_I216_MN0 (XI1_I1758_I216_An I1_I1758_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I214_MN1 (XI1_I1758_I214_Bn I1_I1758_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I214_MN5 (XI1_I1758_I214_n2 XI1_I1758_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1758_I214_MN4 (I1_p26_11 XI1_I1758_I214_An XI1_I1758_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1758_I214_MN2 (XI1_I1758_I214_n1 I1_I1758_pn11 I1_p26_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1758_I214_MN3 (VSS I1_I1758_G10_0n XI1_I1758_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1758_I214_MN0 (XI1_I1758_I214_An I1_I1758_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1727_MN1 (XI1_I1727_Bn I1_qu6_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1727_MN5 (XI1_I1727_n2 XI1_I1727_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1727_MN4 (I1_b26_1 XI1_I1727_An XI1_I1727_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1727_MN2 (XI1_I1727_n1 I1_dd1_b3_4 I1_b26_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1727_MN3 (VSS I1_qu6_b3_0 XI1_I1727_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1727_MN0 (XI1_I1727_An I1_dd1_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1726_MN1 (XI1_I1726_Bn I1_qu6_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1726_MN5 (XI1_I1726_n2 XI1_I1726_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1726_MN4 (I1_b26_0 XI1_I1726_An XI1_I1726_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1726_MN2 (XI1_I1726_n1 I1_B_0_b3_4 I1_b26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1726_MN3 (VSS I1_qu6_b3_0 XI1_I1726_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1726_MN0 (XI1_I1726_An I1_B_0_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1664_MN1 (XI1_I1664_Bn I1_qu8_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1664_MN5 (XI1_I1664_n2 XI1_I1664_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1664_MN4 (I1_b24_30 XI1_I1664_An XI1_I1664_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1664_MN2 (XI1_I1664_n1 I1_dd30_b3_4 I1_b24_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1664_MN3 (VSS I1_qu8_b3_5 XI1_I1664_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1664_MN0 (XI1_I1664_An I1_dd30_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1658_MN1 (XI1_I1658_Bn I1_qu8_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1658_MN5 (XI1_I1658_n2 XI1_I1658_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1658_MN4 (I1_b24_24 XI1_I1658_An XI1_I1658_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1658_MN2 (XI1_I1658_n1 I1_dd24_b3_4 I1_b24_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1658_MN3 (VSS I1_qu8_b3_4 XI1_I1658_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1658_MN0 (XI1_I1658_An I1_dd24_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1619_MN1 (XI1_I1619_Bn I1_qu9_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1619_MN5 (XI1_I1619_n2 XI1_I1619_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1619_MN4 (I1_b23_31 XI1_I1619_An XI1_I1619_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1619_MN2 (XI1_I1619_n1 I1_dd31_b3_4 I1_b23_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1619_MN3 (VSS I1_qu9_b3_5 XI1_I1619_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1619_MN0 (XI1_I1619_An I1_dd31_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1799_MN1 (XI1_I1799_Bn I1_qu5_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1799_MN5 (XI1_I1799_n2 XI1_I1799_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1799_MN4 (I1_b27_27 XI1_I1799_An XI1_I1799_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1799_MN2 (XI1_I1799_n1 I1_dd27_b3_4 I1_b27_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1799_MN3 (VSS I1_qu5_b3_4 XI1_I1799_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1799_MN0 (XI1_I1799_An I1_dd27_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1802_MN1 (XI1_I1802_Bn I1_qu5_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1802_MN5 (XI1_I1802_n2 XI1_I1802_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1802_MN4 (I1_b27_30 XI1_I1802_An XI1_I1802_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1802_MN2 (XI1_I1802_n1 I1_dd30_b3_4 I1_b27_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1802_MN3 (VSS I1_qu5_b3_5 XI1_I1802_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1802_MN0 (XI1_I1802_An I1_dd30_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1803_MN1 (XI1_I1803_Bn I1_qu5_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1803_MN5 (XI1_I1803_n2 XI1_I1803_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1803_MN4 (I1_b27_31 XI1_I1803_An XI1_I1803_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1803_MN2 (XI1_I1803_n1 I1_dd31_b3_4 I1_b27_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1803_MN3 (VSS I1_qu5_b3_5 XI1_I1803_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1803_MN0 (XI1_I1803_An I1_dd31_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1796_MN1 (XI1_I1796_Bn I1_qu5_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1796_MN5 (XI1_I1796_n2 XI1_I1796_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1796_MN4 (I1_b27_24 XI1_I1796_An XI1_I1796_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1796_MN2 (XI1_I1796_n1 I1_dd24_b3_4 I1_b27_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1796_MN3 (VSS I1_qu5_b3_4 XI1_I1796_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1796_MN0 (XI1_I1796_An I1_dd24_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1795_MN1 (XI1_I1795_Bn I1_qu5_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1795_MN5 (XI1_I1795_n2 XI1_I1795_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1795_MN4 (I1_b27_23 XI1_I1795_An XI1_I1795_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1795_MN2 (XI1_I1795_n1 I1_dd23_b3_4 I1_b27_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1795_MN3 (VSS I1_qu5_b3_3 XI1_I1795_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1795_MN0 (XI1_I1795_An I1_dd23_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1794_MN1 (XI1_I1794_Bn I1_qu5_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1794_MN5 (XI1_I1794_n2 XI1_I1794_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1794_MN4 (I1_b27_22 XI1_I1794_An XI1_I1794_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1794_MN2 (XI1_I1794_n1 I1_dd22_b3_4 I1_b27_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1794_MN3 (VSS I1_qu5_b3_3 XI1_I1794_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1794_MN0 (XI1_I1794_An I1_dd22_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1793_MN1 (XI1_I1793_Bn I1_qu5_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1793_MN5 (XI1_I1793_n2 XI1_I1793_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1793_MN4 (I1_b27_21 XI1_I1793_An XI1_I1793_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1793_MN2 (XI1_I1793_n1 I1_dd21_b3_4 I1_b27_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1793_MN3 (VSS I1_qu5_b3_3 XI1_I1793_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1793_MN0 (XI1_I1793_An I1_dd21_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1792_MN1 (XI1_I1792_Bn I1_qu5_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1792_MN5 (XI1_I1792_n2 XI1_I1792_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1792_MN4 (I1_b27_20 XI1_I1792_An XI1_I1792_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1792_MN2 (XI1_I1792_n1 I1_dd20_b3_4 I1_b27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1792_MN3 (VSS I1_qu5_b3_3 XI1_I1792_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1792_MN0 (XI1_I1792_An I1_dd20_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1791_MN1 (XI1_I1791_Bn I1_qu5_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1791_MN5 (XI1_I1791_n2 XI1_I1791_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1791_MN4 (I1_b27_19 XI1_I1791_An XI1_I1791_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1791_MN2 (XI1_I1791_n1 I1_dd19_b3_4 I1_b27_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1791_MN3 (VSS I1_qu5_b3_3 XI1_I1791_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1791_MN0 (XI1_I1791_An I1_dd19_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I212_MN1 (XI1_I1758_I212_Bn I1_I1758_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I212_MN5 (XI1_I1758_I212_n2 XI1_I1758_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1758_I212_MN4 (I1_p26_9 XI1_I1758_I212_An XI1_I1758_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1758_I212_MN2 (XI1_I1758_I212_n1 I1_I1758_pn9 I1_p26_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1758_I212_MN3 (VSS I1_I1758_G8_0n XI1_I1758_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1758_I212_MN0 (XI1_I1758_I212_An I1_I1758_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I206_MN1 (XI1_I1758_I206_Bn I1_I1758_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I206_MN5 (XI1_I1758_I206_n2 XI1_I1758_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1758_I206_MN4 (I1_p26_3 XI1_I1758_I206_An XI1_I1758_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1758_I206_MN2 (XI1_I1758_I206_n1 I1_I1758_pn3 I1_p26_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1758_I206_MN3 (VSS I1_I1758_G2_0n XI1_I1758_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1758_I206_MN0 (XI1_I1758_I206_An I1_I1758_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1776_MN1 (XI1_I1776_Bn I1_qu5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1776_MN5 (XI1_I1776_n2 XI1_I1776_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1776_MN4 (I1_b27_4 XI1_I1776_An XI1_I1776_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1776_MN2 (XI1_I1776_n1 I1_dd4_b3_4 I1_b27_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1776_MN3 (VSS I1_qu5_b3_0 XI1_I1776_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1776_MN0 (XI1_I1776_An I1_dd4_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1665_MN1 (XI1_I1665_Bn I1_qu8_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1665_MN5 (XI1_I1665_n2 XI1_I1665_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1665_MN4 (I1_b24_31 XI1_I1665_An XI1_I1665_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1665_MN2 (XI1_I1665_n1 I1_dd31_b3_4 I1_b24_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1665_MN3 (VSS I1_qu8_b3_5 XI1_I1665_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1665_MN0 (XI1_I1665_An I1_dd31_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1660_MN1 (XI1_I1660_Bn I1_qu8_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1660_MN5 (XI1_I1660_n2 XI1_I1660_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1660_MN4 (I1_b24_26 XI1_I1660_An XI1_I1660_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1660_MN2 (XI1_I1660_n1 I1_dd26_b3_4 I1_b24_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1660_MN3 (VSS I1_qu8_b3_4 XI1_I1660_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1660_MN0 (XI1_I1660_An I1_dd26_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1659_MN1 (XI1_I1659_Bn I1_qu8_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1659_MN5 (XI1_I1659_n2 XI1_I1659_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1659_MN4 (I1_b24_25 XI1_I1659_An XI1_I1659_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1659_MN2 (XI1_I1659_n1 I1_dd25_b3_4 I1_b24_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1659_MN3 (VSS I1_qu8_b3_4 XI1_I1659_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1659_MN0 (XI1_I1659_An I1_dd25_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1612_MN1 (XI1_I1612_Bn I1_qu9_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1612_MN5 (XI1_I1612_n2 XI1_I1612_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1612_MN4 (I1_b23_24 XI1_I1612_An XI1_I1612_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1612_MN2 (XI1_I1612_n1 I1_dd24_b3_4 I1_b23_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1612_MN3 (VSS I1_qu9_b3_4 XI1_I1612_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1612_MN0 (XI1_I1612_An I1_dd24_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1613_MN1 (XI1_I1613_Bn I1_qu9_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1613_MN5 (XI1_I1613_n2 XI1_I1613_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1613_MN4 (I1_b23_25 XI1_I1613_An XI1_I1613_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1613_MN2 (XI1_I1613_n1 I1_dd25_b3_4 I1_b23_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1613_MN3 (VSS I1_qu9_b3_4 XI1_I1613_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1613_MN0 (XI1_I1613_An I1_dd25_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1618_MN1 (XI1_I1618_Bn I1_qu9_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1618_MN5 (XI1_I1618_n2 XI1_I1618_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1618_MN4 (I1_b23_30 XI1_I1618_An XI1_I1618_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1618_MN2 (XI1_I1618_n1 I1_dd30_b3_4 I1_b23_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1618_MN3 (VSS I1_qu9_b3_5 XI1_I1618_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1618_MN0 (XI1_I1618_An I1_dd30_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I10_MN1 (XI2_I2_I10_Bn B_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I10_MN5 (XI2_I2_I10_n2 XI2_I2_I10_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I10_MN4 (I2_XOR_1 XI2_I2_I10_An XI2_I2_I10_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I10_MN2 (XI2_I2_I10_n1 A_1 I2_XOR_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I10_MN3 (VSS B_1 XI2_I2_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I10_MN0 (XI2_I2_I10_An A_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I28_MN1 (XI2_I2_I28_Bn B_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I28_MN5 (XI2_I2_I28_n2 XI2_I2_I28_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I28_MN4 (I2_XOR_4 XI2_I2_I28_An XI2_I2_I28_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I28_MN2 (XI2_I2_I28_n1 A_4 I2_XOR_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I28_MN3 (VSS B_4 XI2_I2_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I28_MN0 (XI2_I2_I28_An A_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1798_MN1 (XI1_I1798_Bn I1_qu5_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1798_MN5 (XI1_I1798_n2 XI1_I1798_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1798_MN4 (I1_b27_26 XI1_I1798_An XI1_I1798_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1798_MN2 (XI1_I1798_n1 I1_dd26_b3_4 I1_b27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1798_MN3 (VSS I1_qu5_b3_4 XI1_I1798_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1798_MN0 (XI1_I1798_An I1_dd26_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1800_MN1 (XI1_I1800_Bn I1_qu5_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1800_MN5 (XI1_I1800_n2 XI1_I1800_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1800_MN4 (I1_b27_28 XI1_I1800_An XI1_I1800_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1800_MN2 (XI1_I1800_n1 I1_dd28_b3_4 I1_b27_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1800_MN3 (VSS I1_qu5_b3_4 XI1_I1800_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1800_MN0 (XI1_I1800_An I1_dd28_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1797_MN1 (XI1_I1797_Bn I1_qu5_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1797_MN5 (XI1_I1797_n2 XI1_I1797_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1797_MN4 (I1_b27_25 XI1_I1797_An XI1_I1797_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1797_MN2 (XI1_I1797_n1 I1_dd25_b3_4 I1_b27_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1797_MN3 (VSS I1_qu5_b3_4 XI1_I1797_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1797_MN0 (XI1_I1797_An I1_dd25_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1775_MN1 (XI1_I1775_Bn I1_qu5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1775_MN5 (XI1_I1775_n2 XI1_I1775_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1775_MN4 (I1_b27_3 XI1_I1775_An XI1_I1775_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1775_MN2 (XI1_I1775_n1 I1_dd3_b3_4 I1_b27_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1775_MN3 (VSS I1_qu5_b3_0 XI1_I1775_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1775_MN0 (XI1_I1775_An I1_dd3_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1777_MN1 (XI1_I1777_Bn I1_qu5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1777_MN5 (XI1_I1777_n2 XI1_I1777_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1777_MN4 (I1_b27_5 XI1_I1777_An XI1_I1777_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1777_MN2 (XI1_I1777_n1 I1_dd5_b3_4 I1_b27_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1777_MN3 (VSS I1_qu5_b3_0 XI1_I1777_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1777_MN0 (XI1_I1777_An I1_dd5_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1774_MN1 (XI1_I1774_Bn I1_qu5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1774_MN5 (XI1_I1774_n2 XI1_I1774_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1774_MN4 (I1_b27_2 XI1_I1774_An XI1_I1774_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1774_MN2 (XI1_I1774_n1 I1_dd2_b3_4 I1_b27_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1774_MN3 (VSS I1_qu5_b3_0 XI1_I1774_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1774_MN0 (XI1_I1774_An I1_dd2_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1773_MN1 (XI1_I1773_Bn I1_qu5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1773_MN5 (XI1_I1773_n2 XI1_I1773_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1773_MN4 (I1_b27_1 XI1_I1773_An XI1_I1773_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1773_MN2 (XI1_I1773_n1 I1_dd1_b3_4 I1_b27_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1773_MN3 (VSS I1_qu5_b3_0 XI1_I1773_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1773_MN0 (XI1_I1773_An I1_dd1_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1772_MN1 (XI1_I1772_Bn I1_qu5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1772_MN5 (XI1_I1772_n2 XI1_I1772_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1772_MN4 (I1_b27_0 XI1_I1772_An XI1_I1772_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1772_MN2 (XI1_I1772_n1 I1_B_0_b3_4 I1_b27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1772_MN3 (VSS I1_qu5_b3_0 XI1_I1772_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1772_MN0 (XI1_I1772_An I1_B_0_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1662_MN1 (XI1_I1662_Bn I1_qu8_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1662_MN5 (XI1_I1662_n2 XI1_I1662_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1662_MN4 (I1_b24_28 XI1_I1662_An XI1_I1662_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1662_MN2 (XI1_I1662_n1 I1_dd28_b3_4 I1_b24_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1662_MN3 (VSS I1_qu8_b3_4 XI1_I1662_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1662_MN0 (XI1_I1662_An I1_dd28_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1614_MN1 (XI1_I1614_Bn I1_qu9_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1614_MN5 (XI1_I1614_n2 XI1_I1614_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1614_MN4 (I1_b23_26 XI1_I1614_An XI1_I1614_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1614_MN2 (XI1_I1614_n1 I1_dd26_b3_4 I1_b23_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1614_MN3 (VSS I1_qu9_b3_4 XI1_I1614_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1614_MN0 (XI1_I1614_An I1_dd26_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1616_MN1 (XI1_I1616_Bn I1_qu9_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1616_MN5 (XI1_I1616_n2 XI1_I1616_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1616_MN4 (I1_b23_28 XI1_I1616_An XI1_I1616_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1616_MN2 (XI1_I1616_n1 I1_dd28_b3_4 I1_b23_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1616_MN3 (VSS I1_qu9_b3_4 XI1_I1616_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1616_MN0 (XI1_I1616_An I1_dd28_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1801_MN1 (XI1_I1801_Bn I1_qu5_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1801_MN5 (XI1_I1801_n2 XI1_I1801_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1801_MN4 (I1_b27_29 XI1_I1801_An XI1_I1801_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1801_MN2 (XI1_I1801_n1 I1_dd29_b3_4 I1_b27_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1801_MN3 (VSS I1_qu5_b3_4 XI1_I1801_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1801_MN0 (XI1_I1801_An I1_dd29_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1818_MN1 (XI1_I1818_Bn I1_qu4_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1818_MN5 (XI1_I1818_n2 XI1_I1818_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1818_MN4 (I1_b28_0 XI1_I1818_An XI1_I1818_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1818_MN2 (XI1_I1818_n1 I1_B_0_b3_4 I1_b28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1818_MN3 (VSS I1_qu4_b3_0 XI1_I1818_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1818_MN0 (XI1_I1818_An I1_B_0_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1663_MN1 (XI1_I1663_Bn I1_qu8_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1663_MN5 (XI1_I1663_n2 XI1_I1663_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1663_MN4 (I1_b24_29 XI1_I1663_An XI1_I1663_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1663_MN2 (XI1_I1663_n1 I1_dd29_b3_4 I1_b24_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1663_MN3 (VSS I1_qu8_b3_4 XI1_I1663_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1663_MN0 (XI1_I1663_An I1_dd29_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1661_MN1 (XI1_I1661_Bn I1_qu8_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1661_MN5 (XI1_I1661_n2 XI1_I1661_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1661_MN4 (I1_b24_27 XI1_I1661_An XI1_I1661_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1661_MN2 (XI1_I1661_n1 I1_dd27_b3_4 I1_b24_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1661_MN3 (VSS I1_qu8_b3_4 XI1_I1661_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1661_MN0 (XI1_I1661_An I1_dd27_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1617_MN1 (XI1_I1617_Bn I1_qu9_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1617_MN5 (XI1_I1617_n2 XI1_I1617_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1617_MN4 (I1_b23_29 XI1_I1617_An XI1_I1617_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1617_MN2 (XI1_I1617_n1 I1_dd29_b3_4 I1_b23_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1617_MN3 (VSS I1_qu9_b3_4 XI1_I1617_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1617_MN0 (XI1_I1617_An I1_dd29_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1615_MN1 (XI1_I1615_Bn I1_qu9_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1615_MN5 (XI1_I1615_n2 XI1_I1615_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1615_MN4 (I1_b23_27 XI1_I1615_An XI1_I1615_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1615_MN2 (XI1_I1615_n1 I1_dd27_b3_4 I1_b23_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1615_MN3 (VSS I1_qu9_b3_4 XI1_I1615_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1615_MN0 (XI1_I1615_An I1_dd27_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1911_MN1 (XI1_I1911_Bn I1_qu2_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1911_MN5 (XI1_I1911_n2 XI1_I1911_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1911_MN4 (I1_b30_1 XI1_I1911_An XI1_I1911_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1911_MN2 (XI1_I1911_n1 I1_dd1_b3_5 I1_b30_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1911_MN3 (VSS I1_qu2_b3_0 XI1_I1911_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1911_MN0 (XI1_I1911_An I1_dd1_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1910_MN1 (XI1_I1910_Bn I1_qu2_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1910_MN5 (XI1_I1910_n2 XI1_I1910_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1910_MN4 (I1_b30_0 XI1_I1910_An XI1_I1910_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1910_MN2 (XI1_I1910_n1 I1_B_0_b3_5 I1_b30_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1910_MN3 (VSS I1_qu2_b3_0 XI1_I1910_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1910_MN0 (XI1_I1910_An I1_B_0_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I22_MN1 (XI2_I2_I22_Bn B_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I22_MN5 (XI2_I2_I22_n2 XI2_I2_I22_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I22_MN4 (I2_XOR_3 XI2_I2_I22_An XI2_I2_I22_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I22_MN2 (XI2_I2_I22_n1 A_3 I2_XOR_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I22_MN3 (VSS B_3 XI2_I2_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I22_MN0 (XI2_I2_I22_An A_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I16_MN1 (XI2_I2_I16_Bn B_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I16_MN5 (XI2_I2_I16_n2 XI2_I2_I16_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI2_I2_I16_MN4 (I2_XOR_2 XI2_I2_I16_An XI2_I2_I16_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I16_MN2 (XI2_I2_I16_n1 A_2 I2_XOR_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI2_I2_I16_MN3 (VSS B_2 XI2_I2_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI2_I2_I16_MN0 (XI2_I2_I16_An A_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1819_MN1 (XI1_I1819_Bn I1_qu4_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1819_MN5 (XI1_I1819_n2 XI1_I1819_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1819_MN4 (I1_b28_1 XI1_I1819_An XI1_I1819_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1819_MN2 (XI1_I1819_n1 I1_dd1_b3_5 I1_b28_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1819_MN3 (VSS I1_qu4_b3_0 XI1_I1819_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1819_MN0 (XI1_I1819_An I1_dd1_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1867_MN1 (XI1_I1867_Bn I1_qu3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1867_MN5 (XI1_I1867_n2 XI1_I1867_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1867_MN4 (I1_b29_3 XI1_I1867_An XI1_I1867_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1867_MN2 (XI1_I1867_n1 I1_dd3_b3_5 I1_b29_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1867_MN3 (VSS I1_qu3_b3_0 XI1_I1867_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1867_MN0 (XI1_I1867_An I1_dd3_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1866_MN1 (XI1_I1866_Bn I1_qu3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1866_MN5 (XI1_I1866_n2 XI1_I1866_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1866_MN4 (I1_b29_2 XI1_I1866_An XI1_I1866_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1866_MN2 (XI1_I1866_n1 I1_dd2_b3_5 I1_b29_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1866_MN3 (VSS I1_qu3_b3_0 XI1_I1866_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1866_MN0 (XI1_I1866_An I1_dd2_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1865_MN1 (XI1_I1865_Bn I1_qu3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1865_MN5 (XI1_I1865_n2 XI1_I1865_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1865_MN4 (I1_b29_1 XI1_I1865_An XI1_I1865_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1865_MN2 (XI1_I1865_n1 I1_dd1_b3_5 I1_b29_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1865_MN3 (VSS I1_qu3_b3_0 XI1_I1865_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1865_MN0 (XI1_I1865_An I1_dd1_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1913_MN1 (XI1_I1913_Bn I1_qu2_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1913_MN5 (XI1_I1913_n2 XI1_I1913_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1913_MN4 (I1_b30_3 XI1_I1913_An XI1_I1913_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1913_MN2 (XI1_I1913_n1 I1_dd3_b3_5 I1_b30_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1913_MN3 (VSS I1_qu2_b3_0 XI1_I1913_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1913_MN0 (XI1_I1913_An I1_dd3_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1912_MN1 (XI1_I1912_Bn I1_qu2_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1912_MN5 (XI1_I1912_n2 XI1_I1912_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1912_MN4 (I1_b30_2 XI1_I1912_An XI1_I1912_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1912_MN2 (XI1_I1912_n1 I1_dd2_b3_5 I1_b30_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1912_MN3 (VSS I1_qu2_b3_0 XI1_I1912_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1912_MN0 (XI1_I1912_An I1_dd2_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1864_MN1 (XI1_I1864_Bn I1_qu3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1864_MN5 (XI1_I1864_n2 XI1_I1864_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1864_MN4 (I1_b29_0 XI1_I1864_An XI1_I1864_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1864_MN2 (XI1_I1864_n1 I1_B_0_b3_5 I1_b29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1864_MN3 (VSS I1_qu3_b3_0 XI1_I1864_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1864_MN0 (XI1_I1864_An I1_B_0_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1960_MN1 (XI1_I1960_Bn I1_qu1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1960_MN5 (XI1_I1960_n2 XI1_I1960_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1960_MN4 (I1_b31_4 XI1_I1960_An XI1_I1960_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1960_MN2 (XI1_I1960_n1 I1_dd4_b3_5 I1_b31_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1960_MN3 (VSS I1_qu1_b3_0 XI1_I1960_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1960_MN0 (XI1_I1960_An I1_dd4_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1959_MN1 (XI1_I1959_Bn I1_qu1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1959_MN5 (XI1_I1959_n2 XI1_I1959_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1959_MN4 (I1_b31_3 XI1_I1959_An XI1_I1959_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1959_MN2 (XI1_I1959_n1 I1_dd3_b3_5 I1_b31_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1959_MN3 (VSS I1_qu1_b3_0 XI1_I1959_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1959_MN0 (XI1_I1959_An I1_dd3_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1958_MN1 (XI1_I1958_Bn I1_qu1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1958_MN5 (XI1_I1958_n2 XI1_I1958_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1958_MN4 (I1_b31_2 XI1_I1958_An XI1_I1958_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1958_MN2 (XI1_I1958_n1 I1_dd2_b3_5 I1_b31_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1958_MN3 (VSS I1_qu1_b3_0 XI1_I1958_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1958_MN0 (XI1_I1958_An I1_dd2_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1957_MN1 (XI1_I1957_Bn I1_qu1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1957_MN5 (XI1_I1957_n2 XI1_I1957_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1957_MN4 (I1_b31_1 XI1_I1957_An XI1_I1957_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1957_MN2 (XI1_I1957_n1 I1_dd1_b3_5 I1_b31_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1957_MN3 (VSS I1_qu1_b3_0 XI1_I1957_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1957_MN0 (XI1_I1957_An I1_dd1_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1956_MN1 (XI1_I1956_Bn I1_qu1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1956_MN5 (XI1_I1956_n2 XI1_I1956_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1956_MN4 (I1_b31_0 XI1_I1956_An XI1_I1956_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1956_MN2 (XI1_I1956_n1 I1_B_0_b3_5 I1_b31_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1956_MN3 (VSS I1_qu1_b3_0 XI1_I1956_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1956_MN0 (XI1_I1956_An I1_B_0_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I481_MN1 (XI0_I1660_I481_Bn I0_I1660_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I481_MN5 (XI0_I1660_I481_n2 XI0_I1660_I481_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I481_MN4 (MULP_14 XI0_I1660_I481_An XI0_I1660_I481_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I481_MN2 (XI0_I1660_I481_n1 I0_I1660_pn14 MULP_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I481_MN3 (VSS I0_I1660_G13_0n XI0_I1660_I481_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I481_MN0 (XI0_I1660_I481_An I0_I1660_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I483_MN1 (XI0_I1660_I483_Bn I0_I1660_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I483_MN5 (XI0_I1660_I483_n2 XI0_I1660_I483_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I483_MN4 (MULP_16 XI0_I1660_I483_An XI0_I1660_I483_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I483_MN2 (XI0_I1660_I483_n1 I0_I1660_pn16 MULP_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I483_MN3 (VSS I0_I1660_G15_0n XI0_I1660_I483_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I483_MN0 (XI0_I1660_I483_An I0_I1660_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I206_MN1 (XI1_I1804_I206_Bn I1_I1804_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I206_MN5 (XI1_I1804_I206_n2 XI1_I1804_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1804_I206_MN4 (I1_p27_3 XI1_I1804_I206_An XI1_I1804_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1804_I206_MN2 (XI1_I1804_I206_n1 I1_I1804_pn3 I1_p27_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1804_I206_MN3 (VSS I1_I1804_G2_0n XI1_I1804_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1804_I206_MN0 (XI1_I1804_I206_An I1_I1804_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1820_MN1 (XI1_I1820_Bn I1_qu4_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1820_MN5 (XI1_I1820_n2 XI1_I1820_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1820_MN4 (I1_b28_2 XI1_I1820_An XI1_I1820_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1820_MN2 (XI1_I1820_n1 I1_dd2_b3_5 I1_b28_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1820_MN3 (VSS I1_qu4_b3_0 XI1_I1820_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1820_MN0 (XI1_I1820_An I1_dd2_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1821_MN1 (XI1_I1821_Bn I1_qu4_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1821_MN5 (XI1_I1821_n2 XI1_I1821_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1821_MN4 (I1_b28_3 XI1_I1821_An XI1_I1821_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1821_MN2 (XI1_I1821_n1 I1_dd3_b3_5 I1_b28_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1821_MN3 (VSS I1_qu4_b3_0 XI1_I1821_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1821_MN0 (XI1_I1821_An I1_dd3_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1868_MN1 (XI1_I1868_Bn I1_qu3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1868_MN5 (XI1_I1868_n2 XI1_I1868_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1868_MN4 (I1_b29_4 XI1_I1868_An XI1_I1868_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1868_MN2 (XI1_I1868_n1 I1_dd4_b3_5 I1_b29_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1868_MN3 (VSS I1_qu3_b3_0 XI1_I1868_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1868_MN0 (XI1_I1868_An I1_dd4_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1915_MN1 (XI1_I1915_Bn I1_qu2_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1915_MN5 (XI1_I1915_n2 XI1_I1915_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1915_MN4 (I1_b30_5 XI1_I1915_An XI1_I1915_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1915_MN2 (XI1_I1915_n1 I1_dd5_b3_5 I1_b30_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1915_MN3 (VSS I1_qu2_b3_0 XI1_I1915_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1915_MN0 (XI1_I1915_An I1_dd5_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1914_MN1 (XI1_I1914_Bn I1_qu2_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1914_MN5 (XI1_I1914_n2 XI1_I1914_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1914_MN4 (I1_b30_4 XI1_I1914_An XI1_I1914_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1914_MN2 (XI1_I1914_n1 I1_dd4_b3_5 I1_b30_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1914_MN3 (VSS I1_qu2_b3_0 XI1_I1914_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1914_MN0 (XI1_I1914_An I1_dd4_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I206_MN1 (XI1_I1942_I206_Bn I1_I1942_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I206_MN5 (XI1_I1942_I206_n2 XI1_I1942_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1942_I206_MN4 (I1_p30_3 XI1_I1942_I206_An XI1_I1942_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1942_I206_MN2 (XI1_I1942_I206_n1 I1_I1942_pn3 I1_p30_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1942_I206_MN3 (VSS I1_I1942_G2_0n XI1_I1942_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1942_I206_MN0 (XI1_I1942_I206_An I1_I1942_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1961_MN1 (XI1_I1961_Bn I1_qu1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1961_MN5 (XI1_I1961_n2 XI1_I1961_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1961_MN4 (I1_b31_5 XI1_I1961_An XI1_I1961_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1961_MN2 (XI1_I1961_n1 I1_dd5_b3_5 I1_b31_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1961_MN3 (VSS I1_qu1_b3_0 XI1_I1961_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1961_MN0 (XI1_I1961_An I1_dd5_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I476_MN1 (XI0_I1660_I476_Bn I0_I1660_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I476_MN5 (XI0_I1660_I476_n2 XI0_I1660_I476_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I476_MN4 (MULP_9 XI0_I1660_I476_An XI0_I1660_I476_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I476_MN2 (XI0_I1660_I476_n1 I0_I1660_pn9 MULP_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I476_MN3 (VSS I0_I1660_G8_0n XI0_I1660_I476_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I476_MN0 (XI0_I1660_I476_An I0_I1660_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I478_MN1 (XI0_I1660_I478_Bn I0_I1660_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I478_MN5 (XI0_I1660_I478_n2 XI0_I1660_I478_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I478_MN4 (MULP_11 XI0_I1660_I478_An XI0_I1660_I478_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I478_MN2 (XI0_I1660_I478_n1 I0_I1660_pn11 MULP_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I478_MN3 (VSS I0_I1660_G10_0n XI0_I1660_I478_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I478_MN0 (XI0_I1660_I478_An I0_I1660_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I479_MN1 (XI0_I1660_I479_Bn I0_I1660_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I479_MN5 (XI0_I1660_I479_n2 XI0_I1660_I479_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I479_MN4 (MULP_12 XI0_I1660_I479_An XI0_I1660_I479_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I479_MN2 (XI0_I1660_I479_n1 I0_I1660_pn12 MULP_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I479_MN3 (VSS I0_I1660_G11_0n XI0_I1660_I479_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I479_MN0 (XI0_I1660_I479_An I0_I1660_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I480_MN1 (XI0_I1660_I480_Bn I0_I1660_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I480_MN5 (XI0_I1660_I480_n2 XI0_I1660_I480_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I480_MN4 (MULP_13 XI0_I1660_I480_An XI0_I1660_I480_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I480_MN2 (XI0_I1660_I480_n1 I0_I1660_pn13 MULP_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I480_MN3 (VSS I0_I1660_G12_0n XI0_I1660_I480_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I480_MN0 (XI0_I1660_I480_An I0_I1660_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I482_MN1 (XI0_I1660_I482_Bn I0_I1660_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I482_MN5 (XI0_I1660_I482_n2 XI0_I1660_I482_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I482_MN4 (MULP_15 XI0_I1660_I482_An XI0_I1660_I482_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I482_MN2 (XI0_I1660_I482_n1 I0_I1660_pn15 MULP_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I482_MN3 (VSS I0_I1660_G14_0n XI0_I1660_I482_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I482_MN0 (XI0_I1660_I482_An I0_I1660_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I218_MN1 (XI1_I1804_I218_Bn I1_I1804_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I218_MN5 (XI1_I1804_I218_n2 XI1_I1804_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1804_I218_MN4 (I1_p27_15 XI1_I1804_I218_An XI1_I1804_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1804_I218_MN2 (XI1_I1804_I218_n1 I1_I1804_pn15 I1_p27_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1804_I218_MN3 (VSS I1_I1804_G14_0n XI1_I1804_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1804_I218_MN0 (XI1_I1804_I218_An I1_I1804_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I216_MN1 (XI1_I1804_I216_Bn I1_I1804_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I216_MN5 (XI1_I1804_I216_n2 XI1_I1804_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1804_I216_MN4 (I1_p27_13 XI1_I1804_I216_An XI1_I1804_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1804_I216_MN2 (XI1_I1804_I216_n1 I1_I1804_pn13 I1_p27_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1804_I216_MN3 (VSS I1_I1804_G12_0n XI1_I1804_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1804_I216_MN0 (XI1_I1804_I216_An I1_I1804_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I212_MN1 (XI1_I1804_I212_Bn I1_I1804_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I212_MN5 (XI1_I1804_I212_n2 XI1_I1804_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1804_I212_MN4 (I1_p27_9 XI1_I1804_I212_An XI1_I1804_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1804_I212_MN2 (XI1_I1804_I212_n1 I1_I1804_pn9 I1_p27_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1804_I212_MN3 (VSS I1_I1804_G8_0n XI1_I1804_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1804_I212_MN0 (XI1_I1804_I212_An I1_I1804_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1823_MN1 (XI1_I1823_Bn I1_qu4_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1823_MN5 (XI1_I1823_n2 XI1_I1823_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1823_MN4 (I1_b28_5 XI1_I1823_An XI1_I1823_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1823_MN2 (XI1_I1823_n1 I1_dd5_b3_5 I1_b28_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1823_MN3 (VSS I1_qu4_b3_0 XI1_I1823_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1823_MN0 (XI1_I1823_An I1_dd5_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1822_MN1 (XI1_I1822_Bn I1_qu4_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1822_MN5 (XI1_I1822_n2 XI1_I1822_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1822_MN4 (I1_b28_4 XI1_I1822_An XI1_I1822_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1822_MN2 (XI1_I1822_n1 I1_dd4_b3_5 I1_b28_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1822_MN3 (VSS I1_qu4_b3_0 XI1_I1822_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1822_MN0 (XI1_I1822_An I1_dd4_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1869_MN1 (XI1_I1869_Bn I1_qu3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1869_MN5 (XI1_I1869_n2 XI1_I1869_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1869_MN4 (I1_b29_5 XI1_I1869_An XI1_I1869_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1869_MN2 (XI1_I1869_n1 I1_dd5_b3_5 I1_b29_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1869_MN3 (VSS I1_qu3_b3_0 XI1_I1869_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1869_MN0 (XI1_I1869_An I1_dd5_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I207_MN1 (XI1_I1896_I207_Bn I1_I1896_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I207_MN5 (XI1_I1896_I207_n2 XI1_I1896_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1896_I207_MN4 (I1_p29_4 XI1_I1896_I207_An XI1_I1896_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1896_I207_MN2 (XI1_I1896_I207_n1 I1_I1896_pn4 I1_p29_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1896_I207_MN3 (VSS I1_I1896_G3_0n XI1_I1896_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1896_I207_MN0 (XI1_I1896_I207_An I1_I1896_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I206_MN1 (XI1_I1896_I206_Bn I1_I1896_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I206_MN5 (XI1_I1896_I206_n2 XI1_I1896_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1896_I206_MN4 (I1_p29_3 XI1_I1896_I206_An XI1_I1896_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1896_I206_MN2 (XI1_I1896_I206_n1 I1_I1896_pn3 I1_p29_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1896_I206_MN3 (VSS I1_I1896_G2_0n XI1_I1896_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1896_I206_MN0 (XI1_I1896_I206_An I1_I1896_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1916_MN1 (XI1_I1916_Bn I1_qu2_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1916_MN5 (XI1_I1916_n2 XI1_I1916_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1916_MN4 (I1_b30_6 XI1_I1916_An XI1_I1916_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1916_MN2 (XI1_I1916_n1 I1_dd6_b3_5 I1_b30_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1916_MN3 (VSS I1_qu2_b3_1 XI1_I1916_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1916_MN0 (XI1_I1916_An I1_dd6_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I207_MN1 (XI1_I1942_I207_Bn I1_I1942_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I207_MN5 (XI1_I1942_I207_n2 XI1_I1942_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1942_I207_MN4 (I1_p30_4 XI1_I1942_I207_An XI1_I1942_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1942_I207_MN2 (XI1_I1942_I207_n1 I1_I1942_pn4 I1_p30_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1942_I207_MN3 (VSS I1_I1942_G3_0n XI1_I1942_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1942_I207_MN0 (XI1_I1942_I207_An I1_I1942_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1963_MN1 (XI1_I1963_Bn I1_qu1_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1963_MN5 (XI1_I1963_n2 XI1_I1963_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1963_MN4 (I1_b31_7 XI1_I1963_An XI1_I1963_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1963_MN2 (XI1_I1963_n1 I1_dd7_b3_5 I1_b31_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1963_MN3 (VSS I1_qu1_b3_1 XI1_I1963_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1963_MN0 (XI1_I1963_An I1_dd7_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1962_MN1 (XI1_I1962_Bn I1_qu1_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1962_MN5 (XI1_I1962_n2 XI1_I1962_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1962_MN4 (I1_b31_6 XI1_I1962_An XI1_I1962_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1962_MN2 (XI1_I1962_n1 I1_dd6_b3_5 I1_b31_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1962_MN3 (VSS I1_qu1_b3_1 XI1_I1962_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1962_MN0 (XI1_I1962_An I1_dd6_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I207_MN1 (XI1_I1988_I207_Bn I1_I1988_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I207_MN5 (XI1_I1988_I207_n2 XI1_I1988_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1988_I207_MN4 (I1_p31_4 XI1_I1988_I207_An XI1_I1988_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1988_I207_MN2 (XI1_I1988_I207_n1 I1_I1988_pn4 I1_p31_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1988_I207_MN3 (VSS I1_I1988_G3_0n XI1_I1988_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1988_I207_MN0 (XI1_I1988_I207_An I1_I1988_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I206_MN1 (XI1_I1988_I206_Bn I1_I1988_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I206_MN5 (XI1_I1988_I206_n2 XI1_I1988_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1988_I206_MN4 (I1_p31_3 XI1_I1988_I206_An XI1_I1988_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1988_I206_MN2 (XI1_I1988_I206_n1 I1_I1988_pn3 I1_p31_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1988_I206_MN3 (VSS I1_I1988_G2_0n XI1_I1988_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1988_I206_MN0 (XI1_I1988_I206_An I1_I1988_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I471_MN1 (XI0_I1660_I471_Bn I0_I1660_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I471_MN5 (XI0_I1660_I471_n2 XI0_I1660_I471_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I471_MN4 (MULP_4 XI0_I1660_I471_An XI0_I1660_I471_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I471_MN2 (XI0_I1660_I471_n1 I0_I1660_pn4 MULP_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I471_MN3 (VSS I0_I1660_G3_0n XI0_I1660_I471_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I471_MN0 (XI0_I1660_I471_An I0_I1660_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I477_MN1 (XI0_I1660_I477_Bn I0_I1660_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I477_MN5 (XI0_I1660_I477_n2 XI0_I1660_I477_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I477_MN4 (MULP_10 XI0_I1660_I477_An XI0_I1660_I477_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I477_MN2 (XI0_I1660_I477_n1 I0_I1660_pn10 MULP_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I477_MN3 (VSS I0_I1660_G9_0n XI0_I1660_I477_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I477_MN0 (XI0_I1660_I477_An I0_I1660_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I214_MN1 (XI1_I1804_I214_Bn I1_I1804_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I214_MN5 (XI1_I1804_I214_n2 XI1_I1804_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1804_I214_MN4 (I1_p27_11 XI1_I1804_I214_An XI1_I1804_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1804_I214_MN2 (XI1_I1804_I214_n1 I1_I1804_pn11 I1_p27_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1804_I214_MN3 (VSS I1_I1804_G10_0n XI1_I1804_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1804_I214_MN0 (XI1_I1804_I214_An I1_I1804_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I207_MN1 (XI1_I1804_I207_Bn I1_I1804_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I207_MN5 (XI1_I1804_I207_n2 XI1_I1804_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1804_I207_MN4 (I1_p27_4 XI1_I1804_I207_An XI1_I1804_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1804_I207_MN2 (XI1_I1804_I207_n1 I1_I1804_pn4 I1_p27_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1804_I207_MN3 (VSS I1_I1804_G3_0n XI1_I1804_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1804_I207_MN0 (XI1_I1804_I207_An I1_I1804_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I207_MN1 (XI1_I1850_I207_Bn I1_I1850_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I207_MN5 (XI1_I1850_I207_n2 XI1_I1850_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1850_I207_MN4 (I1_p28_4 XI1_I1850_I207_An XI1_I1850_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1850_I207_MN2 (XI1_I1850_I207_n1 I1_I1850_pn4 I1_p28_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1850_I207_MN3 (VSS I1_I1850_G3_0n XI1_I1850_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1850_I207_MN0 (XI1_I1850_I207_An I1_I1850_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I206_MN1 (XI1_I1850_I206_Bn I1_I1850_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I206_MN5 (XI1_I1850_I206_n2 XI1_I1850_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1850_I206_MN4 (I1_p28_3 XI1_I1850_I206_An XI1_I1850_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1850_I206_MN2 (XI1_I1850_I206_n1 I1_I1850_pn3 I1_p28_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1850_I206_MN3 (VSS I1_I1850_G2_0n XI1_I1850_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1850_I206_MN0 (XI1_I1850_I206_An I1_I1850_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1870_MN1 (XI1_I1870_Bn I1_qu3_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1870_MN5 (XI1_I1870_n2 XI1_I1870_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1870_MN4 (I1_b29_6 XI1_I1870_An XI1_I1870_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1870_MN2 (XI1_I1870_n1 I1_dd6_b3_5 I1_b29_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1870_MN3 (VSS I1_qu3_b3_1 XI1_I1870_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1870_MN0 (XI1_I1870_An I1_dd6_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1918_MN1 (XI1_I1918_Bn I1_qu2_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1918_MN5 (XI1_I1918_n2 XI1_I1918_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1918_MN4 (I1_b30_8 XI1_I1918_An XI1_I1918_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1918_MN2 (XI1_I1918_n1 I1_dd8_b3_5 I1_b30_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1918_MN3 (VSS I1_qu2_b3_1 XI1_I1918_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1918_MN0 (XI1_I1918_An I1_dd8_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1917_MN1 (XI1_I1917_Bn I1_qu2_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1917_MN5 (XI1_I1917_n2 XI1_I1917_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1917_MN4 (I1_b30_7 XI1_I1917_An XI1_I1917_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1917_MN2 (XI1_I1917_n1 I1_dd7_b3_5 I1_b30_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1917_MN3 (VSS I1_qu2_b3_1 XI1_I1917_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1917_MN0 (XI1_I1917_An I1_dd7_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1965_MN1 (XI1_I1965_Bn I1_qu1_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1965_MN5 (XI1_I1965_n2 XI1_I1965_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1965_MN4 (I1_b31_9 XI1_I1965_An XI1_I1965_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1965_MN2 (XI1_I1965_n1 I1_dd9_b3_5 I1_b31_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1965_MN3 (VSS I1_qu1_b3_1 XI1_I1965_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1965_MN0 (XI1_I1965_An I1_dd9_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1964_MN1 (XI1_I1964_Bn I1_qu1_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1964_MN5 (XI1_I1964_n2 XI1_I1964_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1964_MN4 (I1_b31_8 XI1_I1964_An XI1_I1964_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1964_MN2 (XI1_I1964_n1 I1_dd8_b3_5 I1_b31_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1964_MN3 (VSS I1_qu1_b3_1 XI1_I1964_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1964_MN0 (XI1_I1964_An I1_dd8_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1825_MN1 (XI1_I1825_Bn I1_qu4_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1825_MN5 (XI1_I1825_n2 XI1_I1825_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1825_MN4 (I1_b28_7 XI1_I1825_An XI1_I1825_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1825_MN2 (XI1_I1825_n1 I1_dd7_b3_5 I1_b28_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1825_MN3 (VSS I1_qu4_b3_1 XI1_I1825_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1825_MN0 (XI1_I1825_An I1_dd7_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1824_MN1 (XI1_I1824_Bn I1_qu4_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1824_MN5 (XI1_I1824_n2 XI1_I1824_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1824_MN4 (I1_b28_6 XI1_I1824_An XI1_I1824_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1824_MN2 (XI1_I1824_n1 I1_dd6_b3_5 I1_b28_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1824_MN3 (VSS I1_qu4_b3_1 XI1_I1824_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1824_MN0 (XI1_I1824_An I1_dd6_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1872_MN1 (XI1_I1872_Bn I1_qu3_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1872_MN5 (XI1_I1872_n2 XI1_I1872_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1872_MN4 (I1_b29_8 XI1_I1872_An XI1_I1872_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1872_MN2 (XI1_I1872_n1 I1_dd8_b3_5 I1_b29_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1872_MN3 (VSS I1_qu3_b3_1 XI1_I1872_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1872_MN0 (XI1_I1872_An I1_dd8_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1871_MN1 (XI1_I1871_Bn I1_qu3_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1871_MN5 (XI1_I1871_n2 XI1_I1871_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1871_MN4 (I1_b29_7 XI1_I1871_An XI1_I1871_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1871_MN2 (XI1_I1871_n1 I1_dd7_b3_5 I1_b29_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1871_MN3 (VSS I1_qu3_b3_1 XI1_I1871_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1871_MN0 (XI1_I1871_An I1_dd7_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1920_MN1 (XI1_I1920_Bn I1_qu2_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1920_MN5 (XI1_I1920_n2 XI1_I1920_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1920_MN4 (I1_b30_10 XI1_I1920_An XI1_I1920_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1920_MN2 (XI1_I1920_n1 I1_dd10_b3_5 I1_b30_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1920_MN3 (VSS I1_qu2_b3_1 XI1_I1920_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1920_MN0 (XI1_I1920_An I1_dd10_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1919_MN1 (XI1_I1919_Bn I1_qu2_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1919_MN5 (XI1_I1919_n2 XI1_I1919_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1919_MN4 (I1_b30_9 XI1_I1919_An XI1_I1919_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1919_MN2 (XI1_I1919_n1 I1_dd9_b3_5 I1_b30_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1919_MN3 (VSS I1_qu2_b3_1 XI1_I1919_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1919_MN0 (XI1_I1919_An I1_dd9_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I212_MN1 (XI1_I1942_I212_Bn I1_I1942_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I212_MN5 (XI1_I1942_I212_n2 XI1_I1942_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1942_I212_MN4 (I1_p30_9 XI1_I1942_I212_An XI1_I1942_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1942_I212_MN2 (XI1_I1942_I212_n1 I1_I1942_pn9 I1_p30_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1942_I212_MN3 (VSS I1_I1942_G8_0n XI1_I1942_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1942_I212_MN0 (XI1_I1942_I212_An I1_I1942_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1966_MN1 (XI1_I1966_Bn I1_qu1_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1966_MN5 (XI1_I1966_n2 XI1_I1966_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1966_MN4 (I1_b31_10 XI1_I1966_An XI1_I1966_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1966_MN2 (XI1_I1966_n1 I1_dd10_b3_5 I1_b31_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1966_MN3 (VSS I1_qu1_b3_1 XI1_I1966_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1966_MN0 (XI1_I1966_An I1_dd10_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I470_MN1 (XI0_I1660_I470_Bn I0_I1660_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I470_MN5 (XI0_I1660_I470_n2 XI0_I1660_I470_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I470_MN4 (MULP_3 XI0_I1660_I470_An XI0_I1660_I470_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I470_MN2 (XI0_I1660_I470_n1 I0_I1660_pn3 MULP_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I470_MN3 (VSS I0_I1660_G2_0n XI0_I1660_I470_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I470_MN0 (XI0_I1660_I470_An I0_I1660_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I217_MN1 (XI1_I1804_I217_Bn I1_I1804_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I217_MN5 (XI1_I1804_I217_n2 XI1_I1804_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1804_I217_MN4 (I1_p27_14 XI1_I1804_I217_An XI1_I1804_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1804_I217_MN2 (XI1_I1804_I217_n1 I1_I1804_pn14 I1_p27_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1804_I217_MN3 (VSS I1_I1804_G13_0n XI1_I1804_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1804_I217_MN0 (XI1_I1804_I217_An I1_I1804_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I213_MN1 (XI1_I1804_I213_Bn I1_I1804_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I213_MN5 (XI1_I1804_I213_n2 XI1_I1804_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1804_I213_MN4 (I1_p27_10 XI1_I1804_I213_An XI1_I1804_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1804_I213_MN2 (XI1_I1804_I213_n1 I1_I1804_pn10 I1_p27_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1804_I213_MN3 (VSS I1_I1804_G9_0n XI1_I1804_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1804_I213_MN0 (XI1_I1804_I213_An I1_I1804_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1828_MN1 (XI1_I1828_Bn I1_qu4_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1828_MN5 (XI1_I1828_n2 XI1_I1828_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1828_MN4 (I1_b28_10 XI1_I1828_An XI1_I1828_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1828_MN2 (XI1_I1828_n1 I1_dd10_b3_5 I1_b28_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1828_MN3 (VSS I1_qu4_b3_1 XI1_I1828_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1828_MN0 (XI1_I1828_An I1_dd10_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1826_MN1 (XI1_I1826_Bn I1_qu4_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1826_MN5 (XI1_I1826_n2 XI1_I1826_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1826_MN4 (I1_b28_8 XI1_I1826_An XI1_I1826_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1826_MN2 (XI1_I1826_n1 I1_dd8_b3_5 I1_b28_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1826_MN3 (VSS I1_qu4_b3_1 XI1_I1826_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1826_MN0 (XI1_I1826_An I1_dd8_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1874_MN1 (XI1_I1874_Bn I1_qu3_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1874_MN5 (XI1_I1874_n2 XI1_I1874_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1874_MN4 (I1_b29_10 XI1_I1874_An XI1_I1874_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1874_MN2 (XI1_I1874_n1 I1_dd10_b3_5 I1_b29_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1874_MN3 (VSS I1_qu3_b3_1 XI1_I1874_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1874_MN0 (XI1_I1874_An I1_dd10_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1873_MN1 (XI1_I1873_Bn I1_qu3_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1873_MN5 (XI1_I1873_n2 XI1_I1873_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1873_MN4 (I1_b29_9 XI1_I1873_An XI1_I1873_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1873_MN2 (XI1_I1873_n1 I1_dd9_b3_5 I1_b29_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1873_MN3 (VSS I1_qu3_b3_1 XI1_I1873_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1873_MN0 (XI1_I1873_An I1_dd9_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I212_MN1 (XI1_I1896_I212_Bn I1_I1896_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I212_MN5 (XI1_I1896_I212_n2 XI1_I1896_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1896_I212_MN4 (I1_p29_9 XI1_I1896_I212_An XI1_I1896_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1896_I212_MN2 (XI1_I1896_I212_n1 I1_I1896_pn9 I1_p29_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1896_I212_MN3 (VSS I1_I1896_G8_0n XI1_I1896_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1896_I212_MN0 (XI1_I1896_I212_An I1_I1896_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1921_MN1 (XI1_I1921_Bn I1_qu2_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1921_MN5 (XI1_I1921_n2 XI1_I1921_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1921_MN4 (I1_b30_11 XI1_I1921_An XI1_I1921_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1921_MN2 (XI1_I1921_n1 I1_dd11_b3_5 I1_b30_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1921_MN3 (VSS I1_qu2_b3_1 XI1_I1921_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1921_MN0 (XI1_I1921_An I1_dd11_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I213_MN1 (XI1_I1942_I213_Bn I1_I1942_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I213_MN5 (XI1_I1942_I213_n2 XI1_I1942_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1942_I213_MN4 (I1_p30_10 XI1_I1942_I213_An XI1_I1942_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1942_I213_MN2 (XI1_I1942_I213_n1 I1_I1942_pn10 I1_p30_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1942_I213_MN3 (VSS I1_I1942_G9_0n XI1_I1942_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1942_I213_MN0 (XI1_I1942_I213_An I1_I1942_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1967_MN1 (XI1_I1967_Bn I1_qu1_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1967_MN5 (XI1_I1967_n2 XI1_I1967_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1967_MN4 (I1_b31_11 XI1_I1967_An XI1_I1967_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1967_MN2 (XI1_I1967_n1 I1_dd11_b3_5 I1_b31_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1967_MN3 (VSS I1_qu1_b3_1 XI1_I1967_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1967_MN0 (XI1_I1967_An I1_dd11_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I213_MN1 (XI1_I1988_I213_Bn I1_I1988_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I213_MN5 (XI1_I1988_I213_n2 XI1_I1988_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1988_I213_MN4 (I1_p31_10 XI1_I1988_I213_An XI1_I1988_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1988_I213_MN2 (XI1_I1988_I213_n1 I1_I1988_pn10 I1_p31_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1988_I213_MN3 (VSS I1_I1988_G9_0n XI1_I1988_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1988_I213_MN0 (XI1_I1988_I213_An I1_I1988_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I212_MN1 (XI1_I1988_I212_Bn I1_I1988_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I212_MN5 (XI1_I1988_I212_n2 XI1_I1988_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1988_I212_MN4 (I1_p31_9 XI1_I1988_I212_An XI1_I1988_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1988_I212_MN2 (XI1_I1988_I212_n1 I1_I1988_pn9 I1_p31_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1988_I212_MN3 (VSS I1_I1988_G8_0n XI1_I1988_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1988_I212_MN0 (XI1_I1988_I212_An I1_I1988_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I501_MN1 (XI0_I1660_I501_Bn I0_I1660_G33_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I501_MN5 (XI0_I1660_I501_n2 XI0_I1660_I501_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I501_MN4 (MULP_34 XI0_I1660_I501_An XI0_I1660_I501_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I501_MN2 (XI0_I1660_I501_n1 I0_I1660_pn34 MULP_34 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I501_MN3 (VSS I0_I1660_G33_0n XI0_I1660_I501_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I501_MN0 (XI0_I1660_I501_An I0_I1660_pn34 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I215_MN1 (XI1_I1804_I215_Bn I1_I1804_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I215_MN5 (XI1_I1804_I215_n2 XI1_I1804_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1804_I215_MN4 (I1_p27_12 XI1_I1804_I215_An XI1_I1804_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1804_I215_MN2 (XI1_I1804_I215_n1 I1_I1804_pn12 I1_p27_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1804_I215_MN3 (VSS I1_I1804_G11_0n XI1_I1804_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1804_I215_MN0 (XI1_I1804_I215_An I1_I1804_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1829_MN1 (XI1_I1829_Bn I1_qu4_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1829_MN5 (XI1_I1829_n2 XI1_I1829_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1829_MN4 (I1_b28_11 XI1_I1829_An XI1_I1829_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1829_MN2 (XI1_I1829_n1 I1_dd11_b3_5 I1_b28_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1829_MN3 (VSS I1_qu4_b3_1 XI1_I1829_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1829_MN0 (XI1_I1829_An I1_dd11_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1827_MN1 (XI1_I1827_Bn I1_qu4_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1827_MN5 (XI1_I1827_n2 XI1_I1827_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1827_MN4 (I1_b28_9 XI1_I1827_An XI1_I1827_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1827_MN2 (XI1_I1827_n1 I1_dd9_b3_5 I1_b28_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1827_MN3 (VSS I1_qu4_b3_1 XI1_I1827_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1827_MN0 (XI1_I1827_An I1_dd9_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1875_MN1 (XI1_I1875_Bn I1_qu3_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1875_MN5 (XI1_I1875_n2 XI1_I1875_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1875_MN4 (I1_b29_11 XI1_I1875_An XI1_I1875_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1875_MN2 (XI1_I1875_n1 I1_dd11_b3_5 I1_b29_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1875_MN3 (VSS I1_qu3_b3_1 XI1_I1875_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1875_MN0 (XI1_I1875_An I1_dd11_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I213_MN1 (XI1_I1896_I213_Bn I1_I1896_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I213_MN5 (XI1_I1896_I213_n2 XI1_I1896_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1896_I213_MN4 (I1_p29_10 XI1_I1896_I213_An XI1_I1896_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1896_I213_MN2 (XI1_I1896_I213_n1 I1_I1896_pn10 I1_p29_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1896_I213_MN3 (VSS I1_I1896_G9_0n XI1_I1896_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1896_I213_MN0 (XI1_I1896_I213_An I1_I1896_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1923_MN1 (XI1_I1923_Bn I1_qu2_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1923_MN5 (XI1_I1923_n2 XI1_I1923_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1923_MN4 (I1_b30_13 XI1_I1923_An XI1_I1923_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1923_MN2 (XI1_I1923_n1 I1_dd13_b3_5 I1_b30_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1923_MN3 (VSS I1_qu2_b3_2 XI1_I1923_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1923_MN0 (XI1_I1923_An I1_dd13_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I214_MN1 (XI1_I1942_I214_Bn I1_I1942_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I214_MN5 (XI1_I1942_I214_n2 XI1_I1942_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1942_I214_MN4 (I1_p30_11 XI1_I1942_I214_An XI1_I1942_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1942_I214_MN2 (XI1_I1942_I214_n1 I1_I1942_pn11 I1_p30_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1942_I214_MN3 (VSS I1_I1942_G10_0n XI1_I1942_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1942_I214_MN0 (XI1_I1942_I214_An I1_I1942_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1968_MN1 (XI1_I1968_Bn I1_qu1_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1968_MN5 (XI1_I1968_n2 XI1_I1968_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1968_MN4 (I1_b31_12 XI1_I1968_An XI1_I1968_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1968_MN2 (XI1_I1968_n1 I1_dd12_b3_5 I1_b31_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1968_MN3 (VSS I1_qu1_b3_2 XI1_I1968_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1968_MN0 (XI1_I1968_An I1_dd12_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I214_MN1 (XI1_I1988_I214_Bn I1_I1988_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I214_MN5 (XI1_I1988_I214_n2 XI1_I1988_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1988_I214_MN4 (I1_p31_11 XI1_I1988_I214_An XI1_I1988_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1988_I214_MN2 (XI1_I1988_I214_n1 I1_I1988_pn11 I1_p31_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1988_I214_MN3 (VSS I1_I1988_G10_0n XI1_I1988_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1988_I214_MN0 (XI1_I1988_I214_An I1_I1988_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I206_MN1 (XI1_I2066_I206_Bn I1_I2066_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I206_MN5 (XI1_I2066_I206_n2 XI1_I2066_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I2066_I206_MN4 (I1_ru3 XI1_I2066_I206_An XI1_I2066_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I2066_I206_MN2 (XI1_I2066_I206_n1 I1_I2066_pn3 I1_ru3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I2066_I206_MN3 (VSS I1_I2066_G2_0n XI1_I2066_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I2066_I206_MN0 (XI1_I2066_I206_An I1_I2066_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I500_MN1 (XI0_I1660_I500_Bn I0_I1660_G32_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I500_MN5 (XI0_I1660_I500_n2 XI0_I1660_I500_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I500_MN4 (MULP_33 XI0_I1660_I500_An XI0_I1660_I500_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I500_MN2 (XI0_I1660_I500_n1 I0_I1660_pn33 MULP_33 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I500_MN3 (VSS I0_I1660_G32_0n XI0_I1660_I500_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I500_MN0 (XI0_I1660_I500_An I0_I1660_pn33 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I503_MN1 (XI0_I1660_I503_Bn I0_I1660_G35_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I503_MN5 (XI0_I1660_I503_n2 XI0_I1660_I503_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I503_MN4 (MULP_36 XI0_I1660_I503_An XI0_I1660_I503_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I503_MN2 (XI0_I1660_I503_n1 I0_I1660_pn36 MULP_36 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I503_MN3 (VSS I0_I1660_G35_0n XI0_I1660_I503_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I503_MN0 (XI0_I1660_I503_An I0_I1660_pn36 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I505_MN1 (XI0_I1660_I505_Bn I0_I1660_G37_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I505_MN5 (XI0_I1660_I505_n2 XI0_I1660_I505_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I505_MN4 (MULP_38 XI0_I1660_I505_An XI0_I1660_I505_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I505_MN2 (XI0_I1660_I505_n1 I0_I1660_pn38 MULP_38 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I505_MN3 (VSS I0_I1660_G37_0n XI0_I1660_I505_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I505_MN0 (XI0_I1660_I505_An I0_I1660_pn38 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1806_MN1 (XI1_I1806_Bn I1_c27_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1806_MN5 (XI1_I1806_n2 XI1_I1806_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1806_MN4 (I1_p27_32 XI1_I1806_An XI1_I1806_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1806_MN2 (XI1_I1806_n1 I1_h27 I1_p27_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1806_MN3 (VSS I1_c27_o XI1_I1806_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1806_MN0 (XI1_I1806_An I1_h27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I219_MN1 (XI1_I1804_I219_Bn I1_I1804_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I219_MN5 (XI1_I1804_I219_n2 XI1_I1804_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1804_I219_MN4 (I1_p27_16 XI1_I1804_I219_An XI1_I1804_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1804_I219_MN2 (XI1_I1804_I219_n1 I1_I1804_pn16 I1_p27_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1804_I219_MN3 (VSS I1_I1804_G15_0n XI1_I1804_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1804_I219_MN0 (XI1_I1804_I219_An I1_I1804_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I213_MN1 (XI1_I1850_I213_Bn I1_I1850_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I213_MN5 (XI1_I1850_I213_n2 XI1_I1850_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1850_I213_MN4 (I1_p28_10 XI1_I1850_I213_An XI1_I1850_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1850_I213_MN2 (XI1_I1850_I213_n1 I1_I1850_pn10 I1_p28_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1850_I213_MN3 (VSS I1_I1850_G9_0n XI1_I1850_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1850_I213_MN0 (XI1_I1850_I213_An I1_I1850_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1831_MN1 (XI1_I1831_Bn I1_qu4_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1831_MN5 (XI1_I1831_n2 XI1_I1831_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1831_MN4 (I1_b28_13 XI1_I1831_An XI1_I1831_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1831_MN2 (XI1_I1831_n1 I1_dd13_b3_5 I1_b28_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1831_MN3 (VSS I1_qu4_b3_2 XI1_I1831_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1831_MN0 (XI1_I1831_An I1_dd13_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1876_MN1 (XI1_I1876_Bn I1_qu3_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1876_MN5 (XI1_I1876_n2 XI1_I1876_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1876_MN4 (I1_b29_12 XI1_I1876_An XI1_I1876_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1876_MN2 (XI1_I1876_n1 I1_dd12_b3_5 I1_b29_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1876_MN3 (VSS I1_qu3_b3_2 XI1_I1876_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1876_MN0 (XI1_I1876_An I1_dd12_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1877_MN1 (XI1_I1877_Bn I1_qu3_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1877_MN5 (XI1_I1877_n2 XI1_I1877_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1877_MN4 (I1_b29_13 XI1_I1877_An XI1_I1877_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1877_MN2 (XI1_I1877_n1 I1_dd13_b3_5 I1_b29_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1877_MN3 (VSS I1_qu3_b3_2 XI1_I1877_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1877_MN0 (XI1_I1877_An I1_dd13_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I214_MN1 (XI1_I1896_I214_Bn I1_I1896_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I214_MN5 (XI1_I1896_I214_n2 XI1_I1896_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1896_I214_MN4 (I1_p29_11 XI1_I1896_I214_An XI1_I1896_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1896_I214_MN2 (XI1_I1896_I214_n1 I1_I1896_pn11 I1_p29_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1896_I214_MN3 (VSS I1_I1896_G10_0n XI1_I1896_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1896_I214_MN0 (XI1_I1896_I214_An I1_I1896_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1924_MN1 (XI1_I1924_Bn I1_qu2_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1924_MN5 (XI1_I1924_n2 XI1_I1924_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1924_MN4 (I1_b30_14 XI1_I1924_An XI1_I1924_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1924_MN2 (XI1_I1924_n1 I1_dd14_b3_5 I1_b30_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1924_MN3 (VSS I1_qu2_b3_2 XI1_I1924_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1924_MN0 (XI1_I1924_An I1_dd14_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1922_MN1 (XI1_I1922_Bn I1_qu2_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1922_MN5 (XI1_I1922_n2 XI1_I1922_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1922_MN4 (I1_b30_12 XI1_I1922_An XI1_I1922_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1922_MN2 (XI1_I1922_n1 I1_dd12_b3_5 I1_b30_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1922_MN3 (VSS I1_qu2_b3_2 XI1_I1922_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1922_MN0 (XI1_I1922_An I1_dd12_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I215_MN1 (XI1_I1942_I215_Bn I1_I1942_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I215_MN5 (XI1_I1942_I215_n2 XI1_I1942_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1942_I215_MN4 (I1_p30_12 XI1_I1942_I215_An XI1_I1942_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1942_I215_MN2 (XI1_I1942_I215_n1 I1_I1942_pn12 I1_p30_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1942_I215_MN3 (VSS I1_I1942_G11_0n XI1_I1942_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1942_I215_MN0 (XI1_I1942_I215_An I1_I1942_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I216_MN1 (XI1_I1942_I216_Bn I1_I1942_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I216_MN5 (XI1_I1942_I216_n2 XI1_I1942_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1942_I216_MN4 (I1_p30_13 XI1_I1942_I216_An XI1_I1942_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1942_I216_MN2 (XI1_I1942_I216_n1 I1_I1942_pn13 I1_p30_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1942_I216_MN3 (VSS I1_I1942_G12_0n XI1_I1942_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1942_I216_MN0 (XI1_I1942_I216_An I1_I1942_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1971_MN1 (XI1_I1971_Bn I1_qu1_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1971_MN5 (XI1_I1971_n2 XI1_I1971_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1971_MN4 (I1_b31_15 XI1_I1971_An XI1_I1971_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1971_MN2 (XI1_I1971_n1 I1_dd15_b3_5 I1_b31_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1971_MN3 (VSS I1_qu1_b3_2 XI1_I1971_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1971_MN0 (XI1_I1971_An I1_dd15_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1969_MN1 (XI1_I1969_Bn I1_qu1_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1969_MN5 (XI1_I1969_n2 XI1_I1969_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1969_MN4 (I1_b31_13 XI1_I1969_An XI1_I1969_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1969_MN2 (XI1_I1969_n1 I1_dd13_b3_5 I1_b31_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1969_MN3 (VSS I1_qu1_b3_2 XI1_I1969_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1969_MN0 (XI1_I1969_An I1_dd13_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1970_MN1 (XI1_I1970_Bn I1_qu1_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1970_MN5 (XI1_I1970_n2 XI1_I1970_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1970_MN4 (I1_b31_14 XI1_I1970_An XI1_I1970_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1970_MN2 (XI1_I1970_n1 I1_dd14_b3_5 I1_b31_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1970_MN3 (VSS I1_qu1_b3_2 XI1_I1970_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1970_MN0 (XI1_I1970_An I1_dd14_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I215_MN1 (XI1_I1988_I215_Bn I1_I1988_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I215_MN5 (XI1_I1988_I215_n2 XI1_I1988_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1988_I215_MN4 (I1_p31_12 XI1_I1988_I215_An XI1_I1988_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1988_I215_MN2 (XI1_I1988_I215_n1 I1_I1988_pn12 I1_p31_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1988_I215_MN3 (VSS I1_I1988_G11_0n XI1_I1988_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1988_I215_MN0 (XI1_I1988_I215_An I1_I1988_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I216_MN1 (XI1_I1988_I216_Bn I1_I1988_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I216_MN5 (XI1_I1988_I216_n2 XI1_I1988_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1988_I216_MN4 (I1_p31_13 XI1_I1988_I216_An XI1_I1988_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1988_I216_MN2 (XI1_I1988_I216_n1 I1_I1988_pn13 I1_p31_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1988_I216_MN3 (VSS I1_I1988_G12_0n XI1_I1988_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1988_I216_MN0 (XI1_I1988_I216_An I1_I1988_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I207_MN1 (XI1_I2066_I207_Bn I1_I2066_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I207_MN5 (XI1_I2066_I207_n2 XI1_I2066_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I2066_I207_MN4 (I1_ru4 XI1_I2066_I207_An XI1_I2066_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I2066_I207_MN2 (XI1_I2066_I207_n1 I1_I2066_pn4 I1_ru4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I2066_I207_MN3 (VSS I1_I2066_G3_0n XI1_I2066_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I2066_I207_MN0 (XI1_I2066_I207_An I1_I2066_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I504_MN1 (XI0_I1660_I504_Bn I0_I1660_G36_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I504_MN5 (XI0_I1660_I504_n2 XI0_I1660_I504_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I504_MN4 (MULP_37 XI0_I1660_I504_An XI0_I1660_I504_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I504_MN2 (XI0_I1660_I504_n1 I0_I1660_pn37 MULP_37 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I504_MN3 (VSS I0_I1660_G36_0n XI0_I1660_I504_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I504_MN0 (XI0_I1660_I504_An I0_I1660_pn37 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I507_MN1 (XI0_I1660_I507_Bn I0_I1660_G39_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I507_MN5 (XI0_I1660_I507_n2 XI0_I1660_I507_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I507_MN4 (MULP_40 XI0_I1660_I507_An XI0_I1660_I507_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I507_MN2 (XI0_I1660_I507_n1 I0_I1660_pn40 MULP_40 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I507_MN3 (VSS I0_I1660_G39_0n XI0_I1660_I507_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I507_MN0 (XI0_I1660_I507_An I0_I1660_pn40 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1851_MN1 (XI1_I1851_Bn I1_qu4_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1851_MN5 (XI1_I1851_n2 XI1_I1851_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1851_MN4 (I1_h28 XI1_I1851_An XI1_I1851_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1851_MN2 (XI1_I1851_n1 I1_p27_31 I1_h28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1851_MN3 (VSS I1_qu4_b3_5 XI1_I1851_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1851_MN0 (XI1_I1851_An I1_p27_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I215_MN1 (XI1_I1850_I215_Bn I1_I1850_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I215_MN5 (XI1_I1850_I215_n2 XI1_I1850_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1850_I215_MN4 (I1_p28_12 XI1_I1850_I215_An XI1_I1850_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1850_I215_MN2 (XI1_I1850_I215_n1 I1_I1850_pn12 I1_p28_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1850_I215_MN3 (VSS I1_I1850_G11_0n XI1_I1850_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1850_I215_MN0 (XI1_I1850_I215_An I1_I1850_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I214_MN1 (XI1_I1850_I214_Bn I1_I1850_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I214_MN5 (XI1_I1850_I214_n2 XI1_I1850_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1850_I214_MN4 (I1_p28_11 XI1_I1850_I214_An XI1_I1850_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1850_I214_MN2 (XI1_I1850_I214_n1 I1_I1850_pn11 I1_p28_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1850_I214_MN3 (VSS I1_I1850_G10_0n XI1_I1850_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1850_I214_MN0 (XI1_I1850_I214_An I1_I1850_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I212_MN1 (XI1_I1850_I212_Bn I1_I1850_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I212_MN5 (XI1_I1850_I212_n2 XI1_I1850_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1850_I212_MN4 (I1_p28_9 XI1_I1850_I212_An XI1_I1850_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1850_I212_MN2 (XI1_I1850_I212_n1 I1_I1850_pn9 I1_p28_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1850_I212_MN3 (VSS I1_I1850_G8_0n XI1_I1850_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1850_I212_MN0 (XI1_I1850_I212_An I1_I1850_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1833_MN1 (XI1_I1833_Bn I1_qu4_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1833_MN5 (XI1_I1833_n2 XI1_I1833_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1833_MN4 (I1_b28_15 XI1_I1833_An XI1_I1833_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1833_MN2 (XI1_I1833_n1 I1_dd15_b3_5 I1_b28_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1833_MN3 (VSS I1_qu4_b3_2 XI1_I1833_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1833_MN0 (XI1_I1833_An I1_dd15_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1830_MN1 (XI1_I1830_Bn I1_qu4_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1830_MN5 (XI1_I1830_n2 XI1_I1830_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1830_MN4 (I1_b28_12 XI1_I1830_An XI1_I1830_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1830_MN2 (XI1_I1830_n1 I1_dd12_b3_5 I1_b28_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1830_MN3 (VSS I1_qu4_b3_2 XI1_I1830_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1830_MN0 (XI1_I1830_An I1_dd12_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1879_MN1 (XI1_I1879_Bn I1_qu3_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1879_MN5 (XI1_I1879_n2 XI1_I1879_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1879_MN4 (I1_b29_15 XI1_I1879_An XI1_I1879_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1879_MN2 (XI1_I1879_n1 I1_dd15_b3_5 I1_b29_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1879_MN3 (VSS I1_qu3_b3_2 XI1_I1879_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1879_MN0 (XI1_I1879_An I1_dd15_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1878_MN1 (XI1_I1878_Bn I1_qu3_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1878_MN5 (XI1_I1878_n2 XI1_I1878_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1878_MN4 (I1_b29_14 XI1_I1878_An XI1_I1878_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1878_MN2 (XI1_I1878_n1 I1_dd14_b3_5 I1_b29_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1878_MN3 (VSS I1_qu3_b3_2 XI1_I1878_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1878_MN0 (XI1_I1878_An I1_dd14_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I215_MN1 (XI1_I1896_I215_Bn I1_I1896_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I215_MN5 (XI1_I1896_I215_n2 XI1_I1896_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1896_I215_MN4 (I1_p29_12 XI1_I1896_I215_An XI1_I1896_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1896_I215_MN2 (XI1_I1896_I215_n1 I1_I1896_pn12 I1_p29_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1896_I215_MN3 (VSS I1_I1896_G11_0n XI1_I1896_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1896_I215_MN0 (XI1_I1896_I215_An I1_I1896_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I216_MN1 (XI1_I1896_I216_Bn I1_I1896_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I216_MN5 (XI1_I1896_I216_n2 XI1_I1896_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1896_I216_MN4 (I1_p29_13 XI1_I1896_I216_An XI1_I1896_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1896_I216_MN2 (XI1_I1896_I216_n1 I1_I1896_pn13 I1_p29_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1896_I216_MN3 (VSS I1_I1896_G12_0n XI1_I1896_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1896_I216_MN0 (XI1_I1896_I216_An I1_I1896_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1925_MN1 (XI1_I1925_Bn I1_qu2_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1925_MN5 (XI1_I1925_n2 XI1_I1925_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1925_MN4 (I1_b30_15 XI1_I1925_An XI1_I1925_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1925_MN2 (XI1_I1925_n1 I1_dd15_b3_5 I1_b30_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1925_MN3 (VSS I1_qu2_b3_2 XI1_I1925_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1925_MN0 (XI1_I1925_An I1_dd15_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I217_MN1 (XI1_I1942_I217_Bn I1_I1942_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I217_MN5 (XI1_I1942_I217_n2 XI1_I1942_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1942_I217_MN4 (I1_p30_14 XI1_I1942_I217_An XI1_I1942_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1942_I217_MN2 (XI1_I1942_I217_n1 I1_I1942_pn14 I1_p30_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1942_I217_MN3 (VSS I1_I1942_G13_0n XI1_I1942_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1942_I217_MN0 (XI1_I1942_I217_An I1_I1942_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1973_MN1 (XI1_I1973_Bn I1_qu1_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1973_MN5 (XI1_I1973_n2 XI1_I1973_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1973_MN4 (I1_b31_17 XI1_I1973_An XI1_I1973_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1973_MN2 (XI1_I1973_n1 I1_dd17_b3_5 I1_b31_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1973_MN3 (VSS I1_qu1_b3_2 XI1_I1973_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1973_MN0 (XI1_I1973_An I1_dd17_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1972_MN1 (XI1_I1972_Bn I1_qu1_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1972_MN5 (XI1_I1972_n2 XI1_I1972_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1972_MN4 (I1_b31_16 XI1_I1972_An XI1_I1972_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1972_MN2 (XI1_I1972_n1 I1_dd16_b3_5 I1_b31_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1972_MN3 (VSS I1_qu1_b3_2 XI1_I1972_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1972_MN0 (XI1_I1972_An I1_dd16_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I217_MN1 (XI1_I1988_I217_Bn I1_I1988_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I217_MN5 (XI1_I1988_I217_n2 XI1_I1988_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1988_I217_MN4 (I1_p31_14 XI1_I1988_I217_An XI1_I1988_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1988_I217_MN2 (XI1_I1988_I217_n1 I1_I1988_pn14 I1_p31_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1988_I217_MN3 (VSS I1_I1988_G13_0n XI1_I1988_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1988_I217_MN0 (XI1_I1988_I217_An I1_I1988_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I212_MN1 (XI1_I2066_I212_Bn I1_I2066_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I212_MN5 (XI1_I2066_I212_n2 XI1_I2066_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I2066_I212_MN4 (I1_ru9 XI1_I2066_I212_An XI1_I2066_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I2066_I212_MN2 (XI1_I2066_I212_n1 I1_I2066_pn9 I1_ru9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I2066_I212_MN3 (VSS I1_I2066_G8_0n XI1_I2066_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I2066_I212_MN0 (XI1_I2066_I212_An I1_I2066_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I502_MN1 (XI0_I1660_I502_Bn I0_I1660_G34_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I502_MN5 (XI0_I1660_I502_n2 XI0_I1660_I502_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I502_MN4 (MULP_35 XI0_I1660_I502_An XI0_I1660_I502_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I502_MN2 (XI0_I1660_I502_n1 I0_I1660_pn35 MULP_35 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I502_MN3 (VSS I0_I1660_G34_0n XI0_I1660_I502_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I502_MN0 (XI0_I1660_I502_An I0_I1660_pn35 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I509_MN1 (XI0_I1660_I509_Bn I0_I1660_G41_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I509_MN5 (XI0_I1660_I509_n2 XI0_I1660_I509_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I509_MN4 (MULP_42 XI0_I1660_I509_An XI0_I1660_I509_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I509_MN2 (XI0_I1660_I509_n1 I0_I1660_pn42 MULP_42 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I509_MN3 (VSS I0_I1660_G41_0n XI0_I1660_I509_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I509_MN0 (XI0_I1660_I509_An I0_I1660_pn42 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I216_MN1 (XI1_I1850_I216_Bn I1_I1850_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I216_MN5 (XI1_I1850_I216_n2 XI1_I1850_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1850_I216_MN4 (I1_p28_13 XI1_I1850_I216_An XI1_I1850_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1850_I216_MN2 (XI1_I1850_I216_n1 I1_I1850_pn13 I1_p28_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1850_I216_MN3 (VSS I1_I1850_G12_0n XI1_I1850_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1850_I216_MN0 (XI1_I1850_I216_An I1_I1850_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1835_MN1 (XI1_I1835_Bn I1_qu4_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1835_MN5 (XI1_I1835_n2 XI1_I1835_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1835_MN4 (I1_b28_17 XI1_I1835_An XI1_I1835_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1835_MN2 (XI1_I1835_n1 I1_dd17_b3_5 I1_b28_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1835_MN3 (VSS I1_qu4_b3_2 XI1_I1835_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1835_MN0 (XI1_I1835_An I1_dd17_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1834_MN1 (XI1_I1834_Bn I1_qu4_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1834_MN5 (XI1_I1834_n2 XI1_I1834_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1834_MN4 (I1_b28_16 XI1_I1834_An XI1_I1834_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1834_MN2 (XI1_I1834_n1 I1_dd16_b3_5 I1_b28_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1834_MN3 (VSS I1_qu4_b3_2 XI1_I1834_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1834_MN0 (XI1_I1834_An I1_dd16_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1832_MN1 (XI1_I1832_Bn I1_qu4_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1832_MN5 (XI1_I1832_n2 XI1_I1832_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1832_MN4 (I1_b28_14 XI1_I1832_An XI1_I1832_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1832_MN2 (XI1_I1832_n1 I1_dd14_b3_5 I1_b28_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1832_MN3 (VSS I1_qu4_b3_2 XI1_I1832_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1832_MN0 (XI1_I1832_An I1_dd14_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1881_MN1 (XI1_I1881_Bn I1_qu3_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1881_MN5 (XI1_I1881_n2 XI1_I1881_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1881_MN4 (I1_b29_17 XI1_I1881_An XI1_I1881_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1881_MN2 (XI1_I1881_n1 I1_dd17_b3_5 I1_b29_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1881_MN3 (VSS I1_qu3_b3_2 XI1_I1881_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1881_MN0 (XI1_I1881_An I1_dd17_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1880_MN1 (XI1_I1880_Bn I1_qu3_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1880_MN5 (XI1_I1880_n2 XI1_I1880_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1880_MN4 (I1_b29_16 XI1_I1880_An XI1_I1880_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1880_MN2 (XI1_I1880_n1 I1_dd16_b3_5 I1_b29_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1880_MN3 (VSS I1_qu3_b3_2 XI1_I1880_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1880_MN0 (XI1_I1880_An I1_dd16_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I217_MN1 (XI1_I1896_I217_Bn I1_I1896_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I217_MN5 (XI1_I1896_I217_n2 XI1_I1896_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1896_I217_MN4 (I1_p29_14 XI1_I1896_I217_An XI1_I1896_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1896_I217_MN2 (XI1_I1896_I217_n1 I1_I1896_pn14 I1_p29_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1896_I217_MN3 (VSS I1_I1896_G13_0n XI1_I1896_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1896_I217_MN0 (XI1_I1896_I217_An I1_I1896_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1927_MN1 (XI1_I1927_Bn I1_qu2_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1927_MN5 (XI1_I1927_n2 XI1_I1927_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1927_MN4 (I1_b30_17 XI1_I1927_An XI1_I1927_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1927_MN2 (XI1_I1927_n1 I1_dd17_b3_5 I1_b30_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1927_MN3 (VSS I1_qu2_b3_2 XI1_I1927_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1927_MN0 (XI1_I1927_An I1_dd17_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1926_MN1 (XI1_I1926_Bn I1_qu2_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1926_MN5 (XI1_I1926_n2 XI1_I1926_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1926_MN4 (I1_b30_16 XI1_I1926_An XI1_I1926_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1926_MN2 (XI1_I1926_n1 I1_dd16_b3_5 I1_b30_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1926_MN3 (VSS I1_qu2_b3_2 XI1_I1926_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1926_MN0 (XI1_I1926_An I1_dd16_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I219_MN1 (XI1_I1942_I219_Bn I1_I1942_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I219_MN5 (XI1_I1942_I219_n2 XI1_I1942_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1942_I219_MN4 (I1_p30_16 XI1_I1942_I219_An XI1_I1942_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1942_I219_MN2 (XI1_I1942_I219_n1 I1_I1942_pn16 I1_p30_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1942_I219_MN3 (VSS I1_I1942_G15_0n XI1_I1942_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1942_I219_MN0 (XI1_I1942_I219_An I1_I1942_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I218_MN1 (XI1_I1942_I218_Bn I1_I1942_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I218_MN5 (XI1_I1942_I218_n2 XI1_I1942_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1942_I218_MN4 (I1_p30_15 XI1_I1942_I218_An XI1_I1942_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1942_I218_MN2 (XI1_I1942_I218_n1 I1_I1942_pn15 I1_p30_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1942_I218_MN3 (VSS I1_I1942_G14_0n XI1_I1942_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1942_I218_MN0 (XI1_I1942_I218_An I1_I1942_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I218_MN1 (XI1_I1988_I218_Bn I1_I1988_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I218_MN5 (XI1_I1988_I218_n2 XI1_I1988_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1988_I218_MN4 (I1_p31_15 XI1_I1988_I218_An XI1_I1988_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1988_I218_MN2 (XI1_I1988_I218_n1 I1_I1988_pn15 I1_p31_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1988_I218_MN3 (VSS I1_I1988_G14_0n XI1_I1988_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1988_I218_MN0 (XI1_I1988_I218_An I1_I1988_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I213_MN1 (XI1_I2066_I213_Bn I1_I2066_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I213_MN5 (XI1_I2066_I213_n2 XI1_I2066_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I2066_I213_MN4 (I1_ru10 XI1_I2066_I213_An XI1_I2066_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I2066_I213_MN2 (XI1_I2066_I213_n1 I1_I2066_pn10 I1_ru10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I2066_I213_MN3 (VSS I1_I2066_G9_0n XI1_I2066_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I2066_I213_MN0 (XI1_I2066_I213_An I1_I2066_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I508_MN1 (XI0_I1660_I508_Bn I0_I1660_G40_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I508_MN5 (XI0_I1660_I508_n2 XI0_I1660_I508_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I508_MN4 (MULP_41 XI0_I1660_I508_An XI0_I1660_I508_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I508_MN2 (XI0_I1660_I508_n1 I0_I1660_pn41 MULP_41 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I508_MN3 (VSS I0_I1660_G40_0n XI0_I1660_I508_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I508_MN0 (XI0_I1660_I508_An I0_I1660_pn41 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I511_MN1 (XI0_I1660_I511_Bn I0_I1660_G43_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I511_MN5 (XI0_I1660_I511_n2 XI0_I1660_I511_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I511_MN4 (MULP_44 XI0_I1660_I511_An XI0_I1660_I511_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I511_MN2 (XI0_I1660_I511_n1 I0_I1660_pn44 MULP_44 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I511_MN3 (VSS I0_I1660_G43_0n XI0_I1660_I511_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I511_MN0 (XI0_I1660_I511_An I0_I1660_pn44 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1852_MN1 (XI1_I1852_Bn I1_c28_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1852_MN5 (XI1_I1852_n2 XI1_I1852_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1852_MN4 (I1_p28_32 XI1_I1852_An XI1_I1852_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1852_MN2 (XI1_I1852_n1 I1_h28 I1_p28_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1852_MN3 (VSS I1_c28_o XI1_I1852_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1852_MN0 (XI1_I1852_An I1_h28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I219_MN1 (XI1_I1850_I219_Bn I1_I1850_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I219_MN5 (XI1_I1850_I219_n2 XI1_I1850_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1850_I219_MN4 (I1_p28_16 XI1_I1850_I219_An XI1_I1850_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1850_I219_MN2 (XI1_I1850_I219_n1 I1_I1850_pn16 I1_p28_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1850_I219_MN3 (VSS I1_I1850_G15_0n XI1_I1850_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1850_I219_MN0 (XI1_I1850_I219_An I1_I1850_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I217_MN1 (XI1_I1850_I217_Bn I1_I1850_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I217_MN5 (XI1_I1850_I217_n2 XI1_I1850_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1850_I217_MN4 (I1_p28_14 XI1_I1850_I217_An XI1_I1850_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1850_I217_MN2 (XI1_I1850_I217_n1 I1_I1850_pn14 I1_p28_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1850_I217_MN3 (VSS I1_I1850_G13_0n XI1_I1850_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1850_I217_MN0 (XI1_I1850_I217_An I1_I1850_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I219_MN1 (XI1_I1896_I219_Bn I1_I1896_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I219_MN5 (XI1_I1896_I219_n2 XI1_I1896_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1896_I219_MN4 (I1_p29_16 XI1_I1896_I219_An XI1_I1896_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1896_I219_MN2 (XI1_I1896_I219_n1 I1_I1896_pn16 I1_p29_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1896_I219_MN3 (VSS I1_I1896_G15_0n XI1_I1896_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1896_I219_MN0 (XI1_I1896_I219_An I1_I1896_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I218_MN1 (XI1_I1896_I218_Bn I1_I1896_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I218_MN5 (XI1_I1896_I218_n2 XI1_I1896_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1896_I218_MN4 (I1_p29_15 XI1_I1896_I218_An XI1_I1896_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1896_I218_MN2 (XI1_I1896_I218_n1 I1_I1896_pn15 I1_p29_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1896_I218_MN3 (VSS I1_I1896_G14_0n XI1_I1896_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1896_I218_MN0 (XI1_I1896_I218_An I1_I1896_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1928_MN1 (XI1_I1928_Bn I1_qu2_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1928_MN5 (XI1_I1928_n2 XI1_I1928_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1928_MN4 (I1_b30_18 XI1_I1928_An XI1_I1928_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1928_MN2 (XI1_I1928_n1 I1_dd18_b3_5 I1_b30_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1928_MN3 (VSS I1_qu2_b3_3 XI1_I1928_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1928_MN0 (XI1_I1928_An I1_dd18_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1974_MN1 (XI1_I1974_Bn I1_qu1_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1974_MN5 (XI1_I1974_n2 XI1_I1974_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1974_MN4 (I1_b31_18 XI1_I1974_An XI1_I1974_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1974_MN2 (XI1_I1974_n1 I1_dd18_b3_5 I1_b31_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1974_MN3 (VSS I1_qu1_b3_3 XI1_I1974_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1974_MN0 (XI1_I1974_An I1_dd18_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1975_MN1 (XI1_I1975_Bn I1_qu1_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1975_MN5 (XI1_I1975_n2 XI1_I1975_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1975_MN4 (I1_b31_19 XI1_I1975_An XI1_I1975_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1975_MN2 (XI1_I1975_n1 I1_dd19_b3_5 I1_b31_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1975_MN3 (VSS I1_qu1_b3_3 XI1_I1975_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1975_MN0 (XI1_I1975_An I1_dd19_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I219_MN1 (XI1_I1988_I219_Bn I1_I1988_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I219_MN5 (XI1_I1988_I219_n2 XI1_I1988_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1988_I219_MN4 (I1_p31_16 XI1_I1988_I219_An XI1_I1988_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1988_I219_MN2 (XI1_I1988_I219_n1 I1_I1988_pn16 I1_p31_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1988_I219_MN3 (VSS I1_I1988_G15_0n XI1_I1988_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1988_I219_MN0 (XI1_I1988_I219_An I1_I1988_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I214_MN1 (XI1_I2066_I214_Bn I1_I2066_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I214_MN5 (XI1_I2066_I214_n2 XI1_I2066_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I2066_I214_MN4 (I1_ru11 XI1_I2066_I214_An XI1_I2066_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I2066_I214_MN2 (XI1_I2066_I214_n1 I1_I2066_pn11 I1_ru11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I2066_I214_MN3 (VSS I1_I2066_G10_0n XI1_I2066_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I2066_I214_MN0 (XI1_I2066_I214_An I1_I2066_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I506_MN1 (XI0_I1660_I506_Bn I0_I1660_G38_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I506_MN5 (XI0_I1660_I506_n2 XI0_I1660_I506_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I506_MN4 (MULP_39 XI0_I1660_I506_An XI0_I1660_I506_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I506_MN2 (XI0_I1660_I506_n1 I0_I1660_pn39 MULP_39 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I506_MN3 (VSS I0_I1660_G38_0n XI0_I1660_I506_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I506_MN0 (XI0_I1660_I506_An I0_I1660_pn39 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I512_MN1 (XI0_I1660_I512_Bn I0_I1660_G44_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I512_MN5 (XI0_I1660_I512_n2 XI0_I1660_I512_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I512_MN4 (MULP_45 XI0_I1660_I512_An XI0_I1660_I512_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I512_MN2 (XI0_I1660_I512_n1 I0_I1660_pn45 MULP_45 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I512_MN3 (VSS I0_I1660_G44_0n XI0_I1660_I512_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I512_MN0 (XI0_I1660_I512_An I0_I1660_pn45 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I513_MN1 (XI0_I1660_I513_Bn I0_I1660_G45_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I513_MN5 (XI0_I1660_I513_n2 XI0_I1660_I513_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I513_MN4 (MULP_46 XI0_I1660_I513_An XI0_I1660_I513_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I513_MN2 (XI0_I1660_I513_n1 I0_I1660_pn46 MULP_46 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I513_MN3 (VSS I0_I1660_G45_0n XI0_I1660_I513_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I513_MN0 (XI0_I1660_I513_An I0_I1660_pn46 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I218_MN1 (XI1_I1850_I218_Bn I1_I1850_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I218_MN5 (XI1_I1850_I218_n2 XI1_I1850_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1850_I218_MN4 (I1_p28_15 XI1_I1850_I218_An XI1_I1850_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1850_I218_MN2 (XI1_I1850_I218_n1 I1_I1850_pn15 I1_p28_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1850_I218_MN3 (VSS I1_I1850_G14_0n XI1_I1850_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1850_I218_MN0 (XI1_I1850_I218_An I1_I1850_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1836_MN1 (XI1_I1836_Bn I1_qu4_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1836_MN5 (XI1_I1836_n2 XI1_I1836_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1836_MN4 (I1_b28_18 XI1_I1836_An XI1_I1836_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1836_MN2 (XI1_I1836_n1 I1_dd18_b3_5 I1_b28_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1836_MN3 (VSS I1_qu4_b3_3 XI1_I1836_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1836_MN0 (XI1_I1836_An I1_dd18_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1882_MN1 (XI1_I1882_Bn I1_qu3_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1882_MN5 (XI1_I1882_n2 XI1_I1882_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1882_MN4 (I1_b29_18 XI1_I1882_An XI1_I1882_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1882_MN2 (XI1_I1882_n1 I1_dd18_b3_5 I1_b29_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1882_MN3 (VSS I1_qu3_b3_3 XI1_I1882_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1882_MN0 (XI1_I1882_An I1_dd18_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1929_MN1 (XI1_I1929_Bn I1_qu2_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1929_MN5 (XI1_I1929_n2 XI1_I1929_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1929_MN4 (I1_b30_19 XI1_I1929_An XI1_I1929_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1929_MN2 (XI1_I1929_n1 I1_dd19_b3_5 I1_b30_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1929_MN3 (VSS I1_qu2_b3_3 XI1_I1929_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1929_MN0 (XI1_I1929_An I1_dd19_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1930_MN1 (XI1_I1930_Bn I1_qu2_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1930_MN5 (XI1_I1930_n2 XI1_I1930_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1930_MN4 (I1_b30_20 XI1_I1930_An XI1_I1930_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1930_MN2 (XI1_I1930_n1 I1_dd20_b3_5 I1_b30_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1930_MN3 (VSS I1_qu2_b3_3 XI1_I1930_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1930_MN0 (XI1_I1930_An I1_dd20_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1976_MN1 (XI1_I1976_Bn I1_qu1_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1976_MN5 (XI1_I1976_n2 XI1_I1976_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1976_MN4 (I1_b31_20 XI1_I1976_An XI1_I1976_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1976_MN2 (XI1_I1976_n1 I1_dd20_b3_5 I1_b31_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1976_MN3 (VSS I1_qu1_b3_3 XI1_I1976_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1976_MN0 (XI1_I1976_An I1_dd20_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I216_MN1 (XI1_I2066_I216_Bn I1_I2066_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I216_MN5 (XI1_I2066_I216_n2 XI1_I2066_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I2066_I216_MN4 (I1_ru13 XI1_I2066_I216_An XI1_I2066_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I2066_I216_MN2 (XI1_I2066_I216_n1 I1_I2066_pn13 I1_ru13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I2066_I216_MN3 (VSS I1_I2066_G12_0n XI1_I2066_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I2066_I216_MN0 (XI1_I2066_I216_An I1_I2066_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I215_MN1 (XI1_I2066_I215_Bn I1_I2066_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I215_MN5 (XI1_I2066_I215_n2 XI1_I2066_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I2066_I215_MN4 (I1_ru12 XI1_I2066_I215_An XI1_I2066_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I2066_I215_MN2 (XI1_I2066_I215_n1 I1_I2066_pn12 I1_ru12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I2066_I215_MN3 (VSS I1_I2066_G11_0n XI1_I2066_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I2066_I215_MN0 (XI1_I2066_I215_An I1_I2066_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I510_MN1 (XI0_I1660_I510_Bn I0_I1660_G42_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I510_MN5 (XI0_I1660_I510_n2 XI0_I1660_I510_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I510_MN4 (MULP_43 XI0_I1660_I510_An XI0_I1660_I510_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I510_MN2 (XI0_I1660_I510_n1 I0_I1660_pn43 MULP_43 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I510_MN3 (VSS I0_I1660_G42_0n XI0_I1660_I510_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I510_MN0 (XI0_I1660_I510_An I0_I1660_pn43 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1837_MN1 (XI1_I1837_Bn I1_qu4_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1837_MN5 (XI1_I1837_n2 XI1_I1837_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1837_MN4 (I1_b28_19 XI1_I1837_An XI1_I1837_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1837_MN2 (XI1_I1837_n1 I1_dd19_b3_5 I1_b28_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1837_MN3 (VSS I1_qu4_b3_3 XI1_I1837_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1837_MN0 (XI1_I1837_An I1_dd19_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1838_MN1 (XI1_I1838_Bn I1_qu4_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1838_MN5 (XI1_I1838_n2 XI1_I1838_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1838_MN4 (I1_b28_20 XI1_I1838_An XI1_I1838_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1838_MN2 (XI1_I1838_n1 I1_dd20_b3_5 I1_b28_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1838_MN3 (VSS I1_qu4_b3_3 XI1_I1838_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1838_MN0 (XI1_I1838_An I1_dd20_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1884_MN1 (XI1_I1884_Bn I1_qu3_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1884_MN5 (XI1_I1884_n2 XI1_I1884_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1884_MN4 (I1_b29_20 XI1_I1884_An XI1_I1884_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1884_MN2 (XI1_I1884_n1 I1_dd20_b3_5 I1_b29_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1884_MN3 (VSS I1_qu3_b3_3 XI1_I1884_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1884_MN0 (XI1_I1884_An I1_dd20_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1883_MN1 (XI1_I1883_Bn I1_qu3_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1883_MN5 (XI1_I1883_n2 XI1_I1883_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1883_MN4 (I1_b29_19 XI1_I1883_An XI1_I1883_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1883_MN2 (XI1_I1883_n1 I1_dd19_b3_5 I1_b29_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1883_MN3 (VSS I1_qu3_b3_3 XI1_I1883_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1883_MN0 (XI1_I1883_An I1_dd19_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1931_MN1 (XI1_I1931_Bn I1_qu2_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1931_MN5 (XI1_I1931_n2 XI1_I1931_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1931_MN4 (I1_b30_21 XI1_I1931_An XI1_I1931_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1931_MN2 (XI1_I1931_n1 I1_dd21_b3_5 I1_b30_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1931_MN3 (VSS I1_qu2_b3_3 XI1_I1931_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1931_MN0 (XI1_I1931_An I1_dd21_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1977_MN1 (XI1_I1977_Bn I1_qu1_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1977_MN5 (XI1_I1977_n2 XI1_I1977_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1977_MN4 (I1_b31_21 XI1_I1977_An XI1_I1977_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1977_MN2 (XI1_I1977_n1 I1_dd21_b3_5 I1_b31_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1977_MN3 (VSS I1_qu1_b3_3 XI1_I1977_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1977_MN0 (XI1_I1977_An I1_dd21_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1978_MN1 (XI1_I1978_Bn I1_qu1_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1978_MN5 (XI1_I1978_n2 XI1_I1978_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1978_MN4 (I1_b31_22 XI1_I1978_An XI1_I1978_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1978_MN2 (XI1_I1978_n1 I1_dd22_b3_5 I1_b31_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1978_MN3 (VSS I1_qu1_b3_3 XI1_I1978_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1978_MN0 (XI1_I1978_An I1_dd22_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I516_MN1 (XI0_I1660_I516_Bn I0_I1660_G48_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I516_MN5 (XI0_I1660_I516_n2 XI0_I1660_I516_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I516_MN4 (MULP_49 XI0_I1660_I516_An XI0_I1660_I516_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I516_MN2 (XI0_I1660_I516_n1 I0_I1660_pn49 MULP_49 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I516_MN3 (VSS I0_I1660_G48_0n XI0_I1660_I516_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I516_MN0 (XI0_I1660_I516_An I0_I1660_pn49 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I518_MN1 (XI0_I1660_I518_Bn I0_I1660_G50_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I518_MN5 (XI0_I1660_I518_n2 XI0_I1660_I518_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I518_MN4 (MULP_51 XI0_I1660_I518_An XI0_I1660_I518_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I518_MN2 (XI0_I1660_I518_n1 I0_I1660_pn51 MULP_51 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I518_MN3 (VSS I0_I1660_G50_0n XI0_I1660_I518_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I518_MN0 (XI0_I1660_I518_An I0_I1660_pn51 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I515_MN1 (XI0_I1660_I515_Bn I0_I1660_G47_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I515_MN5 (XI0_I1660_I515_n2 XI0_I1660_I515_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I515_MN4 (MULP_48 XI0_I1660_I515_An XI0_I1660_I515_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I515_MN2 (XI0_I1660_I515_n1 I0_I1660_pn48 MULP_48 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I515_MN3 (VSS I0_I1660_G47_0n XI0_I1660_I515_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I515_MN0 (XI0_I1660_I515_An I0_I1660_pn48 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1840_MN1 (XI1_I1840_Bn I1_qu4_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1840_MN5 (XI1_I1840_n2 XI1_I1840_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1840_MN4 (I1_b28_22 XI1_I1840_An XI1_I1840_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1840_MN2 (XI1_I1840_n1 I1_dd22_b3_5 I1_b28_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1840_MN3 (VSS I1_qu4_b3_3 XI1_I1840_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1840_MN0 (XI1_I1840_An I1_dd22_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1839_MN1 (XI1_I1839_Bn I1_qu4_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1839_MN5 (XI1_I1839_n2 XI1_I1839_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1839_MN4 (I1_b28_21 XI1_I1839_An XI1_I1839_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1839_MN2 (XI1_I1839_n1 I1_dd21_b3_5 I1_b28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1839_MN3 (VSS I1_qu4_b3_3 XI1_I1839_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1839_MN0 (XI1_I1839_An I1_dd21_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1885_MN1 (XI1_I1885_Bn I1_qu3_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1885_MN5 (XI1_I1885_n2 XI1_I1885_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1885_MN4 (I1_b29_21 XI1_I1885_An XI1_I1885_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1885_MN2 (XI1_I1885_n1 I1_dd21_b3_5 I1_b29_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1885_MN3 (VSS I1_qu3_b3_3 XI1_I1885_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1885_MN0 (XI1_I1885_An I1_dd21_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1886_MN1 (XI1_I1886_Bn I1_qu3_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1886_MN5 (XI1_I1886_n2 XI1_I1886_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1886_MN4 (I1_b29_22 XI1_I1886_An XI1_I1886_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1886_MN2 (XI1_I1886_n1 I1_dd22_b3_5 I1_b29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1886_MN3 (VSS I1_qu3_b3_3 XI1_I1886_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1886_MN0 (XI1_I1886_An I1_dd22_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1932_MN1 (XI1_I1932_Bn I1_qu2_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1932_MN5 (XI1_I1932_n2 XI1_I1932_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1932_MN4 (I1_b30_22 XI1_I1932_An XI1_I1932_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1932_MN2 (XI1_I1932_n1 I1_dd22_b3_5 I1_b30_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1932_MN3 (VSS I1_qu2_b3_3 XI1_I1932_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1932_MN0 (XI1_I1932_An I1_dd22_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1933_MN1 (XI1_I1933_Bn I1_qu2_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1933_MN5 (XI1_I1933_n2 XI1_I1933_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1933_MN4 (I1_b30_23 XI1_I1933_An XI1_I1933_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1933_MN2 (XI1_I1933_n1 I1_dd23_b3_5 I1_b30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1933_MN3 (VSS I1_qu2_b3_3 XI1_I1933_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1933_MN0 (XI1_I1933_An I1_dd23_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1979_MN1 (XI1_I1979_Bn I1_qu1_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1979_MN5 (XI1_I1979_n2 XI1_I1979_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1979_MN4 (I1_b31_23 XI1_I1979_An XI1_I1979_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1979_MN2 (XI1_I1979_n1 I1_dd23_b3_5 I1_b31_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1979_MN3 (VSS I1_qu1_b3_3 XI1_I1979_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1979_MN0 (XI1_I1979_An I1_dd23_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I218_MN1 (XI1_I2066_I218_Bn I1_I2066_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I218_MN5 (XI1_I2066_I218_n2 XI1_I2066_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I2066_I218_MN4 (I1_ru15 XI1_I2066_I218_An XI1_I2066_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I2066_I218_MN2 (XI1_I2066_I218_n1 I1_I2066_pn15 I1_ru15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I2066_I218_MN3 (VSS I1_I2066_G14_0n XI1_I2066_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I2066_I218_MN0 (XI1_I2066_I218_An I1_I2066_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I217_MN1 (XI1_I2066_I217_Bn I1_I2066_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I217_MN5 (XI1_I2066_I217_n2 XI1_I2066_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I2066_I217_MN4 (I1_ru14 XI1_I2066_I217_An XI1_I2066_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I2066_I217_MN2 (XI1_I2066_I217_n1 I1_I2066_pn14 I1_ru14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I2066_I217_MN3 (VSS I1_I2066_G13_0n XI1_I2066_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I2066_I217_MN0 (XI1_I2066_I217_An I1_I2066_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I219_MN1 (XI1_I2066_I219_Bn I1_I2066_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I219_MN5 (XI1_I2066_I219_n2 XI1_I2066_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I2066_I219_MN4 (I1_ru16 XI1_I2066_I219_An XI1_I2066_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I2066_I219_MN2 (XI1_I2066_I219_n1 I1_I2066_pn16 I1_ru16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I2066_I219_MN3 (VSS I1_I2066_G15_0n XI1_I2066_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I2066_I219_MN0 (XI1_I2066_I219_An I1_I2066_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I514_MN1 (XI0_I1660_I514_Bn I0_I1660_G46_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I514_MN5 (XI0_I1660_I514_n2 XI0_I1660_I514_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I514_MN4 (MULP_47 XI0_I1660_I514_An XI0_I1660_I514_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I514_MN2 (XI0_I1660_I514_n1 I0_I1660_pn47 MULP_47 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I514_MN3 (VSS I0_I1660_G46_0n XI0_I1660_I514_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I514_MN0 (XI0_I1660_I514_An I0_I1660_pn47 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I517_MN1 (XI0_I1660_I517_Bn I0_I1660_G49_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I517_MN5 (XI0_I1660_I517_n2 XI0_I1660_I517_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I517_MN4 (MULP_50 XI0_I1660_I517_An XI0_I1660_I517_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I517_MN2 (XI0_I1660_I517_n1 I0_I1660_pn50 MULP_50 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I517_MN3 (VSS I0_I1660_G49_0n XI0_I1660_I517_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I517_MN0 (XI0_I1660_I517_An I0_I1660_pn50 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I519_MN1 (XI0_I1660_I519_Bn I0_I1660_G51_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I519_MN5 (XI0_I1660_I519_n2 XI0_I1660_I519_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I519_MN4 (MULP_52 XI0_I1660_I519_An XI0_I1660_I519_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I519_MN2 (XI0_I1660_I519_n1 I0_I1660_pn52 MULP_52 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I519_MN3 (VSS I0_I1660_G51_0n XI0_I1660_I519_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I519_MN0 (XI0_I1660_I519_An I0_I1660_pn52 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1841_MN1 (XI1_I1841_Bn I1_qu4_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1841_MN5 (XI1_I1841_n2 XI1_I1841_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1841_MN4 (I1_b28_23 XI1_I1841_An XI1_I1841_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1841_MN2 (XI1_I1841_n1 I1_dd23_b3_5 I1_b28_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1841_MN3 (VSS I1_qu4_b3_3 XI1_I1841_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1841_MN0 (XI1_I1841_An I1_dd23_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1888_MN1 (XI1_I1888_Bn I1_qu3_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1888_MN5 (XI1_I1888_n2 XI1_I1888_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1888_MN4 (I1_b29_24 XI1_I1888_An XI1_I1888_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1888_MN2 (XI1_I1888_n1 I1_dd24_b3_5 I1_b29_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1888_MN3 (VSS I1_qu3_b3_4 XI1_I1888_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1888_MN0 (XI1_I1888_An I1_dd24_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1887_MN1 (XI1_I1887_Bn I1_qu3_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1887_MN5 (XI1_I1887_n2 XI1_I1887_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1887_MN4 (I1_b29_23 XI1_I1887_An XI1_I1887_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1887_MN2 (XI1_I1887_n1 I1_dd23_b3_5 I1_b29_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1887_MN3 (VSS I1_qu3_b3_3 XI1_I1887_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1887_MN0 (XI1_I1887_An I1_dd23_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1980_MN1 (XI1_I1980_Bn I1_qu1_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1980_MN5 (XI1_I1980_n2 XI1_I1980_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1980_MN4 (I1_b31_24 XI1_I1980_An XI1_I1980_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1980_MN2 (XI1_I1980_n1 I1_dd24_b3_5 I1_b31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1980_MN3 (VSS I1_qu1_b3_4 XI1_I1980_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1980_MN0 (XI1_I1980_An I1_dd24_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1989_MN1 (XI1_I1989_Bn I1_qu1_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1989_MN5 (XI1_I1989_n2 XI1_I1989_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1989_MN4 (I1_h31 XI1_I1989_An XI1_I1989_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1989_MN2 (XI1_I1989_n1 I1_p30_31 I1_h31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1989_MN3 (VSS I1_qu1_b3_5 XI1_I1989_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1989_MN0 (XI1_I1989_An I1_p30_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1990_MN1 (XI1_I1990_Bn I1_c31_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1990_MN5 (XI1_I1990_n2 XI1_I1990_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1990_MN4 (I1_p31_32 XI1_I1990_An XI1_I1990_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1990_MN2 (XI1_I1990_n1 I1_h31 I1_p31_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1990_MN3 (VSS I1_c31_o XI1_I1990_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1990_MN0 (XI1_I1990_An I1_h31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I520_MN1 (XI0_I1660_I520_Bn I0_I1660_G52_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I520_MN5 (XI0_I1660_I520_n2 XI0_I1660_I520_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I520_MN4 (MULP_53 XI0_I1660_I520_An XI0_I1660_I520_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I520_MN2 (XI0_I1660_I520_n1 I0_I1660_pn53 MULP_53 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I520_MN3 (VSS I0_I1660_G52_0n XI0_I1660_I520_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I520_MN0 (XI0_I1660_I520_An I0_I1660_pn53 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I524_MN1 (XI0_I1660_I524_Bn I0_I1660_G56_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I524_MN5 (XI0_I1660_I524_n2 XI0_I1660_I524_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I524_MN4 (MULP_57 XI0_I1660_I524_An XI0_I1660_I524_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I524_MN2 (XI0_I1660_I524_n1 I0_I1660_pn57 MULP_57 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I524_MN3 (VSS I0_I1660_G56_0n XI0_I1660_I524_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I524_MN0 (XI0_I1660_I524_An I0_I1660_pn57 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I525_MN1 (XI0_I1660_I525_Bn I0_I1660_G57_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I525_MN5 (XI0_I1660_I525_n2 XI0_I1660_I525_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I525_MN4 (MULP_58 XI0_I1660_I525_An XI0_I1660_I525_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I525_MN2 (XI0_I1660_I525_n1 I0_I1660_pn58 MULP_58 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I525_MN3 (VSS I0_I1660_G57_0n XI0_I1660_I525_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I525_MN0 (XI0_I1660_I525_An I0_I1660_pn58 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I523_MN1 (XI0_I1660_I523_Bn I0_I1660_G55_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I523_MN5 (XI0_I1660_I523_n2 XI0_I1660_I523_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I523_MN4 (MULP_56 XI0_I1660_I523_An XI0_I1660_I523_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I523_MN2 (XI0_I1660_I523_n1 I0_I1660_pn56 MULP_56 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I523_MN3 (VSS I0_I1660_G55_0n XI0_I1660_I523_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I523_MN0 (XI0_I1660_I523_An I0_I1660_pn56 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1842_MN1 (XI1_I1842_Bn I1_qu4_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1842_MN5 (XI1_I1842_n2 XI1_I1842_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1842_MN4 (I1_b28_24 XI1_I1842_An XI1_I1842_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1842_MN2 (XI1_I1842_n1 I1_dd24_b3_5 I1_b28_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1842_MN3 (VSS I1_qu4_b3_4 XI1_I1842_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1842_MN0 (XI1_I1842_An I1_dd24_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1849_MN1 (XI1_I1849_Bn I1_qu4_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1849_MN5 (XI1_I1849_n2 XI1_I1849_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1849_MN4 (I1_b28_31 XI1_I1849_An XI1_I1849_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1849_MN2 (XI1_I1849_n1 I1_dd31_b3_5 I1_b28_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1849_MN3 (VSS I1_qu4_b3_5 XI1_I1849_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1849_MN0 (XI1_I1849_An I1_dd31_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1848_MN1 (XI1_I1848_Bn I1_qu4_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1848_MN5 (XI1_I1848_n2 XI1_I1848_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1848_MN4 (I1_b28_30 XI1_I1848_An XI1_I1848_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1848_MN2 (XI1_I1848_n1 I1_dd30_b3_5 I1_b28_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1848_MN3 (VSS I1_qu4_b3_5 XI1_I1848_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1848_MN0 (XI1_I1848_An I1_dd30_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1895_MN1 (XI1_I1895_Bn I1_qu3_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1895_MN5 (XI1_I1895_n2 XI1_I1895_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1895_MN4 (I1_b29_31 XI1_I1895_An XI1_I1895_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1895_MN2 (XI1_I1895_n1 I1_dd31_b3_5 I1_b29_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1895_MN3 (VSS I1_qu3_b3_5 XI1_I1895_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1895_MN0 (XI1_I1895_An I1_dd31_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1934_MN1 (XI1_I1934_Bn I1_qu2_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1934_MN5 (XI1_I1934_n2 XI1_I1934_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1934_MN4 (I1_b30_24 XI1_I1934_An XI1_I1934_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1934_MN2 (XI1_I1934_n1 I1_dd24_b3_5 I1_b30_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1934_MN3 (VSS I1_qu2_b3_4 XI1_I1934_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1934_MN0 (XI1_I1934_An I1_dd24_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1981_MN1 (XI1_I1981_Bn I1_qu1_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1981_MN5 (XI1_I1981_n2 XI1_I1981_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1981_MN4 (I1_b31_25 XI1_I1981_An XI1_I1981_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1981_MN2 (XI1_I1981_n1 I1_dd25_b3_5 I1_b31_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1981_MN3 (VSS I1_qu1_b3_4 XI1_I1981_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1981_MN0 (XI1_I1981_An I1_dd25_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I522_MN1 (XI0_I1660_I522_Bn I0_I1660_G54_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I522_MN5 (XI0_I1660_I522_n2 XI0_I1660_I522_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I522_MN4 (MULP_55 XI0_I1660_I522_An XI0_I1660_I522_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I522_MN2 (XI0_I1660_I522_n1 I0_I1660_pn55 MULP_55 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I522_MN3 (VSS I0_I1660_G54_0n XI0_I1660_I522_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I522_MN0 (XI0_I1660_I522_An I0_I1660_pn55 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I526_MN1 (XI0_I1660_I526_Bn I0_I1660_G58_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I526_MN5 (XI0_I1660_I526_n2 XI0_I1660_I526_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I526_MN4 (MULP_59 XI0_I1660_I526_An XI0_I1660_I526_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I526_MN2 (XI0_I1660_I526_n1 I0_I1660_pn59 MULP_59 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I526_MN3 (VSS I0_I1660_G58_0n XI0_I1660_I526_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I526_MN0 (XI0_I1660_I526_An I0_I1660_pn59 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1844_MN1 (XI1_I1844_Bn I1_qu4_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1844_MN5 (XI1_I1844_n2 XI1_I1844_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1844_MN4 (I1_b28_26 XI1_I1844_An XI1_I1844_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1844_MN2 (XI1_I1844_n1 I1_dd26_b3_5 I1_b28_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1844_MN3 (VSS I1_qu4_b3_4 XI1_I1844_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1844_MN0 (XI1_I1844_An I1_dd26_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1843_MN1 (XI1_I1843_Bn I1_qu4_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1843_MN5 (XI1_I1843_n2 XI1_I1843_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1843_MN4 (I1_b28_25 XI1_I1843_An XI1_I1843_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1843_MN2 (XI1_I1843_n1 I1_dd25_b3_5 I1_b28_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1843_MN3 (VSS I1_qu4_b3_4 XI1_I1843_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1843_MN0 (XI1_I1843_An I1_dd25_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1891_MN1 (XI1_I1891_Bn I1_qu3_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1891_MN5 (XI1_I1891_n2 XI1_I1891_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1891_MN4 (I1_b29_27 XI1_I1891_An XI1_I1891_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1891_MN2 (XI1_I1891_n1 I1_dd27_b3_5 I1_b29_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1891_MN3 (VSS I1_qu3_b3_4 XI1_I1891_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1891_MN0 (XI1_I1891_An I1_dd27_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1890_MN1 (XI1_I1890_Bn I1_qu3_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1890_MN5 (XI1_I1890_n2 XI1_I1890_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1890_MN4 (I1_b29_26 XI1_I1890_An XI1_I1890_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1890_MN2 (XI1_I1890_n1 I1_dd26_b3_5 I1_b29_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1890_MN3 (VSS I1_qu3_b3_4 XI1_I1890_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1890_MN0 (XI1_I1890_An I1_dd26_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1892_MN1 (XI1_I1892_Bn I1_qu3_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1892_MN5 (XI1_I1892_n2 XI1_I1892_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1892_MN4 (I1_b29_28 XI1_I1892_An XI1_I1892_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1892_MN2 (XI1_I1892_n1 I1_dd28_b3_5 I1_b29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1892_MN3 (VSS I1_qu3_b3_4 XI1_I1892_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1892_MN0 (XI1_I1892_An I1_dd28_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1889_MN1 (XI1_I1889_Bn I1_qu3_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1889_MN5 (XI1_I1889_n2 XI1_I1889_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1889_MN4 (I1_b29_25 XI1_I1889_An XI1_I1889_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1889_MN2 (XI1_I1889_n1 I1_dd25_b3_5 I1_b29_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1889_MN3 (VSS I1_qu3_b3_4 XI1_I1889_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1889_MN0 (XI1_I1889_An I1_dd25_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1897_MN1 (XI1_I1897_Bn I1_qu3_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1897_MN5 (XI1_I1897_n2 XI1_I1897_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1897_MN4 (I1_h29 XI1_I1897_An XI1_I1897_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1897_MN2 (XI1_I1897_n1 I1_p28_31 I1_h29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1897_MN3 (VSS I1_qu3_b3_5 XI1_I1897_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1897_MN0 (XI1_I1897_An I1_p28_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1894_MN1 (XI1_I1894_Bn I1_qu3_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1894_MN5 (XI1_I1894_n2 XI1_I1894_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1894_MN4 (I1_b29_30 XI1_I1894_An XI1_I1894_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1894_MN2 (XI1_I1894_n1 I1_dd30_b3_5 I1_b29_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1894_MN3 (VSS I1_qu3_b3_5 XI1_I1894_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1894_MN0 (XI1_I1894_An I1_dd30_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1898_MN1 (XI1_I1898_Bn I1_c29_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1898_MN5 (XI1_I1898_n2 XI1_I1898_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1898_MN4 (I1_p29_32 XI1_I1898_An XI1_I1898_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1898_MN2 (XI1_I1898_n1 I1_h29 I1_p29_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1898_MN3 (VSS I1_c29_o XI1_I1898_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1898_MN0 (XI1_I1898_An I1_h29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1935_MN1 (XI1_I1935_Bn I1_qu2_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1935_MN5 (XI1_I1935_n2 XI1_I1935_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1935_MN4 (I1_b30_25 XI1_I1935_An XI1_I1935_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1935_MN2 (XI1_I1935_n1 I1_dd25_b3_5 I1_b30_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1935_MN3 (VSS I1_qu2_b3_4 XI1_I1935_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1935_MN0 (XI1_I1935_An I1_dd25_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1936_MN1 (XI1_I1936_Bn I1_qu2_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1936_MN5 (XI1_I1936_n2 XI1_I1936_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1936_MN4 (I1_b30_26 XI1_I1936_An XI1_I1936_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1936_MN2 (XI1_I1936_n1 I1_dd26_b3_5 I1_b30_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1936_MN3 (VSS I1_qu2_b3_4 XI1_I1936_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1936_MN0 (XI1_I1936_An I1_dd26_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1943_MN1 (XI1_I1943_Bn I1_qu2_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1943_MN5 (XI1_I1943_n2 XI1_I1943_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1943_MN4 (I1_h30 XI1_I1943_An XI1_I1943_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1943_MN2 (XI1_I1943_n1 I1_p29_31 I1_h30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1943_MN3 (VSS I1_qu2_b3_5 XI1_I1943_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1943_MN0 (XI1_I1943_An I1_p29_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1944_MN1 (XI1_I1944_Bn I1_c30_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1944_MN5 (XI1_I1944_n2 XI1_I1944_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1944_MN4 (I1_p30_32 XI1_I1944_An XI1_I1944_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1944_MN2 (XI1_I1944_n1 I1_h30 I1_p30_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1944_MN3 (VSS I1_c30_o XI1_I1944_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1944_MN0 (XI1_I1944_An I1_h30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1984_MN1 (XI1_I1984_Bn I1_qu1_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1984_MN5 (XI1_I1984_n2 XI1_I1984_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1984_MN4 (I1_b31_28 XI1_I1984_An XI1_I1984_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1984_MN2 (XI1_I1984_n1 I1_dd28_b3_5 I1_b31_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1984_MN3 (VSS I1_qu1_b3_4 XI1_I1984_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1984_MN0 (XI1_I1984_An I1_dd28_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1982_MN1 (XI1_I1982_Bn I1_qu1_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1982_MN5 (XI1_I1982_n2 XI1_I1982_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1982_MN4 (I1_b31_26 XI1_I1982_An XI1_I1982_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1982_MN2 (XI1_I1982_n1 I1_dd26_b3_5 I1_b31_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1982_MN3 (VSS I1_qu1_b3_4 XI1_I1982_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1982_MN0 (XI1_I1982_An I1_dd26_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1983_MN1 (XI1_I1983_Bn I1_qu1_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1983_MN5 (XI1_I1983_n2 XI1_I1983_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1983_MN4 (I1_b31_27 XI1_I1983_An XI1_I1983_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1983_MN2 (XI1_I1983_n1 I1_dd27_b3_5 I1_b31_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1983_MN3 (VSS I1_qu1_b3_4 XI1_I1983_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1983_MN0 (XI1_I1983_An I1_dd27_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I528_MN1 (XI0_I1660_I528_Bn I0_I1660_G60_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I528_MN5 (XI0_I1660_I528_n2 XI0_I1660_I528_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I528_MN4 (MULP_61 XI0_I1660_I528_An XI0_I1660_I528_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I528_MN2 (XI0_I1660_I528_n1 I0_I1660_pn61 MULP_61 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I528_MN3 (VSS I0_I1660_G60_0n XI0_I1660_I528_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I528_MN0 (XI0_I1660_I528_An I0_I1660_pn61 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I521_MN1 (XI0_I1660_I521_Bn I0_I1660_G53_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I521_MN5 (XI0_I1660_I521_n2 XI0_I1660_I521_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I521_MN4 (MULP_54 XI0_I1660_I521_An XI0_I1660_I521_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I521_MN2 (XI0_I1660_I521_n1 I0_I1660_pn54 MULP_54 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I521_MN3 (VSS I0_I1660_G53_0n XI0_I1660_I521_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I521_MN0 (XI0_I1660_I521_An I0_I1660_pn54 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I527_MN1 (XI0_I1660_I527_Bn I0_I1660_G59_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I527_MN5 (XI0_I1660_I527_n2 XI0_I1660_I527_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I527_MN4 (MULP_60 XI0_I1660_I527_An XI0_I1660_I527_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I527_MN2 (XI0_I1660_I527_n1 I0_I1660_pn60 MULP_60 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I527_MN3 (VSS I0_I1660_G59_0n XI0_I1660_I527_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I527_MN0 (XI0_I1660_I527_An I0_I1660_pn60 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1847_MN1 (XI1_I1847_Bn I1_qu4_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1847_MN5 (XI1_I1847_n2 XI1_I1847_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1847_MN4 (I1_b28_29 XI1_I1847_An XI1_I1847_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1847_MN2 (XI1_I1847_n1 I1_dd29_b3_5 I1_b28_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1847_MN3 (VSS I1_qu4_b3_4 XI1_I1847_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1847_MN0 (XI1_I1847_An I1_dd29_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1845_MN1 (XI1_I1845_Bn I1_qu4_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1845_MN5 (XI1_I1845_n2 XI1_I1845_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1845_MN4 (I1_b28_27 XI1_I1845_An XI1_I1845_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1845_MN2 (XI1_I1845_n1 I1_dd27_b3_5 I1_b28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1845_MN3 (VSS I1_qu4_b3_4 XI1_I1845_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1845_MN0 (XI1_I1845_An I1_dd27_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1846_MN1 (XI1_I1846_Bn I1_qu4_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1846_MN5 (XI1_I1846_n2 XI1_I1846_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1846_MN4 (I1_b28_28 XI1_I1846_An XI1_I1846_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1846_MN2 (XI1_I1846_n1 I1_dd28_b3_5 I1_b28_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1846_MN3 (VSS I1_qu4_b3_4 XI1_I1846_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1846_MN0 (XI1_I1846_An I1_dd28_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1893_MN1 (XI1_I1893_Bn I1_qu3_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1893_MN5 (XI1_I1893_n2 XI1_I1893_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1893_MN4 (I1_b29_29 XI1_I1893_An XI1_I1893_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1893_MN2 (XI1_I1893_n1 I1_dd29_b3_5 I1_b29_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1893_MN3 (VSS I1_qu3_b3_4 XI1_I1893_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1893_MN0 (XI1_I1893_An I1_dd29_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1939_MN1 (XI1_I1939_Bn I1_qu2_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1939_MN5 (XI1_I1939_n2 XI1_I1939_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1939_MN4 (I1_b30_29 XI1_I1939_An XI1_I1939_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1939_MN2 (XI1_I1939_n1 I1_dd29_b3_5 I1_b30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1939_MN3 (VSS I1_qu2_b3_4 XI1_I1939_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1939_MN0 (XI1_I1939_An I1_dd29_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1937_MN1 (XI1_I1937_Bn I1_qu2_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1937_MN5 (XI1_I1937_n2 XI1_I1937_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1937_MN4 (I1_b30_27 XI1_I1937_An XI1_I1937_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1937_MN2 (XI1_I1937_n1 I1_dd27_b3_5 I1_b30_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1937_MN3 (VSS I1_qu2_b3_4 XI1_I1937_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1937_MN0 (XI1_I1937_An I1_dd27_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1938_MN1 (XI1_I1938_Bn I1_qu2_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1938_MN5 (XI1_I1938_n2 XI1_I1938_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1938_MN4 (I1_b30_28 XI1_I1938_An XI1_I1938_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1938_MN2 (XI1_I1938_n1 I1_dd28_b3_5 I1_b30_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1938_MN3 (VSS I1_qu2_b3_4 XI1_I1938_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1938_MN0 (XI1_I1938_An I1_dd28_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1941_MN1 (XI1_I1941_Bn I1_qu2_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1941_MN5 (XI1_I1941_n2 XI1_I1941_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1941_MN4 (I1_b30_31 XI1_I1941_An XI1_I1941_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1941_MN2 (XI1_I1941_n1 I1_dd31_b3_5 I1_b30_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1941_MN3 (VSS I1_qu2_b3_5 XI1_I1941_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1941_MN0 (XI1_I1941_An I1_dd31_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1940_MN1 (XI1_I1940_Bn I1_qu2_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1940_MN5 (XI1_I1940_n2 XI1_I1940_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1940_MN4 (I1_b30_30 XI1_I1940_An XI1_I1940_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1940_MN2 (XI1_I1940_n1 I1_dd30_b3_5 I1_b30_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1940_MN3 (VSS I1_qu2_b3_5 XI1_I1940_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1940_MN0 (XI1_I1940_An I1_dd30_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1985_MN1 (XI1_I1985_Bn I1_qu1_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1985_MN5 (XI1_I1985_n2 XI1_I1985_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1985_MN4 (I1_b31_29 XI1_I1985_An XI1_I1985_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1985_MN2 (XI1_I1985_n1 I1_dd29_b3_5 I1_b31_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1985_MN3 (VSS I1_qu1_b3_4 XI1_I1985_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1985_MN0 (XI1_I1985_An I1_dd29_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1987_MN1 (XI1_I1987_Bn I1_qu1_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1987_MN5 (XI1_I1987_n2 XI1_I1987_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1987_MN4 (I1_b31_31 XI1_I1987_An XI1_I1987_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1987_MN2 (XI1_I1987_n1 I1_dd31_b3_5 I1_b31_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1987_MN3 (VSS I1_qu1_b3_5 XI1_I1987_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1987_MN0 (XI1_I1987_An I1_dd31_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1986_MN1 (XI1_I1986_Bn I1_qu1_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1986_MN5 (XI1_I1986_n2 XI1_I1986_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1986_MN4 (I1_b31_30 XI1_I1986_An XI1_I1986_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1986_MN2 (XI1_I1986_n1 I1_dd30_b3_5 I1_b31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1986_MN3 (VSS I1_qu1_b3_5 XI1_I1986_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1986_MN0 (XI1_I1986_An I1_dd30_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I530_MN1 (XI0_I1660_I530_Bn I0_I1660_G62_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I530_MN5 (XI0_I1660_I530_n2 XI0_I1660_I530_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I530_MN4 (MULP_63 XI0_I1660_I530_An XI0_I1660_I530_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I530_MN2 (XI0_I1660_I530_n1 I0_I1660_pn63 MULP_63 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I530_MN3 (VSS I0_I1660_G62_0n XI0_I1660_I530_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I530_MN0 (XI0_I1660_I530_An I0_I1660_pn63 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I529_MN1 (XI0_I1660_I529_Bn I0_I1660_G61_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I529_MN5 (XI0_I1660_I529_n2 XI0_I1660_I529_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1660_I529_MN4 (MULP_62 XI0_I1660_I529_An XI0_I1660_I529_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I529_MN2 (XI0_I1660_I529_n1 I0_I1660_pn62 MULP_62 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1660_I529_MN3 (VSS I0_I1660_G61_0n XI0_I1660_I529_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1660_I529_MN0 (XI0_I1660_I529_An I0_I1660_pn62 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I142_XG_MP2 (VDD I1_I1160_G17_14n I1_I1160_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1160_I142_XG_MP0 (XI1_I1160_I142_XG_p1 I1_I1160_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1160_I142_XG_MP1 (I1_I1160_G17_10 I1_I1160_G13_10n XI1_I1160_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I138_XG_MP2 (VDD I1_I1160_G13_10n I1_I1160_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1160_I138_XG_MP0 (XI1_I1160_I138_XG_p1 I1_I1160_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1160_I138_XG_MP1 (I1_I1160_G13_6 I1_I1160_G9_6n XI1_I1160_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I151_XG_MP2 (VDD I1_I930_G26_23n I1_I930_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I930_I151_XG_MP0 (XI1_I930_I151_XG_p1 I1_I930_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I930_I151_XG_MP1 (I1_I930_G26_19 I1_I930_G22_19n XI1_I930_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I147_XG_MP2 (VDD I1_I930_G22_19n I1_I930_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I930_I147_XG_MP0 (XI1_I930_I147_XG_p1 I1_I930_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I930_I147_XG_MP1 (I1_I930_G22_15 I1_I930_G18_15n XI1_I930_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I83_XG_MP2 (VDD I1_I1436_gn17 I1_I1436_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1436_I83_XG_MP0 (XI1_I1436_I83_XG_p1 I1_I1436_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1436_I83_XG_MP1 (I1_I1436_G17_16 I1_I1436_gn16 XI1_I1436_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I82_XG_MP2 (VDD I1_I1436_gn16 I1_I1436_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1436_I82_XG_MP0 (XI1_I1436_I82_XG_p1 I1_I1436_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1436_I82_XG_MP1 (I1_I1436_G16_15 I1_I1436_gn15 XI1_I1436_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I148_XG_MP2 (VDD I1_I1758_G23_20n I1_I1758_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1758_I148_XG_MP0 (XI1_I1758_I148_XG_p1 I1_I1758_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1758_I148_XG_MP1 (I1_I1758_G23_16 I1_I1758_G19_16n XI1_I1758_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I150_XG_MP2 (VDD I1_I1758_G25_22n I1_I1758_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1758_I150_XG_MP0 (XI1_I1758_I150_XG_p1 I1_I1758_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1758_I150_XG_MP1 (I1_I1758_G25_18 I1_I1758_G21_18n XI1_I1758_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I146_XG_MP2 (VDD I1_I1758_G21_18n I1_I1758_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1758_I146_XG_MP0 (XI1_I1758_I146_XG_p1 I1_I1758_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1758_I146_XG_MP1 (I1_I1758_G21_14 I1_I1758_G17_14n XI1_I1758_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I89_XG_MP2 (VDD I1_I1666_gn23 I1_I1666_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1666_I89_XG_MP0 (XI1_I1666_I89_XG_p1 I1_I1666_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1666_I89_XG_MP1 (I1_I1666_G23_22 I1_I1666_gn22 XI1_I1666_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I88_XG_MP2 (VDD I1_I1666_gn22 I1_I1666_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1666_I88_XG_MP0 (XI1_I1666_I88_XG_p1 I1_I1666_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1666_I88_XG_MP1 (I1_I1666_G22_21 I1_I1666_gn21 XI1_I1666_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I71_XG_MP2 (VDD I1_I1804_gn5 I1_I1804_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1804_I71_XG_MP0 (XI1_I1804_I71_XG_p1 I1_I1804_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1804_I71_XG_MP1 (I1_I1804_G5_4 I1_I1804_gn4 XI1_I1804_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I70_XG_MP2 (VDD I1_I1804_gn4 I1_I1804_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1804_I70_XG_MP0 (XI1_I1804_I70_XG_p1 I1_I1804_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1804_I70_XG_MP1 (I1_I1804_G4_3 I1_I1804_gn3 XI1_I1804_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I151_XG_MP2 (VDD I1_I1804_G26_23n I1_I1804_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1804_I151_XG_MP0 (XI1_I1804_I151_XG_p1 I1_I1804_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1804_I151_XG_MP1 (I1_I1804_G26_19 I1_I1804_G22_19n XI1_I1804_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I147_XG_MP2 (VDD I1_I1804_G22_19n I1_I1804_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1804_I147_XG_MP0 (XI1_I1804_I147_XG_p1 I1_I1804_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1804_I147_XG_MP1 (I1_I1804_G22_15 I1_I1804_G18_15n XI1_I1804_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I137_XG_MP2 (VDD I1_I1850_G12_9n I1_I1850_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1850_I137_XG_MP0 (XI1_I1850_I137_XG_p1 I1_I1850_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1850_I137_XG_MP1 (I1_I1850_G12_5 I1_I1850_G8_5n XI1_I1850_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I135_XG_MP2 (VDD I1_I1850_G10_7n I1_I1850_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1850_I135_XG_MP0 (XI1_I1850_I135_XG_p1 I1_I1850_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1850_I135_XG_MP1 (I1_I1850_G10_3 I1_I1850_G6_3n XI1_I1850_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I151_XG_MP2 (VDD I1_I1896_G26_23n I1_I1896_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1896_I151_XG_MP0 (XI1_I1896_I151_XG_p1 I1_I1896_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1896_I151_XG_MP1 (I1_I1896_G26_19 I1_I1896_G22_19n XI1_I1896_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I147_XG_MP2 (VDD I1_I1896_G22_19n I1_I1896_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1896_I147_XG_MP0 (XI1_I1896_I147_XG_p1 I1_I1896_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1896_I147_XG_MP1 (I1_I1896_G22_15 I1_I1896_G18_15n XI1_I1896_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I97_XG_MP2 (VDD I1_I1988_gn31 I1_I1988_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1988_I97_XG_MP0 (XI1_I1988_I97_XG_p1 I1_I1988_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1988_I97_XG_MP1 (I1_I1988_G31_30 I1_I1988_gn30 XI1_I1988_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I96_XG_MP2 (VDD I1_I1988_gn30 I1_I1988_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1988_I96_XG_MP0 (XI1_I1988_I96_XG_p1 I1_I1988_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1988_I96_XG_MP1 (I1_I1988_G30_29 I1_I1988_gn29 XI1_I1988_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I117_XG_MP2 (XI1_I838_I117_XG_p1 I1_I838_G21_20 I1_I838_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I117_XG_MP0 (VDD I1_I838_P21_20 XI1_I838_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I117_XG_MP1 (XI1_I838_I117_XG_p1 I1_I838_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I115_XG_MP2 (XI1_I838_I115_XG_p1 I1_I838_G19_18 I1_I838_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I115_XG_MP0 (VDD I1_I838_P19_18 XI1_I838_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I115_XG_MP1 (XI1_I838_I115_XG_p1 I1_I838_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I177_XG_MP2 (XI1_I838_I177_XG_p1 I1_I838_G26_19 I1_I838_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I177_XG_MP0 (VDD I1_I838_P26_19 XI1_I838_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I177_XG_MP1 (XI1_I838_I177_XG_p1 I1_I838_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I173_XG_MP2 (XI1_I838_I173_XG_p1 I1_I838_G22_15 I1_I838_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I173_XG_MP0 (VDD I1_I838_P22_15 XI1_I838_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I173_XG_MP1 (XI1_I838_I173_XG_p1 I1_I838_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I101_XG_MP2 (XI1_I1298_I101_XG_p1 I1_I1298_G5_4 I1_I1298_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I101_XG_MP0 (VDD I1_I1298_P5_4 XI1_I1298_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I101_XG_MP1 (XI1_I1298_I101_XG_p1 I1_I1298_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I99_XG_MP2 (XI1_I1298_I99_XG_p1 I1_I1298_G3_2 I1_I1298_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I99_XG_MP0 (VDD I1_I1298_P3_2 XI1_I1298_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I99_XG_MP1 (XI1_I1298_I99_XG_p1 I1_I1298_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I120_XG_MP2 (XI1_I884_I120_XG_p1 I1_I884_G24_23 I1_I884_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I120_XG_MP0 (VDD I1_I884_P24_23 XI1_I884_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I120_XG_MP1 (XI1_I884_I120_XG_p1 I1_I884_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I118_XG_MP2 (XI1_I884_I118_XG_p1 I1_I884_G22_21 I1_I884_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I118_XG_MP0 (VDD I1_I884_P22_21 XI1_I884_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I118_XG_MP1 (XI1_I884_I118_XG_p1 I1_I884_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I176_XG_MP2 (XI1_I1390_I176_XG_p1 I1_I1390_G25_18 I1_I1390_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I176_XG_MP0 (VDD I1_I1390_P25_18 XI1_I1390_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I176_XG_MP1 (XI1_I1390_I176_XG_p1 I1_I1390_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I172_XG_MP2 (XI1_I1390_I172_XG_p1 I1_I1390_G21_14 I1_I1390_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I172_XG_MP0 (VDD I1_I1390_P21_14 XI1_I1390_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I172_XG_MP1 (XI1_I1390_I172_XG_p1 I1_I1390_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I121_XG_MP2 (XI1_I1160_I121_XG_p1 I1_I1160_G25_24 I1_I1160_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I121_XG_MP0 (VDD I1_I1160_P25_24 XI1_I1160_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I121_XG_MP1 (XI1_I1160_I121_XG_p1 I1_I1160_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I119_XG_MP2 (XI1_I1160_I119_XG_p1 I1_I1160_G23_22 I1_I1160_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I119_XG_MP0 (VDD I1_I1160_P23_22 XI1_I1160_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I119_XG_MP1 (XI1_I1160_I119_XG_p1 I1_I1160_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I176_XG_MP2 (XI1_I1436_I176_XG_p1 I1_I1436_G25_18 I1_I1436_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I176_XG_MP0 (VDD I1_I1436_P25_18 XI1_I1436_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I176_XG_MP1 (XI1_I1436_I176_XG_p1 I1_I1436_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I172_XG_MP2 (XI1_I1436_I172_XG_p1 I1_I1436_G21_14 I1_I1436_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I172_XG_MP0 (VDD I1_I1436_P21_14 XI1_I1436_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I172_XG_MP1 (XI1_I1436_I172_XG_p1 I1_I1436_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I179_XG_MP2 (XI1_I1022_I179_XG_p1 I1_I1022_G28_21 I1_I1022_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I179_XG_MP0 (VDD I1_I1022_P28_21 XI1_I1022_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I179_XG_MP1 (XI1_I1022_I179_XG_p1 I1_I1022_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I116_XG_MP2 (XI1_I1022_I116_XG_p1 I1_I1022_G20_19 I1_I1022_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I116_XG_MP0 (VDD I1_I1022_P20_19 XI1_I1022_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I116_XG_MP1 (XI1_I1022_I116_XG_p1 I1_I1022_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I125_XG_MP2 (XI1_I1712_I125_XG_p1 I1_I1712_G29_28 I1_I1712_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I125_XG_MP0 (VDD I1_I1712_P29_28 XI1_I1712_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I125_XG_MP1 (XI1_I1712_I125_XG_p1 I1_I1712_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I123_XG_MP2 (XI1_I1712_I123_XG_p1 I1_I1712_G27_26 I1_I1712_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I123_XG_MP0 (VDD I1_I1712_P27_26 XI1_I1712_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I123_XG_MP1 (XI1_I1712_I123_XG_p1 I1_I1712_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I114_XG_MP2 (XI1_I1712_I114_XG_p1 I1_I1712_G18_17 I1_I1712_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I114_XG_MP0 (VDD I1_I1712_P18_17 XI1_I1712_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I114_XG_MP1 (XI1_I1712_I114_XG_p1 I1_I1712_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I112_XG_MP2 (XI1_I1712_I112_XG_p1 I1_I1712_G16_15 I1_I1712_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I112_XG_MP0 (VDD I1_I1712_P16_15 XI1_I1712_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I112_XG_MP1 (XI1_I1712_I112_XG_p1 I1_I1712_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I110_XG_MP2 (XI1_I1712_I110_XG_p1 I1_I1712_G14_13 I1_I1712_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I110_XG_MP0 (VDD I1_I1712_P14_13 XI1_I1712_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I110_XG_MP1 (XI1_I1712_I110_XG_p1 I1_I1712_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I128_MP2 (XI2_I3_I128_p1 I2_I3_o3_2 I2_I3_q3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I128_MP0 (VDD I2_I3_SEL_AS_b3_0 XI2_I3_I128_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I128_MP1 (XI2_I3_I128_p1 I2_S_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I116_MP2 (XI2_I3_I116_p1 I2_I3_o2_2 I2_I3_q2_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I116_MP0 (VDD I2_I3_SEL_AS_b3_0 XI2_I3_I116_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I116_MP1 (XI2_I3_I116_p1 I2_S_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I123_XG_MP2 (XI1_I1850_I123_XG_p1 I1_I1850_G27_26 I1_I1850_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I123_XG_MP0 (VDD I1_I1850_P27_26 XI1_I1850_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I123_XG_MP1 (XI1_I1850_I123_XG_p1 I1_I1850_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I125_XG_MP2 (XI1_I1850_I125_XG_p1 I1_I1850_G29_28 I1_I1850_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I125_XG_MP0 (VDD I1_I1850_P29_28 XI1_I1850_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I125_XG_MP1 (XI1_I1850_I125_XG_p1 I1_I1850_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I198_XG_MP2 (VDD I1_I838_G27_12n I1_I838_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I838_I198_XG_MP0 (XI1_I838_I198_XG_p1 I1_I838_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I838_I198_XG_MP1 (I1_I838_G27_0 I1_I838_G11_0n XI1_I838_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I148_XG_MP2 (VDD I1_I838_G23_20n I1_I838_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I838_I148_XG_MP0 (XI1_I838_I148_XG_p1 I1_I838_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I838_I148_XG_MP1 (I1_I838_G23_16 I1_I838_G19_16n XI1_I838_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I148_XG_MP2 (VDD I1_I1160_G23_20n I1_I1160_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1160_I148_XG_MP0 (XI1_I1160_I148_XG_p1 I1_I1160_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1160_I148_XG_MP1 (I1_I1160_G23_16 I1_I1160_G19_16n XI1_I1160_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I150_XG_MP2 (VDD I1_I1160_G25_22n I1_I1160_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1160_I150_XG_MP0 (XI1_I1160_I150_XG_p1 I1_I1160_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1160_I150_XG_MP1 (I1_I1160_G25_18 I1_I1160_G21_18n XI1_I1160_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I87_XG_MP2 (VDD I1_I930_gn21 I1_I930_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I930_I87_XG_MP0 (XI1_I930_I87_XG_p1 I1_I930_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I930_I87_XG_MP1 (I1_I930_G21_20 I1_I930_gn20 XI1_I930_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I86_XG_MP2 (VDD I1_I930_gn20 I1_I930_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I930_I86_XG_MP0 (XI1_I930_I86_XG_p1 I1_I930_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I930_I86_XG_MP1 (I1_I930_G20_19 I1_I930_gn19 XI1_I930_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I151_XG_MP2 (VDD I1_I1160_G26_23n I1_I1160_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1160_I151_XG_MP0 (XI1_I1160_I151_XG_p1 I1_I1160_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1160_I151_XG_MP1 (I1_I1160_G26_19 I1_I1160_G22_19n XI1_I1160_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I147_XG_MP2 (VDD I1_I1160_G22_19n I1_I1160_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1160_I147_XG_MP0 (XI1_I1160_I147_XG_p1 I1_I1160_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1160_I147_XG_MP1 (I1_I1160_G22_15 I1_I1160_G18_15n XI1_I1160_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I197_XG_MP2 (VDD I1_I930_G26_11n I1_I930_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I930_I197_XG_MP0 (XI1_I930_I197_XG_p1 I1_I930_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I930_I197_XG_MP1 (I1_I930_G26_0 I1_I930_G10_0n XI1_I930_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I149_XG_MP2 (VDD I1_I930_G24_21n I1_I930_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I930_I149_XG_MP0 (XI1_I930_I149_XG_p1 I1_I930_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I930_I149_XG_MP1 (I1_I930_G24_17 I1_I930_G20_17n XI1_I930_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I145_XG_MP2 (VDD I1_I930_G20_17n I1_I930_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I930_I145_XG_MP0 (XI1_I930_I145_XG_p1 I1_I930_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I930_I145_XG_MP1 (I1_I930_G20_13 I1_I930_G16_13n XI1_I930_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I200_XG_MP2 (VDD I1_I1482_G29_14n I1_I1482_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1482_I200_XG_MP0 (XI1_I1482_I200_XG_p1 I1_I1482_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1482_I200_XG_MP1 (I1_I1482_G29_0 I1_I1482_G13_0n XI1_I1482_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I198_XG_MP2 (VDD I1_I1482_G27_12n I1_I1482_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1482_I198_XG_MP0 (XI1_I1482_I198_XG_p1 I1_I1482_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1482_I198_XG_MP1 (I1_I1482_G27_0 I1_I1482_G11_0n XI1_I1482_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I151_XG_MP2 (VDD I1_I1482_G26_23n I1_I1482_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1482_I151_XG_MP0 (XI1_I1482_I151_XG_p1 I1_I1482_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1482_I151_XG_MP1 (I1_I1482_G26_19 I1_I1482_G22_19n XI1_I1482_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I147_XG_MP2 (VDD I1_I1482_G22_19n I1_I1482_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1482_I147_XG_MP0 (XI1_I1482_I147_XG_p1 I1_I1482_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1482_I147_XG_MP1 (I1_I1482_G22_15 I1_I1482_G18_15n XI1_I1482_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I85_XG_MP2 (VDD I1_I1574_gn19 I1_I1574_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1574_I85_XG_MP0 (XI1_I1574_I85_XG_p1 I1_I1574_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1574_I85_XG_MP1 (I1_I1574_G19_18 I1_I1574_gn18 XI1_I1574_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I84_XG_MP2 (VDD I1_I1574_gn18 I1_I1574_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1574_I84_XG_MP0 (XI1_I1574_I84_XG_p1 I1_I1574_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1574_I84_XG_MP1 (I1_I1574_G18_17 I1_I1574_gn17 XI1_I1574_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I88_XG_MP2 (VDD I1_I1804_gn22 I1_I1804_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1804_I88_XG_MP0 (XI1_I1804_I88_XG_p1 I1_I1804_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1804_I88_XG_MP1 (I1_I1804_G22_21 I1_I1804_gn21 XI1_I1804_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I87_XG_MP2 (VDD I1_I1804_gn21 I1_I1804_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1804_I87_XG_MP0 (XI1_I1804_I87_XG_p1 I1_I1804_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1804_I87_XG_MP1 (I1_I1804_G21_20 I1_I1804_gn20 XI1_I1804_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I135_XG_MP2 (VDD I1_I1804_G10_7n I1_I1804_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1804_I135_XG_MP0 (XI1_I1804_I135_XG_p1 I1_I1804_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1804_I135_XG_MP1 (I1_I1804_G10_3 I1_I1804_G6_3n XI1_I1804_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I183_XG_MP2 (VDD I1_I1804_G16_1n I1_I1804_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1804_I183_XG_MP0 (XI1_I1804_I183_XG_p1 I1_I1804_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1804_I183_XG_MP1 (I1_I1804_G16_0 I1_I1804_G0_0n XI1_I1804_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I94_XG_MP2 (VDD I1_I1298_gn28 I1_I1298_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1298_I94_XG_MP0 (XI1_I1298_I94_XG_p1 I1_I1298_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1298_I94_XG_MP1 (I1_I1298_G28_27 I1_I1298_gn27 XI1_I1298_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I93_XG_MP2 (VDD I1_I1298_gn27 I1_I1298_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1298_I93_XG_MP0 (XI1_I1298_I93_XG_p1 I1_I1298_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1298_I93_XG_MP1 (I1_I1298_G27_26 I1_I1298_gn26 XI1_I1298_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I151_XG_MP2 (VDD I1_I1344_G26_23n I1_I1344_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1344_I151_XG_MP0 (XI1_I1344_I151_XG_p1 I1_I1344_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1344_I151_XG_MP1 (I1_I1344_G26_19 I1_I1344_G22_19n XI1_I1344_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I153_XG_MP2 (VDD I1_I1344_G28_25n I1_I1344_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1344_I153_XG_MP0 (XI1_I1344_I153_XG_p1 I1_I1344_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1344_I153_XG_MP1 (I1_I1344_G28_21 I1_I1344_G24_21n XI1_I1344_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I144_XG_MP2 (VDD I1_I1160_G19_16n I1_I1160_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1160_I144_XG_MP0 (XI1_I1160_I144_XG_p1 I1_I1160_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1160_I144_XG_MP1 (I1_I1160_G19_12 I1_I1160_G15_12n XI1_I1160_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
