    I_MXI1_I1206_I45_MP5 (I1_I1206_pn13 I1_b14_13 XI1_I1206_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I45_MP4 (XI1_I1206_I45_p1 XI1_I1206_I45_An I1_I1206_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I45_MP2 (VDD I1_p13_12 XI1_I1206_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I45_MP3 (XI1_I1206_I45_p1 XI1_I1206_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I45_MP0 (VDD I1_p13_12 XI1_I1206_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I211_MP1 (VDD I1_I1206_G7_0 XI1_I1206_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I211_MP5 (I1_p14_8 I1_I1206_G7_0 XI1_I1206_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I211_MP4 (XI1_I1206_I211_p1 XI1_I1206_I211_An I1_p14_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I211_MP2 (VDD I1_I1206_pn8 XI1_I1206_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I211_MP3 (XI1_I1206_I211_p1 XI1_I1206_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I211_MP0 (VDD I1_I1206_pn8 XI1_I1206_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I210_MP1 (VDD I1_I1206_G6_0 XI1_I1206_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I210_MP5 (I1_p14_7 I1_I1206_G6_0 XI1_I1206_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I210_MP4 (XI1_I1206_I210_p1 XI1_I1206_I210_An I1_p14_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I210_MP2 (VDD I1_I1206_pn7 XI1_I1206_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I210_MP3 (XI1_I1206_I210_p1 XI1_I1206_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I210_MP0 (VDD I1_I1206_pn7 XI1_I1206_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I62_MP1 (VDD I1_b7_30 XI1_I884_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I62_MP5 (I1_I884_pn30 I1_b7_30 XI1_I884_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I62_MP4 (XI1_I884_I62_p1 XI1_I884_I62_An I1_I884_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I62_MP2 (VDD I1_p6_29 XI1_I884_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I62_MP3 (XI1_I884_I62_p1 XI1_I884_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I62_MP0 (VDD I1_p6_29 XI1_I884_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I231_MP1 (VDD I1_I884_G27_0 XI1_I884_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I231_MP5 (I1_p7_28 I1_I884_G27_0 XI1_I884_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I231_MP4 (XI1_I884_I231_p1 XI1_I884_I231_An I1_p7_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I231_MP2 (VDD I1_I884_pn28 XI1_I884_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I231_MP3 (XI1_I884_I231_p1 XI1_I884_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I231_MP0 (VDD I1_I884_pn28 XI1_I884_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I40_MP1 (VDD I1_b7_8 XI1_I884_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I40_MP5 (I1_I884_pn8 I1_b7_8 XI1_I884_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I40_MP4 (XI1_I884_I40_p1 XI1_I884_I40_An I1_I884_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I40_MP2 (VDD I1_p6_7 XI1_I884_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I40_MP3 (XI1_I884_I40_p1 XI1_I884_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I40_MP0 (VDD I1_p6_7 XI1_I884_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I39_MP1 (VDD I1_b7_7 XI1_I884_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I39_MP5 (I1_I884_pn7 I1_b7_7 XI1_I884_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I39_MP4 (XI1_I884_I39_p1 XI1_I884_I39_An I1_I884_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I39_MP2 (VDD I1_p6_6 XI1_I884_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I39_MP3 (XI1_I884_I39_p1 XI1_I884_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I39_MP0 (VDD I1_p6_6 XI1_I884_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I205_MP1 (VDD I1_I838_G1_0 XI1_I838_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I205_MP5 (I1_p6_2 I1_I838_G1_0 XI1_I838_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I205_MP4 (XI1_I838_I205_p1 XI1_I838_I205_An I1_p6_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I205_MP2 (VDD I1_I838_pn2 XI1_I838_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I205_MP3 (XI1_I838_I205_p1 XI1_I838_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I205_MP0 (VDD I1_I838_pn2 XI1_I838_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I34_MP1 (VDD I1_b6_2 XI1_I838_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I34_MP5 (I1_I838_pn2 I1_b6_2 XI1_I838_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I34_MP4 (XI1_I838_I34_p1 XI1_I838_I34_An I1_I838_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I34_MP2 (VDD I1_p5_1 XI1_I838_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I34_MP3 (XI1_I838_I34_p1 XI1_I838_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I34_MP0 (VDD I1_p5_1 XI1_I838_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I36_MP1 (VDD I1_b5_4 XI1_I792_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I36_MP5 (I1_I792_pn4 I1_b5_4 XI1_I792_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I36_MP4 (XI1_I792_I36_p1 XI1_I792_I36_An I1_I792_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I36_MP2 (VDD I1_p4_3 XI1_I792_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I36_MP3 (XI1_I792_I36_p1 XI1_I792_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I36_MP0 (VDD I1_p4_3 XI1_I792_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I44_MP1 (VDD I1_b4_12 XI1_I746_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I44_MP5 (I1_I746_pn12 I1_b4_12 XI1_I746_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I44_MP4 (XI1_I746_I44_p1 XI1_I746_I44_An I1_I746_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I44_MP2 (VDD I1_p3_11 XI1_I746_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I44_MP3 (XI1_I746_I44_p1 XI1_I746_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I44_MP0 (VDD I1_p3_11 XI1_I746_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I46_MP1 (VDD I1_b4_14 XI1_I746_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I46_MP5 (I1_I746_pn14 I1_b4_14 XI1_I746_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I46_MP4 (XI1_I746_I46_p1 XI1_I746_I46_An I1_I746_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I46_MP2 (VDD I1_p3_13 XI1_I746_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I46_MP3 (XI1_I746_I46_p1 XI1_I746_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I46_MP0 (VDD I1_p3_13 XI1_I746_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I48_MP1 (VDD I1_b4_16 XI1_I746_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I48_MP5 (I1_I746_pn16 I1_b4_16 XI1_I746_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I48_MP4 (XI1_I746_I48_p1 XI1_I746_I48_An I1_I746_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I48_MP2 (VDD I1_p3_15 XI1_I746_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I48_MP3 (XI1_I746_I48_p1 XI1_I746_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I48_MP0 (VDD I1_p3_15 XI1_I746_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I50_MP1 (VDD I1_b4_18 XI1_I746_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I50_MP5 (I1_I746_pn18 I1_b4_18 XI1_I746_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I50_MP4 (XI1_I746_I50_p1 XI1_I746_I50_An I1_I746_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I50_MP2 (VDD I1_p3_17 XI1_I746_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I50_MP3 (XI1_I746_I50_p1 XI1_I746_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I50_MP0 (VDD I1_p3_17 XI1_I746_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I52_MP1 (VDD I1_b4_20 XI1_I746_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I52_MP5 (I1_I746_pn20 I1_b4_20 XI1_I746_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I52_MP4 (XI1_I746_I52_p1 XI1_I746_I52_An I1_I746_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I52_MP2 (VDD I1_p3_19 XI1_I746_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I52_MP3 (XI1_I746_I52_p1 XI1_I746_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I52_MP0 (VDD I1_p3_19 XI1_I746_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I54_MP1 (VDD I1_b4_22 XI1_I746_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I54_MP5 (I1_I746_pn22 I1_b4_22 XI1_I746_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I54_MP4 (XI1_I746_I54_p1 XI1_I746_I54_An I1_I746_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I54_MP2 (VDD I1_p3_21 XI1_I746_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I54_MP3 (XI1_I746_I54_p1 XI1_I746_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I54_MP0 (VDD I1_p3_21 XI1_I746_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I62_MP1 (VDD I1_b18_30 XI1_I1390_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I62_MP5 (I1_I1390_pn30 I1_b18_30 XI1_I1390_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I62_MP4 (XI1_I1390_I62_p1 XI1_I1390_I62_An I1_I1390_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I62_MP2 (VDD I1_p17_29 XI1_I1390_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I62_MP3 (XI1_I1390_I62_p1 XI1_I1390_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I62_MP0 (VDD I1_p17_29 XI1_I1390_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I55_MP1 (VDD I1_b18_23 XI1_I1390_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I55_MP5 (I1_I1390_pn23 I1_b18_23 XI1_I1390_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I55_MP4 (XI1_I1390_I55_p1 XI1_I1390_I55_An I1_I1390_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I55_MP2 (VDD I1_p17_22 XI1_I1390_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I55_MP3 (XI1_I1390_I55_p1 XI1_I1390_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I55_MP0 (VDD I1_p17_22 XI1_I1390_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I50_MP1 (VDD I1_b18_18 XI1_I1390_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I50_MP5 (I1_I1390_pn18 I1_b18_18 XI1_I1390_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I50_MP4 (XI1_I1390_I50_p1 XI1_I1390_I50_An I1_I1390_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I50_MP2 (VDD I1_p17_17 XI1_I1390_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I50_MP3 (XI1_I1390_I50_p1 XI1_I1390_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I50_MP0 (VDD I1_p17_17 XI1_I1390_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I49_MP1 (VDD I1_b18_17 XI1_I1390_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I49_MP5 (I1_I1390_pn17 I1_b18_17 XI1_I1390_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I49_MP4 (XI1_I1390_I49_p1 XI1_I1390_I49_An I1_I1390_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I49_MP2 (VDD I1_p17_16 XI1_I1390_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I49_MP3 (XI1_I1390_I49_p1 XI1_I1390_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I49_MP0 (VDD I1_p17_16 XI1_I1390_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I210_MP1 (VDD I1_I1344_G6_0 XI1_I1344_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I210_MP5 (I1_p17_7 I1_I1344_G6_0 XI1_I1344_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I210_MP4 (XI1_I1344_I210_p1 XI1_I1344_I210_An I1_p17_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I210_MP2 (VDD I1_I1344_pn7 XI1_I1344_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I210_MP3 (XI1_I1344_I210_p1 XI1_I1344_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I210_MP0 (VDD I1_I1344_pn7 XI1_I1344_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I39_MP1 (VDD I1_b17_7 XI1_I1344_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I39_MP5 (I1_I1344_pn7 I1_b17_7 XI1_I1344_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I39_MP4 (XI1_I1344_I39_p1 XI1_I1344_I39_An I1_I1344_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I39_MP2 (VDD I1_p16_6 XI1_I1344_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I39_MP3 (XI1_I1344_I39_p1 XI1_I1344_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I39_MP0 (VDD I1_p16_6 XI1_I1344_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I209_MP1 (VDD I1_I1298_G5_0 XI1_I1298_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I209_MP5 (I1_p16_6 I1_I1298_G5_0 XI1_I1298_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I209_MP4 (XI1_I1298_I209_p1 XI1_I1298_I209_An I1_p16_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I209_MP2 (VDD I1_I1298_pn6 XI1_I1298_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I209_MP3 (XI1_I1298_I209_p1 XI1_I1298_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I209_MP0 (VDD I1_I1298_pn6 XI1_I1298_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I40_MP1 (VDD I1_b16_8 XI1_I1298_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I40_MP5 (I1_I1298_pn8 I1_b16_8 XI1_I1298_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I40_MP4 (XI1_I1298_I40_p1 XI1_I1298_I40_An I1_I1298_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I40_MP2 (VDD I1_p15_7 XI1_I1298_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I40_MP3 (XI1_I1298_I40_p1 XI1_I1298_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I40_MP0 (VDD I1_p15_7 XI1_I1298_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I209_MP1 (VDD I1_I1252_G5_0 XI1_I1252_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I209_MP5 (I1_p15_6 I1_I1252_G5_0 XI1_I1252_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I209_MP4 (XI1_I1252_I209_p1 XI1_I1252_I209_An I1_p15_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I209_MP2 (VDD I1_I1252_pn6 XI1_I1252_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I209_MP3 (XI1_I1252_I209_p1 XI1_I1252_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I209_MP0 (VDD I1_I1252_pn6 XI1_I1252_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I39_MP1 (VDD I1_b15_7 XI1_I1252_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I39_MP5 (I1_I1252_pn7 I1_b15_7 XI1_I1252_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I39_MP4 (XI1_I1252_I39_p1 XI1_I1252_I39_An I1_I1252_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I39_MP2 (VDD I1_p14_6 XI1_I1252_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I39_MP3 (XI1_I1252_I39_p1 XI1_I1252_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I39_MP0 (VDD I1_p14_6 XI1_I1252_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I40_MP1 (VDD I1_b15_8 XI1_I1252_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I40_MP5 (I1_I1252_pn8 I1_b15_8 XI1_I1252_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I40_MP4 (XI1_I1252_I40_p1 XI1_I1252_I40_An I1_I1252_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I40_MP2 (VDD I1_p14_7 XI1_I1252_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I40_MP3 (XI1_I1252_I40_p1 XI1_I1252_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I40_MP0 (VDD I1_p14_7 XI1_I1252_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I42_MP1 (VDD I1_b15_10 XI1_I1252_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I42_MP5 (I1_I1252_pn10 I1_b15_10 XI1_I1252_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I42_MP4 (XI1_I1252_I42_p1 XI1_I1252_I42_An I1_I1252_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I42_MP2 (VDD I1_p14_9 XI1_I1252_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I42_MP3 (XI1_I1252_I42_p1 XI1_I1252_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I42_MP0 (VDD I1_p14_9 XI1_I1252_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I44_MP1 (VDD I1_b14_12 XI1_I1206_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I44_MP5 (I1_I1206_pn12 I1_b14_12 XI1_I1206_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I44_MP4 (XI1_I1206_I44_p1 XI1_I1206_I44_An I1_I1206_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I44_MP2 (VDD I1_p13_11 XI1_I1206_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I44_MP3 (XI1_I1206_I44_p1 XI1_I1206_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I44_MP0 (VDD I1_p13_11 XI1_I1206_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I42_MP1 (VDD I1_b14_10 XI1_I1206_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I42_MP5 (I1_I1206_pn10 I1_b14_10 XI1_I1206_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I42_MP4 (XI1_I1206_I42_p1 XI1_I1206_I42_An I1_I1206_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I42_MP2 (VDD I1_p13_9 XI1_I1206_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I42_MP3 (XI1_I1206_I42_p1 XI1_I1206_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I42_MP0 (VDD I1_p13_9 XI1_I1206_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I43_MP1 (VDD I1_b14_11 XI1_I1206_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I43_MP5 (I1_I1206_pn11 I1_b14_11 XI1_I1206_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I43_MP4 (XI1_I1206_I43_p1 XI1_I1206_I43_An I1_I1206_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I43_MP2 (VDD I1_p13_10 XI1_I1206_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I43_MP3 (XI1_I1206_I43_p1 XI1_I1206_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I43_MP0 (VDD I1_p13_10 XI1_I1206_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I41_MP1 (VDD I1_b14_9 XI1_I1206_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I41_MP5 (I1_I1206_pn9 I1_b14_9 XI1_I1206_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I41_MP4 (XI1_I1206_I41_p1 XI1_I1206_I41_An I1_I1206_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I41_MP2 (VDD I1_p13_8 XI1_I1206_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I41_MP3 (XI1_I1206_I41_p1 XI1_I1206_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I41_MP0 (VDD I1_p13_8 XI1_I1206_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I209_MP1 (VDD I1_I1206_G5_0 XI1_I1206_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I209_MP5 (I1_p14_6 I1_I1206_G5_0 XI1_I1206_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I209_MP4 (XI1_I1206_I209_p1 XI1_I1206_I209_An I1_p14_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I209_MP2 (VDD I1_I1206_pn6 XI1_I1206_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I209_MP3 (XI1_I1206_I209_p1 XI1_I1206_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I209_MP0 (VDD I1_I1206_pn6 XI1_I1206_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I229_MP1 (VDD I1_I884_G25_0 XI1_I884_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I229_MP5 (I1_p7_26 I1_I884_G25_0 XI1_I884_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I229_MP4 (XI1_I884_I229_p1 XI1_I884_I229_An I1_p7_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I229_MP2 (VDD I1_I884_pn26 XI1_I884_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I229_MP3 (XI1_I884_I229_p1 XI1_I884_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I229_MP0 (VDD I1_I884_pn26 XI1_I884_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I227_MP1 (VDD I1_I884_G23_0 XI1_I884_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I227_MP5 (I1_p7_24 I1_I884_G23_0 XI1_I884_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I227_MP4 (XI1_I884_I227_p1 XI1_I884_I227_An I1_p7_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I227_MP2 (VDD I1_I884_pn24 XI1_I884_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I227_MP3 (XI1_I884_I227_p1 XI1_I884_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I227_MP0 (VDD I1_I884_pn24 XI1_I884_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I225_MP1 (VDD I1_I884_G21_0 XI1_I884_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I225_MP5 (I1_p7_22 I1_I884_G21_0 XI1_I884_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I225_MP4 (XI1_I884_I225_p1 XI1_I884_I225_An I1_p7_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I225_MP2 (VDD I1_I884_pn22 XI1_I884_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I225_MP3 (XI1_I884_I225_p1 XI1_I884_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I225_MP0 (VDD I1_I884_pn22 XI1_I884_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I223_MP1 (VDD I1_I884_G19_0 XI1_I884_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I223_MP5 (I1_p7_20 I1_I884_G19_0 XI1_I884_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I223_MP4 (XI1_I884_I223_p1 XI1_I884_I223_An I1_p7_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I223_MP2 (VDD I1_I884_pn20 XI1_I884_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I223_MP3 (XI1_I884_I223_p1 XI1_I884_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I223_MP0 (VDD I1_I884_pn20 XI1_I884_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I221_MP1 (VDD I1_I884_G17_0 XI1_I884_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I221_MP5 (I1_p7_18 I1_I884_G17_0 XI1_I884_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I221_MP4 (XI1_I884_I221_p1 XI1_I884_I221_An I1_p7_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I221_MP2 (VDD I1_I884_pn18 XI1_I884_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I221_MP3 (XI1_I884_I221_p1 XI1_I884_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I221_MP0 (VDD I1_I884_pn18 XI1_I884_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I38_MP1 (VDD I1_b7_6 XI1_I884_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I38_MP5 (I1_I884_pn6 I1_b7_6 XI1_I884_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I38_MP4 (XI1_I884_I38_p1 XI1_I884_I38_An I1_I884_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I38_MP2 (VDD I1_p6_5 XI1_I884_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I38_MP3 (XI1_I884_I38_p1 XI1_I884_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I38_MP0 (VDD I1_p6_5 XI1_I884_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I37_MP1 (VDD I1_b7_5 XI1_I884_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I37_MP5 (I1_I884_pn5 I1_b7_5 XI1_I884_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I37_MP4 (XI1_I884_I37_p1 XI1_I884_I37_An I1_I884_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I37_MP2 (VDD I1_p6_4 XI1_I884_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I37_MP3 (XI1_I884_I37_p1 XI1_I884_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I37_MP0 (VDD I1_p6_4 XI1_I884_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I35_MP1 (VDD I1_b5_3 XI1_I792_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I35_MP5 (I1_I792_pn3 I1_b5_3 XI1_I792_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I35_MP4 (XI1_I792_I35_p1 XI1_I792_I35_An I1_I792_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I35_MP2 (VDD I1_p4_2 XI1_I792_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I35_MP3 (XI1_I792_I35_p1 XI1_I792_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I35_MP0 (VDD I1_p4_2 XI1_I792_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I204_MP1 (VDD I1_I792_G0_0 XI1_I792_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I204_MP5 (I1_p5_1 I1_I792_G0_0 XI1_I792_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I204_MP4 (XI1_I792_I204_p1 XI1_I792_I204_An I1_p5_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I204_MP2 (VDD I1_I792_pn1 XI1_I792_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I204_MP3 (XI1_I792_I204_p1 XI1_I792_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I204_MP0 (VDD I1_I792_pn1 XI1_I792_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I205_MP1 (VDD I1_I746_G1_0 XI1_I746_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I205_MP5 (I1_p4_2 I1_I746_G1_0 XI1_I746_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I205_MP4 (XI1_I746_I205_p1 XI1_I746_I205_An I1_p4_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I205_MP2 (VDD I1_I746_pn2 XI1_I746_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I205_MP3 (XI1_I746_I205_p1 XI1_I746_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I205_MP0 (VDD I1_I746_pn2 XI1_I746_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I38_MP1 (VDD I1_b4_6 XI1_I746_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I38_MP5 (I1_I746_pn6 I1_b4_6 XI1_I746_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I38_MP4 (XI1_I746_I38_p1 XI1_I746_I38_An I1_I746_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I38_MP2 (VDD I1_p3_5 XI1_I746_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I38_MP3 (XI1_I746_I38_p1 XI1_I746_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I38_MP0 (VDD I1_p3_5 XI1_I746_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I40_MP1 (VDD I1_b4_8 XI1_I746_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I40_MP5 (I1_I746_pn8 I1_b4_8 XI1_I746_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I40_MP4 (XI1_I746_I40_p1 XI1_I746_I40_An I1_I746_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I40_MP2 (VDD I1_p3_7 XI1_I746_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I40_MP3 (XI1_I746_I40_p1 XI1_I746_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I40_MP0 (VDD I1_p3_7 XI1_I746_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I42_MP1 (VDD I1_b4_10 XI1_I746_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I42_MP5 (I1_I746_pn10 I1_b4_10 XI1_I746_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I42_MP4 (XI1_I746_I42_p1 XI1_I746_I42_An I1_I746_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I42_MP2 (VDD I1_p3_9 XI1_I746_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I42_MP3 (XI1_I746_I42_p1 XI1_I746_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I42_MP0 (VDD I1_p3_9 XI1_I746_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I45_MP1 (VDD I1_b4_13 XI1_I746_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I45_MP5 (I1_I746_pn13 I1_b4_13 XI1_I746_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I45_MP4 (XI1_I746_I45_p1 XI1_I746_I45_An I1_I746_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I45_MP2 (VDD I1_p3_12 XI1_I746_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I45_MP3 (XI1_I746_I45_p1 XI1_I746_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I45_MP0 (VDD I1_p3_12 XI1_I746_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I47_MP1 (VDD I1_b4_15 XI1_I746_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I47_MP5 (I1_I746_pn15 I1_b4_15 XI1_I746_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I47_MP4 (XI1_I746_I47_p1 XI1_I746_I47_An I1_I746_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I47_MP2 (VDD I1_p3_14 XI1_I746_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I47_MP3 (XI1_I746_I47_p1 XI1_I746_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I47_MP0 (VDD I1_p3_14 XI1_I746_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I49_MP1 (VDD I1_b4_17 XI1_I746_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I49_MP5 (I1_I746_pn17 I1_b4_17 XI1_I746_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I49_MP4 (XI1_I746_I49_p1 XI1_I746_I49_An I1_I746_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I49_MP2 (VDD I1_p3_16 XI1_I746_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I49_MP3 (XI1_I746_I49_p1 XI1_I746_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I49_MP0 (VDD I1_p3_16 XI1_I746_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I51_MP1 (VDD I1_b4_19 XI1_I746_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I51_MP5 (I1_I746_pn19 I1_b4_19 XI1_I746_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I51_MP4 (XI1_I746_I51_p1 XI1_I746_I51_An I1_I746_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I51_MP2 (VDD I1_p3_18 XI1_I746_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I51_MP3 (XI1_I746_I51_p1 XI1_I746_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I51_MP0 (VDD I1_p3_18 XI1_I746_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I223_MP1 (VDD I1_I700_G19_0 XI1_I700_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I223_MP5 (I1_p3_20 I1_I700_G19_0 XI1_I700_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I223_MP4 (XI1_I700_I223_p1 XI1_I700_I223_An I1_p3_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I223_MP2 (VDD I1_I700_pn20 XI1_I700_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I223_MP3 (XI1_I700_I223_p1 XI1_I700_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I223_MP0 (VDD I1_I700_pn20 XI1_I700_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I225_MP1 (VDD I1_I700_G21_0 XI1_I700_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I225_MP5 (I1_p3_22 I1_I700_G21_0 XI1_I700_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I225_MP4 (XI1_I700_I225_p1 XI1_I700_I225_An I1_p3_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I225_MP2 (VDD I1_I700_pn22 XI1_I700_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I225_MP3 (XI1_I700_I225_p1 XI1_I700_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I225_MP0 (VDD I1_I700_pn22 XI1_I700_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I227_MP1 (VDD I1_I700_G23_0 XI1_I700_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I227_MP5 (I1_p3_24 I1_I700_G23_0 XI1_I700_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I227_MP4 (XI1_I700_I227_p1 XI1_I700_I227_An I1_p3_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I227_MP2 (VDD I1_I700_pn24 XI1_I700_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I227_MP3 (XI1_I700_I227_p1 XI1_I700_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I227_MP0 (VDD I1_I700_pn24 XI1_I700_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I229_MP1 (VDD I1_I700_G25_0 XI1_I700_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I229_MP5 (I1_p3_26 I1_I700_G25_0 XI1_I700_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I229_MP4 (XI1_I700_I229_p1 XI1_I700_I229_An I1_p3_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I229_MP2 (VDD I1_I700_pn26 XI1_I700_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I229_MP3 (XI1_I700_I229_p1 XI1_I700_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I229_MP0 (VDD I1_I700_pn26 XI1_I700_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I53_MP1 (VDD I1_b18_21 XI1_I1390_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I53_MP5 (I1_I1390_pn21 I1_b18_21 XI1_I1390_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I53_MP4 (XI1_I1390_I53_p1 XI1_I1390_I53_An I1_I1390_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I53_MP2 (VDD I1_p17_20 XI1_I1390_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I53_MP3 (XI1_I1390_I53_p1 XI1_I1390_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I53_MP0 (VDD I1_p17_20 XI1_I1390_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I51_MP1 (VDD I1_b18_19 XI1_I1390_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I51_MP5 (I1_I1390_pn19 I1_b18_19 XI1_I1390_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I51_MP4 (XI1_I1390_I51_p1 XI1_I1390_I51_An I1_I1390_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I51_MP2 (VDD I1_p17_18 XI1_I1390_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I51_MP3 (XI1_I1390_I51_p1 XI1_I1390_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I51_MP0 (VDD I1_p17_18 XI1_I1390_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I48_MP1 (VDD I1_b18_16 XI1_I1390_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I48_MP5 (I1_I1390_pn16 I1_b18_16 XI1_I1390_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I48_MP4 (XI1_I1390_I48_p1 XI1_I1390_I48_An I1_I1390_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I48_MP2 (VDD I1_p17_15 XI1_I1390_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I48_MP3 (XI1_I1390_I48_p1 XI1_I1390_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I48_MP0 (VDD I1_p17_15 XI1_I1390_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I47_MP1 (VDD I1_b18_15 XI1_I1390_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I47_MP5 (I1_I1390_pn15 I1_b18_15 XI1_I1390_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I47_MP4 (XI1_I1390_I47_p1 XI1_I1390_I47_An I1_I1390_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I47_MP2 (VDD I1_p17_14 XI1_I1390_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I47_MP3 (XI1_I1390_I47_p1 XI1_I1390_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I47_MP0 (VDD I1_p17_14 XI1_I1390_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I45_MP1 (VDD I1_b18_13 XI1_I1390_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I45_MP5 (I1_I1390_pn13 I1_b18_13 XI1_I1390_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I45_MP4 (XI1_I1390_I45_p1 XI1_I1390_I45_An I1_I1390_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I45_MP2 (VDD I1_p17_12 XI1_I1390_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I45_MP3 (XI1_I1390_I45_p1 XI1_I1390_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I45_MP0 (VDD I1_p17_12 XI1_I1390_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I209_MP1 (VDD I1_I1344_G5_0 XI1_I1344_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I209_MP5 (I1_p17_6 I1_I1344_G5_0 XI1_I1344_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I209_MP4 (XI1_I1344_I209_p1 XI1_I1344_I209_An I1_p17_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I209_MP2 (VDD I1_I1344_pn6 XI1_I1344_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I209_MP3 (XI1_I1344_I209_p1 XI1_I1344_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I209_MP0 (VDD I1_I1344_pn6 XI1_I1344_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I208_MP1 (VDD I1_I1344_G4_0 XI1_I1344_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I208_MP5 (I1_p17_5 I1_I1344_G4_0 XI1_I1344_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I208_MP4 (XI1_I1344_I208_p1 XI1_I1344_I208_An I1_p17_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I208_MP2 (VDD I1_I1344_pn5 XI1_I1344_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I208_MP3 (XI1_I1344_I208_p1 XI1_I1344_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I208_MP0 (VDD I1_I1344_pn5 XI1_I1344_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I38_MP1 (VDD I1_b17_6 XI1_I1344_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I38_MP5 (I1_I1344_pn6 I1_b17_6 XI1_I1344_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I38_MP4 (XI1_I1344_I38_p1 XI1_I1344_I38_An I1_I1344_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I38_MP2 (VDD I1_p16_5 XI1_I1344_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I38_MP3 (XI1_I1344_I38_p1 XI1_I1344_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I38_MP0 (VDD I1_p16_5 XI1_I1344_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I37_MP1 (VDD I1_b17_5 XI1_I1344_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I37_MP5 (I1_I1344_pn5 I1_b17_5 XI1_I1344_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I37_MP4 (XI1_I1344_I37_p1 XI1_I1344_I37_An I1_I1344_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I37_MP2 (VDD I1_p16_4 XI1_I1344_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I37_MP3 (XI1_I1344_I37_p1 XI1_I1344_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I37_MP0 (VDD I1_p16_4 XI1_I1344_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I208_MP1 (VDD I1_I1298_G4_0 XI1_I1298_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I208_MP5 (I1_p16_5 I1_I1298_G4_0 XI1_I1298_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I208_MP4 (XI1_I1298_I208_p1 XI1_I1298_I208_An I1_p16_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I208_MP2 (VDD I1_I1298_pn5 XI1_I1298_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I208_MP3 (XI1_I1298_I208_p1 XI1_I1298_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I208_MP0 (VDD I1_I1298_pn5 XI1_I1298_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I38_MP1 (VDD I1_b16_6 XI1_I1298_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I38_MP5 (I1_I1298_pn6 I1_b16_6 XI1_I1298_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I38_MP4 (XI1_I1298_I38_p1 XI1_I1298_I38_An I1_I1298_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I38_MP2 (VDD I1_p15_5 XI1_I1298_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I38_MP3 (XI1_I1298_I38_p1 XI1_I1298_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I38_MP0 (VDD I1_p15_5 XI1_I1298_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I39_MP1 (VDD I1_b16_7 XI1_I1298_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I39_MP5 (I1_I1298_pn7 I1_b16_7 XI1_I1298_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I39_MP4 (XI1_I1298_I39_p1 XI1_I1298_I39_An I1_I1298_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I39_MP2 (VDD I1_p15_6 XI1_I1298_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I39_MP3 (XI1_I1298_I39_p1 XI1_I1298_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I39_MP0 (VDD I1_p15_6 XI1_I1298_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I37_MP1 (VDD I1_b16_5 XI1_I1298_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I37_MP5 (I1_I1298_pn5 I1_b16_5 XI1_I1298_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I37_MP4 (XI1_I1298_I37_p1 XI1_I1298_I37_An I1_I1298_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I37_MP2 (VDD I1_p15_4 XI1_I1298_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I37_MP3 (XI1_I1298_I37_p1 XI1_I1298_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I37_MP0 (VDD I1_p15_4 XI1_I1298_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I208_MP1 (VDD I1_I1252_G4_0 XI1_I1252_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I208_MP5 (I1_p15_5 I1_I1252_G4_0 XI1_I1252_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I208_MP4 (XI1_I1252_I208_p1 XI1_I1252_I208_An I1_p15_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I208_MP2 (VDD I1_I1252_pn5 XI1_I1252_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I208_MP3 (XI1_I1252_I208_p1 XI1_I1252_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I208_MP0 (VDD I1_I1252_pn5 XI1_I1252_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I38_MP1 (VDD I1_b15_6 XI1_I1252_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I38_MP5 (I1_I1252_pn6 I1_b15_6 XI1_I1252_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I38_MP4 (XI1_I1252_I38_p1 XI1_I1252_I38_An I1_I1252_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I38_MP2 (VDD I1_p14_5 XI1_I1252_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I38_MP3 (XI1_I1252_I38_p1 XI1_I1252_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I38_MP0 (VDD I1_p14_5 XI1_I1252_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I227_MP1 (VDD I1_I1160_G23_0 XI1_I1160_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I227_MP5 (I1_p13_24 I1_I1160_G23_0 XI1_I1160_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I227_MP4 (XI1_I1160_I227_p1 XI1_I1160_I227_An I1_p13_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I227_MP2 (VDD I1_I1160_pn24 XI1_I1160_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I227_MP3 (XI1_I1160_I227_p1 XI1_I1160_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I227_MP0 (VDD I1_I1160_pn24 XI1_I1160_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I231_MP1 (VDD I1_I1160_G27_0 XI1_I1160_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I231_MP5 (I1_p13_28 I1_I1160_G27_0 XI1_I1160_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I231_MP4 (XI1_I1160_I231_p1 XI1_I1160_I231_An I1_p13_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I231_MP2 (VDD I1_I1160_pn28 XI1_I1160_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I231_MP3 (XI1_I1160_I231_p1 XI1_I1160_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I231_MP0 (VDD I1_I1160_pn28 XI1_I1160_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I233_MP1 (VDD I1_I1160_G29_0 XI1_I1160_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I233_MP5 (I1_p13_30 I1_I1160_G29_0 XI1_I1160_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I233_MP4 (XI1_I1160_I233_p1 XI1_I1160_I233_An I1_p13_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I233_MP2 (VDD I1_I1160_pn30 XI1_I1160_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I233_MP3 (XI1_I1160_I233_p1 XI1_I1160_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I233_MP0 (VDD I1_I1160_pn30 XI1_I1160_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I225_MP1 (VDD I1_I1160_G21_0 XI1_I1160_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I225_MP5 (I1_p13_22 I1_I1160_G21_0 XI1_I1160_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I225_MP4 (XI1_I1160_I225_p1 XI1_I1160_I225_An I1_p13_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I225_MP2 (VDD I1_I1160_pn22 XI1_I1160_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I225_MP3 (XI1_I1160_I225_p1 XI1_I1160_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I225_MP0 (VDD I1_I1160_pn22 XI1_I1160_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I223_MP1 (VDD I1_I1160_G19_0 XI1_I1160_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I223_MP5 (I1_p13_20 I1_I1160_G19_0 XI1_I1160_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I223_MP4 (XI1_I1160_I223_p1 XI1_I1160_I223_An I1_p13_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I223_MP2 (VDD I1_I1160_pn20 XI1_I1160_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I223_MP3 (XI1_I1160_I223_p1 XI1_I1160_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I223_MP0 (VDD I1_I1160_pn20 XI1_I1160_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I40_MP1 (VDD I1_b14_8 XI1_I1206_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I40_MP5 (I1_I1206_pn8 I1_b14_8 XI1_I1206_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I40_MP4 (XI1_I1206_I40_p1 XI1_I1206_I40_An I1_I1206_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I40_MP2 (VDD I1_p13_7 XI1_I1206_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I40_MP3 (XI1_I1206_I40_p1 XI1_I1206_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I40_MP0 (VDD I1_p13_7 XI1_I1206_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I38_MP1 (VDD I1_b14_6 XI1_I1206_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I38_MP5 (I1_I1206_pn6 I1_b14_6 XI1_I1206_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I38_MP4 (XI1_I1206_I38_p1 XI1_I1206_I38_An I1_I1206_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I38_MP2 (VDD I1_p13_5 XI1_I1206_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I38_MP3 (XI1_I1206_I38_p1 XI1_I1206_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I38_MP0 (VDD I1_p13_5 XI1_I1206_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I208_MP1 (VDD I1_I1206_G4_0 XI1_I1206_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I208_MP5 (I1_p14_5 I1_I1206_G4_0 XI1_I1206_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I208_MP4 (XI1_I1206_I208_p1 XI1_I1206_I208_An I1_p14_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I208_MP2 (VDD I1_I1206_pn5 XI1_I1206_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I208_MP3 (XI1_I1206_I208_p1 XI1_I1206_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I208_MP0 (VDD I1_I1206_pn5 XI1_I1206_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I234_MP1 (VDD I1_c7_m XI1_I884_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I234_MP5 (I1_p7_31 I1_c7_m XI1_I884_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I234_MP4 (XI1_I884_I234_p1 XI1_I884_I234_An I1_p7_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I234_MP2 (VDD I1_I884_pn31 XI1_I884_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I234_MP3 (XI1_I884_I234_p1 XI1_I884_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I234_MP0 (VDD I1_I884_pn31 XI1_I884_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I233_MP1 (VDD I1_I884_G29_0 XI1_I884_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I233_MP5 (I1_p7_30 I1_I884_G29_0 XI1_I884_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I233_MP4 (XI1_I884_I233_p1 XI1_I884_I233_An I1_p7_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I233_MP2 (VDD I1_I884_pn30 XI1_I884_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I233_MP3 (XI1_I884_I233_p1 XI1_I884_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I233_MP0 (VDD I1_I884_pn30 XI1_I884_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I211_MP1 (VDD I1_I884_G7_0 XI1_I884_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I211_MP5 (I1_p7_8 I1_I884_G7_0 XI1_I884_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I211_MP4 (XI1_I884_I211_p1 XI1_I884_I211_An I1_p7_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I211_MP2 (VDD I1_I884_pn8 XI1_I884_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I211_MP3 (XI1_I884_I211_p1 XI1_I884_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I211_MP0 (VDD I1_I884_pn8 XI1_I884_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I209_MP1 (VDD I1_I884_G5_0 XI1_I884_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I209_MP5 (I1_p7_6 I1_I884_G5_0 XI1_I884_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I209_MP4 (XI1_I884_I209_p1 XI1_I884_I209_An I1_p7_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I209_MP2 (VDD I1_I884_pn6 XI1_I884_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I209_MP3 (XI1_I884_I209_p1 XI1_I884_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I209_MP0 (VDD I1_I884_pn6 XI1_I884_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I204_MP1 (VDD I1_I838_G0_0 XI1_I838_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I204_MP5 (I1_p6_1 I1_I838_G0_0 XI1_I838_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I204_MP4 (XI1_I838_I204_p1 XI1_I838_I204_An I1_p6_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I204_MP2 (VDD I1_I838_pn1 XI1_I838_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I204_MP3 (XI1_I838_I204_p1 XI1_I838_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I204_MP0 (VDD I1_I838_pn1 XI1_I838_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I36_MP1 (VDD I1_b7_4 XI1_I884_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I36_MP5 (I1_I884_pn4 I1_b7_4 XI1_I884_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I36_MP4 (XI1_I884_I36_p1 XI1_I884_I36_An I1_I884_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I36_MP2 (VDD I1_p6_3 XI1_I884_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I36_MP3 (XI1_I884_I36_p1 XI1_I884_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I36_MP0 (VDD I1_p6_3 XI1_I884_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I34_MP1 (VDD I1_b5_2 XI1_I792_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I34_MP5 (I1_I792_pn2 I1_b5_2 XI1_I792_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I34_MP4 (XI1_I792_I34_p1 XI1_I792_I34_An I1_I792_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I34_MP2 (VDD I1_p4_1 XI1_I792_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I34_MP3 (XI1_I792_I34_p1 XI1_I792_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I34_MP0 (VDD I1_p4_1 XI1_I792_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I204_MP1 (VDD I1_I746_G0_0 XI1_I746_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I204_MP5 (I1_p4_1 I1_I746_G0_0 XI1_I746_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I204_MP4 (XI1_I746_I204_p1 XI1_I746_I204_An I1_p4_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I204_MP2 (VDD I1_I746_pn1 XI1_I746_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I204_MP3 (XI1_I746_I204_p1 XI1_I746_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I204_MP0 (VDD I1_I746_pn1 XI1_I746_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I33_MP1 (VDD I1_b5_1 XI1_I792_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I33_MP5 (I1_I792_pn1 I1_b5_1 XI1_I792_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I33_MP4 (XI1_I792_I33_p1 XI1_I792_I33_An I1_I792_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I33_MP2 (VDD I1_p4_0 XI1_I792_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I33_MP3 (XI1_I792_I33_p1 XI1_I792_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I33_MP0 (VDD I1_p4_0 XI1_I792_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I35_MP1 (VDD I1_b4_3 XI1_I746_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I35_MP5 (I1_I746_pn3 I1_b4_3 XI1_I746_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I35_MP4 (XI1_I746_I35_p1 XI1_I746_I35_An I1_I746_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I35_MP2 (VDD I1_p3_2 XI1_I746_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I35_MP3 (XI1_I746_I35_p1 XI1_I746_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I35_MP0 (VDD I1_p3_2 XI1_I746_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I41_MP1 (VDD I1_b4_9 XI1_I746_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I41_MP5 (I1_I746_pn9 I1_b4_9 XI1_I746_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I41_MP4 (XI1_I746_I41_p1 XI1_I746_I41_An I1_I746_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I41_MP2 (VDD I1_p3_8 XI1_I746_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I41_MP3 (XI1_I746_I41_p1 XI1_I746_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I41_MP0 (VDD I1_p3_8 XI1_I746_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I43_MP1 (VDD I1_b4_11 XI1_I746_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I43_MP5 (I1_I746_pn11 I1_b4_11 XI1_I746_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I43_MP4 (XI1_I746_I43_p1 XI1_I746_I43_An I1_I746_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I43_MP2 (VDD I1_p3_10 XI1_I746_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I43_MP3 (XI1_I746_I43_p1 XI1_I746_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I43_MP0 (VDD I1_p3_10 XI1_I746_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I211_MP1 (VDD I1_I700_G7_0 XI1_I700_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I211_MP5 (I1_p3_8 I1_I700_G7_0 XI1_I700_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I211_MP4 (XI1_I700_I211_p1 XI1_I700_I211_An I1_p3_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I211_MP2 (VDD I1_I700_pn8 XI1_I700_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I211_MP3 (XI1_I700_I211_p1 XI1_I700_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I211_MP0 (VDD I1_I700_pn8 XI1_I700_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I231_MP1 (VDD I1_I700_G27_0 XI1_I700_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I231_MP5 (I1_p3_28 I1_I700_G27_0 XI1_I700_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I231_MP4 (XI1_I700_I231_p1 XI1_I700_I231_An I1_p3_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I231_MP2 (VDD I1_I700_pn28 XI1_I700_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I231_MP3 (XI1_I700_I231_p1 XI1_I700_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I231_MP0 (VDD I1_I700_pn28 XI1_I700_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I233_MP1 (VDD I1_I700_G29_0 XI1_I700_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I233_MP5 (I1_p3_30 I1_I700_G29_0 XI1_I700_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I233_MP4 (XI1_I700_I233_p1 XI1_I700_I233_An I1_p3_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I233_MP2 (VDD I1_I700_pn30 XI1_I700_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I233_MP3 (XI1_I700_I233_p1 XI1_I700_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I233_MP0 (VDD I1_I700_pn30 XI1_I700_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I46_MP1 (VDD I1_b18_14 XI1_I1390_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I46_MP5 (I1_I1390_pn14 I1_b18_14 XI1_I1390_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I46_MP4 (XI1_I1390_I46_p1 XI1_I1390_I46_An I1_I1390_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I46_MP2 (VDD I1_p17_13 XI1_I1390_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I46_MP3 (XI1_I1390_I46_p1 XI1_I1390_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I46_MP0 (VDD I1_p17_13 XI1_I1390_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I42_MP1 (VDD I1_b18_10 XI1_I1390_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I42_MP5 (I1_I1390_pn10 I1_b18_10 XI1_I1390_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I42_MP4 (XI1_I1390_I42_p1 XI1_I1390_I42_An I1_I1390_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I42_MP2 (VDD I1_p17_9 XI1_I1390_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I42_MP3 (XI1_I1390_I42_p1 XI1_I1390_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I42_MP0 (VDD I1_p17_9 XI1_I1390_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I36_MP1 (VDD I1_b17_4 XI1_I1344_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I36_MP5 (I1_I1344_pn4 I1_b17_4 XI1_I1344_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I36_MP4 (XI1_I1344_I36_p1 XI1_I1344_I36_An I1_I1344_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I36_MP2 (VDD I1_p16_3 XI1_I1344_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I36_MP3 (XI1_I1344_I36_p1 XI1_I1344_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I36_MP0 (VDD I1_p16_3 XI1_I1344_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I36_MP1 (VDD I1_b16_4 XI1_I1298_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I36_MP5 (I1_I1298_pn4 I1_b16_4 XI1_I1298_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I36_MP4 (XI1_I1298_I36_p1 XI1_I1298_I36_An I1_I1298_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I36_MP2 (VDD I1_p15_3 XI1_I1298_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I36_MP3 (XI1_I1298_I36_p1 XI1_I1298_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I36_MP0 (VDD I1_p15_3 XI1_I1298_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I36_MP1 (VDD I1_b15_4 XI1_I1252_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I36_MP5 (I1_I1252_pn4 I1_b15_4 XI1_I1252_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I36_MP4 (XI1_I1252_I36_p1 XI1_I1252_I36_An I1_I1252_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I36_MP2 (VDD I1_p14_3 XI1_I1252_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I36_MP3 (XI1_I1252_I36_p1 XI1_I1252_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I36_MP0 (VDD I1_p14_3 XI1_I1252_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I37_MP1 (VDD I1_b15_5 XI1_I1252_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I37_MP5 (I1_I1252_pn5 I1_b15_5 XI1_I1252_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I37_MP4 (XI1_I1252_I37_p1 XI1_I1252_I37_An I1_I1252_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I37_MP2 (VDD I1_p14_4 XI1_I1252_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I37_MP3 (XI1_I1252_I37_p1 XI1_I1252_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I37_MP0 (VDD I1_p14_4 XI1_I1252_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I229_MP1 (VDD I1_I1160_G25_0 XI1_I1160_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I229_MP5 (I1_p13_26 I1_I1160_G25_0 XI1_I1160_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I229_MP4 (XI1_I1160_I229_p1 XI1_I1160_I229_An I1_p13_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I229_MP2 (VDD I1_I1160_pn26 XI1_I1160_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I229_MP3 (XI1_I1160_I229_p1 XI1_I1160_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I229_MP0 (VDD I1_I1160_pn26 XI1_I1160_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I211_MP1 (VDD I1_I1160_G7_0 XI1_I1160_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I211_MP5 (I1_p13_8 I1_I1160_G7_0 XI1_I1160_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I211_MP4 (XI1_I1160_I211_p1 XI1_I1160_I211_An I1_p13_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I211_MP2 (VDD I1_I1160_pn8 XI1_I1160_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I211_MP3 (XI1_I1160_I211_p1 XI1_I1160_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I211_MP0 (VDD I1_I1160_pn8 XI1_I1160_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I39_MP1 (VDD I1_b14_7 XI1_I1206_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I39_MP5 (I1_I1206_pn7 I1_b14_7 XI1_I1206_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I39_MP4 (XI1_I1206_I39_p1 XI1_I1206_I39_An I1_I1206_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I39_MP2 (VDD I1_p13_6 XI1_I1206_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I39_MP3 (XI1_I1206_I39_p1 XI1_I1206_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I39_MP0 (VDD I1_p13_6 XI1_I1206_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I36_MP1 (VDD I1_b14_4 XI1_I1206_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I36_MP5 (I1_I1206_pn4 I1_b14_4 XI1_I1206_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I36_MP4 (XI1_I1206_I36_p1 XI1_I1206_I36_An I1_I1206_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I36_MP2 (VDD I1_p13_3 XI1_I1206_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I36_MP3 (XI1_I1206_I36_p1 XI1_I1206_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I36_MP0 (VDD I1_p13_3 XI1_I1206_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I205_MP1 (VDD I1_I1206_G1_0 XI1_I1206_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I205_MP5 (I1_p14_2 I1_I1206_G1_0 XI1_I1206_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I205_MP4 (XI1_I1206_I205_p1 XI1_I1206_I205_An I1_p14_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I205_MP2 (VDD I1_I1206_pn2 XI1_I1206_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I205_MP3 (XI1_I1206_I205_p1 XI1_I1206_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I205_MP0 (VDD I1_I1206_pn2 XI1_I1206_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I232_MP1 (VDD I1_I884_G28_0 XI1_I884_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I232_MP5 (I1_p7_29 I1_I884_G28_0 XI1_I884_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I232_MP4 (XI1_I884_I232_p1 XI1_I884_I232_An I1_p7_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I232_MP2 (VDD I1_I884_pn29 XI1_I884_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I232_MP3 (XI1_I884_I232_p1 XI1_I884_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I232_MP0 (VDD I1_I884_pn29 XI1_I884_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I230_MP1 (VDD I1_I884_G26_0 XI1_I884_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I230_MP5 (I1_p7_27 I1_I884_G26_0 XI1_I884_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I230_MP4 (XI1_I884_I230_p1 XI1_I884_I230_An I1_p7_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I230_MP2 (VDD I1_I884_pn27 XI1_I884_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I230_MP3 (XI1_I884_I230_p1 XI1_I884_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I230_MP0 (VDD I1_I884_pn27 XI1_I884_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I226_MP1 (VDD I1_I884_G22_0 XI1_I884_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I226_MP5 (I1_p7_23 I1_I884_G22_0 XI1_I884_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I226_MP4 (XI1_I884_I226_p1 XI1_I884_I226_An I1_p7_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I226_MP2 (VDD I1_I884_pn23 XI1_I884_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I226_MP3 (XI1_I884_I226_p1 XI1_I884_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I226_MP0 (VDD I1_I884_pn23 XI1_I884_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I224_MP1 (VDD I1_I884_G20_0 XI1_I884_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I224_MP5 (I1_p7_21 I1_I884_G20_0 XI1_I884_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I224_MP4 (XI1_I884_I224_p1 XI1_I884_I224_An I1_p7_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I224_MP2 (VDD I1_I884_pn21 XI1_I884_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I224_MP3 (XI1_I884_I224_p1 XI1_I884_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I224_MP0 (VDD I1_I884_pn21 XI1_I884_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I220_MP1 (VDD I1_I884_G16_0 XI1_I884_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I220_MP5 (I1_p7_17 I1_I884_G16_0 XI1_I884_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I220_MP4 (XI1_I884_I220_p1 XI1_I884_I220_An I1_p7_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I220_MP2 (VDD I1_I884_pn17 XI1_I884_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I220_MP3 (XI1_I884_I220_p1 XI1_I884_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I220_MP0 (VDD I1_I884_pn17 XI1_I884_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I210_MP1 (VDD I1_I884_G6_0 XI1_I884_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I210_MP5 (I1_p7_7 I1_I884_G6_0 XI1_I884_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I210_MP4 (XI1_I884_I210_p1 XI1_I884_I210_An I1_p7_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I210_MP2 (VDD I1_I884_pn7 XI1_I884_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I210_MP3 (XI1_I884_I210_p1 XI1_I884_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I210_MP0 (VDD I1_I884_pn7 XI1_I884_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I208_MP1 (VDD I1_I884_G4_0 XI1_I884_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I208_MP5 (I1_p7_5 I1_I884_G4_0 XI1_I884_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I208_MP4 (XI1_I884_I208_p1 XI1_I884_I208_An I1_p7_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I208_MP2 (VDD I1_I884_pn5 XI1_I884_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I208_MP3 (XI1_I884_I208_p1 XI1_I884_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I208_MP0 (VDD I1_I884_pn5 XI1_I884_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I34_MP1 (VDD I1_b7_2 XI1_I884_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I34_MP5 (I1_I884_pn2 I1_b7_2 XI1_I884_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I34_MP4 (XI1_I884_I34_p1 XI1_I884_I34_An I1_I884_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I34_MP2 (VDD I1_p6_1 XI1_I884_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I34_MP3 (XI1_I884_I34_p1 XI1_I884_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I34_MP0 (VDD I1_p6_1 XI1_I884_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I33_MP1 (VDD I1_b6_1 XI1_I838_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I33_MP5 (I1_I838_pn1 I1_b6_1 XI1_I838_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I33_MP4 (XI1_I838_I33_p1 XI1_I838_I33_An I1_I838_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I33_MP2 (VDD I1_p5_0 XI1_I838_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I33_MP3 (XI1_I838_I33_p1 XI1_I838_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I33_MP0 (VDD I1_p5_0 XI1_I838_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I35_MP1 (VDD I1_b7_3 XI1_I884_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I35_MP5 (I1_I884_pn3 I1_b7_3 XI1_I884_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I35_MP4 (XI1_I884_I35_p1 XI1_I884_I35_An I1_I884_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I35_MP2 (VDD I1_p6_2 XI1_I884_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I35_MP3 (XI1_I884_I35_p1 XI1_I884_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I35_MP0 (VDD I1_p6_2 XI1_I884_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I34_MP1 (VDD I1_b4_2 XI1_I746_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I34_MP5 (I1_I746_pn2 I1_b4_2 XI1_I746_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I34_MP4 (XI1_I746_I34_p1 XI1_I746_I34_An I1_I746_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I34_MP2 (VDD I1_p3_1 XI1_I746_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I34_MP3 (XI1_I746_I34_p1 XI1_I746_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I34_MP0 (VDD I1_p3_1 XI1_I746_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I36_MP1 (VDD I1_b4_4 XI1_I746_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I36_MP5 (I1_I746_pn4 I1_b4_4 XI1_I746_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I36_MP4 (XI1_I746_I36_p1 XI1_I746_I36_An I1_I746_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I36_MP2 (VDD I1_p3_3 XI1_I746_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I36_MP3 (XI1_I746_I36_p1 XI1_I746_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I36_MP0 (VDD I1_p3_3 XI1_I746_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I37_MP1 (VDD I1_b4_5 XI1_I746_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I37_MP5 (I1_I746_pn5 I1_b4_5 XI1_I746_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I37_MP4 (XI1_I746_I37_p1 XI1_I746_I37_An I1_I746_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I37_MP2 (VDD I1_p3_4 XI1_I746_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I37_MP3 (XI1_I746_I37_p1 XI1_I746_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I37_MP0 (VDD I1_p3_4 XI1_I746_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I39_MP1 (VDD I1_b4_7 XI1_I746_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I39_MP5 (I1_I746_pn7 I1_b4_7 XI1_I746_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I39_MP4 (XI1_I746_I39_p1 XI1_I746_I39_An I1_I746_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I39_MP2 (VDD I1_p3_6 XI1_I746_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I39_MP3 (XI1_I746_I39_p1 XI1_I746_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I39_MP0 (VDD I1_p3_6 XI1_I746_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I209_MP1 (VDD I1_I700_G5_0 XI1_I700_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I209_MP5 (I1_p3_6 I1_I700_G5_0 XI1_I700_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I209_MP4 (XI1_I700_I209_p1 XI1_I700_I209_An I1_p3_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I209_MP2 (VDD I1_I700_pn6 XI1_I700_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I209_MP3 (XI1_I700_I209_p1 XI1_I700_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I209_MP0 (VDD I1_I700_pn6 XI1_I700_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I221_MP1 (VDD I1_I700_G17_0 XI1_I700_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I221_MP5 (I1_p3_18 I1_I700_G17_0 XI1_I700_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I221_MP4 (XI1_I700_I221_p1 XI1_I700_I221_An I1_p3_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I221_MP2 (VDD I1_I700_pn18 XI1_I700_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I221_MP3 (XI1_I700_I221_p1 XI1_I700_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I221_MP0 (VDD I1_I700_pn18 XI1_I700_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I44_MP1 (VDD I1_b18_12 XI1_I1390_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I44_MP5 (I1_I1390_pn12 I1_b18_12 XI1_I1390_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I44_MP4 (XI1_I1390_I44_p1 XI1_I1390_I44_An I1_I1390_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I44_MP2 (VDD I1_p17_11 XI1_I1390_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I44_MP3 (XI1_I1390_I44_p1 XI1_I1390_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I44_MP0 (VDD I1_p17_11 XI1_I1390_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I43_MP1 (VDD I1_b18_11 XI1_I1390_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I43_MP5 (I1_I1390_pn11 I1_b18_11 XI1_I1390_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I43_MP4 (XI1_I1390_I43_p1 XI1_I1390_I43_An I1_I1390_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I43_MP2 (VDD I1_p17_10 XI1_I1390_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I43_MP3 (XI1_I1390_I43_p1 XI1_I1390_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I43_MP0 (VDD I1_p17_10 XI1_I1390_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I41_MP1 (VDD I1_b18_9 XI1_I1390_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I41_MP5 (I1_I1390_pn9 I1_b18_9 XI1_I1390_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I41_MP4 (XI1_I1390_I41_p1 XI1_I1390_I41_An I1_I1390_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I41_MP2 (VDD I1_p17_8 XI1_I1390_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I41_MP3 (XI1_I1390_I41_p1 XI1_I1390_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I41_MP0 (VDD I1_p17_8 XI1_I1390_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I40_MP1 (VDD I1_b18_8 XI1_I1390_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I40_MP5 (I1_I1390_pn8 I1_b18_8 XI1_I1390_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I40_MP4 (XI1_I1390_I40_p1 XI1_I1390_I40_An I1_I1390_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I40_MP2 (VDD I1_p17_7 XI1_I1390_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I40_MP3 (XI1_I1390_I40_p1 XI1_I1390_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I40_MP0 (VDD I1_p17_7 XI1_I1390_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I205_MP1 (VDD I1_I1298_G1_0 XI1_I1298_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I205_MP5 (I1_p16_2 I1_I1298_G1_0 XI1_I1298_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I205_MP4 (XI1_I1298_I205_p1 XI1_I1298_I205_An I1_p16_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I205_MP2 (VDD I1_I1298_pn2 XI1_I1298_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I205_MP3 (XI1_I1298_I205_p1 XI1_I1298_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I205_MP0 (VDD I1_I1298_pn2 XI1_I1298_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I34_MP1 (VDD I1_b16_2 XI1_I1298_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I34_MP5 (I1_I1298_pn2 I1_b16_2 XI1_I1298_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I34_MP4 (XI1_I1298_I34_p1 XI1_I1298_I34_An I1_I1298_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I34_MP2 (VDD I1_p15_1 XI1_I1298_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I34_MP3 (XI1_I1298_I34_p1 XI1_I1298_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I34_MP0 (VDD I1_p15_1 XI1_I1298_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I35_MP1 (VDD I1_b16_3 XI1_I1298_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I35_MP5 (I1_I1298_pn3 I1_b16_3 XI1_I1298_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I35_MP4 (XI1_I1298_I35_p1 XI1_I1298_I35_An I1_I1298_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I35_MP2 (VDD I1_p15_2 XI1_I1298_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I35_MP3 (XI1_I1298_I35_p1 XI1_I1298_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I35_MP0 (VDD I1_p15_2 XI1_I1298_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I204_MP1 (VDD I1_I1252_G0_0 XI1_I1252_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I204_MP5 (I1_p15_1 I1_I1252_G0_0 XI1_I1252_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I204_MP4 (XI1_I1252_I204_p1 XI1_I1252_I204_An I1_p15_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I204_MP2 (VDD I1_I1252_pn1 XI1_I1252_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I204_MP3 (XI1_I1252_I204_p1 XI1_I1252_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I204_MP0 (VDD I1_I1252_pn1 XI1_I1252_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I205_MP1 (VDD I1_I1252_G1_0 XI1_I1252_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I205_MP5 (I1_p15_2 I1_I1252_G1_0 XI1_I1252_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I205_MP4 (XI1_I1252_I205_p1 XI1_I1252_I205_An I1_p15_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I205_MP2 (VDD I1_I1252_pn2 XI1_I1252_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I205_MP3 (XI1_I1252_I205_p1 XI1_I1252_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I205_MP0 (VDD I1_I1252_pn2 XI1_I1252_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I35_MP1 (VDD I1_b15_3 XI1_I1252_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I35_MP5 (I1_I1252_pn3 I1_b15_3 XI1_I1252_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I35_MP4 (XI1_I1252_I35_p1 XI1_I1252_I35_An I1_I1252_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I35_MP2 (VDD I1_p14_2 XI1_I1252_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I35_MP3 (XI1_I1252_I35_p1 XI1_I1252_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I35_MP0 (VDD I1_p14_2 XI1_I1252_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I34_MP1 (VDD I1_b15_2 XI1_I1252_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I34_MP5 (I1_I1252_pn2 I1_b15_2 XI1_I1252_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I34_MP4 (XI1_I1252_I34_p1 XI1_I1252_I34_An I1_I1252_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I34_MP2 (VDD I1_p14_1 XI1_I1252_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I34_MP3 (XI1_I1252_I34_p1 XI1_I1252_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I34_MP0 (VDD I1_p14_1 XI1_I1252_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I221_MP1 (VDD I1_I1160_G17_0 XI1_I1160_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I221_MP5 (I1_p13_18 I1_I1160_G17_0 XI1_I1160_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I221_MP4 (XI1_I1160_I221_p1 XI1_I1160_I221_An I1_p13_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I221_MP2 (VDD I1_I1160_pn18 XI1_I1160_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I221_MP3 (XI1_I1160_I221_p1 XI1_I1160_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I221_MP0 (VDD I1_I1160_pn18 XI1_I1160_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I209_MP1 (VDD I1_I1160_G5_0 XI1_I1160_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I209_MP5 (I1_p13_6 I1_I1160_G5_0 XI1_I1160_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I209_MP4 (XI1_I1160_I209_p1 XI1_I1160_I209_An I1_p13_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I209_MP2 (VDD I1_I1160_pn6 XI1_I1160_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I209_MP3 (XI1_I1160_I209_p1 XI1_I1160_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I209_MP0 (VDD I1_I1160_pn6 XI1_I1160_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I37_MP1 (VDD I1_b14_5 XI1_I1206_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I37_MP5 (I1_I1206_pn5 I1_b14_5 XI1_I1206_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I37_MP4 (XI1_I1206_I37_p1 XI1_I1206_I37_An I1_I1206_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I37_MP2 (VDD I1_p13_4 XI1_I1206_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I37_MP3 (XI1_I1206_I37_p1 XI1_I1206_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I37_MP0 (VDD I1_p13_4 XI1_I1206_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I35_MP1 (VDD I1_b14_3 XI1_I1206_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I35_MP5 (I1_I1206_pn3 I1_b14_3 XI1_I1206_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I35_MP4 (XI1_I1206_I35_p1 XI1_I1206_I35_An I1_I1206_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I35_MP2 (VDD I1_p13_2 XI1_I1206_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I35_MP3 (XI1_I1206_I35_p1 XI1_I1206_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I35_MP0 (VDD I1_p13_2 XI1_I1206_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I34_MP1 (VDD I1_b14_2 XI1_I1206_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I34_MP5 (I1_I1206_pn2 I1_b14_2 XI1_I1206_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I34_MP4 (XI1_I1206_I34_p1 XI1_I1206_I34_An I1_I1206_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I34_MP2 (VDD I1_p13_1 XI1_I1206_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I34_MP3 (XI1_I1206_I34_p1 XI1_I1206_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I34_MP0 (VDD I1_p13_1 XI1_I1206_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I204_MP1 (VDD I1_I1206_G0_0 XI1_I1206_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I204_MP5 (I1_p14_1 I1_I1206_G0_0 XI1_I1206_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I204_MP4 (XI1_I1206_I204_p1 XI1_I1206_I204_An I1_p14_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I204_MP2 (VDD I1_I1206_pn1 XI1_I1206_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I204_MP3 (XI1_I1206_I204_p1 XI1_I1206_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I204_MP0 (VDD I1_I1206_pn1 XI1_I1206_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I59_MP1 (VDD I1_b8_27 XI1_I930_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I59_MP5 (I1_I930_pn27 I1_b8_27 XI1_I930_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I59_MP4 (XI1_I930_I59_p1 XI1_I930_I59_An I1_I930_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I59_MP2 (VDD I1_p7_26 XI1_I930_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I59_MP3 (XI1_I930_I59_p1 XI1_I930_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I59_MP0 (VDD I1_p7_26 XI1_I930_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I228_MP1 (VDD I1_I884_G24_0 XI1_I884_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I228_MP5 (I1_p7_25 I1_I884_G24_0 XI1_I884_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I228_MP4 (XI1_I884_I228_p1 XI1_I884_I228_An I1_p7_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I228_MP2 (VDD I1_I884_pn25 XI1_I884_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I228_MP3 (XI1_I884_I228_p1 XI1_I884_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I228_MP0 (VDD I1_I884_pn25 XI1_I884_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I55_MP1 (VDD I1_b8_23 XI1_I930_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I55_MP5 (I1_I930_pn23 I1_b8_23 XI1_I930_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I55_MP4 (XI1_I930_I55_p1 XI1_I930_I55_An I1_I930_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I55_MP2 (VDD I1_p7_22 XI1_I930_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I55_MP3 (XI1_I930_I55_p1 XI1_I930_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I55_MP0 (VDD I1_p7_22 XI1_I930_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I53_MP1 (VDD I1_b8_21 XI1_I930_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I53_MP5 (I1_I930_pn21 I1_b8_21 XI1_I930_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I53_MP4 (XI1_I930_I53_p1 XI1_I930_I53_An I1_I930_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I53_MP2 (VDD I1_p7_20 XI1_I930_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I53_MP3 (XI1_I930_I53_p1 XI1_I930_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I53_MP0 (VDD I1_p7_20 XI1_I930_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I222_MP1 (VDD I1_I884_G18_0 XI1_I884_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I222_MP5 (I1_p7_19 I1_I884_G18_0 XI1_I884_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I222_MP4 (XI1_I884_I222_p1 XI1_I884_I222_An I1_p7_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I222_MP2 (VDD I1_I884_pn19 XI1_I884_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I222_MP3 (XI1_I884_I222_p1 XI1_I884_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I222_MP0 (VDD I1_I884_pn19 XI1_I884_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I50_MP1 (VDD I1_b8_18 XI1_I930_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I50_MP5 (I1_I930_pn18 I1_b8_18 XI1_I930_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I50_MP4 (XI1_I930_I50_p1 XI1_I930_I50_An I1_I930_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I50_MP2 (VDD I1_p7_17 XI1_I930_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I50_MP3 (XI1_I930_I50_p1 XI1_I930_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I50_MP0 (VDD I1_p7_17 XI1_I930_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I49_MP1 (VDD I1_b8_17 XI1_I930_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I49_MP5 (I1_I930_pn17 I1_b8_17 XI1_I930_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I49_MP4 (XI1_I930_I49_p1 XI1_I930_I49_An I1_I930_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I49_MP2 (VDD I1_p7_16 XI1_I930_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I49_MP3 (XI1_I930_I49_p1 XI1_I930_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I49_MP0 (VDD I1_p7_16 XI1_I930_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I46_MP1 (VDD I1_b8_14 XI1_I930_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I46_MP5 (I1_I930_pn14 I1_b8_14 XI1_I930_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I46_MP4 (XI1_I930_I46_p1 XI1_I930_I46_An I1_I930_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I46_MP2 (VDD I1_p7_13 XI1_I930_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I46_MP3 (XI1_I930_I46_p1 XI1_I930_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I46_MP0 (VDD I1_p7_13 XI1_I930_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I42_MP1 (VDD I1_b8_10 XI1_I930_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I42_MP5 (I1_I930_pn10 I1_b8_10 XI1_I930_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I42_MP4 (XI1_I930_I42_p1 XI1_I930_I42_An I1_I930_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I42_MP2 (VDD I1_p7_9 XI1_I930_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I42_MP3 (XI1_I930_I42_p1 XI1_I930_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I42_MP0 (VDD I1_p7_9 XI1_I930_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I205_MP1 (VDD I1_I884_G1_0 XI1_I884_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I205_MP5 (I1_p7_2 I1_I884_G1_0 XI1_I884_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I205_MP4 (XI1_I884_I205_p1 XI1_I884_I205_An I1_p7_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I205_MP2 (VDD I1_I884_pn2 XI1_I884_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I205_MP3 (XI1_I884_I205_p1 XI1_I884_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I205_MP0 (VDD I1_I884_pn2 XI1_I884_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I203_MP1 (VDD I1_qu27_b3_5 XI1_I792_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I203_MP5 (I1_p5_0 I1_qu27_b3_5 XI1_I792_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I203_MP4 (XI1_I792_I203_p1 XI1_I792_I203_An I1_p5_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I203_MP2 (VDD I1_I792_pn0 XI1_I792_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I203_MP3 (XI1_I792_I203_p1 XI1_I792_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I203_MP0 (VDD I1_I792_pn0 XI1_I792_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I33_MP1 (VDD I1_b4_1 XI1_I746_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I33_MP5 (I1_I746_pn1 I1_b4_1 XI1_I746_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I33_MP4 (XI1_I746_I33_p1 XI1_I746_I33_An I1_I746_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I33_MP2 (VDD I1_p3_0 XI1_I746_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I33_MP3 (XI1_I746_I33_p1 XI1_I746_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I33_MP0 (VDD I1_p3_0 XI1_I746_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I205_MP1 (VDD I1_I700_G1_0 XI1_I700_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I205_MP5 (I1_p3_2 I1_I700_G1_0 XI1_I700_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I205_MP4 (XI1_I700_I205_p1 XI1_I700_I205_An I1_p3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I205_MP2 (VDD I1_I700_pn2 XI1_I700_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I205_MP3 (XI1_I700_I205_p1 XI1_I700_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I205_MP0 (VDD I1_I700_pn2 XI1_I700_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I208_MP1 (VDD I1_I700_G4_0 XI1_I700_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I208_MP5 (I1_p3_5 I1_I700_G4_0 XI1_I700_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I208_MP4 (XI1_I700_I208_p1 XI1_I700_I208_An I1_p3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I208_MP2 (VDD I1_I700_pn5 XI1_I700_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I208_MP3 (XI1_I700_I208_p1 XI1_I700_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I208_MP0 (VDD I1_I700_pn5 XI1_I700_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I210_MP1 (VDD I1_I700_G6_0 XI1_I700_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I210_MP5 (I1_p3_7 I1_I700_G6_0 XI1_I700_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I210_MP4 (XI1_I700_I210_p1 XI1_I700_I210_An I1_p3_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I210_MP2 (VDD I1_I700_pn7 XI1_I700_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I210_MP3 (XI1_I700_I210_p1 XI1_I700_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I210_MP0 (VDD I1_I700_pn7 XI1_I700_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I220_MP1 (VDD I1_I700_G16_0 XI1_I700_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I220_MP5 (I1_p3_17 I1_I700_G16_0 XI1_I700_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I220_MP4 (XI1_I700_I220_p1 XI1_I700_I220_An I1_p3_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I220_MP2 (VDD I1_I700_pn17 XI1_I700_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I220_MP3 (XI1_I700_I220_p1 XI1_I700_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I220_MP0 (VDD I1_I700_pn17 XI1_I700_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I222_MP1 (VDD I1_I700_G18_0 XI1_I700_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I222_MP5 (I1_p3_19 I1_I700_G18_0 XI1_I700_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I222_MP4 (XI1_I700_I222_p1 XI1_I700_I222_An I1_p3_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I222_MP2 (VDD I1_I700_pn19 XI1_I700_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I222_MP3 (XI1_I700_I222_p1 XI1_I700_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I222_MP0 (VDD I1_I700_pn19 XI1_I700_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I224_MP1 (VDD I1_I700_G20_0 XI1_I700_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I224_MP5 (I1_p3_21 I1_I700_G20_0 XI1_I700_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I224_MP4 (XI1_I700_I224_p1 XI1_I700_I224_An I1_p3_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I224_MP2 (VDD I1_I700_pn21 XI1_I700_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I224_MP3 (XI1_I700_I224_p1 XI1_I700_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I224_MP0 (VDD I1_I700_pn21 XI1_I700_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I226_MP1 (VDD I1_I700_G22_0 XI1_I700_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I226_MP5 (I1_p3_23 I1_I700_G22_0 XI1_I700_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I226_MP4 (XI1_I700_I226_p1 XI1_I700_I226_An I1_p3_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I226_MP2 (VDD I1_I700_pn23 XI1_I700_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I226_MP3 (XI1_I700_I226_p1 XI1_I700_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I226_MP0 (VDD I1_I700_pn23 XI1_I700_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I228_MP1 (VDD I1_I700_G24_0 XI1_I700_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I228_MP5 (I1_p3_25 I1_I700_G24_0 XI1_I700_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I228_MP4 (XI1_I700_I228_p1 XI1_I700_I228_An I1_p3_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I228_MP2 (VDD I1_I700_pn25 XI1_I700_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I228_MP3 (XI1_I700_I228_p1 XI1_I700_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I228_MP0 (VDD I1_I700_pn25 XI1_I700_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I234_MP1 (VDD I1_c3_m XI1_I700_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I234_MP5 (I1_p3_31 I1_c3_m XI1_I700_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I234_MP4 (XI1_I700_I234_p1 XI1_I700_I234_An I1_p3_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I234_MP2 (VDD I1_I700_pn31 XI1_I700_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I234_MP3 (XI1_I700_I234_p1 XI1_I700_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I234_MP0 (VDD I1_I700_pn31 XI1_I700_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I233_MP1 (VDD I1_I1390_G29_0 XI1_I1390_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I233_MP5 (I1_p18_30 I1_I1390_G29_0 XI1_I1390_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I233_MP4 (XI1_I1390_I233_p1 XI1_I1390_I233_An I1_p18_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I233_MP2 (VDD I1_I1390_pn30 XI1_I1390_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I233_MP3 (XI1_I1390_I233_p1 XI1_I1390_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I233_MP0 (VDD I1_I1390_pn30 XI1_I1390_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I227_MP1 (VDD I1_I1390_G23_0 XI1_I1390_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I227_MP5 (I1_p18_24 I1_I1390_G23_0 XI1_I1390_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I227_MP4 (XI1_I1390_I227_p1 XI1_I1390_I227_An I1_p18_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I227_MP2 (VDD I1_I1390_pn24 XI1_I1390_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I227_MP3 (XI1_I1390_I227_p1 XI1_I1390_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I227_MP0 (VDD I1_I1390_pn24 XI1_I1390_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I225_MP1 (VDD I1_I1390_G21_0 XI1_I1390_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I225_MP5 (I1_p18_22 I1_I1390_G21_0 XI1_I1390_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I225_MP4 (XI1_I1390_I225_p1 XI1_I1390_I225_An I1_p18_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I225_MP2 (VDD I1_I1390_pn22 XI1_I1390_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I225_MP3 (XI1_I1390_I225_p1 XI1_I1390_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I225_MP0 (VDD I1_I1390_pn22 XI1_I1390_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I39_MP1 (VDD I1_b18_7 XI1_I1390_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I39_MP5 (I1_I1390_pn7 I1_b18_7 XI1_I1390_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I39_MP4 (XI1_I1390_I39_p1 XI1_I1390_I39_An I1_I1390_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I39_MP2 (VDD I1_p17_6 XI1_I1390_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I39_MP3 (XI1_I1390_I39_p1 XI1_I1390_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I39_MP0 (VDD I1_p17_6 XI1_I1390_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I205_MP1 (VDD I1_I1344_G1_0 XI1_I1344_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I205_MP5 (I1_p17_2 I1_I1344_G1_0 XI1_I1344_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I205_MP4 (XI1_I1344_I205_p1 XI1_I1344_I205_An I1_p17_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I205_MP2 (VDD I1_I1344_pn2 XI1_I1344_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I205_MP3 (XI1_I1344_I205_p1 XI1_I1344_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I205_MP0 (VDD I1_I1344_pn2 XI1_I1344_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I35_MP1 (VDD I1_b17_3 XI1_I1344_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I35_MP5 (I1_I1344_pn3 I1_b17_3 XI1_I1344_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I35_MP4 (XI1_I1344_I35_p1 XI1_I1344_I35_An I1_I1344_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I35_MP2 (VDD I1_p16_2 XI1_I1344_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I35_MP3 (XI1_I1344_I35_p1 XI1_I1344_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I35_MP0 (VDD I1_p16_2 XI1_I1344_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I34_MP1 (VDD I1_b17_2 XI1_I1344_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I34_MP5 (I1_I1344_pn2 I1_b17_2 XI1_I1344_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I34_MP4 (XI1_I1344_I34_p1 XI1_I1344_I34_An I1_I1344_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I34_MP2 (VDD I1_p16_1 XI1_I1344_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I34_MP3 (XI1_I1344_I34_p1 XI1_I1344_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I34_MP0 (VDD I1_p16_1 XI1_I1344_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I204_MP1 (VDD I1_I1298_G0_0 XI1_I1298_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I204_MP5 (I1_p16_1 I1_I1298_G0_0 XI1_I1298_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I204_MP4 (XI1_I1298_I204_p1 XI1_I1298_I204_An I1_p16_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I204_MP2 (VDD I1_I1298_pn1 XI1_I1298_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I204_MP3 (XI1_I1298_I204_p1 XI1_I1298_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I204_MP0 (VDD I1_I1298_pn1 XI1_I1298_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I33_MP1 (VDD I1_b16_1 XI1_I1298_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I33_MP5 (I1_I1298_pn1 I1_b16_1 XI1_I1298_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I33_MP4 (XI1_I1298_I33_p1 XI1_I1298_I33_An I1_I1298_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I33_MP2 (VDD I1_p15_0 XI1_I1298_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I33_MP3 (XI1_I1298_I33_p1 XI1_I1298_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I33_MP0 (VDD I1_p15_0 XI1_I1298_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I203_MP1 (VDD I1_qu17_b3_5 XI1_I1252_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I203_MP5 (I1_p15_0 I1_qu17_b3_5 XI1_I1252_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I203_MP4 (XI1_I1252_I203_p1 XI1_I1252_I203_An I1_p15_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I203_MP2 (VDD I1_I1252_pn0 XI1_I1252_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I203_MP3 (XI1_I1252_I203_p1 XI1_I1252_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I203_MP0 (VDD I1_I1252_pn0 XI1_I1252_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I33_MP1 (VDD I1_b15_1 XI1_I1252_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I33_MP5 (I1_I1252_pn1 I1_b15_1 XI1_I1252_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I33_MP4 (XI1_I1252_I33_p1 XI1_I1252_I33_An I1_I1252_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I33_MP2 (VDD I1_p14_0 XI1_I1252_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I33_MP3 (XI1_I1252_I33_p1 XI1_I1252_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I33_MP0 (VDD I1_p14_0 XI1_I1252_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I63_MP1 (VDD I1_b13_31 XI1_I1160_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I63_MP5 (I1_I1160_pn31 I1_b13_31 XI1_I1160_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I63_MP4 (XI1_I1160_I63_p1 XI1_I1160_I63_An I1_I1160_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I63_MP2 (VDD I1_p12_30 XI1_I1160_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I63_MP3 (XI1_I1160_I63_p1 XI1_I1160_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I63_MP0 (VDD I1_p12_30 XI1_I1160_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I232_MP1 (VDD I1_I1160_G28_0 XI1_I1160_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I232_MP5 (I1_p13_29 I1_I1160_G28_0 XI1_I1160_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I232_MP4 (XI1_I1160_I232_p1 XI1_I1160_I232_An I1_p13_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I232_MP2 (VDD I1_I1160_pn29 XI1_I1160_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I232_MP3 (XI1_I1160_I232_p1 XI1_I1160_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I232_MP0 (VDD I1_I1160_pn29 XI1_I1160_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I224_MP1 (VDD I1_I1160_G20_0 XI1_I1160_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I224_MP5 (I1_p13_21 I1_I1160_G20_0 XI1_I1160_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I224_MP4 (XI1_I1160_I224_p1 XI1_I1160_I224_An I1_p13_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I224_MP2 (VDD I1_I1160_pn21 XI1_I1160_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I224_MP3 (XI1_I1160_I224_p1 XI1_I1160_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I224_MP0 (VDD I1_I1160_pn21 XI1_I1160_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I210_MP1 (VDD I1_I1160_G6_0 XI1_I1160_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I210_MP5 (I1_p13_7 I1_I1160_G6_0 XI1_I1160_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I210_MP4 (XI1_I1160_I210_p1 XI1_I1160_I210_An I1_p13_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I210_MP2 (VDD I1_I1160_pn7 XI1_I1160_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I210_MP3 (XI1_I1160_I210_p1 XI1_I1160_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I210_MP0 (VDD I1_I1160_pn7 XI1_I1160_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I203_MP1 (VDD I1_qu18_b3_5 XI1_I1206_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I203_MP5 (I1_p14_0 I1_qu18_b3_5 XI1_I1206_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I203_MP4 (XI1_I1206_I203_p1 XI1_I1206_I203_An I1_p14_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I203_MP2 (VDD I1_I1206_pn0 XI1_I1206_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I203_MP3 (XI1_I1206_I203_p1 XI1_I1206_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I203_MP0 (VDD I1_I1206_pn0 XI1_I1206_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I33_MP1 (VDD I1_b14_1 XI1_I1206_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I33_MP5 (I1_I1206_pn1 I1_b14_1 XI1_I1206_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I33_MP4 (XI1_I1206_I33_p1 XI1_I1206_I33_An I1_I1206_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I33_MP2 (VDD I1_p13_0 XI1_I1206_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I33_MP3 (XI1_I1206_I33_p1 XI1_I1206_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I33_MP0 (VDD I1_p13_0 XI1_I1206_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I61_MP1 (VDD I1_b8_29 XI1_I930_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I61_MP5 (I1_I930_pn29 I1_b8_29 XI1_I930_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I61_MP4 (XI1_I930_I61_p1 XI1_I930_I61_An I1_I930_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I61_MP2 (VDD I1_p7_28 XI1_I930_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I61_MP3 (XI1_I930_I61_p1 XI1_I930_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I61_MP0 (VDD I1_p7_28 XI1_I930_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I58_MP1 (VDD I1_b8_26 XI1_I930_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I58_MP5 (I1_I930_pn26 I1_b8_26 XI1_I930_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I58_MP4 (XI1_I930_I58_p1 XI1_I930_I58_An I1_I930_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I58_MP2 (VDD I1_p7_25 XI1_I930_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I58_MP3 (XI1_I930_I58_p1 XI1_I930_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I58_MP0 (VDD I1_p7_25 XI1_I930_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I60_MP1 (VDD I1_b8_28 XI1_I930_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I60_MP5 (I1_I930_pn28 I1_b8_28 XI1_I930_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I60_MP4 (XI1_I930_I60_p1 XI1_I930_I60_An I1_I930_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I60_MP2 (VDD I1_p7_27 XI1_I930_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I60_MP3 (XI1_I930_I60_p1 XI1_I930_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I60_MP0 (VDD I1_p7_27 XI1_I930_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I57_MP1 (VDD I1_b8_25 XI1_I930_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I57_MP5 (I1_I930_pn25 I1_b8_25 XI1_I930_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I57_MP4 (XI1_I930_I57_p1 XI1_I930_I57_An I1_I930_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I57_MP2 (VDD I1_p7_24 XI1_I930_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I57_MP3 (XI1_I930_I57_p1 XI1_I930_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I57_MP0 (VDD I1_p7_24 XI1_I930_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I56_MP1 (VDD I1_b8_24 XI1_I930_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I56_MP5 (I1_I930_pn24 I1_b8_24 XI1_I930_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I56_MP4 (XI1_I930_I56_p1 XI1_I930_I56_An I1_I930_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I56_MP2 (VDD I1_p7_23 XI1_I930_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I56_MP3 (XI1_I930_I56_p1 XI1_I930_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I56_MP0 (VDD I1_p7_23 XI1_I930_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I54_MP1 (VDD I1_b8_22 XI1_I930_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I54_MP5 (I1_I930_pn22 I1_b8_22 XI1_I930_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I54_MP4 (XI1_I930_I54_p1 XI1_I930_I54_An I1_I930_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I54_MP2 (VDD I1_p7_21 XI1_I930_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I54_MP3 (XI1_I930_I54_p1 XI1_I930_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I54_MP0 (VDD I1_p7_21 XI1_I930_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I52_MP1 (VDD I1_b8_20 XI1_I930_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I52_MP5 (I1_I930_pn20 I1_b8_20 XI1_I930_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I52_MP4 (XI1_I930_I52_p1 XI1_I930_I52_An I1_I930_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I52_MP2 (VDD I1_p7_19 XI1_I930_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I52_MP3 (XI1_I930_I52_p1 XI1_I930_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I52_MP0 (VDD I1_p7_19 XI1_I930_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I51_MP1 (VDD I1_b8_19 XI1_I930_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I51_MP5 (I1_I930_pn19 I1_b8_19 XI1_I930_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I51_MP4 (XI1_I930_I51_p1 XI1_I930_I51_An I1_I930_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I51_MP2 (VDD I1_p7_18 XI1_I930_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I51_MP3 (XI1_I930_I51_p1 XI1_I930_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I51_MP0 (VDD I1_p7_18 XI1_I930_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I48_MP1 (VDD I1_b8_16 XI1_I930_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I48_MP5 (I1_I930_pn16 I1_b8_16 XI1_I930_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I48_MP4 (XI1_I930_I48_p1 XI1_I930_I48_An I1_I930_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I48_MP2 (VDD I1_p7_15 XI1_I930_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I48_MP3 (XI1_I930_I48_p1 XI1_I930_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I48_MP0 (VDD I1_p7_15 XI1_I930_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I47_MP1 (VDD I1_b8_15 XI1_I930_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I47_MP5 (I1_I930_pn15 I1_b8_15 XI1_I930_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I47_MP4 (XI1_I930_I47_p1 XI1_I930_I47_An I1_I930_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I47_MP2 (VDD I1_p7_14 XI1_I930_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I47_MP3 (XI1_I930_I47_p1 XI1_I930_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I47_MP0 (VDD I1_p7_14 XI1_I930_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I44_MP1 (VDD I1_b8_12 XI1_I930_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I44_MP5 (I1_I930_pn12 I1_b8_12 XI1_I930_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I44_MP4 (XI1_I930_I44_p1 XI1_I930_I44_An I1_I930_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I44_MP2 (VDD I1_p7_11 XI1_I930_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I44_MP3 (XI1_I930_I44_p1 XI1_I930_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I44_MP0 (VDD I1_p7_11 XI1_I930_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I45_MP1 (VDD I1_b8_13 XI1_I930_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I45_MP5 (I1_I930_pn13 I1_b8_13 XI1_I930_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I45_MP4 (XI1_I930_I45_p1 XI1_I930_I45_An I1_I930_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I45_MP2 (VDD I1_p7_12 XI1_I930_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I45_MP3 (XI1_I930_I45_p1 XI1_I930_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I45_MP0 (VDD I1_p7_12 XI1_I930_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I43_MP1 (VDD I1_b8_11 XI1_I930_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I43_MP5 (I1_I930_pn11 I1_b8_11 XI1_I930_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I43_MP4 (XI1_I930_I43_p1 XI1_I930_I43_An I1_I930_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I43_MP2 (VDD I1_p7_10 XI1_I930_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I43_MP3 (XI1_I930_I43_p1 XI1_I930_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I43_MP0 (VDD I1_p7_10 XI1_I930_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I39_MP1 (VDD I1_b8_7 XI1_I930_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I39_MP5 (I1_I930_pn7 I1_b8_7 XI1_I930_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I39_MP4 (XI1_I930_I39_p1 XI1_I930_I39_An I1_I930_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I39_MP2 (VDD I1_p7_6 XI1_I930_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I39_MP3 (XI1_I930_I39_p1 XI1_I930_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I39_MP0 (VDD I1_p7_6 XI1_I930_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I203_MP1 (VDD I1_qu26_b3_5 XI1_I838_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I203_MP5 (I1_p6_0 I1_qu26_b3_5 XI1_I838_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I203_MP4 (XI1_I838_I203_p1 XI1_I838_I203_An I1_p6_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I203_MP2 (VDD I1_I838_pn0 XI1_I838_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I203_MP3 (XI1_I838_I203_p1 XI1_I838_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I203_MP0 (VDD I1_I838_pn0 XI1_I838_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I33_MP1 (VDD I1_b7_1 XI1_I884_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I33_MP5 (I1_I884_pn1 I1_b7_1 XI1_I884_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I33_MP4 (XI1_I884_I33_p1 XI1_I884_I33_An I1_I884_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I33_MP2 (VDD I1_p6_0 XI1_I884_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I33_MP3 (XI1_I884_I33_p1 XI1_I884_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I33_MP0 (VDD I1_p6_0 XI1_I884_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I32_MP1 (VDD I1_b6_0 XI1_I838_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I32_MP5 (I1_I838_pn0 I1_b6_0 XI1_I838_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I32_MP4 (XI1_I838_I32_p1 XI1_I838_I32_An I1_I838_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I32_MP2 (VDD I1_aa25 XI1_I838_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I32_MP3 (XI1_I838_I32_p1 XI1_I838_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I32_MP0 (VDD I1_aa25 XI1_I838_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I32_MP1 (VDD I1_b5_0 XI1_I792_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I32_MP5 (I1_I792_pn0 I1_b5_0 XI1_I792_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I32_MP4 (XI1_I792_I32_p1 XI1_I792_I32_An I1_I792_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I32_MP2 (VDD I1_aa26 XI1_I792_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I32_MP3 (XI1_I792_I32_p1 XI1_I792_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I32_MP0 (VDD I1_aa26 XI1_I792_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I33_MP1 (VDD I1_b3_1 XI1_I700_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I33_MP5 (I1_I700_pn1 I1_b3_1 XI1_I700_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I33_MP4 (XI1_I700_I33_p1 XI1_I700_I33_An I1_I700_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I33_MP2 (VDD I1_p2_0 XI1_I700_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I33_MP3 (XI1_I700_I33_p1 XI1_I700_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I33_MP0 (VDD I1_p2_0 XI1_I700_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I204_MP1 (VDD I1_I700_G0_0 XI1_I700_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I204_MP5 (I1_p3_1 I1_I700_G0_0 XI1_I700_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I204_MP4 (XI1_I700_I204_p1 XI1_I700_I204_An I1_p3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I204_MP2 (VDD I1_I700_pn1 XI1_I700_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I204_MP3 (XI1_I700_I204_p1 XI1_I700_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I204_MP0 (VDD I1_I700_pn1 XI1_I700_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I230_MP1 (VDD I1_I700_G26_0 XI1_I700_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I230_MP5 (I1_p3_27 I1_I700_G26_0 XI1_I700_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I230_MP4 (XI1_I700_I230_p1 XI1_I700_I230_An I1_p3_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I230_MP2 (VDD I1_I700_pn27 XI1_I700_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I230_MP3 (XI1_I700_I230_p1 XI1_I700_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I230_MP0 (VDD I1_I700_pn27 XI1_I700_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I232_MP1 (VDD I1_I700_G28_0 XI1_I700_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I232_MP5 (I1_p3_29 I1_I700_G28_0 XI1_I700_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I232_MP4 (XI1_I700_I232_p1 XI1_I700_I232_An I1_p3_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I232_MP2 (VDD I1_I700_pn29 XI1_I700_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I232_MP3 (XI1_I700_I232_p1 XI1_I700_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I232_MP0 (VDD I1_I700_pn29 XI1_I700_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I231_MP1 (VDD I1_I1390_G27_0 XI1_I1390_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I231_MP5 (I1_p18_28 I1_I1390_G27_0 XI1_I1390_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I231_MP4 (XI1_I1390_I231_p1 XI1_I1390_I231_An I1_p18_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I231_MP2 (VDD I1_I1390_pn28 XI1_I1390_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I231_MP3 (XI1_I1390_I231_p1 XI1_I1390_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I231_MP0 (VDD I1_I1390_pn28 XI1_I1390_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I229_MP1 (VDD I1_I1390_G25_0 XI1_I1390_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I229_MP5 (I1_p18_26 I1_I1390_G25_0 XI1_I1390_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I229_MP4 (XI1_I1390_I229_p1 XI1_I1390_I229_An I1_p18_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I229_MP2 (VDD I1_I1390_pn26 XI1_I1390_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I229_MP3 (XI1_I1390_I229_p1 XI1_I1390_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I229_MP0 (VDD I1_I1390_pn26 XI1_I1390_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I223_MP1 (VDD I1_I1390_G19_0 XI1_I1390_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I223_MP5 (I1_p18_20 I1_I1390_G19_0 XI1_I1390_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I223_MP4 (XI1_I1390_I223_p1 XI1_I1390_I223_An I1_p18_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I223_MP2 (VDD I1_I1390_pn20 XI1_I1390_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I223_MP3 (XI1_I1390_I223_p1 XI1_I1390_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I223_MP0 (VDD I1_I1390_pn20 XI1_I1390_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I221_MP1 (VDD I1_I1390_G17_0 XI1_I1390_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I221_MP5 (I1_p18_18 I1_I1390_G17_0 XI1_I1390_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I221_MP4 (XI1_I1390_I221_p1 XI1_I1390_I221_An I1_p18_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I221_MP2 (VDD I1_I1390_pn18 XI1_I1390_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I221_MP3 (XI1_I1390_I221_p1 XI1_I1390_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I221_MP0 (VDD I1_I1390_pn18 XI1_I1390_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I38_MP1 (VDD I1_b18_6 XI1_I1390_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I38_MP5 (I1_I1390_pn6 I1_b18_6 XI1_I1390_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I38_MP4 (XI1_I1390_I38_p1 XI1_I1390_I38_An I1_I1390_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I38_MP2 (VDD I1_p17_5 XI1_I1390_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I38_MP3 (XI1_I1390_I38_p1 XI1_I1390_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I38_MP0 (VDD I1_p17_5 XI1_I1390_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I37_MP1 (VDD I1_b18_5 XI1_I1390_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I37_MP5 (I1_I1390_pn5 I1_b18_5 XI1_I1390_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I37_MP4 (XI1_I1390_I37_p1 XI1_I1390_I37_An I1_I1390_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I37_MP2 (VDD I1_p17_4 XI1_I1390_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I37_MP3 (XI1_I1390_I37_p1 XI1_I1390_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I37_MP0 (VDD I1_p17_4 XI1_I1390_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I33_MP1 (VDD I1_b17_1 XI1_I1344_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I33_MP5 (I1_I1344_pn1 I1_b17_1 XI1_I1344_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I33_MP4 (XI1_I1344_I33_p1 XI1_I1344_I33_An I1_I1344_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I33_MP2 (VDD I1_p16_0 XI1_I1344_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I33_MP3 (XI1_I1344_I33_p1 XI1_I1344_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I33_MP0 (VDD I1_p16_0 XI1_I1344_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I59_MP1 (VDD I1_b13_27 XI1_I1160_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I59_MP5 (I1_I1160_pn27 I1_b13_27 XI1_I1160_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I59_MP4 (XI1_I1160_I59_p1 XI1_I1160_I59_An I1_I1160_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I59_MP2 (VDD I1_p12_26 XI1_I1160_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I59_MP3 (XI1_I1160_I59_p1 XI1_I1160_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I59_MP0 (VDD I1_p12_26 XI1_I1160_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I32_MP1 (VDD I1_b15_0 XI1_I1252_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I32_MP5 (I1_I1252_pn0 I1_b15_0 XI1_I1252_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I32_MP4 (XI1_I1252_I32_p1 XI1_I1252_I32_An I1_I1252_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I32_MP2 (VDD I1_aa16 XI1_I1252_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I32_MP3 (XI1_I1252_I32_p1 XI1_I1252_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I32_MP0 (VDD I1_aa16 XI1_I1252_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I61_MP1 (VDD I1_b13_29 XI1_I1160_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I61_MP5 (I1_I1160_pn29 I1_b13_29 XI1_I1160_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I61_MP4 (XI1_I1160_I61_p1 XI1_I1160_I61_An I1_I1160_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I61_MP2 (VDD I1_p12_28 XI1_I1160_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I61_MP3 (XI1_I1160_I61_p1 XI1_I1160_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I61_MP0 (VDD I1_p12_28 XI1_I1160_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I234_MP1 (VDD I1_c13_m XI1_I1160_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I234_MP5 (I1_p13_31 I1_c13_m XI1_I1160_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I234_MP4 (XI1_I1160_I234_p1 XI1_I1160_I234_An I1_p13_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I234_MP2 (VDD I1_I1160_pn31 XI1_I1160_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I234_MP3 (XI1_I1160_I234_p1 XI1_I1160_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I234_MP0 (VDD I1_I1160_pn31 XI1_I1160_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I226_MP1 (VDD I1_I1160_G22_0 XI1_I1160_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I226_MP5 (I1_p13_23 I1_I1160_G22_0 XI1_I1160_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I226_MP4 (XI1_I1160_I226_p1 XI1_I1160_I226_An I1_p13_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I226_MP2 (VDD I1_I1160_pn23 XI1_I1160_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I226_MP3 (XI1_I1160_I226_p1 XI1_I1160_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I226_MP0 (VDD I1_I1160_pn23 XI1_I1160_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I220_MP1 (VDD I1_I1160_G16_0 XI1_I1160_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I220_MP5 (I1_p13_17 I1_I1160_G16_0 XI1_I1160_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I220_MP4 (XI1_I1160_I220_p1 XI1_I1160_I220_An I1_p13_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I220_MP2 (VDD I1_I1160_pn17 XI1_I1160_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I220_MP3 (XI1_I1160_I220_p1 XI1_I1160_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I220_MP0 (VDD I1_I1160_pn17 XI1_I1160_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I230_MP1 (VDD I1_I1160_G26_0 XI1_I1160_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I230_MP5 (I1_p13_27 I1_I1160_G26_0 XI1_I1160_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I230_MP4 (XI1_I1160_I230_p1 XI1_I1160_I230_An I1_p13_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I230_MP2 (VDD I1_I1160_pn27 XI1_I1160_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I230_MP3 (XI1_I1160_I230_p1 XI1_I1160_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I230_MP0 (VDD I1_I1160_pn27 XI1_I1160_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I222_MP1 (VDD I1_I1160_G18_0 XI1_I1160_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I222_MP5 (I1_p13_19 I1_I1160_G18_0 XI1_I1160_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I222_MP4 (XI1_I1160_I222_p1 XI1_I1160_I222_An I1_p13_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I222_MP2 (VDD I1_I1160_pn19 XI1_I1160_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I222_MP3 (XI1_I1160_I222_p1 XI1_I1160_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I222_MP0 (VDD I1_I1160_pn19 XI1_I1160_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I228_MP1 (VDD I1_I1160_G24_0 XI1_I1160_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I228_MP5 (I1_p13_25 I1_I1160_G24_0 XI1_I1160_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I228_MP4 (XI1_I1160_I228_p1 XI1_I1160_I228_An I1_p13_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I228_MP2 (VDD I1_I1160_pn25 XI1_I1160_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I228_MP3 (XI1_I1160_I228_p1 XI1_I1160_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I228_MP0 (VDD I1_I1160_pn25 XI1_I1160_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I208_MP1 (VDD I1_I1160_G4_0 XI1_I1160_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I208_MP5 (I1_p13_5 I1_I1160_G4_0 XI1_I1160_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I208_MP4 (XI1_I1160_I208_p1 XI1_I1160_I208_An I1_p13_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I208_MP2 (VDD I1_I1160_pn5 XI1_I1160_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I208_MP3 (XI1_I1160_I208_p1 XI1_I1160_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I208_MP0 (VDD I1_I1160_pn5 XI1_I1160_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I205_MP1 (VDD I1_I1160_G1_0 XI1_I1160_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I205_MP5 (I1_p13_2 I1_I1160_G1_0 XI1_I1160_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I205_MP4 (XI1_I1160_I205_p1 XI1_I1160_I205_An I1_p13_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I205_MP2 (VDD I1_I1160_pn2 XI1_I1160_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I205_MP3 (XI1_I1160_I205_p1 XI1_I1160_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I205_MP0 (VDD I1_I1160_pn2 XI1_I1160_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I204_MP1 (VDD I1_I1160_G0_0 XI1_I1160_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I204_MP5 (I1_p13_1 I1_I1160_G0_0 XI1_I1160_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I204_MP4 (XI1_I1160_I204_p1 XI1_I1160_I204_An I1_p13_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I204_MP2 (VDD I1_I1160_pn1 XI1_I1160_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I204_MP3 (XI1_I1160_I204_p1 XI1_I1160_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I204_MP0 (VDD I1_I1160_pn1 XI1_I1160_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I32_MP1 (VDD I1_b14_0 XI1_I1206_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I32_MP5 (I1_I1206_pn0 I1_b14_0 XI1_I1206_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I32_MP4 (XI1_I1206_I32_p1 XI1_I1206_I32_An I1_I1206_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I32_MP2 (VDD I1_aa17 XI1_I1206_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I32_MP3 (XI1_I1206_I32_p1 XI1_I1206_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I32_MP0 (VDD I1_aa17 XI1_I1206_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I63_MP1 (VDD I1_b8_31 XI1_I930_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I63_MP5 (I1_I930_pn31 I1_b8_31 XI1_I930_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I63_MP4 (XI1_I930_I63_p1 XI1_I930_I63_An I1_I930_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I63_MP2 (VDD I1_p7_30 XI1_I930_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I63_MP3 (XI1_I930_I63_p1 XI1_I930_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I63_MP0 (VDD I1_p7_30 XI1_I930_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I41_MP1 (VDD I1_b8_9 XI1_I930_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I41_MP5 (I1_I930_pn9 I1_b8_9 XI1_I930_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I41_MP4 (XI1_I930_I41_p1 XI1_I930_I41_An I1_I930_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I41_MP2 (VDD I1_p7_8 XI1_I930_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I41_MP3 (XI1_I930_I41_p1 XI1_I930_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I41_MP0 (VDD I1_p7_8 XI1_I930_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I40_MP1 (VDD I1_b8_8 XI1_I930_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I40_MP5 (I1_I930_pn8 I1_b8_8 XI1_I930_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I40_MP4 (XI1_I930_I40_p1 XI1_I930_I40_An I1_I930_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I40_MP2 (VDD I1_p7_7 XI1_I930_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I40_MP3 (XI1_I930_I40_p1 XI1_I930_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I40_MP0 (VDD I1_p7_7 XI1_I930_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I38_MP1 (VDD I1_b8_6 XI1_I930_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I38_MP5 (I1_I930_pn6 I1_b8_6 XI1_I930_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I38_MP4 (XI1_I930_I38_p1 XI1_I930_I38_An I1_I930_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I38_MP2 (VDD I1_p7_5 XI1_I930_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I38_MP3 (XI1_I930_I38_p1 XI1_I930_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I38_MP0 (VDD I1_p7_5 XI1_I930_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I204_MP1 (VDD I1_I884_G0_0 XI1_I884_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I204_MP5 (I1_p7_1 I1_I884_G0_0 XI1_I884_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I204_MP4 (XI1_I884_I204_p1 XI1_I884_I204_An I1_p7_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I204_MP2 (VDD I1_I884_pn1 XI1_I884_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I204_MP3 (XI1_I884_I204_p1 XI1_I884_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I204_MP0 (VDD I1_I884_pn1 XI1_I884_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I203_MP1 (VDD I1_qu28_b3_5 XI1_I746_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I203_MP5 (I1_p4_0 I1_qu28_b3_5 XI1_I746_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I203_MP4 (XI1_I746_I203_p1 XI1_I746_I203_An I1_p4_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I203_MP2 (VDD I1_I746_pn0 XI1_I746_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I203_MP3 (XI1_I746_I203_p1 XI1_I746_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I203_MP0 (VDD I1_I746_pn0 XI1_I746_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I34_MP1 (VDD I1_b3_2 XI1_I700_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I34_MP5 (I1_I700_pn2 I1_b3_2 XI1_I700_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I34_MP4 (XI1_I700_I34_p1 XI1_I700_I34_An I1_I700_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I34_MP2 (VDD I1_p2_1 XI1_I700_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I34_MP3 (XI1_I700_I34_p1 XI1_I700_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I34_MP0 (VDD I1_p2_1 XI1_I700_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I60_MP1 (VDD I1_b3_28 XI1_I700_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I60_MP5 (I1_I700_pn28 I1_b3_28 XI1_I700_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I60_MP4 (XI1_I700_I60_p1 XI1_I700_I60_An I1_I700_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I60_MP2 (VDD I1_p2_27 XI1_I700_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I60_MP3 (XI1_I700_I60_p1 XI1_I700_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I60_MP0 (VDD I1_p2_27 XI1_I700_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I234_MP1 (VDD I1_c18_m XI1_I1390_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I234_MP5 (I1_p18_31 I1_c18_m XI1_I1390_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I234_MP4 (XI1_I1390_I234_p1 XI1_I1390_I234_An I1_p18_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I234_MP2 (VDD I1_I1390_pn31 XI1_I1390_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I234_MP3 (XI1_I1390_I234_p1 XI1_I1390_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I234_MP0 (VDD I1_I1390_pn31 XI1_I1390_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I211_MP1 (VDD I1_I1390_G7_0 XI1_I1390_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I211_MP5 (I1_p18_8 I1_I1390_G7_0 XI1_I1390_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I211_MP4 (XI1_I1390_I211_p1 XI1_I1390_I211_An I1_p18_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I211_MP2 (VDD I1_I1390_pn8 XI1_I1390_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I211_MP3 (XI1_I1390_I211_p1 XI1_I1390_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I211_MP0 (VDD I1_I1390_pn8 XI1_I1390_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I209_MP1 (VDD I1_I1390_G5_0 XI1_I1390_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I209_MP5 (I1_p18_6 I1_I1390_G5_0 XI1_I1390_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I209_MP4 (XI1_I1390_I209_p1 XI1_I1390_I209_An I1_p18_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I209_MP2 (VDD I1_I1390_pn6 XI1_I1390_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I209_MP3 (XI1_I1390_I209_p1 XI1_I1390_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I209_MP0 (VDD I1_I1390_pn6 XI1_I1390_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I36_MP1 (VDD I1_b18_4 XI1_I1390_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I36_MP5 (I1_I1390_pn4 I1_b18_4 XI1_I1390_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I36_MP4 (XI1_I1390_I36_p1 XI1_I1390_I36_An I1_I1390_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I36_MP2 (VDD I1_p17_3 XI1_I1390_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I36_MP3 (XI1_I1390_I36_p1 XI1_I1390_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I36_MP0 (VDD I1_p17_3 XI1_I1390_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I35_MP1 (VDD I1_b18_3 XI1_I1390_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I35_MP5 (I1_I1390_pn3 I1_b18_3 XI1_I1390_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I35_MP4 (XI1_I1390_I35_p1 XI1_I1390_I35_An I1_I1390_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I35_MP2 (VDD I1_p17_2 XI1_I1390_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I35_MP3 (XI1_I1390_I35_p1 XI1_I1390_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I35_MP0 (VDD I1_p17_2 XI1_I1390_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I204_MP1 (VDD I1_I1344_G0_0 XI1_I1344_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I204_MP5 (I1_p17_1 I1_I1344_G0_0 XI1_I1344_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I204_MP4 (XI1_I1344_I204_p1 XI1_I1344_I204_An I1_p17_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I204_MP2 (VDD I1_I1344_pn1 XI1_I1344_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I204_MP3 (XI1_I1344_I204_p1 XI1_I1344_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I204_MP0 (VDD I1_I1344_pn1 XI1_I1344_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I203_MP1 (VDD I1_qu16_b3_5 XI1_I1298_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I203_MP5 (I1_p16_0 I1_qu16_b3_5 XI1_I1298_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I203_MP4 (XI1_I1298_I203_p1 XI1_I1298_I203_An I1_p16_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I203_MP2 (VDD I1_I1298_pn0 XI1_I1298_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I203_MP3 (XI1_I1298_I203_p1 XI1_I1298_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I203_MP0 (VDD I1_I1298_pn0 XI1_I1298_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I32_MP1 (VDD I1_b16_0 XI1_I1298_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I32_MP5 (I1_I1298_pn0 I1_b16_0 XI1_I1298_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I32_MP4 (XI1_I1298_I32_p1 XI1_I1298_I32_An I1_I1298_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I32_MP2 (VDD I1_aa15 XI1_I1298_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I32_MP3 (XI1_I1298_I32_p1 XI1_I1298_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I32_MP0 (VDD I1_aa15 XI1_I1298_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I62_MP1 (VDD I1_b13_30 XI1_I1160_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I62_MP5 (I1_I1160_pn30 I1_b13_30 XI1_I1160_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I62_MP4 (XI1_I1160_I62_p1 XI1_I1160_I62_An I1_I1160_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I62_MP2 (VDD I1_p12_29 XI1_I1160_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I62_MP3 (XI1_I1160_I62_p1 XI1_I1160_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I62_MP0 (VDD I1_p12_29 XI1_I1160_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I33_MP1 (VDD I1_b13_1 XI1_I1160_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I33_MP5 (I1_I1160_pn1 I1_b13_1 XI1_I1160_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I33_MP4 (XI1_I1160_I33_p1 XI1_I1160_I33_An I1_I1160_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I33_MP2 (VDD I1_p12_0 XI1_I1160_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I33_MP3 (XI1_I1160_I33_p1 XI1_I1160_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I33_MP0 (VDD I1_p12_0 XI1_I1160_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I203_MP1 (VDD I1_qu19_b3_5 XI1_I1160_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I203_MP5 (I1_p13_0 I1_qu19_b3_5 XI1_I1160_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I203_MP4 (XI1_I1160_I203_p1 XI1_I1160_I203_An I1_p13_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I203_MP2 (VDD I1_I1160_pn0 XI1_I1160_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I203_MP3 (XI1_I1160_I203_p1 XI1_I1160_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I203_MP0 (VDD I1_I1160_pn0 XI1_I1160_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I62_MP1 (VDD I1_b8_30 XI1_I930_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I62_MP5 (I1_I930_pn30 I1_b8_30 XI1_I930_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I62_MP4 (XI1_I930_I62_p1 XI1_I930_I62_An I1_I930_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I62_MP2 (VDD I1_p7_29 XI1_I930_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I62_MP3 (XI1_I930_I62_p1 XI1_I930_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I62_MP0 (VDD I1_p7_29 XI1_I930_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I37_MP1 (VDD I1_b8_5 XI1_I930_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I37_MP5 (I1_I930_pn5 I1_b8_5 XI1_I930_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I37_MP4 (XI1_I930_I37_p1 XI1_I930_I37_An I1_I930_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I37_MP2 (VDD I1_p7_4 XI1_I930_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I37_MP3 (XI1_I930_I37_p1 XI1_I930_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I37_MP0 (VDD I1_p7_4 XI1_I930_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I35_MP1 (VDD I1_b3_3 XI1_I700_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I35_MP5 (I1_I700_pn3 I1_b3_3 XI1_I700_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I35_MP4 (XI1_I700_I35_p1 XI1_I700_I35_An I1_I700_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I35_MP2 (VDD I1_p2_2 XI1_I700_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I35_MP3 (XI1_I700_I35_p1 XI1_I700_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I35_MP0 (VDD I1_p2_2 XI1_I700_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I37_MP1 (VDD I1_b3_5 XI1_I700_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I37_MP5 (I1_I700_pn5 I1_b3_5 XI1_I700_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I37_MP4 (XI1_I700_I37_p1 XI1_I700_I37_An I1_I700_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I37_MP2 (VDD I1_p2_4 XI1_I700_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I37_MP3 (XI1_I700_I37_p1 XI1_I700_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I37_MP0 (VDD I1_p2_4 XI1_I700_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I38_MP1 (VDD I1_b3_6 XI1_I700_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I38_MP5 (I1_I700_pn6 I1_b3_6 XI1_I700_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I38_MP4 (XI1_I700_I38_p1 XI1_I700_I38_An I1_I700_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I38_MP2 (VDD I1_p2_5 XI1_I700_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I38_MP3 (XI1_I700_I38_p1 XI1_I700_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I38_MP0 (VDD I1_p2_5 XI1_I700_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I40_MP1 (VDD I1_b3_8 XI1_I700_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I40_MP5 (I1_I700_pn8 I1_b3_8 XI1_I700_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I40_MP4 (XI1_I700_I40_p1 XI1_I700_I40_An I1_I700_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I40_MP2 (VDD I1_p2_7 XI1_I700_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I40_MP3 (XI1_I700_I40_p1 XI1_I700_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I40_MP0 (VDD I1_p2_7 XI1_I700_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I39_MP1 (VDD I1_b3_7 XI1_I700_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I39_MP5 (I1_I700_pn7 I1_b3_7 XI1_I700_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I39_MP4 (XI1_I700_I39_p1 XI1_I700_I39_An I1_I700_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I39_MP2 (VDD I1_p2_6 XI1_I700_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I39_MP3 (XI1_I700_I39_p1 XI1_I700_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I39_MP0 (VDD I1_p2_6 XI1_I700_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I41_MP1 (VDD I1_b3_9 XI1_I700_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I41_MP5 (I1_I700_pn9 I1_b3_9 XI1_I700_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I41_MP4 (XI1_I700_I41_p1 XI1_I700_I41_An I1_I700_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I41_MP2 (VDD I1_p2_8 XI1_I700_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I41_MP3 (XI1_I700_I41_p1 XI1_I700_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I41_MP0 (VDD I1_p2_8 XI1_I700_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I43_MP1 (VDD I1_b3_11 XI1_I700_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I43_MP5 (I1_I700_pn11 I1_b3_11 XI1_I700_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I43_MP4 (XI1_I700_I43_p1 XI1_I700_I43_An I1_I700_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I43_MP2 (VDD I1_p2_10 XI1_I700_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I43_MP3 (XI1_I700_I43_p1 XI1_I700_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I43_MP0 (VDD I1_p2_10 XI1_I700_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I45_MP1 (VDD I1_b3_13 XI1_I700_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I45_MP5 (I1_I700_pn13 I1_b3_13 XI1_I700_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I45_MP4 (XI1_I700_I45_p1 XI1_I700_I45_An I1_I700_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I45_MP2 (VDD I1_p2_12 XI1_I700_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I45_MP3 (XI1_I700_I45_p1 XI1_I700_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I45_MP0 (VDD I1_p2_12 XI1_I700_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I46_MP1 (VDD I1_b3_14 XI1_I700_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I46_MP5 (I1_I700_pn14 I1_b3_14 XI1_I700_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I46_MP4 (XI1_I700_I46_p1 XI1_I700_I46_An I1_I700_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I46_MP2 (VDD I1_p2_13 XI1_I700_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I46_MP3 (XI1_I700_I46_p1 XI1_I700_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I46_MP0 (VDD I1_p2_13 XI1_I700_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I51_MP1 (VDD I1_b3_19 XI1_I700_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I51_MP5 (I1_I700_pn19 I1_b3_19 XI1_I700_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I51_MP4 (XI1_I700_I51_p1 XI1_I700_I51_An I1_I700_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I51_MP2 (VDD I1_p2_18 XI1_I700_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I51_MP3 (XI1_I700_I51_p1 XI1_I700_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I51_MP0 (VDD I1_p2_18 XI1_I700_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I52_MP1 (VDD I1_b3_20 XI1_I700_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I52_MP5 (I1_I700_pn20 I1_b3_20 XI1_I700_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I52_MP4 (XI1_I700_I52_p1 XI1_I700_I52_An I1_I700_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I52_MP2 (VDD I1_p2_19 XI1_I700_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I52_MP3 (XI1_I700_I52_p1 XI1_I700_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I52_MP0 (VDD I1_p2_19 XI1_I700_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I54_MP1 (VDD I1_b3_22 XI1_I700_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I54_MP5 (I1_I700_pn22 I1_b3_22 XI1_I700_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I54_MP4 (XI1_I700_I54_p1 XI1_I700_I54_An I1_I700_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I54_MP2 (VDD I1_p2_21 XI1_I700_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I54_MP3 (XI1_I700_I54_p1 XI1_I700_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I54_MP0 (VDD I1_p2_21 XI1_I700_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I56_MP1 (VDD I1_b3_24 XI1_I700_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I56_MP5 (I1_I700_pn24 I1_b3_24 XI1_I700_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I56_MP4 (XI1_I700_I56_p1 XI1_I700_I56_An I1_I700_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I56_MP2 (VDD I1_p2_23 XI1_I700_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I56_MP3 (XI1_I700_I56_p1 XI1_I700_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I56_MP0 (VDD I1_p2_23 XI1_I700_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I59_MP1 (VDD I1_b3_27 XI1_I700_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I59_MP5 (I1_I700_pn27 I1_b3_27 XI1_I700_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I59_MP4 (XI1_I700_I59_p1 XI1_I700_I59_An I1_I700_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I59_MP2 (VDD I1_p2_26 XI1_I700_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I59_MP3 (XI1_I700_I59_p1 XI1_I700_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I59_MP0 (VDD I1_p2_26 XI1_I700_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I232_MP1 (VDD I1_I1390_G28_0 XI1_I1390_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I232_MP5 (I1_p18_29 I1_I1390_G28_0 XI1_I1390_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I232_MP4 (XI1_I1390_I232_p1 XI1_I1390_I232_An I1_p18_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I232_MP2 (VDD I1_I1390_pn29 XI1_I1390_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I232_MP3 (XI1_I1390_I232_p1 XI1_I1390_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I232_MP0 (VDD I1_I1390_pn29 XI1_I1390_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I230_MP1 (VDD I1_I1390_G26_0 XI1_I1390_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I230_MP5 (I1_p18_27 I1_I1390_G26_0 XI1_I1390_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I230_MP4 (XI1_I1390_I230_p1 XI1_I1390_I230_An I1_p18_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I230_MP2 (VDD I1_I1390_pn27 XI1_I1390_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I230_MP3 (XI1_I1390_I230_p1 XI1_I1390_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I230_MP0 (VDD I1_I1390_pn27 XI1_I1390_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I228_MP1 (VDD I1_I1390_G24_0 XI1_I1390_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I228_MP5 (I1_p18_25 I1_I1390_G24_0 XI1_I1390_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I228_MP4 (XI1_I1390_I228_p1 XI1_I1390_I228_An I1_p18_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I228_MP2 (VDD I1_I1390_pn25 XI1_I1390_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I228_MP3 (XI1_I1390_I228_p1 XI1_I1390_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I228_MP0 (VDD I1_I1390_pn25 XI1_I1390_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I208_MP1 (VDD I1_I1390_G4_0 XI1_I1390_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I208_MP5 (I1_p18_5 I1_I1390_G4_0 XI1_I1390_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I208_MP4 (XI1_I1390_I208_p1 XI1_I1390_I208_An I1_p18_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I208_MP2 (VDD I1_I1390_pn5 XI1_I1390_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I208_MP3 (XI1_I1390_I208_p1 XI1_I1390_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I208_MP0 (VDD I1_I1390_pn5 XI1_I1390_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I34_MP1 (VDD I1_b18_2 XI1_I1390_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I34_MP5 (I1_I1390_pn2 I1_b18_2 XI1_I1390_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I34_MP4 (XI1_I1390_I34_p1 XI1_I1390_I34_An I1_I1390_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I34_MP2 (VDD I1_p17_1 XI1_I1390_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I34_MP3 (XI1_I1390_I34_p1 XI1_I1390_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I34_MP0 (VDD I1_p17_1 XI1_I1390_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I57_MP1 (VDD I1_b13_25 XI1_I1160_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I57_MP5 (I1_I1160_pn25 I1_b13_25 XI1_I1160_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I57_MP4 (XI1_I1160_I57_p1 XI1_I1160_I57_An I1_I1160_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I57_MP2 (VDD I1_p12_24 XI1_I1160_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I57_MP3 (XI1_I1160_I57_p1 XI1_I1160_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I57_MP0 (VDD I1_p12_24 XI1_I1160_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I60_MP1 (VDD I1_b13_28 XI1_I1160_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I60_MP5 (I1_I1160_pn28 I1_b13_28 XI1_I1160_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I60_MP4 (XI1_I1160_I60_p1 XI1_I1160_I60_An I1_I1160_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I60_MP2 (VDD I1_p12_27 XI1_I1160_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I60_MP3 (XI1_I1160_I60_p1 XI1_I1160_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I60_MP0 (VDD I1_p12_27 XI1_I1160_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I58_MP1 (VDD I1_b13_26 XI1_I1160_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I58_MP5 (I1_I1160_pn26 I1_b13_26 XI1_I1160_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I58_MP4 (XI1_I1160_I58_p1 XI1_I1160_I58_An I1_I1160_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I58_MP2 (VDD I1_p12_25 XI1_I1160_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I58_MP3 (XI1_I1160_I58_p1 XI1_I1160_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I58_MP0 (VDD I1_p12_25 XI1_I1160_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I56_MP1 (VDD I1_b13_24 XI1_I1160_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I56_MP5 (I1_I1160_pn24 I1_b13_24 XI1_I1160_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I56_MP4 (XI1_I1160_I56_p1 XI1_I1160_I56_An I1_I1160_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I56_MP2 (VDD I1_p12_23 XI1_I1160_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I56_MP3 (XI1_I1160_I56_p1 XI1_I1160_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I56_MP0 (VDD I1_p12_23 XI1_I1160_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I55_MP1 (VDD I1_b13_23 XI1_I1160_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I55_MP5 (I1_I1160_pn23 I1_b13_23 XI1_I1160_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I55_MP4 (XI1_I1160_I55_p1 XI1_I1160_I55_An I1_I1160_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I55_MP2 (VDD I1_p12_22 XI1_I1160_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I55_MP3 (XI1_I1160_I55_p1 XI1_I1160_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I55_MP0 (VDD I1_p12_22 XI1_I1160_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I35_MP1 (VDD I1_b13_3 XI1_I1160_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I35_MP5 (I1_I1160_pn3 I1_b13_3 XI1_I1160_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I35_MP4 (XI1_I1160_I35_p1 XI1_I1160_I35_An I1_I1160_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I35_MP2 (VDD I1_p12_2 XI1_I1160_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I35_MP3 (XI1_I1160_I35_p1 XI1_I1160_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I35_MP0 (VDD I1_p12_2 XI1_I1160_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I34_MP1 (VDD I1_b13_2 XI1_I1160_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I34_MP5 (I1_I1160_pn2 I1_b13_2 XI1_I1160_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I34_MP4 (XI1_I1160_I34_p1 XI1_I1160_I34_An I1_I1160_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I34_MP2 (VDD I1_p12_1 XI1_I1160_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I34_MP3 (XI1_I1160_I34_p1 XI1_I1160_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I34_MP0 (VDD I1_p12_1 XI1_I1160_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I32_MP1 (VDD I1_b13_0 XI1_I1160_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I32_MP5 (I1_I1160_pn0 I1_b13_0 XI1_I1160_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I32_MP4 (XI1_I1160_I32_p1 XI1_I1160_I32_An I1_I1160_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I32_MP2 (VDD I1_aa18 XI1_I1160_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I32_MP3 (XI1_I1160_I32_p1 XI1_I1160_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I32_MP0 (VDD I1_aa18 XI1_I1160_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I233_MP1 (VDD I1_I930_G29_0 XI1_I930_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I233_MP5 (I1_p8_30 I1_I930_G29_0 XI1_I930_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I233_MP4 (XI1_I930_I233_p1 XI1_I930_I233_An I1_p8_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I233_MP2 (VDD I1_I930_pn30 XI1_I930_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I233_MP3 (XI1_I930_I233_p1 XI1_I930_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I233_MP0 (VDD I1_I930_pn30 XI1_I930_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I231_MP1 (VDD I1_I930_G27_0 XI1_I930_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I231_MP5 (I1_p8_28 I1_I930_G27_0 XI1_I930_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I231_MP4 (XI1_I930_I231_p1 XI1_I930_I231_An I1_p8_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I231_MP2 (VDD I1_I930_pn28 XI1_I930_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I231_MP3 (XI1_I930_I231_p1 XI1_I930_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I231_MP0 (VDD I1_I930_pn28 XI1_I930_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I229_MP1 (VDD I1_I930_G25_0 XI1_I930_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I229_MP5 (I1_p8_26 I1_I930_G25_0 XI1_I930_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I229_MP4 (XI1_I930_I229_p1 XI1_I930_I229_An I1_p8_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I229_MP2 (VDD I1_I930_pn26 XI1_I930_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I229_MP3 (XI1_I930_I229_p1 XI1_I930_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I229_MP0 (VDD I1_I930_pn26 XI1_I930_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I227_MP1 (VDD I1_I930_G23_0 XI1_I930_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I227_MP5 (I1_p8_24 I1_I930_G23_0 XI1_I930_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I227_MP4 (XI1_I930_I227_p1 XI1_I930_I227_An I1_p8_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I227_MP2 (VDD I1_I930_pn24 XI1_I930_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I227_MP3 (XI1_I930_I227_p1 XI1_I930_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I227_MP0 (VDD I1_I930_pn24 XI1_I930_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I225_MP1 (VDD I1_I930_G21_0 XI1_I930_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I225_MP5 (I1_p8_22 I1_I930_G21_0 XI1_I930_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I225_MP4 (XI1_I930_I225_p1 XI1_I930_I225_An I1_p8_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I225_MP2 (VDD I1_I930_pn22 XI1_I930_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I225_MP3 (XI1_I930_I225_p1 XI1_I930_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I225_MP0 (VDD I1_I930_pn22 XI1_I930_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I223_MP1 (VDD I1_I930_G19_0 XI1_I930_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I223_MP5 (I1_p8_20 I1_I930_G19_0 XI1_I930_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I223_MP4 (XI1_I930_I223_p1 XI1_I930_I223_An I1_p8_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I223_MP2 (VDD I1_I930_pn20 XI1_I930_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I223_MP3 (XI1_I930_I223_p1 XI1_I930_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I223_MP0 (VDD I1_I930_pn20 XI1_I930_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I221_MP1 (VDD I1_I930_G17_0 XI1_I930_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I221_MP5 (I1_p8_18 I1_I930_G17_0 XI1_I930_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I221_MP4 (XI1_I930_I221_p1 XI1_I930_I221_An I1_p8_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I221_MP2 (VDD I1_I930_pn18 XI1_I930_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I221_MP3 (XI1_I930_I221_p1 XI1_I930_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I221_MP0 (VDD I1_I930_pn18 XI1_I930_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I211_MP1 (VDD I1_I930_G7_0 XI1_I930_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I211_MP5 (I1_p8_8 I1_I930_G7_0 XI1_I930_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I211_MP4 (XI1_I930_I211_p1 XI1_I930_I211_An I1_p8_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I211_MP2 (VDD I1_I930_pn8 XI1_I930_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I211_MP3 (XI1_I930_I211_p1 XI1_I930_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I211_MP0 (VDD I1_I930_pn8 XI1_I930_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I36_MP1 (VDD I1_b8_4 XI1_I930_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I36_MP5 (I1_I930_pn4 I1_b8_4 XI1_I930_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I36_MP4 (XI1_I930_I36_p1 XI1_I930_I36_An I1_I930_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I36_MP2 (VDD I1_p7_3 XI1_I930_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I36_MP3 (XI1_I930_I36_p1 XI1_I930_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I36_MP0 (VDD I1_p7_3 XI1_I930_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I32_MP1 (VDD I1_b4_0 XI1_I746_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I32_MP5 (I1_I746_pn0 I1_b4_0 XI1_I746_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I32_MP4 (XI1_I746_I32_p1 XI1_I746_I32_An I1_I746_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I32_MP2 (VDD I1_aa27 XI1_I746_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I32_MP3 (XI1_I746_I32_p1 XI1_I746_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I32_MP0 (VDD I1_aa27 XI1_I746_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I203_MP1 (VDD I1_qu29_b3_5 XI1_I700_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I203_MP5 (I1_p3_0 I1_qu29_b3_5 XI1_I700_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I203_MP4 (XI1_I700_I203_p1 XI1_I700_I203_An I1_p3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I203_MP2 (VDD I1_I700_pn0 XI1_I700_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I203_MP3 (XI1_I700_I203_p1 XI1_I700_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I203_MP0 (VDD I1_I700_pn0 XI1_I700_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I36_MP1 (VDD I1_b3_4 XI1_I700_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I36_MP5 (I1_I700_pn4 I1_b3_4 XI1_I700_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I36_MP4 (XI1_I700_I36_p1 XI1_I700_I36_An I1_I700_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I36_MP2 (VDD I1_p2_3 XI1_I700_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I36_MP3 (XI1_I700_I36_p1 XI1_I700_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I36_MP0 (VDD I1_p2_3 XI1_I700_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I44_MP1 (VDD I1_b3_12 XI1_I700_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I44_MP5 (I1_I700_pn12 I1_b3_12 XI1_I700_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I44_MP4 (XI1_I700_I44_p1 XI1_I700_I44_An I1_I700_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I44_MP2 (VDD I1_p2_11 XI1_I700_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I44_MP3 (XI1_I700_I44_p1 XI1_I700_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I44_MP0 (VDD I1_p2_11 XI1_I700_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I47_MP1 (VDD I1_b3_15 XI1_I700_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I47_MP5 (I1_I700_pn15 I1_b3_15 XI1_I700_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I47_MP4 (XI1_I700_I47_p1 XI1_I700_I47_An I1_I700_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I47_MP2 (VDD I1_p2_14 XI1_I700_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I47_MP3 (XI1_I700_I47_p1 XI1_I700_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I47_MP0 (VDD I1_p2_14 XI1_I700_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I49_MP1 (VDD I1_b3_17 XI1_I700_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I49_MP5 (I1_I700_pn17 I1_b3_17 XI1_I700_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I49_MP4 (XI1_I700_I49_p1 XI1_I700_I49_An I1_I700_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I49_MP2 (VDD I1_p2_16 XI1_I700_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I49_MP3 (XI1_I700_I49_p1 XI1_I700_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I49_MP0 (VDD I1_p2_16 XI1_I700_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I50_MP1 (VDD I1_b3_18 XI1_I700_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I50_MP5 (I1_I700_pn18 I1_b3_18 XI1_I700_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I50_MP4 (XI1_I700_I50_p1 XI1_I700_I50_An I1_I700_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I50_MP2 (VDD I1_p2_17 XI1_I700_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I50_MP3 (XI1_I700_I50_p1 XI1_I700_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I50_MP0 (VDD I1_p2_17 XI1_I700_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I55_MP1 (VDD I1_b3_23 XI1_I700_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I55_MP5 (I1_I700_pn23 I1_b3_23 XI1_I700_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I55_MP4 (XI1_I700_I55_p1 XI1_I700_I55_An I1_I700_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I55_MP2 (VDD I1_p2_22 XI1_I700_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I55_MP3 (XI1_I700_I55_p1 XI1_I700_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I55_MP0 (VDD I1_p2_22 XI1_I700_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I58_MP1 (VDD I1_b3_26 XI1_I700_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I58_MP5 (I1_I700_pn26 I1_b3_26 XI1_I700_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I58_MP4 (XI1_I700_I58_p1 XI1_I700_I58_An I1_I700_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I58_MP2 (VDD I1_p2_25 XI1_I700_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I58_MP3 (XI1_I700_I58_p1 XI1_I700_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I58_MP0 (VDD I1_p2_25 XI1_I700_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I61_MP1 (VDD I1_b3_29 XI1_I700_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I61_MP5 (I1_I700_pn29 I1_b3_29 XI1_I700_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I61_MP4 (XI1_I700_I61_p1 XI1_I700_I61_An I1_I700_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I61_MP2 (VDD I1_p2_28 XI1_I700_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I61_MP3 (XI1_I700_I61_p1 XI1_I700_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I61_MP0 (VDD I1_p2_28 XI1_I700_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I59_MP1 (VDD I1_b19_27 XI1_I1436_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I59_MP5 (I1_I1436_pn27 I1_b19_27 XI1_I1436_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I59_MP4 (XI1_I1436_I59_p1 XI1_I1436_I59_An I1_I1436_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I59_MP2 (VDD I1_p18_26 XI1_I1436_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I59_MP3 (XI1_I1436_I59_p1 XI1_I1436_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I59_MP0 (VDD I1_p18_26 XI1_I1436_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I226_MP1 (VDD I1_I1390_G22_0 XI1_I1390_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I226_MP5 (I1_p18_23 I1_I1390_G22_0 XI1_I1390_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I226_MP4 (XI1_I1390_I226_p1 XI1_I1390_I226_An I1_p18_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I226_MP2 (VDD I1_I1390_pn23 XI1_I1390_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I226_MP3 (XI1_I1390_I226_p1 XI1_I1390_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I226_MP0 (VDD I1_I1390_pn23 XI1_I1390_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I55_MP1 (VDD I1_b19_23 XI1_I1436_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I55_MP5 (I1_I1436_pn23 I1_b19_23 XI1_I1436_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I55_MP4 (XI1_I1436_I55_p1 XI1_I1436_I55_An I1_I1436_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I55_MP2 (VDD I1_p18_22 XI1_I1436_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I55_MP3 (XI1_I1436_I55_p1 XI1_I1436_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I55_MP0 (VDD I1_p18_22 XI1_I1436_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I224_MP1 (VDD I1_I1390_G20_0 XI1_I1390_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I224_MP5 (I1_p18_21 I1_I1390_G20_0 XI1_I1390_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I224_MP4 (XI1_I1390_I224_p1 XI1_I1390_I224_An I1_p18_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I224_MP2 (VDD I1_I1390_pn21 XI1_I1390_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I224_MP3 (XI1_I1390_I224_p1 XI1_I1390_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I224_MP0 (VDD I1_I1390_pn21 XI1_I1390_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I51_MP1 (VDD I1_b19_19 XI1_I1436_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I51_MP5 (I1_I1436_pn19 I1_b19_19 XI1_I1436_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I51_MP4 (XI1_I1436_I51_p1 XI1_I1436_I51_An I1_I1436_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I51_MP2 (VDD I1_p18_18 XI1_I1436_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I51_MP3 (XI1_I1436_I51_p1 XI1_I1436_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I51_MP0 (VDD I1_p18_18 XI1_I1436_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I222_MP1 (VDD I1_I1390_G18_0 XI1_I1390_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I222_MP5 (I1_p18_19 I1_I1390_G18_0 XI1_I1390_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I222_MP4 (XI1_I1390_I222_p1 XI1_I1390_I222_An I1_p18_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I222_MP2 (VDD I1_I1390_pn19 XI1_I1390_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I222_MP3 (XI1_I1390_I222_p1 XI1_I1390_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I222_MP0 (VDD I1_I1390_pn19 XI1_I1390_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I220_MP1 (VDD I1_I1390_G16_0 XI1_I1390_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I220_MP5 (I1_p18_17 I1_I1390_G16_0 XI1_I1390_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I220_MP4 (XI1_I1390_I220_p1 XI1_I1390_I220_An I1_p18_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I220_MP2 (VDD I1_I1390_pn17 XI1_I1390_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I220_MP3 (XI1_I1390_I220_p1 XI1_I1390_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I220_MP0 (VDD I1_I1390_pn17 XI1_I1390_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I48_MP1 (VDD I1_b19_16 XI1_I1436_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I48_MP5 (I1_I1436_pn16 I1_b19_16 XI1_I1436_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I48_MP4 (XI1_I1436_I48_p1 XI1_I1436_I48_An I1_I1436_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I48_MP2 (VDD I1_p18_15 XI1_I1436_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I48_MP3 (XI1_I1436_I48_p1 XI1_I1436_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I48_MP0 (VDD I1_p18_15 XI1_I1436_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I43_MP1 (VDD I1_b19_11 XI1_I1436_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I43_MP5 (I1_I1436_pn11 I1_b19_11 XI1_I1436_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I43_MP4 (XI1_I1436_I43_p1 XI1_I1436_I43_An I1_I1436_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I43_MP2 (VDD I1_p18_10 XI1_I1436_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I43_MP3 (XI1_I1436_I43_p1 XI1_I1436_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I43_MP0 (VDD I1_p18_10 XI1_I1436_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I210_MP1 (VDD I1_I1390_G6_0 XI1_I1390_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I210_MP5 (I1_p18_7 I1_I1390_G6_0 XI1_I1390_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I210_MP4 (XI1_I1390_I210_p1 XI1_I1390_I210_An I1_p18_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I210_MP2 (VDD I1_I1390_pn7 XI1_I1390_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I210_MP3 (XI1_I1390_I210_p1 XI1_I1390_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I210_MP0 (VDD I1_I1390_pn7 XI1_I1390_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I33_MP1 (VDD I1_b18_1 XI1_I1390_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I33_MP5 (I1_I1390_pn1 I1_b18_1 XI1_I1390_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I33_MP4 (XI1_I1390_I33_p1 XI1_I1390_I33_An I1_I1390_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I33_MP2 (VDD I1_p17_0 XI1_I1390_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I33_MP3 (XI1_I1390_I33_p1 XI1_I1390_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I33_MP0 (VDD I1_p17_0 XI1_I1390_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I203_MP1 (VDD I1_qu15_b3_5 XI1_I1344_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I203_MP5 (I1_p17_0 I1_qu15_b3_5 XI1_I1344_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I203_MP4 (XI1_I1344_I203_p1 XI1_I1344_I203_An I1_p17_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I203_MP2 (VDD I1_I1344_pn0 XI1_I1344_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I203_MP3 (XI1_I1344_I203_p1 XI1_I1344_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I203_MP0 (VDD I1_I1344_pn0 XI1_I1344_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I32_MP1 (VDD I1_b17_0 XI1_I1344_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I32_MP5 (I1_I1344_pn0 I1_b17_0 XI1_I1344_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I32_MP4 (XI1_I1344_I32_p1 XI1_I1344_I32_An I1_I1344_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I32_MP2 (VDD I1_aa14 XI1_I1344_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I32_MP3 (XI1_I1344_I32_p1 XI1_I1344_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I32_MP0 (VDD I1_aa14 XI1_I1344_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I231_MP1 (VDD I1_I1114_G27_0 XI1_I1114_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I231_MP5 (I1_p12_28 I1_I1114_G27_0 XI1_I1114_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I231_MP4 (XI1_I1114_I231_p1 XI1_I1114_I231_An I1_p12_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I231_MP2 (VDD I1_I1114_pn28 XI1_I1114_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I231_MP3 (XI1_I1114_I231_p1 XI1_I1114_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I231_MP0 (VDD I1_I1114_pn28 XI1_I1114_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I60_MP1 (VDD I1_b12_28 XI1_I1114_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I60_MP5 (I1_I1114_pn28 I1_b12_28 XI1_I1114_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I60_MP4 (XI1_I1114_I60_p1 XI1_I1114_I60_An I1_I1114_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I60_MP2 (VDD I1_p11_27 XI1_I1114_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I60_MP3 (XI1_I1114_I60_p1 XI1_I1114_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I60_MP0 (VDD I1_p11_27 XI1_I1114_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I59_MP1 (VDD I1_b12_27 XI1_I1114_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I59_MP5 (I1_I1114_pn27 I1_b12_27 XI1_I1114_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I59_MP4 (XI1_I1114_I59_p1 XI1_I1114_I59_An I1_I1114_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I59_MP2 (VDD I1_p11_26 XI1_I1114_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I59_MP3 (XI1_I1114_I59_p1 XI1_I1114_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I59_MP0 (VDD I1_p11_26 XI1_I1114_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I230_MP1 (VDD I1_I1114_G26_0 XI1_I1114_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I230_MP5 (I1_p12_27 I1_I1114_G26_0 XI1_I1114_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I230_MP4 (XI1_I1114_I230_p1 XI1_I1114_I230_An I1_p12_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I230_MP2 (VDD I1_I1114_pn27 XI1_I1114_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I230_MP3 (XI1_I1114_I230_p1 XI1_I1114_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I230_MP0 (VDD I1_I1114_pn27 XI1_I1114_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I232_MP1 (VDD I1_I1114_G28_0 XI1_I1114_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I232_MP5 (I1_p12_29 I1_I1114_G28_0 XI1_I1114_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I232_MP4 (XI1_I1114_I232_p1 XI1_I1114_I232_An I1_p12_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I232_MP2 (VDD I1_I1114_pn29 XI1_I1114_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I232_MP3 (XI1_I1114_I232_p1 XI1_I1114_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I232_MP0 (VDD I1_I1114_pn29 XI1_I1114_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I54_MP1 (VDD I1_b13_22 XI1_I1160_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I54_MP5 (I1_I1160_pn22 I1_b13_22 XI1_I1160_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I54_MP4 (XI1_I1160_I54_p1 XI1_I1160_I54_An I1_I1160_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I54_MP2 (VDD I1_p12_21 XI1_I1160_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I54_MP3 (XI1_I1160_I54_p1 XI1_I1160_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I54_MP0 (VDD I1_p12_21 XI1_I1160_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I53_MP1 (VDD I1_b13_21 XI1_I1160_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I53_MP5 (I1_I1160_pn21 I1_b13_21 XI1_I1160_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I53_MP4 (XI1_I1160_I53_p1 XI1_I1160_I53_An I1_I1160_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I53_MP2 (VDD I1_p12_20 XI1_I1160_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I53_MP3 (XI1_I1160_I53_p1 XI1_I1160_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I53_MP0 (VDD I1_p12_20 XI1_I1160_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I52_MP1 (VDD I1_b13_20 XI1_I1160_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I52_MP5 (I1_I1160_pn20 I1_b13_20 XI1_I1160_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I52_MP4 (XI1_I1160_I52_p1 XI1_I1160_I52_An I1_I1160_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I52_MP2 (VDD I1_p12_19 XI1_I1160_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I52_MP3 (XI1_I1160_I52_p1 XI1_I1160_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I52_MP0 (VDD I1_p12_19 XI1_I1160_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I38_MP1 (VDD I1_b13_6 XI1_I1160_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I38_MP5 (I1_I1160_pn6 I1_b13_6 XI1_I1160_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I38_MP4 (XI1_I1160_I38_p1 XI1_I1160_I38_An I1_I1160_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I38_MP2 (VDD I1_p12_5 XI1_I1160_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I38_MP3 (XI1_I1160_I38_p1 XI1_I1160_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I38_MP0 (VDD I1_p12_5 XI1_I1160_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I36_MP1 (VDD I1_b13_4 XI1_I1160_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I36_MP5 (I1_I1160_pn4 I1_b13_4 XI1_I1160_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I36_MP4 (XI1_I1160_I36_p1 XI1_I1160_I36_An I1_I1160_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I36_MP2 (VDD I1_p12_3 XI1_I1160_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I36_MP3 (XI1_I1160_I36_p1 XI1_I1160_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I36_MP0 (VDD I1_p12_3 XI1_I1160_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I61_MP1 (VDD I1_b9_29 XI1_I976_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I61_MP5 (I1_I976_pn29 I1_b9_29 XI1_I976_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I61_MP4 (XI1_I976_I61_p1 XI1_I976_I61_An I1_I976_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I61_MP2 (VDD I1_p8_28 XI1_I976_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I61_MP3 (XI1_I976_I61_p1 XI1_I976_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I61_MP0 (VDD I1_p8_28 XI1_I976_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I230_MP1 (VDD I1_I930_G26_0 XI1_I930_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I230_MP5 (I1_p8_27 I1_I930_G26_0 XI1_I930_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I230_MP4 (XI1_I930_I230_p1 XI1_I930_I230_An I1_p8_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I230_MP2 (VDD I1_I930_pn27 XI1_I930_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I230_MP3 (XI1_I930_I230_p1 XI1_I930_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I230_MP0 (VDD I1_I930_pn27 XI1_I930_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I59_MP1 (VDD I1_b9_27 XI1_I976_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I59_MP5 (I1_I976_pn27 I1_b9_27 XI1_I976_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I59_MP4 (XI1_I976_I59_p1 XI1_I976_I59_An I1_I976_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I59_MP2 (VDD I1_p8_26 XI1_I976_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I59_MP3 (XI1_I976_I59_p1 XI1_I976_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I59_MP0 (VDD I1_p8_26 XI1_I976_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I234_MP1 (VDD I1_c8_m XI1_I930_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I234_MP5 (I1_p8_31 I1_c8_m XI1_I930_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I234_MP4 (XI1_I930_I234_p1 XI1_I930_I234_An I1_p8_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I234_MP2 (VDD I1_I930_pn31 XI1_I930_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I234_MP3 (XI1_I930_I234_p1 XI1_I930_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I234_MP0 (VDD I1_I930_pn31 XI1_I930_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I209_MP1 (VDD I1_I930_G5_0 XI1_I930_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I209_MP5 (I1_p8_6 I1_I930_G5_0 XI1_I930_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I209_MP4 (XI1_I930_I209_p1 XI1_I930_I209_An I1_p8_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I209_MP2 (VDD I1_I930_pn6 XI1_I930_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I209_MP3 (XI1_I930_I209_p1 XI1_I930_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I209_MP0 (VDD I1_I930_pn6 XI1_I930_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I35_MP1 (VDD I1_b8_3 XI1_I930_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I35_MP5 (I1_I930_pn3 I1_b8_3 XI1_I930_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I35_MP4 (XI1_I930_I35_p1 XI1_I930_I35_An I1_I930_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I35_MP2 (VDD I1_p7_2 XI1_I930_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I35_MP3 (XI1_I930_I35_p1 XI1_I930_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I35_MP0 (VDD I1_p7_2 XI1_I930_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I205_MP1 (VDD I1_I654_G1_0 XI1_I654_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I205_MP5 (I1_p2_2 I1_I654_G1_0 XI1_I654_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I205_MP4 (XI1_I654_I205_p1 XI1_I654_I205_An I1_p2_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I205_MP2 (VDD I1_I654_pn2 XI1_I654_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I205_MP3 (XI1_I654_I205_p1 XI1_I654_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I205_MP0 (VDD I1_I654_pn2 XI1_I654_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I209_MP1 (VDD I1_I654_G5_0 XI1_I654_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I209_MP5 (I1_p2_6 I1_I654_G5_0 XI1_I654_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I209_MP4 (XI1_I654_I209_p1 XI1_I654_I209_An I1_p2_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I209_MP2 (VDD I1_I654_pn6 XI1_I654_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I209_MP3 (XI1_I654_I209_p1 XI1_I654_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I209_MP0 (VDD I1_I654_pn6 XI1_I654_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I211_MP1 (VDD I1_I654_G7_0 XI1_I654_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I211_MP5 (I1_p2_8 I1_I654_G7_0 XI1_I654_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I211_MP4 (XI1_I654_I211_p1 XI1_I654_I211_An I1_p2_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I211_MP2 (VDD I1_I654_pn8 XI1_I654_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I211_MP3 (XI1_I654_I211_p1 XI1_I654_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I211_MP0 (VDD I1_I654_pn8 XI1_I654_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I42_MP1 (VDD I1_b3_10 XI1_I700_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I42_MP5 (I1_I700_pn10 I1_b3_10 XI1_I700_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I42_MP4 (XI1_I700_I42_p1 XI1_I700_I42_An I1_I700_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I42_MP2 (VDD I1_p2_9 XI1_I700_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I42_MP3 (XI1_I700_I42_p1 XI1_I700_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I42_MP0 (VDD I1_p2_9 XI1_I700_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I48_MP1 (VDD I1_b3_16 XI1_I700_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I48_MP5 (I1_I700_pn16 I1_b3_16 XI1_I700_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I48_MP4 (XI1_I700_I48_p1 XI1_I700_I48_An I1_I700_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I48_MP2 (VDD I1_p2_15 XI1_I700_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I48_MP3 (XI1_I700_I48_p1 XI1_I700_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I48_MP0 (VDD I1_p2_15 XI1_I700_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I221_MP1 (VDD I1_I654_G17_0 XI1_I654_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I221_MP5 (I1_p2_18 I1_I654_G17_0 XI1_I654_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I221_MP4 (XI1_I654_I221_p1 XI1_I654_I221_An I1_p2_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I221_MP2 (VDD I1_I654_pn18 XI1_I654_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I221_MP3 (XI1_I654_I221_p1 XI1_I654_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I221_MP0 (VDD I1_I654_pn18 XI1_I654_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I223_MP1 (VDD I1_I654_G19_0 XI1_I654_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I223_MP5 (I1_p2_20 I1_I654_G19_0 XI1_I654_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I223_MP4 (XI1_I654_I223_p1 XI1_I654_I223_An I1_p2_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I223_MP2 (VDD I1_I654_pn20 XI1_I654_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I223_MP3 (XI1_I654_I223_p1 XI1_I654_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I223_MP0 (VDD I1_I654_pn20 XI1_I654_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I225_MP1 (VDD I1_I654_G21_0 XI1_I654_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I225_MP5 (I1_p2_22 I1_I654_G21_0 XI1_I654_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I225_MP4 (XI1_I654_I225_p1 XI1_I654_I225_An I1_p2_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I225_MP2 (VDD I1_I654_pn22 XI1_I654_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I225_MP3 (XI1_I654_I225_p1 XI1_I654_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I225_MP0 (VDD I1_I654_pn22 XI1_I654_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I53_MP1 (VDD I1_b3_21 XI1_I700_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I53_MP5 (I1_I700_pn21 I1_b3_21 XI1_I700_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I53_MP4 (XI1_I700_I53_p1 XI1_I700_I53_An I1_I700_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I53_MP2 (VDD I1_p2_20 XI1_I700_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I53_MP3 (XI1_I700_I53_p1 XI1_I700_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I53_MP0 (VDD I1_p2_20 XI1_I700_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I227_MP1 (VDD I1_I654_G23_0 XI1_I654_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I227_MP5 (I1_p2_24 I1_I654_G23_0 XI1_I654_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I227_MP4 (XI1_I654_I227_p1 XI1_I654_I227_An I1_p2_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I227_MP2 (VDD I1_I654_pn24 XI1_I654_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I227_MP3 (XI1_I654_I227_p1 XI1_I654_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I227_MP0 (VDD I1_I654_pn24 XI1_I654_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I57_MP1 (VDD I1_b3_25 XI1_I700_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I57_MP5 (I1_I700_pn25 I1_b3_25 XI1_I700_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I57_MP4 (XI1_I700_I57_p1 XI1_I700_I57_An I1_I700_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I57_MP2 (VDD I1_p2_24 XI1_I700_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I57_MP3 (XI1_I700_I57_p1 XI1_I700_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I57_MP0 (VDD I1_p2_24 XI1_I700_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I62_MP1 (VDD I1_b3_30 XI1_I700_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I62_MP5 (I1_I700_pn30 I1_b3_30 XI1_I700_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I62_MP4 (XI1_I700_I62_p1 XI1_I700_I62_An I1_I700_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I62_MP2 (VDD I1_p2_29 XI1_I700_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I62_MP3 (XI1_I700_I62_p1 XI1_I700_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I62_MP0 (VDD I1_p2_29 XI1_I700_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I63_MP1 (VDD I1_b3_31 XI1_I700_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I63_MP5 (I1_I700_pn31 I1_b3_31 XI1_I700_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I63_MP4 (XI1_I700_I63_p1 XI1_I700_I63_An I1_I700_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I63_MP2 (VDD I1_p2_30 XI1_I700_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I63_MP3 (XI1_I700_I63_p1 XI1_I700_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I63_MP0 (VDD I1_p2_30 XI1_I700_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I57_MP1 (VDD I1_b19_25 XI1_I1436_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I57_MP5 (I1_I1436_pn25 I1_b19_25 XI1_I1436_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I57_MP4 (XI1_I1436_I57_p1 XI1_I1436_I57_An I1_I1436_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I57_MP2 (VDD I1_p18_24 XI1_I1436_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I57_MP3 (XI1_I1436_I57_p1 XI1_I1436_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I57_MP0 (VDD I1_p18_24 XI1_I1436_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I53_MP1 (VDD I1_b19_21 XI1_I1436_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I53_MP5 (I1_I1436_pn21 I1_b19_21 XI1_I1436_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I53_MP4 (XI1_I1436_I53_p1 XI1_I1436_I53_An I1_I1436_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I53_MP2 (VDD I1_p18_20 XI1_I1436_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I53_MP3 (XI1_I1436_I53_p1 XI1_I1436_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I53_MP0 (VDD I1_p18_20 XI1_I1436_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I50_MP1 (VDD I1_b19_18 XI1_I1436_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I50_MP5 (I1_I1436_pn18 I1_b19_18 XI1_I1436_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I50_MP4 (XI1_I1436_I50_p1 XI1_I1436_I50_An I1_I1436_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I50_MP2 (VDD I1_p18_17 XI1_I1436_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I50_MP3 (XI1_I1436_I50_p1 XI1_I1436_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I50_MP0 (VDD I1_p18_17 XI1_I1436_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I49_MP1 (VDD I1_b19_17 XI1_I1436_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I49_MP5 (I1_I1436_pn17 I1_b19_17 XI1_I1436_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I49_MP4 (XI1_I1436_I49_p1 XI1_I1436_I49_An I1_I1436_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I49_MP2 (VDD I1_p18_16 XI1_I1436_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I49_MP3 (XI1_I1436_I49_p1 XI1_I1436_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I49_MP0 (VDD I1_p18_16 XI1_I1436_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I47_MP1 (VDD I1_b19_15 XI1_I1436_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I47_MP5 (I1_I1436_pn15 I1_b19_15 XI1_I1436_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I47_MP4 (XI1_I1436_I47_p1 XI1_I1436_I47_An I1_I1436_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I47_MP2 (VDD I1_p18_14 XI1_I1436_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I47_MP3 (XI1_I1436_I47_p1 XI1_I1436_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I47_MP0 (VDD I1_p18_14 XI1_I1436_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I45_MP1 (VDD I1_b19_13 XI1_I1436_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I45_MP5 (I1_I1436_pn13 I1_b19_13 XI1_I1436_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I45_MP4 (XI1_I1436_I45_p1 XI1_I1436_I45_An I1_I1436_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I45_MP2 (VDD I1_p18_12 XI1_I1436_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I45_MP3 (XI1_I1436_I45_p1 XI1_I1436_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I45_MP0 (VDD I1_p18_12 XI1_I1436_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I40_MP1 (VDD I1_b19_8 XI1_I1436_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I40_MP5 (I1_I1436_pn8 I1_b19_8 XI1_I1436_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I40_MP4 (XI1_I1436_I40_p1 XI1_I1436_I40_An I1_I1436_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I40_MP2 (VDD I1_p18_7 XI1_I1436_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I40_MP3 (XI1_I1436_I40_p1 XI1_I1436_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I40_MP0 (VDD I1_p18_7 XI1_I1436_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I38_MP1 (VDD I1_b19_6 XI1_I1436_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I38_MP5 (I1_I1436_pn6 I1_b19_6 XI1_I1436_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I38_MP4 (XI1_I1436_I38_p1 XI1_I1436_I38_An I1_I1436_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I38_MP2 (VDD I1_p18_5 XI1_I1436_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I38_MP3 (XI1_I1436_I38_p1 XI1_I1436_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I38_MP0 (VDD I1_p18_5 XI1_I1436_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I205_MP1 (VDD I1_I1390_G1_0 XI1_I1390_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I205_MP5 (I1_p18_2 I1_I1390_G1_0 XI1_I1390_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I205_MP4 (XI1_I1390_I205_p1 XI1_I1390_I205_An I1_p18_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I205_MP2 (VDD I1_I1390_pn2 XI1_I1390_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I205_MP3 (XI1_I1390_I205_p1 XI1_I1390_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I205_MP0 (VDD I1_I1390_pn2 XI1_I1390_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I204_MP1 (VDD I1_I1390_G0_0 XI1_I1390_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I204_MP5 (I1_p18_1 I1_I1390_G0_0 XI1_I1390_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I204_MP4 (XI1_I1390_I204_p1 XI1_I1390_I204_An I1_p18_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I204_MP2 (VDD I1_I1390_pn1 XI1_I1390_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I204_MP3 (XI1_I1390_I204_p1 XI1_I1390_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I204_MP0 (VDD I1_I1390_pn1 XI1_I1390_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I61_MP1 (VDD I1_b12_29 XI1_I1114_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I61_MP5 (I1_I1114_pn29 I1_b12_29 XI1_I1114_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I61_MP4 (XI1_I1114_I61_p1 XI1_I1114_I61_An I1_I1114_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I61_MP2 (VDD I1_p11_28 XI1_I1114_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I61_MP3 (XI1_I1114_I61_p1 XI1_I1114_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I61_MP0 (VDD I1_p11_28 XI1_I1114_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I234_MP1 (VDD I1_c12_m XI1_I1114_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I234_MP5 (I1_p12_31 I1_c12_m XI1_I1114_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I234_MP4 (XI1_I1114_I234_p1 XI1_I1114_I234_An I1_p12_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I234_MP2 (VDD I1_I1114_pn31 XI1_I1114_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I234_MP3 (XI1_I1114_I234_p1 XI1_I1114_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I234_MP0 (VDD I1_I1114_pn31 XI1_I1114_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I62_MP1 (VDD I1_b12_30 XI1_I1114_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I62_MP5 (I1_I1114_pn30 I1_b12_30 XI1_I1114_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I62_MP4 (XI1_I1114_I62_p1 XI1_I1114_I62_An I1_I1114_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I62_MP2 (VDD I1_p11_29 XI1_I1114_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I62_MP3 (XI1_I1114_I62_p1 XI1_I1114_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I62_MP0 (VDD I1_p11_29 XI1_I1114_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I50_MP1 (VDD I1_b13_18 XI1_I1160_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I50_MP5 (I1_I1160_pn18 I1_b13_18 XI1_I1160_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I50_MP4 (XI1_I1160_I50_p1 XI1_I1160_I50_An I1_I1160_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I50_MP2 (VDD I1_p12_17 XI1_I1160_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I50_MP3 (XI1_I1160_I50_p1 XI1_I1160_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I50_MP0 (VDD I1_p12_17 XI1_I1160_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I48_MP1 (VDD I1_b13_16 XI1_I1160_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I48_MP5 (I1_I1160_pn16 I1_b13_16 XI1_I1160_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I48_MP4 (XI1_I1160_I48_p1 XI1_I1160_I48_An I1_I1160_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I48_MP2 (VDD I1_p12_15 XI1_I1160_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I48_MP3 (XI1_I1160_I48_p1 XI1_I1160_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I48_MP0 (VDD I1_p12_15 XI1_I1160_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I46_MP1 (VDD I1_b13_14 XI1_I1160_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I46_MP5 (I1_I1160_pn14 I1_b13_14 XI1_I1160_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I46_MP4 (XI1_I1160_I46_p1 XI1_I1160_I46_An I1_I1160_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I46_MP2 (VDD I1_p12_13 XI1_I1160_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I46_MP3 (XI1_I1160_I46_p1 XI1_I1160_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I46_MP0 (VDD I1_p12_13 XI1_I1160_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I45_MP1 (VDD I1_b13_13 XI1_I1160_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I45_MP5 (I1_I1160_pn13 I1_b13_13 XI1_I1160_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I45_MP4 (XI1_I1160_I45_p1 XI1_I1160_I45_An I1_I1160_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I45_MP2 (VDD I1_p12_12 XI1_I1160_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I45_MP3 (XI1_I1160_I45_p1 XI1_I1160_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I45_MP0 (VDD I1_p12_12 XI1_I1160_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I42_MP1 (VDD I1_b13_10 XI1_I1160_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I42_MP5 (I1_I1160_pn10 I1_b13_10 XI1_I1160_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I42_MP4 (XI1_I1160_I42_p1 XI1_I1160_I42_An I1_I1160_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I42_MP2 (VDD I1_p12_9 XI1_I1160_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I42_MP3 (XI1_I1160_I42_p1 XI1_I1160_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I42_MP0 (VDD I1_p12_9 XI1_I1160_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I41_MP1 (VDD I1_b13_9 XI1_I1160_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I41_MP5 (I1_I1160_pn9 I1_b13_9 XI1_I1160_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I41_MP4 (XI1_I1160_I41_p1 XI1_I1160_I41_An I1_I1160_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I41_MP2 (VDD I1_p12_8 XI1_I1160_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I41_MP3 (XI1_I1160_I41_p1 XI1_I1160_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I41_MP0 (VDD I1_p12_8 XI1_I1160_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I39_MP1 (VDD I1_b13_7 XI1_I1160_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I39_MP5 (I1_I1160_pn7 I1_b13_7 XI1_I1160_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I39_MP4 (XI1_I1160_I39_p1 XI1_I1160_I39_An I1_I1160_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I39_MP2 (VDD I1_p12_6 XI1_I1160_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I39_MP3 (XI1_I1160_I39_p1 XI1_I1160_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I39_MP0 (VDD I1_p12_6 XI1_I1160_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I37_MP1 (VDD I1_b13_5 XI1_I1160_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I37_MP5 (I1_I1160_pn5 I1_b13_5 XI1_I1160_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I37_MP4 (XI1_I1160_I37_p1 XI1_I1160_I37_An I1_I1160_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I37_MP2 (VDD I1_p12_4 XI1_I1160_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I37_MP3 (XI1_I1160_I37_p1 XI1_I1160_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I37_MP0 (VDD I1_p12_4 XI1_I1160_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I60_MP1 (VDD I1_b9_28 XI1_I976_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I60_MP5 (I1_I976_pn28 I1_b9_28 XI1_I976_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I60_MP4 (XI1_I976_I60_p1 XI1_I976_I60_An I1_I976_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I60_MP2 (VDD I1_p8_27 XI1_I976_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I60_MP3 (XI1_I976_I60_p1 XI1_I976_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I60_MP0 (VDD I1_p8_27 XI1_I976_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I232_MP1 (VDD I1_I930_G28_0 XI1_I930_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I232_MP5 (I1_p8_29 I1_I930_G28_0 XI1_I930_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I232_MP4 (XI1_I930_I232_p1 XI1_I930_I232_An I1_p8_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I232_MP2 (VDD I1_I930_pn29 XI1_I930_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I232_MP3 (XI1_I930_I232_p1 XI1_I930_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I232_MP0 (VDD I1_I930_pn29 XI1_I930_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I228_MP1 (VDD I1_I930_G24_0 XI1_I930_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I228_MP5 (I1_p8_25 I1_I930_G24_0 XI1_I930_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I228_MP4 (XI1_I930_I228_p1 XI1_I930_I228_An I1_p8_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I228_MP2 (VDD I1_I930_pn25 XI1_I930_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I228_MP3 (XI1_I930_I228_p1 XI1_I930_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I228_MP0 (VDD I1_I930_pn25 XI1_I930_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I56_MP1 (VDD I1_b9_24 XI1_I976_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I56_MP5 (I1_I976_pn24 I1_b9_24 XI1_I976_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I56_MP4 (XI1_I976_I56_p1 XI1_I976_I56_An I1_I976_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I56_MP2 (VDD I1_p8_23 XI1_I976_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I56_MP3 (XI1_I976_I56_p1 XI1_I976_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I56_MP0 (VDD I1_p8_23 XI1_I976_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I226_MP1 (VDD I1_I930_G22_0 XI1_I930_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I226_MP5 (I1_p8_23 I1_I930_G22_0 XI1_I930_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I226_MP4 (XI1_I930_I226_p1 XI1_I930_I226_An I1_p8_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I226_MP2 (VDD I1_I930_pn23 XI1_I930_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I226_MP3 (XI1_I930_I226_p1 XI1_I930_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I226_MP0 (VDD I1_I930_pn23 XI1_I930_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I224_MP1 (VDD I1_I930_G20_0 XI1_I930_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I224_MP5 (I1_p8_21 I1_I930_G20_0 XI1_I930_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I224_MP4 (XI1_I930_I224_p1 XI1_I930_I224_An I1_p8_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I224_MP2 (VDD I1_I930_pn21 XI1_I930_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I224_MP3 (XI1_I930_I224_p1 XI1_I930_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I224_MP0 (VDD I1_I930_pn21 XI1_I930_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I222_MP1 (VDD I1_I930_G18_0 XI1_I930_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I222_MP5 (I1_p8_19 I1_I930_G18_0 XI1_I930_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I222_MP4 (XI1_I930_I222_p1 XI1_I930_I222_An I1_p8_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I222_MP2 (VDD I1_I930_pn19 XI1_I930_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I222_MP3 (XI1_I930_I222_p1 XI1_I930_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I222_MP0 (VDD I1_I930_pn19 XI1_I930_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I220_MP1 (VDD I1_I930_G16_0 XI1_I930_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I220_MP5 (I1_p8_17 I1_I930_G16_0 XI1_I930_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I220_MP4 (XI1_I930_I220_p1 XI1_I930_I220_An I1_p8_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I220_MP2 (VDD I1_I930_pn17 XI1_I930_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I220_MP3 (XI1_I930_I220_p1 XI1_I930_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I220_MP0 (VDD I1_I930_pn17 XI1_I930_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I49_MP1 (VDD I1_b9_17 XI1_I976_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I49_MP5 (I1_I976_pn17 I1_b9_17 XI1_I976_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I49_MP4 (XI1_I976_I49_p1 XI1_I976_I49_An I1_I976_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I49_MP2 (VDD I1_p8_16 XI1_I976_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I49_MP3 (XI1_I976_I49_p1 XI1_I976_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I49_MP0 (VDD I1_p8_16 XI1_I976_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I210_MP1 (VDD I1_I930_G6_0 XI1_I930_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I210_MP5 (I1_p8_7 I1_I930_G6_0 XI1_I930_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I210_MP4 (XI1_I930_I210_p1 XI1_I930_I210_An I1_p8_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I210_MP2 (VDD I1_I930_pn7 XI1_I930_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I210_MP3 (XI1_I930_I210_p1 XI1_I930_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I210_MP0 (VDD I1_I930_pn7 XI1_I930_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I34_MP1 (VDD I1_b8_2 XI1_I930_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I34_MP5 (I1_I930_pn2 I1_b8_2 XI1_I930_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I34_MP4 (XI1_I930_I34_p1 XI1_I930_I34_An I1_I930_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I34_MP2 (VDD I1_p7_1 XI1_I930_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I34_MP3 (XI1_I930_I34_p1 XI1_I930_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I34_MP0 (VDD I1_p7_1 XI1_I930_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I32_MP1 (VDD I1_b3_0 XI1_I700_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I700_I32_MP5 (I1_I700_pn0 I1_b3_0 XI1_I700_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I32_MP4 (XI1_I700_I32_p1 XI1_I700_I32_An I1_I700_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I32_MP2 (VDD I1_aa28 XI1_I700_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I32_MP3 (XI1_I700_I32_p1 XI1_I700_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I32_MP0 (VDD I1_aa28 XI1_I700_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I229_MP1 (VDD I1_I654_G25_0 XI1_I654_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I229_MP5 (I1_p2_26 I1_I654_G25_0 XI1_I654_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I229_MP4 (XI1_I654_I229_p1 XI1_I654_I229_An I1_p2_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I229_MP2 (VDD I1_I654_pn26 XI1_I654_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I229_MP3 (XI1_I654_I229_p1 XI1_I654_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I229_MP0 (VDD I1_I654_pn26 XI1_I654_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I231_MP1 (VDD I1_I654_G27_0 XI1_I654_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I231_MP5 (I1_p2_28 I1_I654_G27_0 XI1_I654_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I231_MP4 (XI1_I654_I231_p1 XI1_I654_I231_An I1_p2_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I231_MP2 (VDD I1_I654_pn28 XI1_I654_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I231_MP3 (XI1_I654_I231_p1 XI1_I654_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I231_MP0 (VDD I1_I654_pn28 XI1_I654_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I233_MP1 (VDD I1_I654_G29_0 XI1_I654_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I233_MP5 (I1_p2_30 I1_I654_G29_0 XI1_I654_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I233_MP4 (XI1_I654_I233_p1 XI1_I654_I233_An I1_p2_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I233_MP2 (VDD I1_I654_pn30 XI1_I654_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I233_MP3 (XI1_I654_I233_p1 XI1_I654_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I233_MP0 (VDD I1_I654_pn30 XI1_I654_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I61_MP1 (VDD I1_b19_29 XI1_I1436_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I61_MP5 (I1_I1436_pn29 I1_b19_29 XI1_I1436_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I61_MP4 (XI1_I1436_I61_p1 XI1_I1436_I61_An I1_I1436_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I61_MP2 (VDD I1_p18_28 XI1_I1436_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I61_MP3 (XI1_I1436_I61_p1 XI1_I1436_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I61_MP0 (VDD I1_p18_28 XI1_I1436_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I60_MP1 (VDD I1_b19_28 XI1_I1436_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I60_MP5 (I1_I1436_pn28 I1_b19_28 XI1_I1436_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I60_MP4 (XI1_I1436_I60_p1 XI1_I1436_I60_An I1_I1436_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I60_MP2 (VDD I1_p18_27 XI1_I1436_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I60_MP3 (XI1_I1436_I60_p1 XI1_I1436_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I60_MP0 (VDD I1_p18_27 XI1_I1436_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I58_MP1 (VDD I1_b19_26 XI1_I1436_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I58_MP5 (I1_I1436_pn26 I1_b19_26 XI1_I1436_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I58_MP4 (XI1_I1436_I58_p1 XI1_I1436_I58_An I1_I1436_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I58_MP2 (VDD I1_p18_25 XI1_I1436_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I58_MP3 (XI1_I1436_I58_p1 XI1_I1436_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I58_MP0 (VDD I1_p18_25 XI1_I1436_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I56_MP1 (VDD I1_b19_24 XI1_I1436_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I56_MP5 (I1_I1436_pn24 I1_b19_24 XI1_I1436_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I56_MP4 (XI1_I1436_I56_p1 XI1_I1436_I56_An I1_I1436_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I56_MP2 (VDD I1_p18_23 XI1_I1436_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I56_MP3 (XI1_I1436_I56_p1 XI1_I1436_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I56_MP0 (VDD I1_p18_23 XI1_I1436_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I54_MP1 (VDD I1_b19_22 XI1_I1436_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I54_MP5 (I1_I1436_pn22 I1_b19_22 XI1_I1436_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I54_MP4 (XI1_I1436_I54_p1 XI1_I1436_I54_An I1_I1436_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I54_MP2 (VDD I1_p18_21 XI1_I1436_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I54_MP3 (XI1_I1436_I54_p1 XI1_I1436_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I54_MP0 (VDD I1_p18_21 XI1_I1436_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I52_MP1 (VDD I1_b19_20 XI1_I1436_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I52_MP5 (I1_I1436_pn20 I1_b19_20 XI1_I1436_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I52_MP4 (XI1_I1436_I52_p1 XI1_I1436_I52_An I1_I1436_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I52_MP2 (VDD I1_p18_19 XI1_I1436_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I52_MP3 (XI1_I1436_I52_p1 XI1_I1436_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I52_MP0 (VDD I1_p18_19 XI1_I1436_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I46_MP1 (VDD I1_b19_14 XI1_I1436_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I46_MP5 (I1_I1436_pn14 I1_b19_14 XI1_I1436_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I46_MP4 (XI1_I1436_I46_p1 XI1_I1436_I46_An I1_I1436_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I46_MP2 (VDD I1_p18_13 XI1_I1436_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I46_MP3 (XI1_I1436_I46_p1 XI1_I1436_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I46_MP0 (VDD I1_p18_13 XI1_I1436_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I44_MP1 (VDD I1_b19_12 XI1_I1436_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I44_MP5 (I1_I1436_pn12 I1_b19_12 XI1_I1436_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I44_MP4 (XI1_I1436_I44_p1 XI1_I1436_I44_An I1_I1436_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I44_MP2 (VDD I1_p18_11 XI1_I1436_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I44_MP3 (XI1_I1436_I44_p1 XI1_I1436_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I44_MP0 (VDD I1_p18_11 XI1_I1436_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I42_MP1 (VDD I1_b19_10 XI1_I1436_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I42_MP5 (I1_I1436_pn10 I1_b19_10 XI1_I1436_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I42_MP4 (XI1_I1436_I42_p1 XI1_I1436_I42_An I1_I1436_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I42_MP2 (VDD I1_p18_9 XI1_I1436_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I42_MP3 (XI1_I1436_I42_p1 XI1_I1436_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I42_MP0 (VDD I1_p18_9 XI1_I1436_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I41_MP1 (VDD I1_b19_9 XI1_I1436_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I41_MP5 (I1_I1436_pn9 I1_b19_9 XI1_I1436_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I41_MP4 (XI1_I1436_I41_p1 XI1_I1436_I41_An I1_I1436_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I41_MP2 (VDD I1_p18_8 XI1_I1436_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I41_MP3 (XI1_I1436_I41_p1 XI1_I1436_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I41_MP0 (VDD I1_p18_8 XI1_I1436_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I39_MP1 (VDD I1_b19_7 XI1_I1436_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I39_MP5 (I1_I1436_pn7 I1_b19_7 XI1_I1436_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I39_MP4 (XI1_I1436_I39_p1 XI1_I1436_I39_An I1_I1436_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I39_MP2 (VDD I1_p18_6 XI1_I1436_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I39_MP3 (XI1_I1436_I39_p1 XI1_I1436_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I39_MP0 (VDD I1_p18_6 XI1_I1436_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I37_MP1 (VDD I1_b19_5 XI1_I1436_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I37_MP5 (I1_I1436_pn5 I1_b19_5 XI1_I1436_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I37_MP4 (XI1_I1436_I37_p1 XI1_I1436_I37_An I1_I1436_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I37_MP2 (VDD I1_p18_4 XI1_I1436_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I37_MP3 (XI1_I1436_I37_p1 XI1_I1436_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I37_MP0 (VDD I1_p18_4 XI1_I1436_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I36_MP1 (VDD I1_b19_4 XI1_I1436_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I36_MP5 (I1_I1436_pn4 I1_b19_4 XI1_I1436_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I36_MP4 (XI1_I1436_I36_p1 XI1_I1436_I36_An I1_I1436_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I36_MP2 (VDD I1_p18_3 XI1_I1436_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I36_MP3 (XI1_I1436_I36_p1 XI1_I1436_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I36_MP0 (VDD I1_p18_3 XI1_I1436_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I32_MP1 (VDD I1_b18_0 XI1_I1390_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I32_MP5 (I1_I1390_pn0 I1_b18_0 XI1_I1390_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I32_MP4 (XI1_I1390_I32_p1 XI1_I1390_I32_An I1_I1390_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I32_MP2 (VDD I1_aa13 XI1_I1390_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I32_MP3 (XI1_I1390_I32_p1 XI1_I1390_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I32_MP0 (VDD I1_aa13 XI1_I1390_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I58_MP1 (VDD I1_b12_26 XI1_I1114_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I58_MP5 (I1_I1114_pn26 I1_b12_26 XI1_I1114_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I58_MP4 (XI1_I1114_I58_p1 XI1_I1114_I58_An I1_I1114_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I58_MP2 (VDD I1_p11_25 XI1_I1114_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I58_MP3 (XI1_I1114_I58_p1 XI1_I1114_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I58_MP0 (VDD I1_p11_25 XI1_I1114_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I233_MP1 (VDD I1_I1114_G29_0 XI1_I1114_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I233_MP5 (I1_p12_30 I1_I1114_G29_0 XI1_I1114_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I233_MP4 (XI1_I1114_I233_p1 XI1_I1114_I233_An I1_p12_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I233_MP2 (VDD I1_I1114_pn30 XI1_I1114_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I233_MP3 (XI1_I1114_I233_p1 XI1_I1114_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I233_MP0 (VDD I1_I1114_pn30 XI1_I1114_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I63_MP1 (VDD I1_b12_31 XI1_I1114_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I63_MP5 (I1_I1114_pn31 I1_b12_31 XI1_I1114_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I63_MP4 (XI1_I1114_I63_p1 XI1_I1114_I63_An I1_I1114_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I63_MP2 (VDD I1_p11_30 XI1_I1114_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I63_MP3 (XI1_I1114_I63_p1 XI1_I1114_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I63_MP0 (VDD I1_p11_30 XI1_I1114_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I51_MP1 (VDD I1_b13_19 XI1_I1160_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I51_MP5 (I1_I1160_pn19 I1_b13_19 XI1_I1160_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I51_MP4 (XI1_I1160_I51_p1 XI1_I1160_I51_An I1_I1160_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I51_MP2 (VDD I1_p12_18 XI1_I1160_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I51_MP3 (XI1_I1160_I51_p1 XI1_I1160_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I51_MP0 (VDD I1_p12_18 XI1_I1160_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I49_MP1 (VDD I1_b13_17 XI1_I1160_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I49_MP5 (I1_I1160_pn17 I1_b13_17 XI1_I1160_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I49_MP4 (XI1_I1160_I49_p1 XI1_I1160_I49_An I1_I1160_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I49_MP2 (VDD I1_p12_16 XI1_I1160_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I49_MP3 (XI1_I1160_I49_p1 XI1_I1160_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I49_MP0 (VDD I1_p12_16 XI1_I1160_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I47_MP1 (VDD I1_b13_15 XI1_I1160_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I47_MP5 (I1_I1160_pn15 I1_b13_15 XI1_I1160_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I47_MP4 (XI1_I1160_I47_p1 XI1_I1160_I47_An I1_I1160_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I47_MP2 (VDD I1_p12_14 XI1_I1160_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I47_MP3 (XI1_I1160_I47_p1 XI1_I1160_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I47_MP0 (VDD I1_p12_14 XI1_I1160_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I43_MP1 (VDD I1_b13_11 XI1_I1160_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I43_MP5 (I1_I1160_pn11 I1_b13_11 XI1_I1160_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I43_MP4 (XI1_I1160_I43_p1 XI1_I1160_I43_An I1_I1160_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I43_MP2 (VDD I1_p12_10 XI1_I1160_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I43_MP3 (XI1_I1160_I43_p1 XI1_I1160_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I43_MP0 (VDD I1_p12_10 XI1_I1160_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I233_MP1 (VDD I1_I1068_G29_0 XI1_I1068_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I233_MP5 (I1_p11_30 I1_I1068_G29_0 XI1_I1068_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I233_MP4 (XI1_I1068_I233_p1 XI1_I1068_I233_An I1_p11_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I233_MP2 (VDD I1_I1068_pn30 XI1_I1068_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I233_MP3 (XI1_I1068_I233_p1 XI1_I1068_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I233_MP0 (VDD I1_I1068_pn30 XI1_I1068_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I40_MP1 (VDD I1_b13_8 XI1_I1160_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I40_MP5 (I1_I1160_pn8 I1_b13_8 XI1_I1160_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I40_MP4 (XI1_I1160_I40_p1 XI1_I1160_I40_An I1_I1160_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I40_MP2 (VDD I1_p12_7 XI1_I1160_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I40_MP3 (XI1_I1160_I40_p1 XI1_I1160_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I40_MP0 (VDD I1_p12_7 XI1_I1160_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I60_MP1 (VDD I1_b11_28 XI1_I1068_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I60_MP5 (I1_I1068_pn28 I1_b11_28 XI1_I1068_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I60_MP4 (XI1_I1068_I60_p1 XI1_I1068_I60_An I1_I1068_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I60_MP2 (VDD I1_p10_27 XI1_I1068_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I60_MP3 (XI1_I1068_I60_p1 XI1_I1068_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I60_MP0 (VDD I1_p10_27 XI1_I1068_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I61_MP1 (VDD I1_b11_29 XI1_I1068_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I61_MP5 (I1_I1068_pn29 I1_b11_29 XI1_I1068_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I61_MP4 (XI1_I1068_I61_p1 XI1_I1068_I61_An I1_I1068_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I61_MP2 (VDD I1_p10_28 XI1_I1068_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I61_MP3 (XI1_I1068_I61_p1 XI1_I1068_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I61_MP0 (VDD I1_p10_28 XI1_I1068_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I203_MP1 (VDD I1_qu20_b3_5 XI1_I1114_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I203_MP5 (I1_p12_0 I1_qu20_b3_5 XI1_I1114_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I203_MP4 (XI1_I1114_I203_p1 XI1_I1114_I203_An I1_p12_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I203_MP2 (VDD I1_I1114_pn0 XI1_I1114_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I203_MP3 (XI1_I1114_I203_p1 XI1_I1114_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I203_MP0 (VDD I1_I1114_pn0 XI1_I1114_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I231_MP1 (VDD I1_I1022_G27_0 XI1_I1022_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I231_MP5 (I1_p10_28 I1_I1022_G27_0 XI1_I1022_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I231_MP4 (XI1_I1022_I231_p1 XI1_I1022_I231_An I1_p10_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I231_MP2 (VDD I1_I1022_pn28 XI1_I1022_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I231_MP3 (XI1_I1022_I231_p1 XI1_I1022_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I231_MP0 (VDD I1_I1022_pn28 XI1_I1022_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I63_MP1 (VDD I1_b9_31 XI1_I976_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I63_MP5 (I1_I976_pn31 I1_b9_31 XI1_I976_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I63_MP4 (XI1_I976_I63_p1 XI1_I976_I63_An I1_I976_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I63_MP2 (VDD I1_p8_30 XI1_I976_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I63_MP3 (XI1_I976_I63_p1 XI1_I976_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I63_MP0 (VDD I1_p8_30 XI1_I976_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I58_MP1 (VDD I1_b9_26 XI1_I976_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I58_MP5 (I1_I976_pn26 I1_b9_26 XI1_I976_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I58_MP4 (XI1_I976_I58_p1 XI1_I976_I58_An I1_I976_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I58_MP2 (VDD I1_p8_25 XI1_I976_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I58_MP3 (XI1_I976_I58_p1 XI1_I976_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I58_MP0 (VDD I1_p8_25 XI1_I976_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I55_MP1 (VDD I1_b9_23 XI1_I976_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I55_MP5 (I1_I976_pn23 I1_b9_23 XI1_I976_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I55_MP4 (XI1_I976_I55_p1 XI1_I976_I55_An I1_I976_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I55_MP2 (VDD I1_p8_22 XI1_I976_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I55_MP3 (XI1_I976_I55_p1 XI1_I976_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I55_MP0 (VDD I1_p8_22 XI1_I976_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I54_MP1 (VDD I1_b9_22 XI1_I976_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I54_MP5 (I1_I976_pn22 I1_b9_22 XI1_I976_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I54_MP4 (XI1_I976_I54_p1 XI1_I976_I54_An I1_I976_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I54_MP2 (VDD I1_p8_21 XI1_I976_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I54_MP3 (XI1_I976_I54_p1 XI1_I976_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I54_MP0 (VDD I1_p8_21 XI1_I976_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I52_MP1 (VDD I1_b9_20 XI1_I976_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I52_MP5 (I1_I976_pn20 I1_b9_20 XI1_I976_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I52_MP4 (XI1_I976_I52_p1 XI1_I976_I52_An I1_I976_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I52_MP2 (VDD I1_p8_19 XI1_I976_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I52_MP3 (XI1_I976_I52_p1 XI1_I976_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I52_MP0 (VDD I1_p8_19 XI1_I976_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I51_MP1 (VDD I1_b9_19 XI1_I976_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I51_MP5 (I1_I976_pn19 I1_b9_19 XI1_I976_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I51_MP4 (XI1_I976_I51_p1 XI1_I976_I51_An I1_I976_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I51_MP2 (VDD I1_p8_18 XI1_I976_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I51_MP3 (XI1_I976_I51_p1 XI1_I976_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I51_MP0 (VDD I1_p8_18 XI1_I976_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I43_MP1 (VDD I1_b9_11 XI1_I976_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I43_MP5 (I1_I976_pn11 I1_b9_11 XI1_I976_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I43_MP4 (XI1_I976_I43_p1 XI1_I976_I43_An I1_I976_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I43_MP2 (VDD I1_p8_10 XI1_I976_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I43_MP3 (XI1_I976_I43_p1 XI1_I976_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I43_MP0 (VDD I1_p8_10 XI1_I976_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I208_MP1 (VDD I1_I930_G4_0 XI1_I930_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I208_MP5 (I1_p8_5 I1_I930_G4_0 XI1_I930_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I208_MP4 (XI1_I930_I208_p1 XI1_I930_I208_An I1_p8_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I208_MP2 (VDD I1_I930_pn5 XI1_I930_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I208_MP3 (XI1_I930_I208_p1 XI1_I930_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I208_MP0 (VDD I1_I930_pn5 XI1_I930_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I33_MP1 (VDD I1_b2_1 XI1_I654_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I33_MP5 (I1_I654_pn1 I1_b2_1 XI1_I654_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I33_MP4 (XI1_I654_I33_p1 XI1_I654_I33_An I1_I654_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I33_MP2 (VDD I1_p1_0 XI1_I654_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I33_MP3 (XI1_I654_I33_p1 XI1_I654_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I33_MP0 (VDD I1_p1_0 XI1_I654_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I204_MP1 (VDD I1_I654_G0_0 XI1_I654_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I204_MP5 (I1_p2_1 I1_I654_G0_0 XI1_I654_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I204_MP4 (XI1_I654_I204_p1 XI1_I654_I204_An I1_p2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I204_MP2 (VDD I1_I654_pn1 XI1_I654_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I204_MP3 (XI1_I654_I204_p1 XI1_I654_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I204_MP0 (VDD I1_I654_pn1 XI1_I654_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I208_MP1 (VDD I1_I654_G4_0 XI1_I654_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I208_MP5 (I1_p2_5 I1_I654_G4_0 XI1_I654_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I208_MP4 (XI1_I654_I208_p1 XI1_I654_I208_An I1_p2_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I208_MP2 (VDD I1_I654_pn5 XI1_I654_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I208_MP3 (XI1_I654_I208_p1 XI1_I654_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I208_MP0 (VDD I1_I654_pn5 XI1_I654_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I210_MP1 (VDD I1_I654_G6_0 XI1_I654_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I210_MP5 (I1_p2_7 I1_I654_G6_0 XI1_I654_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I210_MP4 (XI1_I654_I210_p1 XI1_I654_I210_An I1_p2_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I210_MP2 (VDD I1_I654_pn7 XI1_I654_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I210_MP3 (XI1_I654_I210_p1 XI1_I654_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I210_MP0 (VDD I1_I654_pn7 XI1_I654_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I220_MP1 (VDD I1_I654_G16_0 XI1_I654_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I220_MP5 (I1_p2_17 I1_I654_G16_0 XI1_I654_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I220_MP4 (XI1_I654_I220_p1 XI1_I654_I220_An I1_p2_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I220_MP2 (VDD I1_I654_pn17 XI1_I654_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I220_MP3 (XI1_I654_I220_p1 XI1_I654_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I220_MP0 (VDD I1_I654_pn17 XI1_I654_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I222_MP1 (VDD I1_I654_G18_0 XI1_I654_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I222_MP5 (I1_p2_19 I1_I654_G18_0 XI1_I654_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I222_MP4 (XI1_I654_I222_p1 XI1_I654_I222_An I1_p2_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I222_MP2 (VDD I1_I654_pn19 XI1_I654_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I222_MP3 (XI1_I654_I222_p1 XI1_I654_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I222_MP0 (VDD I1_I654_pn19 XI1_I654_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I232_MP1 (VDD I1_I654_G28_0 XI1_I654_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I232_MP5 (I1_p2_29 I1_I654_G28_0 XI1_I654_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I232_MP4 (XI1_I654_I232_p1 XI1_I654_I232_An I1_p2_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I232_MP2 (VDD I1_I654_pn29 XI1_I654_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I232_MP3 (XI1_I654_I232_p1 XI1_I654_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I232_MP0 (VDD I1_I654_pn29 XI1_I654_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I35_MP1 (VDD I1_b19_3 XI1_I1436_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I35_MP5 (I1_I1436_pn3 I1_b19_3 XI1_I1436_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I35_MP4 (XI1_I1436_I35_p1 XI1_I1436_I35_An I1_I1436_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I35_MP2 (VDD I1_p18_2 XI1_I1436_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I35_MP3 (XI1_I1436_I35_p1 XI1_I1436_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I35_MP0 (VDD I1_p18_2 XI1_I1436_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I203_MP1 (VDD I1_qu14_b3_5 XI1_I1390_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I203_MP5 (I1_p18_0 I1_qu14_b3_5 XI1_I1390_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I203_MP4 (XI1_I1390_I203_p1 XI1_I1390_I203_An I1_p18_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I203_MP2 (VDD I1_I1390_pn0 XI1_I1390_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I203_MP3 (XI1_I1390_I203_p1 XI1_I1390_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I203_MP0 (VDD I1_I1390_pn0 XI1_I1390_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I227_MP1 (VDD I1_I1114_G23_0 XI1_I1114_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I227_MP5 (I1_p12_24 I1_I1114_G23_0 XI1_I1114_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I227_MP4 (XI1_I1114_I227_p1 XI1_I1114_I227_An I1_p12_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I227_MP2 (VDD I1_I1114_pn24 XI1_I1114_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I227_MP3 (XI1_I1114_I227_p1 XI1_I1114_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I227_MP0 (VDD I1_I1114_pn24 XI1_I1114_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I229_MP1 (VDD I1_I1114_G25_0 XI1_I1114_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I229_MP5 (I1_p12_26 I1_I1114_G25_0 XI1_I1114_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I229_MP4 (XI1_I1114_I229_p1 XI1_I1114_I229_An I1_p12_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I229_MP2 (VDD I1_I1114_pn26 XI1_I1114_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I229_MP3 (XI1_I1114_I229_p1 XI1_I1114_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I229_MP0 (VDD I1_I1114_pn26 XI1_I1114_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I228_MP1 (VDD I1_I1114_G24_0 XI1_I1114_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I228_MP5 (I1_p12_25 I1_I1114_G24_0 XI1_I1114_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I228_MP4 (XI1_I1114_I228_p1 XI1_I1114_I228_An I1_p12_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I228_MP2 (VDD I1_I1114_pn25 XI1_I1114_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I228_MP3 (XI1_I1114_I228_p1 XI1_I1114_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I228_MP0 (VDD I1_I1114_pn25 XI1_I1114_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I226_MP1 (VDD I1_I1114_G22_0 XI1_I1114_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I226_MP5 (I1_p12_23 I1_I1114_G22_0 XI1_I1114_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I226_MP4 (XI1_I1114_I226_p1 XI1_I1114_I226_An I1_p12_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I226_MP2 (VDD I1_I1114_pn23 XI1_I1114_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I226_MP3 (XI1_I1114_I226_p1 XI1_I1114_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I226_MP0 (VDD I1_I1114_pn23 XI1_I1114_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I55_MP1 (VDD I1_b12_23 XI1_I1114_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I55_MP5 (I1_I1114_pn23 I1_b12_23 XI1_I1114_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I55_MP4 (XI1_I1114_I55_p1 XI1_I1114_I55_An I1_I1114_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I55_MP2 (VDD I1_p11_22 XI1_I1114_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I55_MP3 (XI1_I1114_I55_p1 XI1_I1114_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I55_MP0 (VDD I1_p11_22 XI1_I1114_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I232_MP1 (VDD I1_I1068_G28_0 XI1_I1068_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I232_MP5 (I1_p11_29 I1_I1068_G28_0 XI1_I1068_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I232_MP4 (XI1_I1068_I232_p1 XI1_I1068_I232_An I1_p11_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I232_MP2 (VDD I1_I1068_pn29 XI1_I1068_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I232_MP3 (XI1_I1068_I232_p1 XI1_I1068_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I232_MP0 (VDD I1_I1068_pn29 XI1_I1068_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I230_MP1 (VDD I1_I1068_G26_0 XI1_I1068_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I230_MP5 (I1_p11_27 I1_I1068_G26_0 XI1_I1068_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I230_MP4 (XI1_I1068_I230_p1 XI1_I1068_I230_An I1_p11_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I230_MP2 (VDD I1_I1068_pn27 XI1_I1068_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I230_MP3 (XI1_I1068_I230_p1 XI1_I1068_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I230_MP0 (VDD I1_I1068_pn27 XI1_I1068_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I234_MP1 (VDD I1_c11_m XI1_I1068_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I234_MP5 (I1_p11_31 I1_c11_m XI1_I1068_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I234_MP4 (XI1_I1068_I234_p1 XI1_I1068_I234_An I1_p11_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I234_MP2 (VDD I1_I1068_pn31 XI1_I1068_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I234_MP3 (XI1_I1068_I234_p1 XI1_I1068_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I234_MP0 (VDD I1_I1068_pn31 XI1_I1068_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I44_MP1 (VDD I1_b13_12 XI1_I1160_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1160_I44_MP5 (I1_I1160_pn12 I1_b13_12 XI1_I1160_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I44_MP4 (XI1_I1160_I44_p1 XI1_I1160_I44_An I1_I1160_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I44_MP2 (VDD I1_p12_11 XI1_I1160_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I44_MP3 (XI1_I1160_I44_p1 XI1_I1160_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I44_MP0 (VDD I1_p12_11 XI1_I1160_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I229_MP1 (VDD I1_I1068_G25_0 XI1_I1068_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I229_MP5 (I1_p11_26 I1_I1068_G25_0 XI1_I1068_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I229_MP4 (XI1_I1068_I229_p1 XI1_I1068_I229_An I1_p11_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I229_MP2 (VDD I1_I1068_pn26 XI1_I1068_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I229_MP3 (XI1_I1068_I229_p1 XI1_I1068_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I229_MP0 (VDD I1_I1068_pn26 XI1_I1068_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I231_MP1 (VDD I1_I1068_G27_0 XI1_I1068_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I231_MP5 (I1_p11_28 I1_I1068_G27_0 XI1_I1068_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I231_MP4 (XI1_I1068_I231_p1 XI1_I1068_I231_An I1_p11_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I231_MP2 (VDD I1_I1068_pn28 XI1_I1068_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I231_MP3 (XI1_I1068_I231_p1 XI1_I1068_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I231_MP0 (VDD I1_I1068_pn28 XI1_I1068_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I59_MP1 (VDD I1_b11_27 XI1_I1068_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I59_MP5 (I1_I1068_pn27 I1_b11_27 XI1_I1068_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I59_MP4 (XI1_I1068_I59_p1 XI1_I1068_I59_An I1_I1068_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I59_MP2 (VDD I1_p10_26 XI1_I1068_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I59_MP3 (XI1_I1068_I59_p1 XI1_I1068_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I59_MP0 (VDD I1_p10_26 XI1_I1068_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I62_MP1 (VDD I1_b11_30 XI1_I1068_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I62_MP5 (I1_I1068_pn30 I1_b11_30 XI1_I1068_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I62_MP4 (XI1_I1068_I62_p1 XI1_I1068_I62_An I1_I1068_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I62_MP2 (VDD I1_p10_29 XI1_I1068_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I62_MP3 (XI1_I1068_I62_p1 XI1_I1068_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I62_MP0 (VDD I1_p10_29 XI1_I1068_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I63_MP1 (VDD I1_b11_31 XI1_I1068_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I63_MP5 (I1_I1068_pn31 I1_b11_31 XI1_I1068_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I63_MP4 (XI1_I1068_I63_p1 XI1_I1068_I63_An I1_I1068_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I63_MP2 (VDD I1_p10_30 XI1_I1068_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I63_MP3 (XI1_I1068_I63_p1 XI1_I1068_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I63_MP0 (VDD I1_p10_30 XI1_I1068_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I61_MP1 (VDD I1_b10_29 XI1_I1022_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I61_MP5 (I1_I1022_pn29 I1_b10_29 XI1_I1022_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I61_MP4 (XI1_I1022_I61_p1 XI1_I1022_I61_An I1_I1022_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I61_MP2 (VDD I1_p9_28 XI1_I1022_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I61_MP3 (XI1_I1022_I61_p1 XI1_I1022_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I61_MP0 (VDD I1_p9_28 XI1_I1022_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I60_MP1 (VDD I1_b10_28 XI1_I1022_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I60_MP5 (I1_I1022_pn28 I1_b10_28 XI1_I1022_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I60_MP4 (XI1_I1022_I60_p1 XI1_I1022_I60_An I1_I1022_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I60_MP2 (VDD I1_p9_27 XI1_I1022_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I60_MP3 (XI1_I1022_I60_p1 XI1_I1022_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I60_MP0 (VDD I1_p9_27 XI1_I1022_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I62_MP1 (VDD I1_b9_30 XI1_I976_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I62_MP5 (I1_I976_pn30 I1_b9_30 XI1_I976_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I62_MP4 (XI1_I976_I62_p1 XI1_I976_I62_An I1_I976_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I62_MP2 (VDD I1_p8_29 XI1_I976_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I62_MP3 (XI1_I976_I62_p1 XI1_I976_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I62_MP0 (VDD I1_p8_29 XI1_I976_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I57_MP1 (VDD I1_b9_25 XI1_I976_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I57_MP5 (I1_I976_pn25 I1_b9_25 XI1_I976_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I57_MP4 (XI1_I976_I57_p1 XI1_I976_I57_An I1_I976_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I57_MP2 (VDD I1_p8_24 XI1_I976_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I57_MP3 (XI1_I976_I57_p1 XI1_I976_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I57_MP0 (VDD I1_p8_24 XI1_I976_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I53_MP1 (VDD I1_b9_21 XI1_I976_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I53_MP5 (I1_I976_pn21 I1_b9_21 XI1_I976_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I53_MP4 (XI1_I976_I53_p1 XI1_I976_I53_An I1_I976_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I53_MP2 (VDD I1_p8_20 XI1_I976_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I53_MP3 (XI1_I976_I53_p1 XI1_I976_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I53_MP0 (VDD I1_p8_20 XI1_I976_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I50_MP1 (VDD I1_b9_18 XI1_I976_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I50_MP5 (I1_I976_pn18 I1_b9_18 XI1_I976_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I50_MP4 (XI1_I976_I50_p1 XI1_I976_I50_An I1_I976_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I50_MP2 (VDD I1_p8_17 XI1_I976_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I50_MP3 (XI1_I976_I50_p1 XI1_I976_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I50_MP0 (VDD I1_p8_17 XI1_I976_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I48_MP1 (VDD I1_b9_16 XI1_I976_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I48_MP5 (I1_I976_pn16 I1_b9_16 XI1_I976_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I48_MP4 (XI1_I976_I48_p1 XI1_I976_I48_An I1_I976_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I48_MP2 (VDD I1_p8_15 XI1_I976_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I48_MP3 (XI1_I976_I48_p1 XI1_I976_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I48_MP0 (VDD I1_p8_15 XI1_I976_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I47_MP1 (VDD I1_b9_15 XI1_I976_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I47_MP5 (I1_I976_pn15 I1_b9_15 XI1_I976_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I47_MP4 (XI1_I976_I47_p1 XI1_I976_I47_An I1_I976_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I47_MP2 (VDD I1_p8_14 XI1_I976_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I47_MP3 (XI1_I976_I47_p1 XI1_I976_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I47_MP0 (VDD I1_p8_14 XI1_I976_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I46_MP1 (VDD I1_b9_14 XI1_I976_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I46_MP5 (I1_I976_pn14 I1_b9_14 XI1_I976_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I46_MP4 (XI1_I976_I46_p1 XI1_I976_I46_An I1_I976_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I46_MP2 (VDD I1_p8_13 XI1_I976_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I46_MP3 (XI1_I976_I46_p1 XI1_I976_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I46_MP0 (VDD I1_p8_13 XI1_I976_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I44_MP1 (VDD I1_b9_12 XI1_I976_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I44_MP5 (I1_I976_pn12 I1_b9_12 XI1_I976_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I44_MP4 (XI1_I976_I44_p1 XI1_I976_I44_An I1_I976_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I44_MP2 (VDD I1_p8_11 XI1_I976_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I44_MP3 (XI1_I976_I44_p1 XI1_I976_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I44_MP0 (VDD I1_p8_11 XI1_I976_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I41_MP1 (VDD I1_b9_9 XI1_I976_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I41_MP5 (I1_I976_pn9 I1_b9_9 XI1_I976_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I41_MP4 (XI1_I976_I41_p1 XI1_I976_I41_An I1_I976_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I41_MP2 (VDD I1_p8_8 XI1_I976_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I41_MP3 (XI1_I976_I41_p1 XI1_I976_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I41_MP0 (VDD I1_p8_8 XI1_I976_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I205_MP1 (VDD I1_I930_G1_0 XI1_I930_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I930_I205_MP5 (I1_p8_2 I1_I930_G1_0 XI1_I930_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I205_MP4 (XI1_I930_I205_p1 XI1_I930_I205_An I1_p8_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I205_MP2 (VDD I1_I930_pn2 XI1_I930_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I205_MP3 (XI1_I930_I205_p1 XI1_I930_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I205_MP0 (VDD I1_I930_pn2 XI1_I930_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I34_MP1 (VDD I1_b2_2 XI1_I654_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I34_MP5 (I1_I654_pn2 I1_b2_2 XI1_I654_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I34_MP4 (XI1_I654_I34_p1 XI1_I654_I34_An I1_I654_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I34_MP2 (VDD I1_p1_1 XI1_I654_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I34_MP3 (XI1_I654_I34_p1 XI1_I654_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I34_MP0 (VDD I1_p1_1 XI1_I654_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I35_MP1 (VDD I1_b2_3 XI1_I654_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I35_MP5 (I1_I654_pn3 I1_b2_3 XI1_I654_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I35_MP4 (XI1_I654_I35_p1 XI1_I654_I35_An I1_I654_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I35_MP2 (VDD I1_p1_2 XI1_I654_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I35_MP3 (XI1_I654_I35_p1 XI1_I654_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I35_MP0 (VDD I1_p1_2 XI1_I654_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I224_MP1 (VDD I1_I654_G20_0 XI1_I654_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I224_MP5 (I1_p2_21 I1_I654_G20_0 XI1_I654_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I224_MP4 (XI1_I654_I224_p1 XI1_I654_I224_An I1_p2_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I224_MP2 (VDD I1_I654_pn21 XI1_I654_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I224_MP3 (XI1_I654_I224_p1 XI1_I654_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I224_MP0 (VDD I1_I654_pn21 XI1_I654_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I226_MP1 (VDD I1_I654_G22_0 XI1_I654_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I226_MP5 (I1_p2_23 I1_I654_G22_0 XI1_I654_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I226_MP4 (XI1_I654_I226_p1 XI1_I654_I226_An I1_p2_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I226_MP2 (VDD I1_I654_pn23 XI1_I654_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I226_MP3 (XI1_I654_I226_p1 XI1_I654_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I226_MP0 (VDD I1_I654_pn23 XI1_I654_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I228_MP1 (VDD I1_I654_G24_0 XI1_I654_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I228_MP5 (I1_p2_25 I1_I654_G24_0 XI1_I654_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I228_MP4 (XI1_I654_I228_p1 XI1_I654_I228_An I1_p2_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I228_MP2 (VDD I1_I654_pn25 XI1_I654_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I228_MP3 (XI1_I654_I228_p1 XI1_I654_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I228_MP0 (VDD I1_I654_pn25 XI1_I654_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I230_MP1 (VDD I1_I654_G26_0 XI1_I654_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I230_MP5 (I1_p2_27 I1_I654_G26_0 XI1_I654_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I230_MP4 (XI1_I654_I230_p1 XI1_I654_I230_An I1_p2_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I230_MP2 (VDD I1_I654_pn27 XI1_I654_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I230_MP3 (XI1_I654_I230_p1 XI1_I654_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I230_MP0 (VDD I1_I654_pn27 XI1_I654_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I234_MP1 (VDD I1_c2_m XI1_I654_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I234_MP5 (I1_p2_31 I1_c2_m XI1_I654_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I234_MP4 (XI1_I654_I234_p1 XI1_I654_I234_An I1_p2_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I234_MP2 (VDD I1_I654_pn31 XI1_I654_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I234_MP3 (XI1_I654_I234_p1 XI1_I654_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I234_MP0 (VDD I1_I654_pn31 XI1_I654_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I62_MP1 (VDD I1_b19_30 XI1_I1436_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I62_MP5 (I1_I1436_pn30 I1_b19_30 XI1_I1436_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I62_MP4 (XI1_I1436_I62_p1 XI1_I1436_I62_An I1_I1436_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I62_MP2 (VDD I1_p18_29 XI1_I1436_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I62_MP3 (XI1_I1436_I62_p1 XI1_I1436_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I62_MP0 (VDD I1_p18_29 XI1_I1436_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I230_MP1 (VDD I1_I1436_G26_0 XI1_I1436_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I230_MP5 (I1_p19_27 I1_I1436_G26_0 XI1_I1436_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I230_MP4 (XI1_I1436_I230_p1 XI1_I1436_I230_An I1_p19_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I230_MP2 (VDD I1_I1436_pn27 XI1_I1436_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I230_MP3 (XI1_I1436_I230_p1 XI1_I1436_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I230_MP0 (VDD I1_I1436_pn27 XI1_I1436_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I228_MP1 (VDD I1_I1436_G24_0 XI1_I1436_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I228_MP5 (I1_p19_25 I1_I1436_G24_0 XI1_I1436_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I228_MP4 (XI1_I1436_I228_p1 XI1_I1436_I228_An I1_p19_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I228_MP2 (VDD I1_I1436_pn25 XI1_I1436_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I228_MP3 (XI1_I1436_I228_p1 XI1_I1436_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I228_MP0 (VDD I1_I1436_pn25 XI1_I1436_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I34_MP1 (VDD I1_b19_2 XI1_I1436_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I34_MP5 (I1_I1436_pn2 I1_b19_2 XI1_I1436_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I34_MP4 (XI1_I1436_I34_p1 XI1_I1436_I34_An I1_I1436_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I34_MP2 (VDD I1_p18_1 XI1_I1436_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I34_MP3 (XI1_I1436_I34_p1 XI1_I1436_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I34_MP0 (VDD I1_p18_1 XI1_I1436_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I57_MP1 (VDD I1_b12_25 XI1_I1114_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I57_MP5 (I1_I1114_pn25 I1_b12_25 XI1_I1114_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I57_MP4 (XI1_I1114_I57_p1 XI1_I1114_I57_An I1_I1114_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I57_MP2 (VDD I1_p11_24 XI1_I1114_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I57_MP3 (XI1_I1114_I57_p1 XI1_I1114_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I57_MP0 (VDD I1_p11_24 XI1_I1114_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I56_MP1 (VDD I1_b12_24 XI1_I1114_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I56_MP5 (I1_I1114_pn24 I1_b12_24 XI1_I1114_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I56_MP4 (XI1_I1114_I56_p1 XI1_I1114_I56_An I1_I1114_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I56_MP2 (VDD I1_p11_23 XI1_I1114_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I56_MP3 (XI1_I1114_I56_p1 XI1_I1114_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I56_MP0 (VDD I1_p11_23 XI1_I1114_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I224_MP1 (VDD I1_I1114_G20_0 XI1_I1114_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I224_MP5 (I1_p12_21 I1_I1114_G20_0 XI1_I1114_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I224_MP4 (XI1_I1114_I224_p1 XI1_I1114_I224_An I1_p12_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I224_MP2 (VDD I1_I1114_pn21 XI1_I1114_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I224_MP3 (XI1_I1114_I224_p1 XI1_I1114_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I224_MP0 (VDD I1_I1114_pn21 XI1_I1114_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I54_MP1 (VDD I1_b12_22 XI1_I1114_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I54_MP5 (I1_I1114_pn22 I1_b12_22 XI1_I1114_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I54_MP4 (XI1_I1114_I54_p1 XI1_I1114_I54_An I1_I1114_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I54_MP2 (VDD I1_p11_21 XI1_I1114_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I54_MP3 (XI1_I1114_I54_p1 XI1_I1114_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I54_MP0 (VDD I1_p11_21 XI1_I1114_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I53_MP1 (VDD I1_b12_21 XI1_I1114_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I53_MP5 (I1_I1114_pn21 I1_b12_21 XI1_I1114_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I53_MP4 (XI1_I1114_I53_p1 XI1_I1114_I53_An I1_I1114_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I53_MP2 (VDD I1_p11_20 XI1_I1114_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I53_MP3 (XI1_I1114_I53_p1 XI1_I1114_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I53_MP0 (VDD I1_p11_20 XI1_I1114_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I228_MP1 (VDD I1_I1068_G24_0 XI1_I1068_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I228_MP5 (I1_p11_25 I1_I1068_G24_0 XI1_I1068_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I228_MP4 (XI1_I1068_I228_p1 XI1_I1068_I228_An I1_p11_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I228_MP2 (VDD I1_I1068_pn25 XI1_I1068_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I228_MP3 (XI1_I1068_I228_p1 XI1_I1068_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I228_MP0 (VDD I1_I1068_pn25 XI1_I1068_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I57_MP1 (VDD I1_b11_25 XI1_I1068_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I57_MP5 (I1_I1068_pn25 I1_b11_25 XI1_I1068_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I57_MP4 (XI1_I1068_I57_p1 XI1_I1068_I57_An I1_I1068_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I57_MP2 (VDD I1_p10_24 XI1_I1068_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I57_MP3 (XI1_I1068_I57_p1 XI1_I1068_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I57_MP0 (VDD I1_p10_24 XI1_I1068_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I58_MP1 (VDD I1_b11_26 XI1_I1068_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I58_MP5 (I1_I1068_pn26 I1_b11_26 XI1_I1068_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I58_MP4 (XI1_I1068_I58_p1 XI1_I1068_I58_An I1_I1068_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I58_MP2 (VDD I1_p10_25 XI1_I1068_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I58_MP3 (XI1_I1068_I58_p1 XI1_I1068_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I58_MP0 (VDD I1_p10_25 XI1_I1068_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I232_MP1 (VDD I1_I1022_G28_0 XI1_I1022_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I232_MP5 (I1_p10_29 I1_I1022_G28_0 XI1_I1022_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I232_MP4 (XI1_I1022_I232_p1 XI1_I1022_I232_An I1_p10_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I232_MP2 (VDD I1_I1022_pn29 XI1_I1022_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I232_MP3 (XI1_I1022_I232_p1 XI1_I1022_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I232_MP0 (VDD I1_I1022_pn29 XI1_I1022_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I233_MP1 (VDD I1_I1022_G29_0 XI1_I1022_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I233_MP5 (I1_p10_30 I1_I1022_G29_0 XI1_I1022_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I233_MP4 (XI1_I1022_I233_p1 XI1_I1022_I233_An I1_p10_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I233_MP2 (VDD I1_I1022_pn30 XI1_I1022_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I233_MP3 (XI1_I1022_I233_p1 XI1_I1022_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I233_MP0 (VDD I1_I1022_pn30 XI1_I1022_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I62_MP1 (VDD I1_b10_30 XI1_I1022_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I62_MP5 (I1_I1022_pn30 I1_b10_30 XI1_I1022_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I62_MP4 (XI1_I1022_I62_p1 XI1_I1022_I62_An I1_I1022_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I62_MP2 (VDD I1_p9_29 XI1_I1022_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I62_MP3 (XI1_I1022_I62_p1 XI1_I1022_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I62_MP0 (VDD I1_p9_29 XI1_I1022_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I63_MP1 (VDD I1_b10_31 XI1_I1022_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I63_MP5 (I1_I1022_pn31 I1_b10_31 XI1_I1022_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I63_MP4 (XI1_I1022_I63_p1 XI1_I1022_I63_An I1_I1022_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I63_MP2 (VDD I1_p9_30 XI1_I1022_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I63_MP3 (XI1_I1022_I63_p1 XI1_I1022_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I63_MP0 (VDD I1_p9_30 XI1_I1022_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I231_MP1 (VDD I1_I976_G27_0 XI1_I976_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I231_MP5 (I1_p9_28 I1_I976_G27_0 XI1_I976_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I231_MP4 (XI1_I976_I231_p1 XI1_I976_I231_An I1_p9_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I231_MP2 (VDD I1_I976_pn28 XI1_I976_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I231_MP3 (XI1_I976_I231_p1 XI1_I976_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I231_MP0 (VDD I1_I976_pn28 XI1_I976_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I230_MP1 (VDD I1_I976_G26_0 XI1_I976_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I230_MP5 (I1_p9_27 I1_I976_G26_0 XI1_I976_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I230_MP4 (XI1_I976_I230_p1 XI1_I976_I230_An I1_p9_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I230_MP2 (VDD I1_I976_pn27 XI1_I976_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I230_MP3 (XI1_I976_I230_p1 XI1_I976_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I230_MP0 (VDD I1_I976_pn27 XI1_I976_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I45_MP1 (VDD I1_b9_13 XI1_I976_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I45_MP5 (I1_I976_pn13 I1_b9_13 XI1_I976_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I45_MP4 (XI1_I976_I45_p1 XI1_I976_I45_An I1_I976_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I45_MP2 (VDD I1_p8_12 XI1_I976_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I45_MP3 (XI1_I976_I45_p1 XI1_I976_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I45_MP0 (VDD I1_p8_12 XI1_I976_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I42_MP1 (VDD I1_b9_10 XI1_I976_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I42_MP5 (I1_I976_pn10 I1_b9_10 XI1_I976_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I42_MP4 (XI1_I976_I42_p1 XI1_I976_I42_An I1_I976_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I42_MP2 (VDD I1_p8_9 XI1_I976_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I42_MP3 (XI1_I976_I42_p1 XI1_I976_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I42_MP0 (VDD I1_p8_9 XI1_I976_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I39_MP1 (VDD I1_b9_7 XI1_I976_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I39_MP5 (I1_I976_pn7 I1_b9_7 XI1_I976_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I39_MP4 (XI1_I976_I39_p1 XI1_I976_I39_An I1_I976_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I39_MP2 (VDD I1_p8_6 XI1_I976_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I39_MP3 (XI1_I976_I39_p1 XI1_I976_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I39_MP0 (VDD I1_p8_6 XI1_I976_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I203_MP1 (VDD I1_qu25_b3_5 XI1_I884_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I203_MP5 (I1_p7_0 I1_qu25_b3_5 XI1_I884_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I203_MP4 (XI1_I884_I203_p1 XI1_I884_I203_An I1_p7_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I203_MP2 (VDD I1_I884_pn0 XI1_I884_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I203_MP3 (XI1_I884_I203_p1 XI1_I884_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I203_MP0 (VDD I1_I884_pn0 XI1_I884_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I32_MP1 (VDD I1_b7_0 XI1_I884_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I32_MP5 (I1_I884_pn0 I1_b7_0 XI1_I884_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I32_MP4 (XI1_I884_I32_p1 XI1_I884_I32_An I1_I884_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I32_MP2 (VDD I1_aa24 XI1_I884_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I32_MP3 (XI1_I884_I32_p1 XI1_I884_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I32_MP0 (VDD I1_aa24 XI1_I884_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I60_MP1 (VDD I1_b2_28 XI1_I654_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I60_MP5 (I1_I654_pn28 I1_b2_28 XI1_I654_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I60_MP4 (XI1_I654_I60_p1 XI1_I654_I60_An I1_I654_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I60_MP2 (VDD I1_p1_27 XI1_I654_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I60_MP3 (XI1_I654_I60_p1 XI1_I654_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I60_MP0 (VDD I1_p1_27 XI1_I654_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I61_MP1 (VDD I1_b2_29 XI1_I654_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I654_I61_MP5 (I1_I654_pn29 I1_b2_29 XI1_I654_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I61_MP4 (XI1_I654_I61_p1 XI1_I654_I61_An I1_I654_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I61_MP2 (VDD I1_p1_28 XI1_I654_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I61_MP3 (XI1_I654_I61_p1 XI1_I654_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I61_MP0 (VDD I1_p1_28 XI1_I654_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I232_MP1 (VDD I1_I1436_G28_0 XI1_I1436_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I232_MP5 (I1_p19_29 I1_I1436_G28_0 XI1_I1436_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I232_MP4 (XI1_I1436_I232_p1 XI1_I1436_I232_An I1_p19_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I232_MP2 (VDD I1_I1436_pn29 XI1_I1436_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I232_MP3 (XI1_I1436_I232_p1 XI1_I1436_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I232_MP0 (VDD I1_I1436_pn29 XI1_I1436_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I226_MP1 (VDD I1_I1436_G22_0 XI1_I1436_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I226_MP5 (I1_p19_23 I1_I1436_G22_0 XI1_I1436_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I226_MP4 (XI1_I1436_I226_p1 XI1_I1436_I226_An I1_p19_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I226_MP2 (VDD I1_I1436_pn23 XI1_I1436_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I226_MP3 (XI1_I1436_I226_p1 XI1_I1436_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I226_MP0 (VDD I1_I1436_pn23 XI1_I1436_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I224_MP1 (VDD I1_I1436_G20_0 XI1_I1436_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I224_MP5 (I1_p19_21 I1_I1436_G20_0 XI1_I1436_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I224_MP4 (XI1_I1436_I224_p1 XI1_I1436_I224_An I1_p19_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I224_MP2 (VDD I1_I1436_pn21 XI1_I1436_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I224_MP3 (XI1_I1436_I224_p1 XI1_I1436_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I224_MP0 (VDD I1_I1436_pn21 XI1_I1436_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I222_MP1 (VDD I1_I1436_G18_0 XI1_I1436_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I222_MP5 (I1_p19_19 I1_I1436_G18_0 XI1_I1436_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I222_MP4 (XI1_I1436_I222_p1 XI1_I1436_I222_An I1_p19_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I222_MP2 (VDD I1_I1436_pn19 XI1_I1436_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I222_MP3 (XI1_I1436_I222_p1 XI1_I1436_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I222_MP0 (VDD I1_I1436_pn19 XI1_I1436_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I220_MP1 (VDD I1_I1436_G16_0 XI1_I1436_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I220_MP5 (I1_p19_17 I1_I1436_G16_0 XI1_I1436_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I220_MP4 (XI1_I1436_I220_p1 XI1_I1436_I220_An I1_p19_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I220_MP2 (VDD I1_I1436_pn17 XI1_I1436_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I220_MP3 (XI1_I1436_I220_p1 XI1_I1436_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I220_MP0 (VDD I1_I1436_pn17 XI1_I1436_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I210_MP1 (VDD I1_I1436_G6_0 XI1_I1436_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I210_MP5 (I1_p19_7 I1_I1436_G6_0 XI1_I1436_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I210_MP4 (XI1_I1436_I210_p1 XI1_I1436_I210_An I1_p19_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I210_MP2 (VDD I1_I1436_pn7 XI1_I1436_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I210_MP3 (XI1_I1436_I210_p1 XI1_I1436_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I210_MP0 (VDD I1_I1436_pn7 XI1_I1436_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I208_MP1 (VDD I1_I1436_G4_0 XI1_I1436_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I208_MP5 (I1_p19_5 I1_I1436_G4_0 XI1_I1436_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I208_MP4 (XI1_I1436_I208_p1 XI1_I1436_I208_An I1_p19_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I208_MP2 (VDD I1_I1436_pn5 XI1_I1436_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I208_MP3 (XI1_I1436_I208_p1 XI1_I1436_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I208_MP0 (VDD I1_I1436_pn5 XI1_I1436_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I33_MP1 (VDD I1_b19_1 XI1_I1436_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I33_MP5 (I1_I1436_pn1 I1_b19_1 XI1_I1436_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I33_MP4 (XI1_I1436_I33_p1 XI1_I1436_I33_An I1_I1436_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I33_MP2 (VDD I1_p18_0 XI1_I1436_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I33_MP3 (XI1_I1436_I33_p1 XI1_I1436_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I33_MP0 (VDD I1_p18_0 XI1_I1436_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I204_MP1 (VDD I1_I1436_G0_0 XI1_I1436_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1436_I204_MP5 (I1_p19_1 I1_I1436_G0_0 XI1_I1436_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I204_MP4 (XI1_I1436_I204_p1 XI1_I1436_I204_An I1_p19_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I204_MP2 (VDD I1_I1436_pn1 XI1_I1436_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I204_MP3 (XI1_I1436_I204_p1 XI1_I1436_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I204_MP0 (VDD I1_I1436_pn1 XI1_I1436_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I225_MP1 (VDD I1_I1114_G21_0 XI1_I1114_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I225_MP5 (I1_p12_22 I1_I1114_G21_0 XI1_I1114_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I225_MP4 (XI1_I1114_I225_p1 XI1_I1114_I225_An I1_p12_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I225_MP2 (VDD I1_I1114_pn22 XI1_I1114_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I225_MP3 (XI1_I1114_I225_p1 XI1_I1114_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I225_MP0 (VDD I1_I1114_pn22 XI1_I1114_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I223_MP1 (VDD I1_I1114_G19_0 XI1_I1114_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I223_MP5 (I1_p12_20 I1_I1114_G19_0 XI1_I1114_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I223_MP4 (XI1_I1114_I223_p1 XI1_I1114_I223_An I1_p12_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I223_MP2 (VDD I1_I1114_pn20 XI1_I1114_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I223_MP3 (XI1_I1114_I223_p1 XI1_I1114_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I223_MP0 (VDD I1_I1114_pn20 XI1_I1114_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I222_MP1 (VDD I1_I1114_G18_0 XI1_I1114_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I222_MP5 (I1_p12_19 I1_I1114_G18_0 XI1_I1114_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I222_MP4 (XI1_I1114_I222_p1 XI1_I1114_I222_An I1_p12_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I222_MP2 (VDD I1_I1114_pn19 XI1_I1114_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I222_MP3 (XI1_I1114_I222_p1 XI1_I1114_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I222_MP0 (VDD I1_I1114_pn19 XI1_I1114_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I52_MP1 (VDD I1_b12_20 XI1_I1114_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I52_MP5 (I1_I1114_pn20 I1_b12_20 XI1_I1114_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I52_MP4 (XI1_I1114_I52_p1 XI1_I1114_I52_An I1_I1114_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I52_MP2 (VDD I1_p11_19 XI1_I1114_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I52_MP3 (XI1_I1114_I52_p1 XI1_I1114_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I52_MP0 (VDD I1_p11_19 XI1_I1114_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I51_MP1 (VDD I1_b12_19 XI1_I1114_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1114_I51_MP5 (I1_I1114_pn19 I1_b12_19 XI1_I1114_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I51_MP4 (XI1_I1114_I51_p1 XI1_I1114_I51_An I1_I1114_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I51_MP2 (VDD I1_p11_18 XI1_I1114_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I51_MP3 (XI1_I1114_I51_p1 XI1_I1114_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I51_MP0 (VDD I1_p11_18 XI1_I1114_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I226_MP1 (VDD I1_I1068_G22_0 XI1_I1068_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I226_MP5 (I1_p11_23 I1_I1068_G22_0 XI1_I1068_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I226_MP4 (XI1_I1068_I226_p1 XI1_I1068_I226_An I1_p11_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I226_MP2 (VDD I1_I1068_pn23 XI1_I1068_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I226_MP3 (XI1_I1068_I226_p1 XI1_I1068_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I226_MP0 (VDD I1_I1068_pn23 XI1_I1068_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I227_MP1 (VDD I1_I1068_G23_0 XI1_I1068_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I227_MP5 (I1_p11_24 I1_I1068_G23_0 XI1_I1068_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I227_MP4 (XI1_I1068_I227_p1 XI1_I1068_I227_An I1_p11_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I227_MP2 (VDD I1_I1068_pn24 XI1_I1068_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I227_MP3 (XI1_I1068_I227_p1 XI1_I1068_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I227_MP0 (VDD I1_I1068_pn24 XI1_I1068_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I225_MP1 (VDD I1_I1068_G21_0 XI1_I1068_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I225_MP5 (I1_p11_22 I1_I1068_G21_0 XI1_I1068_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I225_MP4 (XI1_I1068_I225_p1 XI1_I1068_I225_An I1_p11_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I225_MP2 (VDD I1_I1068_pn22 XI1_I1068_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I225_MP3 (XI1_I1068_I225_p1 XI1_I1068_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I225_MP0 (VDD I1_I1068_pn22 XI1_I1068_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I56_MP1 (VDD I1_b11_24 XI1_I1068_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I56_MP5 (I1_I1068_pn24 I1_b11_24 XI1_I1068_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I56_MP4 (XI1_I1068_I56_p1 XI1_I1068_I56_An I1_I1068_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I56_MP2 (VDD I1_p10_23 XI1_I1068_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I56_MP3 (XI1_I1068_I56_p1 XI1_I1068_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I56_MP0 (VDD I1_p10_23 XI1_I1068_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I55_MP1 (VDD I1_b11_23 XI1_I1068_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1068_I55_MP5 (I1_I1068_pn23 I1_b11_23 XI1_I1068_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I55_MP4 (XI1_I1068_I55_p1 XI1_I1068_I55_An I1_I1068_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I55_MP2 (VDD I1_p10_22 XI1_I1068_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I55_MP3 (XI1_I1068_I55_p1 XI1_I1068_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I55_MP0 (VDD I1_p10_22 XI1_I1068_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I230_MP1 (VDD I1_I1022_G26_0 XI1_I1022_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I230_MP5 (I1_p10_27 I1_I1022_G26_0 XI1_I1022_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I230_MP4 (XI1_I1022_I230_p1 XI1_I1022_I230_An I1_p10_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I230_MP2 (VDD I1_I1022_pn27 XI1_I1022_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I230_MP3 (XI1_I1022_I230_p1 XI1_I1022_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I230_MP0 (VDD I1_I1022_pn27 XI1_I1022_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I234_MP1 (VDD I1_c10_m XI1_I1022_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I234_MP5 (I1_p10_31 I1_c10_m XI1_I1022_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I234_MP4 (XI1_I1022_I234_p1 XI1_I1022_I234_An I1_p10_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I234_MP2 (VDD I1_I1022_pn31 XI1_I1022_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I234_MP3 (XI1_I1022_I234_p1 XI1_I1022_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I234_MP0 (VDD I1_I1022_pn31 XI1_I1022_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I59_MP1 (VDD I1_b10_27 XI1_I1022_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1022_I59_MP5 (I1_I1022_pn27 I1_b10_27 XI1_I1022_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I59_MP4 (XI1_I1022_I59_p1 XI1_I1022_I59_An I1_I1022_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I59_MP2 (VDD I1_p9_26 XI1_I1022_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I59_MP3 (XI1_I1022_I59_p1 XI1_I1022_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I59_MP0 (VDD I1_p9_26 XI1_I1022_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I233_MP1 (VDD I1_I976_G29_0 XI1_I976_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I976_I233_MP5 (I1_p9_30 I1_I976_G29_0 XI1_I976_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I233_MP4 (XI1_I976_I233_p1 XI1_I976_I233_An I1_p9_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
