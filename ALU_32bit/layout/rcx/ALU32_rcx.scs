    I_MXI0_I1517_MN10_1 (VSS I0_cm41_0 XI0_I1517_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1517_MN6 (XI0_I1517_n3 I0_cm41_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1517_MN7 (VSS I0_cm42_0 XI0_I1517_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1517_MN8 (XI0_I1517_n3 I0_pp12_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1517_MN9 (XI0_I1517_sn XI0_I1517_con XI0_I1517_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1517_MN12_1 (XI0_I1517_n5 I0_pp12_0 XI0_I1517_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1394_MN12 (XI0_I1394_sn I0_pp10_1 XI0_I1394_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1394_MN25 (I0_fa33_0 XI0_I1394_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1394_MN5 (XI0_I1394_con I0_pp10_1 XI0_I1394_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1394_MN2 (XI0_I1394_n1 I0_pp9_3 XI0_I1394_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1394_MN1 (VSS I0_pp8_5 XI0_I1394_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1394_MN3 (XI0_I1394_n2 I0_pp8_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1394_MN4 (VSS I0_pp9_3 XI0_I1394_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1394_MN27 (I0_fa33_1 XI0_I1394_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1394_MN10 (XI0_I1394_n4 I0_pp8_5 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1394_MN11 (XI0_I1394_n5 I0_pp9_3 XI0_I1394_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1394_MN11_1 (XI0_I1394_n4 I0_pp9_3 XI0_I1394_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1394_MN10_1 (VSS I0_pp8_5 XI0_I1394_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1394_MN6 (XI0_I1394_n3 I0_pp8_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1394_MN7 (VSS I0_pp9_3 XI0_I1394_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1394_MN8 (XI0_I1394_n3 I0_pp10_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1394_MN9 (XI0_I1394_sn XI0_I1394_con XI0_I1394_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1394_MN12_1 (XI0_I1394_n5 I0_pp10_1 XI0_I1394_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1641_MN12 (XI0_I1641_sn I0_cm84_2 XI0_I1641_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1641_MN25 (I0_fa280_0 XI0_I1641_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1641_MN5 (XI0_I1641_con I0_cm84_2 XI0_I1641_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1641_MN2 (XI0_I1641_n1 I0_cm230_0 XI0_I1641_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1641_MN1 (VSS I0_cm229_1 XI0_I1641_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1641_MN3 (XI0_I1641_n2 I0_cm229_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1641_MN4 (VSS I0_cm230_0 XI0_I1641_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1641_MN27 (I0_fa280_1 XI0_I1641_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1641_MN10 (XI0_I1641_n4 I0_cm229_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1641_MN11 (XI0_I1641_n5 I0_cm230_0 XI0_I1641_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1641_MN11_1 (XI0_I1641_n4 I0_cm230_0 XI0_I1641_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1641_MN10_1 (VSS I0_cm229_1 XI0_I1641_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1641_MN6 (XI0_I1641_n3 I0_cm229_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1641_MN7 (VSS I0_cm230_0 XI0_I1641_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1641_MN8 (XI0_I1641_n3 I0_cm84_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1641_MN9 (XI0_I1641_sn XI0_I1641_con XI0_I1641_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1641_MN12_1 (XI0_I1641_n5 I0_cm84_2 XI0_I1641_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1498_MN12 (XI0_I1498_sn I0_pp1_1 XI0_I1498_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1498_MN25 (I0_fa137_0 XI0_I1498_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1498_MN5 (XI0_I1498_con I0_pp1_1 XI0_I1498_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1498_MN2 (XI0_I1498_n1 I0_pp0_3 XI0_I1498_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1498_MN1 (VSS I0_fa1_1 XI0_I1498_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1498_MN3 (XI0_I1498_n2 I0_fa1_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1498_MN4 (VSS I0_pp0_3 XI0_I1498_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1498_MN27 (I0_fa137_1 XI0_I1498_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1498_MN10 (XI0_I1498_n4 I0_fa1_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1498_MN11 (XI0_I1498_n5 I0_pp0_3 XI0_I1498_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1498_MN11_1 (XI0_I1498_n4 I0_pp0_3 XI0_I1498_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1498_MN10_1 (VSS I0_fa1_1 XI0_I1498_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1498_MN6 (XI0_I1498_n3 I0_fa1_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1498_MN7 (VSS I0_pp0_3 XI0_I1498_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1498_MN8 (XI0_I1498_n3 I0_pp1_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1498_MN9 (XI0_I1498_sn XI0_I1498_con XI0_I1498_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1498_MN12_1 (XI0_I1498_n5 I0_pp1_1 XI0_I1498_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1362_MN12 (XI0_I1362_sn I0_B_3_b3_5 XI0_I1362_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1362_MN25 (I0_fa1_0 XI0_I1362_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1362_MN5 (XI0_I1362_con I0_B_3_b3_5 XI0_I1362_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1362_MN2 (XI0_I1362_n1 I0_pp1_0 XI0_I1362_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1362_MN1 (VSS I0_pp0_2 XI0_I1362_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1362_MN3 (XI0_I1362_n2 I0_pp0_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1362_MN4 (VSS I0_pp1_0 XI0_I1362_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1362_MN27 (I0_fa1_1 XI0_I1362_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1362_MN10 (XI0_I1362_n4 I0_pp0_2 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1362_MN11 (XI0_I1362_n5 I0_pp1_0 XI0_I1362_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1362_MN11_1 (XI0_I1362_n4 I0_pp1_0 XI0_I1362_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1362_MN10_1 (VSS I0_pp0_2 XI0_I1362_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1362_MN6 (XI0_I1362_n3 I0_pp0_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1362_MN7 (VSS I0_pp1_0 XI0_I1362_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1362_MN8 (XI0_I1362_n3 I0_B_3_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1362_MN9 (XI0_I1362_sn XI0_I1362_con XI0_I1362_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1362_MN12_1 (XI0_I1362_n5 I0_B_3_b3_5 XI0_I1362_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1500_MN12 (XI0_I1500_sn I0_pp4_1 XI0_I1500_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1500_MN25 (I0_fa139_0 XI0_I1500_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1500_MN5 (XI0_I1500_con I0_pp4_1 XI0_I1500_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1500_MN2 (XI0_I1500_n1 I0_cm7_0 XI0_I1500_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1500_MN1 (VSS I0_cm6_1 XI0_I1500_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1500_MN3 (XI0_I1500_n2 I0_cm6_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1500_MN4 (VSS I0_cm7_0 XI0_I1500_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1500_MN27 (I0_fa139_1 XI0_I1500_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1500_MN10 (XI0_I1500_n4 I0_cm6_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1500_MN11 (XI0_I1500_n5 I0_cm7_0 XI0_I1500_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1500_MN11_1 (XI0_I1500_n4 I0_cm7_0 XI0_I1500_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1500_MN10_1 (VSS I0_cm6_1 XI0_I1500_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1500_MN6 (XI0_I1500_n3 I0_cm6_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1500_MN7 (VSS I0_cm7_0 XI0_I1500_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1500_MN8 (XI0_I1500_n3 I0_pp4_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1500_MN9 (XI0_I1500_sn XI0_I1500_con XI0_I1500_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1500_MN12_1 (XI0_I1500_n5 I0_pp4_1 XI0_I1500_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1391_MN12 (XI0_I1391_sn I0_pp10_0 XI0_I1391_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1391_MN25 (I0_fa30_0 XI0_I1391_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1391_MN5 (XI0_I1391_con I0_pp10_0 XI0_I1391_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1391_MN2 (XI0_I1391_n1 I0_pp9_2 XI0_I1391_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1391_MN1 (VSS I0_pp8_4 XI0_I1391_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1391_MN3 (XI0_I1391_n2 I0_pp8_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1391_MN4 (VSS I0_pp9_2 XI0_I1391_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1391_MN27 (I0_fa30_1 XI0_I1391_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1391_MN10 (XI0_I1391_n4 I0_pp8_4 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1391_MN11 (XI0_I1391_n5 I0_pp9_2 XI0_I1391_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1391_MN11_1 (XI0_I1391_n4 I0_pp9_2 XI0_I1391_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1391_MN10_1 (VSS I0_pp8_4 XI0_I1391_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1391_MN6 (XI0_I1391_n3 I0_pp8_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1391_MN7 (VSS I0_pp9_2 XI0_I1391_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1391_MN8 (XI0_I1391_n3 I0_pp10_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1391_MN9 (XI0_I1391_sn XI0_I1391_con XI0_I1391_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1391_MN12_1 (XI0_I1391_n5 I0_pp10_0 XI0_I1391_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1570_MN12 (XI0_I1570_sn I0_B_5_b3_5 XI0_I1570_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1570_MN25 (I0_fa209_0 XI0_I1570_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1570_MN5 (XI0_I1570_con I0_B_5_b3_5 XI0_I1570_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1570_MN2 (XI0_I1570_n1 I0_fa2_0 XI0_I1570_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1570_MN1 (VSS I0_fa137_1 XI0_I1570_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1570_MN3 (XI0_I1570_n2 I0_fa137_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1570_MN4 (VSS I0_fa2_0 XI0_I1570_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1570_MN27 (I0_fa209_1 XI0_I1570_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1570_MN10 (XI0_I1570_n4 I0_fa137_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1570_MN11 (XI0_I1570_n5 I0_fa2_0 XI0_I1570_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1570_MN11_1 (XI0_I1570_n4 I0_fa2_0 XI0_I1570_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1570_MN10_1 (VSS I0_fa137_1 XI0_I1570_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1570_MN6 (XI0_I1570_n3 I0_fa137_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1570_MN7 (VSS I0_fa2_0 XI0_I1570_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1570_MN8 (XI0_I1570_n3 I0_B_5_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1570_MN9 (XI0_I1570_sn XI0_I1570_con XI0_I1570_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1570_MN12_1 (XI0_I1570_n5 I0_B_5_b3_5 XI0_I1570_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1364_MN12 (XI0_I1364_sn I0_pp2_1 XI0_I1364_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1364_MN25 (I0_fa3_0 XI0_I1364_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1364_MN5 (XI0_I1364_con I0_pp2_1 XI0_I1364_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1364_MN2 (XI0_I1364_n1 I0_pp1_3 XI0_I1364_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1364_MN1 (VSS I0_pp0_5 XI0_I1364_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1364_MN3 (XI0_I1364_n2 I0_pp0_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1364_MN4 (VSS I0_pp1_3 XI0_I1364_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1364_MN27 (I0_fa3_1 XI0_I1364_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1364_MN10 (XI0_I1364_n4 I0_pp0_5 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1364_MN11 (XI0_I1364_n5 I0_pp1_3 XI0_I1364_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1364_MN11_1 (XI0_I1364_n4 I0_pp1_3 XI0_I1364_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1364_MN10_1 (VSS I0_pp0_5 XI0_I1364_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1364_MN6 (XI0_I1364_n3 I0_pp0_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1364_MN7 (VSS I0_pp1_3 XI0_I1364_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1364_MN8 (XI0_I1364_n3 I0_pp2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1364_MN9 (XI0_I1364_sn XI0_I1364_con XI0_I1364_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1364_MN12_1 (XI0_I1364_n5 I0_pp2_1 XI0_I1364_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1571_MN12 (XI0_I1571_sn I0_pp8_0 XI0_I1571_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1571_MN25 (I0_fa210_0 XI0_I1571_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1571_MN5 (XI0_I1571_con I0_pp8_0 XI0_I1571_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1571_MN2 (XI0_I1571_n1 I0_cm146_0 XI0_I1571_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1571_MN1 (VSS I0_cm145_1 XI0_I1571_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1571_MN3 (XI0_I1571_n2 I0_cm145_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1571_MN4 (VSS I0_cm146_0 XI0_I1571_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1571_MN27 (I0_fa210_1 XI0_I1571_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1571_MN10 (XI0_I1571_n4 I0_cm145_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1571_MN11 (XI0_I1571_n5 I0_cm146_0 XI0_I1571_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1571_MN11_1 (XI0_I1571_n4 I0_cm146_0 XI0_I1571_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1571_MN10_1 (VSS I0_cm145_1 XI0_I1571_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1571_MN6 (XI0_I1571_n3 I0_cm145_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1571_MN7 (VSS I0_cm146_0 XI0_I1571_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1571_MN8 (XI0_I1571_n3 I0_pp8_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1571_MN9 (XI0_I1571_sn XI0_I1571_con XI0_I1571_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1571_MN12_1 (XI0_I1571_n5 I0_pp8_0 XI0_I1571_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1573_MN12 (XI0_I1573_sn I0_fa25_0 XI0_I1573_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1573_MN25 (I0_fa212_0 XI0_I1573_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1573_MN5 (XI0_I1573_con I0_fa25_0 XI0_I1573_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1573_MN2 (XI0_I1573_n1 I0_cm148_0 XI0_I1573_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1573_MN1 (VSS I0_cm147_1 XI0_I1573_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1573_MN3 (XI0_I1573_n2 I0_cm147_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1573_MN4 (VSS I0_cm148_0 XI0_I1573_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1573_MN27 (I0_fa212_1 XI0_I1573_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1573_MN10 (XI0_I1573_n4 I0_cm147_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1573_MN11 (XI0_I1573_n5 I0_cm148_0 XI0_I1573_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1573_MN11_1 (XI0_I1573_n4 I0_cm148_0 XI0_I1573_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1573_MN10_1 (VSS I0_cm147_1 XI0_I1573_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1573_MN6 (XI0_I1573_n3 I0_cm147_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1573_MN7 (VSS I0_cm148_0 XI0_I1573_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1573_MN8 (XI0_I1573_n3 I0_fa25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1573_MN9 (XI0_I1573_sn XI0_I1573_con XI0_I1573_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1573_MN12_1 (XI0_I1573_n5 I0_fa25_0 XI0_I1573_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1572_MN12 (XI0_I1572_sn I0_pp8_1 XI0_I1572_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1572_MN25 (I0_fa211_0 XI0_I1572_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1572_MN5 (XI0_I1572_con I0_pp8_1 XI0_I1572_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1572_MN2 (XI0_I1572_n1 I0_cm147_0 XI0_I1572_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1572_MN1 (VSS I0_cm146_1 XI0_I1572_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1572_MN3 (XI0_I1572_n2 I0_cm146_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1572_MN4 (VSS I0_cm147_0 XI0_I1572_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1572_MN27 (I0_fa211_1 XI0_I1572_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1572_MN10 (XI0_I1572_n4 I0_cm146_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1572_MN11 (XI0_I1572_n5 I0_cm147_0 XI0_I1572_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1572_MN11_1 (XI0_I1572_n4 I0_cm147_0 XI0_I1572_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1572_MN10_1 (VSS I0_cm146_1 XI0_I1572_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1572_MN6 (XI0_I1572_n3 I0_cm146_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1572_MN7 (VSS I0_cm147_0 XI0_I1572_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1572_MN8 (XI0_I1572_n3 I0_pp8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1572_MN9 (XI0_I1572_sn XI0_I1572_con XI0_I1572_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1572_MN12_1 (XI0_I1572_n5 I0_pp8_1 XI0_I1572_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1511_MN12 (XI0_I1511_sn I0_pp9_1 XI0_I1511_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1511_MN25 (I0_fa150_0 XI0_I1511_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1511_MN5 (XI0_I1511_con I0_pp9_1 XI0_I1511_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1511_MN2 (XI0_I1511_n1 I0_pp8_3 XI0_I1511_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1511_MN1 (VSS I0_cm27_0 XI0_I1511_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1511_MN3 (XI0_I1511_n2 I0_cm27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1511_MN4 (VSS I0_pp8_3 XI0_I1511_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1511_MN27 (I0_fa150_1 XI0_I1511_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1511_MN10 (XI0_I1511_n4 I0_cm27_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1511_MN11 (XI0_I1511_n5 I0_pp8_3 XI0_I1511_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1511_MN11_1 (XI0_I1511_n4 I0_pp8_3 XI0_I1511_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1511_MN10_1 (VSS I0_cm27_0 XI0_I1511_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1511_MN6 (XI0_I1511_n3 I0_cm27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1511_MN7 (VSS I0_pp8_3 XI0_I1511_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1511_MN8 (XI0_I1511_n3 I0_pp9_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1511_MN9 (XI0_I1511_sn XI0_I1511_con XI0_I1511_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1511_MN12_1 (XI0_I1511_n5 I0_pp9_1 XI0_I1511_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1386_MN12 (XI0_I1386_sn I0_B_19_b3_5 XI0_I1386_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1386_MN25 (I0_fa25_0 XI0_I1386_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1386_MN5 (XI0_I1386_con I0_B_19_b3_5 XI0_I1386_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1386_MN2 (XI0_I1386_n1 I0_pp9_0 XI0_I1386_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1386_MN1 (VSS I0_pp8_2 XI0_I1386_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1386_MN3 (XI0_I1386_n2 I0_pp8_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1386_MN4 (VSS I0_pp9_0 XI0_I1386_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1386_MN27 (I0_fa25_1 XI0_I1386_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1386_MN10 (XI0_I1386_n4 I0_pp8_2 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1386_MN11 (XI0_I1386_n5 I0_pp9_0 XI0_I1386_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1386_MN11_1 (XI0_I1386_n4 I0_pp9_0 XI0_I1386_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1386_MN10_1 (VSS I0_pp8_2 XI0_I1386_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1386_MN6 (XI0_I1386_n3 I0_pp8_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1386_MN7 (VSS I0_pp9_0 XI0_I1386_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1386_MN8 (XI0_I1386_n3 I0_B_19_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1386_MN9 (XI0_I1386_sn XI0_I1386_con XI0_I1386_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1386_MN12_1 (XI0_I1386_n5 I0_B_19_b3_5 XI0_I1386_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1644_MN12 (XI0_I1644_sn I0_cm184_2 XI0_I1644_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1644_MN25 (I0_fa283_0 XI0_I1644_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1644_MN5 (XI0_I1644_con I0_cm184_2 XI0_I1644_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1644_MN2 (XI0_I1644_n1 I0_cm233_0 XI0_I1644_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1644_MN1 (VSS I0_cm232_1 XI0_I1644_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1644_MN3 (XI0_I1644_n2 I0_cm232_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1644_MN4 (VSS I0_cm233_0 XI0_I1644_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1644_MN27 (I0_fa283_1 XI0_I1644_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1644_MN10 (XI0_I1644_n4 I0_cm232_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1644_MN11 (XI0_I1644_n5 I0_cm233_0 XI0_I1644_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1644_MN11_1 (XI0_I1644_n4 I0_cm233_0 XI0_I1644_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1644_MN10_1 (VSS I0_cm232_1 XI0_I1644_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1644_MN6 (XI0_I1644_n3 I0_cm232_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1644_MN7 (VSS I0_cm233_0 XI0_I1644_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1644_MN8 (XI0_I1644_n3 I0_cm184_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1644_MN9 (XI0_I1644_sn XI0_I1644_con XI0_I1644_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1644_MN12_1 (XI0_I1644_n5 I0_cm184_2 XI0_I1644_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1610_MN12 (XI0_I1610_sn I0_fa3_0 XI0_I1610_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1610_MN25 (I0_fa249_0 XI0_I1610_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1610_MN5 (XI0_I1610_con I0_fa3_0 XI0_I1610_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1610_MN2 (XI0_I1610_n1 I0_fa2_1 XI0_I1610_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1610_MN1 (VSS I0_fa209_1 XI0_I1610_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1610_MN3 (XI0_I1610_n2 I0_fa209_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1610_MN4 (VSS I0_fa2_1 XI0_I1610_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1610_MN27 (I0_fa249_1 XI0_I1610_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1610_MN10 (XI0_I1610_n4 I0_fa209_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1610_MN11 (XI0_I1610_n5 I0_fa2_1 XI0_I1610_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1610_MN11_1 (XI0_I1610_n4 I0_fa2_1 XI0_I1610_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1610_MN10_1 (VSS I0_fa209_1 XI0_I1610_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1610_MN6 (XI0_I1610_n3 I0_fa209_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1610_MN7 (VSS I0_fa2_1 XI0_I1610_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1610_MN8 (XI0_I1610_n3 I0_fa3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1610_MN9 (XI0_I1610_sn XI0_I1610_con XI0_I1610_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1610_MN12_1 (XI0_I1610_n5 I0_fa3_0 XI0_I1610_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1574_MN12 (XI0_I1574_sn I0_fa150_0 XI0_I1574_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1574_MN25 (I0_fa213_0 XI0_I1574_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1574_MN5 (XI0_I1574_con I0_fa150_0 XI0_I1574_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1574_MN2 (XI0_I1574_n1 I0_cm149_0 XI0_I1574_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1574_MN1 (VSS I0_cm148_1 XI0_I1574_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1574_MN3 (XI0_I1574_n2 I0_cm148_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1574_MN4 (VSS I0_cm149_0 XI0_I1574_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1574_MN27 (I0_fa213_1 XI0_I1574_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1574_MN10 (XI0_I1574_n4 I0_cm148_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1574_MN11 (XI0_I1574_n5 I0_cm149_0 XI0_I1574_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1574_MN11_1 (XI0_I1574_n4 I0_cm149_0 XI0_I1574_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1574_MN10_1 (VSS I0_cm148_1 XI0_I1574_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1574_MN6 (XI0_I1574_n3 I0_cm148_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1574_MN7 (VSS I0_cm149_0 XI0_I1574_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1574_MN8 (XI0_I1574_n3 I0_fa150_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1574_MN9 (XI0_I1574_sn XI0_I1574_con XI0_I1574_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1574_MN12_1 (XI0_I1574_n5 I0_fa150_0 XI0_I1574_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1449_MN12 (XI0_I1449_sn I0_pp15_6 XI0_I1449_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1449_MN25 (I0_fa88_0 XI0_I1449_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1449_MN5 (XI0_I1449_con I0_pp15_6 XI0_I1449_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1449_MN2 (XI0_I1449_n1 I0_pp14_8 XI0_I1449_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1449_MN1 (VSS I0_pp13_10 XI0_I1449_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1449_MN3 (XI0_I1449_n2 I0_pp13_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1449_MN4 (VSS I0_pp14_8 XI0_I1449_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1449_MN27 (I0_fa88_1 XI0_I1449_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1449_MN10 (XI0_I1449_n4 I0_pp13_10 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1449_MN11 (XI0_I1449_n5 I0_pp14_8 XI0_I1449_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1449_MN11_1 (XI0_I1449_n4 I0_pp14_8 XI0_I1449_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1449_MN10_1 (VSS I0_pp13_10 XI0_I1449_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1449_MN6 (XI0_I1449_n3 I0_pp13_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1449_MN7 (VSS I0_pp14_8 XI0_I1449_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1449_MN8 (XI0_I1449_n3 I0_pp15_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1449_MN9 (XI0_I1449_sn XI0_I1449_con XI0_I1449_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1449_MN12_1 (XI0_I1449_n5 I0_pp15_6 XI0_I1449_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1547_MN12 (XI0_I1547_sn I0_pp15_9 XI0_I1547_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1547_MN25 (I0_fa186_0 XI0_I1547_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1547_MN5 (XI0_I1547_con I0_pp15_9 XI0_I1547_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1547_MN2 (XI0_I1547_n1 I0_cm97_0 XI0_I1547_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1547_MN1 (VSS I0_cm96_0 XI0_I1547_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1547_MN3 (XI0_I1547_n2 I0_cm96_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1547_MN4 (VSS I0_cm97_0 XI0_I1547_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1547_MN27 (I0_fa186_1 XI0_I1547_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1547_MN10 (XI0_I1547_n4 I0_cm96_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1547_MN11 (XI0_I1547_n5 I0_cm97_0 XI0_I1547_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1547_MN11_1 (XI0_I1547_n4 I0_cm97_0 XI0_I1547_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1547_MN10_1 (VSS I0_cm96_0 XI0_I1547_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1547_MN6 (XI0_I1547_n3 I0_cm96_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1547_MN7 (VSS I0_cm97_0 XI0_I1547_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1547_MN8 (XI0_I1547_n3 I0_pp15_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1547_MN9 (XI0_I1547_sn XI0_I1547_con XI0_I1547_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1547_MN12_1 (XI0_I1547_n5 I0_pp15_9 XI0_I1547_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1421_MN12 (XI0_I1421_sn I0_pp14_1 XI0_I1421_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1421_MN25 (I0_fa60_0 XI0_I1421_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1421_MN5 (XI0_I1421_con I0_pp14_1 XI0_I1421_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1421_MN2 (XI0_I1421_n1 I0_pp13_3 XI0_I1421_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1421_MN1 (VSS I0_pp12_5 XI0_I1421_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1421_MN3 (XI0_I1421_n2 I0_pp12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1421_MN4 (VSS I0_pp13_3 XI0_I1421_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1421_MN27 (I0_fa60_1 XI0_I1421_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1421_MN10 (XI0_I1421_n4 I0_pp12_5 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1421_MN11 (XI0_I1421_n5 I0_pp13_3 XI0_I1421_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1421_MN11_1 (XI0_I1421_n4 I0_pp13_3 XI0_I1421_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1421_MN10_1 (VSS I0_pp12_5 XI0_I1421_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1421_MN6 (XI0_I1421_n3 I0_pp12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1421_MN7 (VSS I0_pp13_3 XI0_I1421_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1421_MN8 (XI0_I1421_n3 I0_pp14_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1421_MN9 (XI0_I1421_sn XI0_I1421_con XI0_I1421_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1421_MN12_1 (XI0_I1421_n5 I0_pp14_1 XI0_I1421_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1549_MN12 (XI0_I1549_sn I0_pp15_10 XI0_I1549_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1549_MN25 (I0_fa188_0 XI0_I1549_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1549_MN5 (XI0_I1549_con I0_pp15_10 XI0_I1549_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1549_MN2 (XI0_I1549_n1 I0_cm100_0 XI0_I1549_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1549_MN1 (VSS I0_cm99_0 XI0_I1549_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1549_MN3 (XI0_I1549_n2 I0_cm99_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1549_MN4 (VSS I0_cm100_0 XI0_I1549_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1549_MN27 (I0_fa188_1 XI0_I1549_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1549_MN10 (XI0_I1549_n4 I0_cm99_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1549_MN11 (XI0_I1549_n5 I0_cm100_0 XI0_I1549_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1549_MN11_1 (XI0_I1549_n4 I0_cm100_0 XI0_I1549_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1549_MN10_1 (VSS I0_cm99_0 XI0_I1549_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1549_MN6 (XI0_I1549_n3 I0_cm99_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1549_MN7 (VSS I0_cm100_0 XI0_I1549_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1549_MN8 (XI0_I1549_n3 I0_pp15_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1549_MN9 (XI0_I1549_sn XI0_I1549_con XI0_I1549_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1549_MN12_1 (XI0_I1549_n5 I0_pp15_10 XI0_I1549_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1642_MN12 (XI0_I1642_sn I0_pp15_7 XI0_I1642_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1642_MN25 (I0_fa281_0 XI0_I1642_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1642_MN5 (XI0_I1642_con I0_pp15_7 XI0_I1642_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1642_MN2 (XI0_I1642_n1 I0_cm231_0 XI0_I1642_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1642_MN1 (VSS I0_cm230_1 XI0_I1642_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1642_MN3 (XI0_I1642_n2 I0_cm230_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1642_MN4 (VSS I0_cm231_0 XI0_I1642_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1642_MN27 (I0_fa281_1 XI0_I1642_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1642_MN10 (XI0_I1642_n4 I0_cm230_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1642_MN11 (XI0_I1642_n5 I0_cm231_0 XI0_I1642_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1642_MN11_1 (XI0_I1642_n4 I0_cm231_0 XI0_I1642_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1642_MN10_1 (VSS I0_cm230_1 XI0_I1642_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1642_MN6 (XI0_I1642_n3 I0_cm230_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1642_MN7 (VSS I0_cm231_0 XI0_I1642_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1642_MN8 (XI0_I1642_n3 I0_pp15_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1642_MN9 (XI0_I1642_sn XI0_I1642_con XI0_I1642_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1642_MN12_1 (XI0_I1642_n5 I0_pp15_7 XI0_I1642_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1646_MN12 (XI0_I1646_sn I0_cm103_0 XI0_I1646_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1646_MN25 (I0_fa285_0 XI0_I1646_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1646_MN5 (XI0_I1646_con I0_cm103_0 XI0_I1646_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1646_MN2 (XI0_I1646_n1 I0_cm235_0 XI0_I1646_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1646_MN1 (VSS I0_cm234_1 XI0_I1646_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1646_MN3 (XI0_I1646_n2 I0_cm234_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1646_MN4 (VSS I0_cm235_0 XI0_I1646_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1646_MN27 (I0_fa285_1 XI0_I1646_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1646_MN10 (XI0_I1646_n4 I0_cm234_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1646_MN11 (XI0_I1646_n5 I0_cm235_0 XI0_I1646_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1646_MN11_1 (XI0_I1646_n4 I0_cm235_0 XI0_I1646_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1646_MN10_1 (VSS I0_cm234_1 XI0_I1646_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1646_MN6 (XI0_I1646_n3 I0_cm234_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1646_MN7 (VSS I0_cm235_0 XI0_I1646_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1646_MN8 (XI0_I1646_n3 I0_cm103_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1646_MN9 (XI0_I1646_sn XI0_I1646_con XI0_I1646_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1646_MN12_1 (XI0_I1646_n5 I0_cm103_0 XI0_I1646_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1410_MN12 (XI0_I1410_sn I0_B_27_b3_5 XI0_I1410_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1410_MN25 (I0_fa49_0 XI0_I1410_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1410_MN5 (XI0_I1410_con I0_B_27_b3_5 XI0_I1410_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1410_MN2 (XI0_I1410_n1 I0_pp13_0 XI0_I1410_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1410_MN1 (VSS I0_pp12_2 XI0_I1410_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1410_MN3 (XI0_I1410_n2 I0_pp12_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1410_MN4 (VSS I0_pp13_0 XI0_I1410_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1410_MN27 (I0_fa49_1 XI0_I1410_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1410_MN10 (XI0_I1410_n4 I0_pp12_2 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1410_MN11 (XI0_I1410_n5 I0_pp13_0 XI0_I1410_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1410_MN11_1 (XI0_I1410_n4 I0_pp13_0 XI0_I1410_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1410_MN10_1 (VSS I0_pp12_2 XI0_I1410_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1410_MN6 (XI0_I1410_n3 I0_pp12_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1410_MN7 (VSS I0_pp13_0 XI0_I1410_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1410_MN8 (XI0_I1410_n3 I0_B_27_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1410_MN9 (XI0_I1410_sn XI0_I1410_con XI0_I1410_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1410_MN12_1 (XI0_I1410_n5 I0_B_27_b3_5 XI0_I1410_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1417_MN12 (XI0_I1417_sn I0_pp14_0 XI0_I1417_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1417_MN25 (I0_fa56_0 XI0_I1417_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1417_MN5 (XI0_I1417_con I0_pp14_0 XI0_I1417_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1417_MN2 (XI0_I1417_n1 I0_pp13_2 XI0_I1417_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1417_MN1 (VSS I0_pp12_4 XI0_I1417_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1417_MN3 (XI0_I1417_n2 I0_pp12_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1417_MN4 (VSS I0_pp13_2 XI0_I1417_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1417_MN27 (I0_fa56_1 XI0_I1417_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1417_MN10 (XI0_I1417_n4 I0_pp12_4 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1417_MN11 (XI0_I1417_n5 I0_pp13_2 XI0_I1417_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1417_MN11_1 (XI0_I1417_n4 I0_pp13_2 XI0_I1417_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1417_MN10_1 (VSS I0_pp12_4 XI0_I1417_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1417_MN6 (XI0_I1417_n3 I0_pp12_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1417_MN7 (VSS I0_pp13_2 XI0_I1417_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1417_MN8 (XI0_I1417_n3 I0_pp14_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1417_MN9 (XI0_I1417_sn XI0_I1417_con XI0_I1417_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1417_MN12_1 (XI0_I1417_n5 I0_pp14_0 XI0_I1417_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1598_MN12 (XI0_I1598_sn I0_fa192_0 XI0_I1598_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1598_MN25 (I0_fa237_0 XI0_I1598_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1598_MN5 (XI0_I1598_con I0_fa192_0 XI0_I1598_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1598_MN2 (XI0_I1598_n1 I0_cm191_0 XI0_I1598_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1598_MN1 (VSS I0_cm190_1 XI0_I1598_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1598_MN3 (XI0_I1598_n2 I0_cm190_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1598_MN4 (VSS I0_cm191_0 XI0_I1598_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1598_MN27 (I0_fa237_1 XI0_I1598_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1598_MN10 (XI0_I1598_n4 I0_cm190_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1598_MN11 (XI0_I1598_n5 I0_cm191_0 XI0_I1598_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1598_MN11_1 (XI0_I1598_n4 I0_cm191_0 XI0_I1598_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1598_MN10_1 (VSS I0_cm190_1 XI0_I1598_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1598_MN6 (XI0_I1598_n3 I0_cm190_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1598_MN7 (VSS I0_cm191_0 XI0_I1598_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1598_MN8 (XI0_I1598_n3 I0_fa192_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1598_MN9 (XI0_I1598_sn XI0_I1598_con XI0_I1598_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1598_MN12_1 (XI0_I1598_n5 I0_fa192_0 XI0_I1598_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1470_MN12 (XI0_I1470_sn I0_pp15_13 XI0_I1470_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1470_MN25 (I0_fa109_0 XI0_I1470_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1470_MN5 (XI0_I1470_con I0_pp15_13 XI0_I1470_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1470_MN2 (XI0_I1470_n1 I0_pp14_15 XI0_I1470_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1470_MN1 (VSS I0_pp13_17 XI0_I1470_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1470_MN3 (XI0_I1470_n2 I0_pp13_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1470_MN4 (VSS I0_pp14_15 XI0_I1470_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1470_MN27 (I0_fa109_1 XI0_I1470_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1470_MN10 (XI0_I1470_n4 I0_pp13_17 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1470_MN11 (XI0_I1470_n5 I0_pp14_15 XI0_I1470_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1470_MN11_1 (XI0_I1470_n4 I0_pp14_15 XI0_I1470_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1470_MN10_1 (VSS I0_pp13_17 XI0_I1470_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1470_MN6 (XI0_I1470_n3 I0_pp13_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1470_MN7 (VSS I0_pp14_15 XI0_I1470_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1470_MN8 (XI0_I1470_n3 I0_pp15_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1470_MN9 (XI0_I1470_sn XI0_I1470_con XI0_I1470_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1470_MN12_1 (XI0_I1470_n5 I0_pp15_13 XI0_I1470_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1553_MN12 (XI0_I1553_sn I0_cm106_2 XI0_I1553_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1553_MN25 (I0_fa192_0 XI0_I1553_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1553_MN5 (XI0_I1553_con I0_cm106_2 XI0_I1553_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1553_MN2 (XI0_I1553_n1 I0_fa109_0 XI0_I1553_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1553_MN1 (VSS I0_cm108_0 XI0_I1553_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1553_MN3 (XI0_I1553_n2 I0_cm108_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1553_MN4 (VSS I0_fa109_0 XI0_I1553_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1553_MN27 (I0_fa192_1 XI0_I1553_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1553_MN10 (XI0_I1553_n4 I0_cm108_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1553_MN11 (XI0_I1553_n5 I0_fa109_0 XI0_I1553_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1553_MN11_1 (XI0_I1553_n4 I0_fa109_0 XI0_I1553_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1553_MN10_1 (VSS I0_cm108_0 XI0_I1553_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1553_MN6 (XI0_I1553_n3 I0_cm108_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1553_MN7 (VSS I0_fa109_0 XI0_I1553_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1553_MN8 (XI0_I1553_n3 I0_cm106_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1553_MN9 (XI0_I1553_sn XI0_I1553_con XI0_I1553_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1553_MN12_1 (XI0_I1553_n5 I0_cm106_2 XI0_I1553_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1648_MN12 (XI0_I1648_sn I0_cm236_2 XI0_I1648_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1648_MN25 (I0_fa287_0 XI0_I1648_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1648_MN5 (XI0_I1648_con I0_cm236_2 XI0_I1648_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1648_MN2 (XI0_I1648_n1 I0_fa237_0 XI0_I1648_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1648_MN1 (VSS I0_cm236_1 XI0_I1648_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1648_MN3 (XI0_I1648_n2 I0_cm236_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1648_MN4 (VSS I0_fa237_0 XI0_I1648_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1648_MN27 (I0_fa287_1 XI0_I1648_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1648_MN10 (XI0_I1648_n4 I0_cm236_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1648_MN11 (XI0_I1648_n5 I0_fa237_0 XI0_I1648_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1648_MN11_1 (XI0_I1648_n4 I0_fa237_0 XI0_I1648_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1648_MN10_1 (VSS I0_cm236_1 XI0_I1648_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1648_MN6 (XI0_I1648_n3 I0_cm236_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1648_MN7 (VSS I0_fa237_0 XI0_I1648_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1648_MN8 (XI0_I1648_n3 I0_cm236_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1648_MN9 (XI0_I1648_sn XI0_I1648_con XI0_I1648_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1648_MN12_1 (XI0_I1648_n5 I0_cm236_2 XI0_I1648_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1473_MN12 (XI0_I1473_sn I0_pp15_14 XI0_I1473_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1473_MN25 (I0_fa112_0 XI0_I1473_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1473_MN5 (XI0_I1473_con I0_pp15_14 XI0_I1473_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1473_MN2 (XI0_I1473_n1 I0_pp14_16 XI0_I1473_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1473_MN1 (VSS I0_pp13_18 XI0_I1473_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1473_MN3 (XI0_I1473_n2 I0_pp13_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1473_MN4 (VSS I0_pp14_16 XI0_I1473_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1473_MN27 (I0_fa112_1 XI0_I1473_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1473_MN10 (XI0_I1473_n4 I0_pp13_18 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1473_MN11 (XI0_I1473_n5 I0_pp14_16 XI0_I1473_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1473_MN11_1 (XI0_I1473_n4 I0_pp14_16 XI0_I1473_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1473_MN10_1 (VSS I0_pp13_18 XI0_I1473_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1473_MN6 (XI0_I1473_n3 I0_pp13_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1473_MN7 (VSS I0_pp14_16 XI0_I1473_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1473_MN8 (XI0_I1473_n3 I0_pp15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1473_MN9 (XI0_I1473_sn XI0_I1473_con XI0_I1473_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1473_MN12_1 (XI0_I1473_n5 I0_pp15_14 XI0_I1473_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1650_MN12 (XI0_I1650_sn I0_cm238_2 XI0_I1650_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1650_MN25 (I0_fa289_0 XI0_I1650_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1650_MN5 (XI0_I1650_con I0_cm238_2 XI0_I1650_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1650_MN2 (XI0_I1650_n1 I0_fa239_0 XI0_I1650_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1650_MN1 (VSS I0_cm238_1 XI0_I1650_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1650_MN3 (XI0_I1650_n2 I0_cm238_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1650_MN4 (VSS I0_fa239_0 XI0_I1650_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1650_MN27 (I0_fa289_1 XI0_I1650_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1650_MN10 (XI0_I1650_n4 I0_cm238_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1650_MN11 (XI0_I1650_n5 I0_fa239_0 XI0_I1650_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1650_MN11_1 (XI0_I1650_n4 I0_fa239_0 XI0_I1650_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1650_MN10_1 (VSS I0_cm238_1 XI0_I1650_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1650_MN6 (XI0_I1650_n3 I0_cm238_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1650_MN7 (VSS I0_fa239_0 XI0_I1650_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1650_MN8 (XI0_I1650_n3 I0_cm238_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1650_MN9 (XI0_I1650_sn XI0_I1650_con XI0_I1650_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1650_MN12_1 (XI0_I1650_n5 I0_cm238_2 XI0_I1650_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1600_MN12 (XI0_I1600_sn I0_fa195_0 XI0_I1600_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1600_MN25 (I0_fa239_0 XI0_I1600_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1600_MN5 (XI0_I1600_con I0_fa195_0 XI0_I1600_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1600_MN2 (XI0_I1600_n1 I0_cm194_0 XI0_I1600_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1600_MN1 (VSS I0_cm193_1 XI0_I1600_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1600_MN3 (XI0_I1600_n2 I0_cm193_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1600_MN4 (VSS I0_cm194_0 XI0_I1600_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1600_MN27 (I0_fa239_1 XI0_I1600_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1600_MN10 (XI0_I1600_n4 I0_cm193_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1600_MN11 (XI0_I1600_n5 I0_cm194_0 XI0_I1600_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1600_MN11_1 (XI0_I1600_n4 I0_cm194_0 XI0_I1600_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1600_MN10_1 (VSS I0_cm193_1 XI0_I1600_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1600_MN6 (XI0_I1600_n3 I0_cm193_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1600_MN7 (VSS I0_cm194_0 XI0_I1600_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1600_MN8 (XI0_I1600_n3 I0_fa195_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1600_MN9 (XI0_I1600_sn XI0_I1600_con XI0_I1600_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1600_MN12_1 (XI0_I1600_n5 I0_fa195_0 XI0_I1600_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1556_MN12 (XI0_I1556_sn I0_pp15_15 XI0_I1556_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1556_MN25 (I0_fa195_0 XI0_I1556_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1556_MN5 (XI0_I1556_con I0_pp15_15 XI0_I1556_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1556_MN2 (XI0_I1556_n1 I0_pp14_17 XI0_I1556_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1556_MN1 (VSS I0_cm114_0 XI0_I1556_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1556_MN3 (XI0_I1556_n2 I0_cm114_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1556_MN4 (VSS I0_pp14_17 XI0_I1556_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1556_MN27 (I0_fa195_1 XI0_I1556_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1556_MN10 (XI0_I1556_n4 I0_cm114_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1556_MN11 (XI0_I1556_n5 I0_pp14_17 XI0_I1556_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1556_MN11_1 (XI0_I1556_n4 I0_pp14_17 XI0_I1556_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1556_MN10_1 (VSS I0_cm114_0 XI0_I1556_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1556_MN6 (XI0_I1556_n3 I0_cm114_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1556_MN7 (VSS I0_pp14_17 XI0_I1556_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1556_MN8 (XI0_I1556_n3 I0_pp15_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1556_MN9 (XI0_I1556_sn XI0_I1556_con XI0_I1556_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1556_MN12_1 (XI0_I1556_n5 I0_pp15_15 XI0_I1556_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1652_MN12 (XI0_I1652_sn I0_cm240_2 XI0_I1652_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1652_MN25 (I0_fa291_0 XI0_I1652_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.16u ps=1.16u
    I_MXI0_I1652_MN5 (XI0_I1652_con I0_cm240_2 XI0_I1652_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.68u ps=1.16u
    I_MXI0_I1652_MN2 (XI0_I1652_n1 I0_fa241_0 XI0_I1652_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1652_MN1 (VSS I0_cm240_1 XI0_I1652_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1652_MN3 (XI0_I1652_n2 I0_cm240_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1652_MN4 (VSS I0_fa241_0 XI0_I1652_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1652_MN27 (I0_fa291_1 XI0_I1652_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.16u ps=0.68u
    I_MXI0_I1652_MN10 (XI0_I1652_n4 I0_cm240_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.68u ps=1.16u
    I_MXI0_I1652_MN11 (XI0_I1652_n5 I0_fa241_0 XI0_I1652_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1652_MN11_1 (XI0_I1652_n4 I0_fa241_0 XI0_I1652_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1652_MN10_1 (VSS I0_cm240_1 XI0_I1652_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.68u ps=0.68u
    I_MXI0_I1652_MN6 (XI0_I1652_n3 I0_cm240_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1652_MN7 (VSS I0_fa241_0 XI0_I1652_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.22u ps=0.68u
    I_MXI0_I1652_MN8 (XI0_I1652_n3 I0_cm240_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.68u ps=1.22u
    I_MXI0_I1652_MN9 (XI0_I1652_sn XI0_I1652_con XI0_I1652_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.68u ps=0.68u
    I_MXI0_I1652_MN12_1 (XI0_I1652_n5 I0_cm240_2 XI0_I1652_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.68u ps=0.68u
    I_MXI0_I1567_MN12 (XI0_I1567_sn I0_pp15_26 XI0_I1567_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1567_MN25 (I0_fa206_0 XI0_I1567_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1567_MN5 (XI0_I1567_con I0_pp15_26 XI0_I1567_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1567_MN2 (XI0_I1567_n1 I0_cm132_0 XI0_I1567_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1567_MN1 (VSS I0_cm131_1 XI0_I1567_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1567_MN3 (XI0_I1567_n2 I0_cm131_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1567_MN4 (VSS I0_cm132_0 XI0_I1567_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1567_MN27 (I0_fa206_1 XI0_I1567_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1567_MN10 (XI0_I1567_n4 I0_cm131_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.67999u ps=1.15999u
    I_MXI0_I1567_MN11 (XI0_I1567_n5 I0_cm132_0 XI0_I1567_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1567_MN11_1 (XI0_I1567_n4 I0_cm132_0 XI0_I1567_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1567_MN10_1 (VSS I0_cm131_1 XI0_I1567_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1567_MN6 (XI0_I1567_n3 I0_cm131_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1567_MN7 (VSS I0_cm132_0 XI0_I1567_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.21999u ps=0.67999u
    I_MXI0_I1567_MN8 (XI0_I1567_n3 I0_pp15_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.67999u ps=1.21999u
    I_MXI0_I1567_MN9 (XI0_I1567_sn XI0_I1567_con XI0_I1567_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1567_MN12_1 (XI0_I1567_n5 I0_pp15_26 XI0_I1567_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1607_MN12 (XI0_I1607_sn I0_cm133_0 XI0_I1607_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1607_MN25 (I0_fa246_0 XI0_I1607_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1607_MN5 (XI0_I1607_con I0_cm133_0 XI0_I1607_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1607_MN2 (XI0_I1607_n1 I0_cm132_1 XI0_I1607_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1607_MN1 (VSS I0_fa206_1 XI0_I1607_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1607_MN3 (XI0_I1607_n2 I0_fa206_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1607_MN4 (VSS I0_cm132_1 XI0_I1607_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1607_MN27 (I0_fa246_1 XI0_I1607_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1607_MN10 (XI0_I1607_n4 I0_fa206_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.67999u ps=1.15999u
    I_MXI0_I1607_MN11 (XI0_I1607_n5 I0_cm132_1 XI0_I1607_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1607_MN11_1 (XI0_I1607_n4 I0_cm132_1 XI0_I1607_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1607_MN10_1 (VSS I0_fa206_1 XI0_I1607_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1607_MN6 (XI0_I1607_n3 I0_fa206_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1607_MN7 (VSS I0_cm132_1 XI0_I1607_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.21999u ps=0.67999u
    I_MXI0_I1607_MN8 (XI0_I1607_n3 I0_cm133_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.67999u ps=1.21999u
    I_MXI0_I1607_MN9 (XI0_I1607_sn XI0_I1607_con XI0_I1607_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1607_MN12_1 (XI0_I1607_n5 I0_cm133_0 XI0_I1607_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1602_MN12 (XI0_I1602_sn I0_pp15_17 XI0_I1602_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1602_MN25 (I0_fa241_0 XI0_I1602_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1602_MN5 (XI0_I1602_con I0_pp15_17 XI0_I1602_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1602_MN2 (XI0_I1602_n1 I0_cm197_0 XI0_I1602_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1602_MN1 (VSS I0_cm196_1 XI0_I1602_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1602_MN3 (XI0_I1602_n2 I0_cm196_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1602_MN4 (VSS I0_cm197_0 XI0_I1602_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1602_MN27 (I0_fa241_1 XI0_I1602_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1602_MN10 (XI0_I1602_n4 I0_cm196_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.67999u ps=1.15999u
    I_MXI0_I1602_MN11 (XI0_I1602_n5 I0_cm197_0 XI0_I1602_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1602_MN11_1 (XI0_I1602_n4 I0_cm197_0 XI0_I1602_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1602_MN10_1 (VSS I0_cm196_1 XI0_I1602_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1602_MN6 (XI0_I1602_n3 I0_cm196_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1602_MN7 (VSS I0_cm197_0 XI0_I1602_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.21999u ps=0.67999u
    I_MXI0_I1602_MN8 (XI0_I1602_n3 I0_pp15_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.67999u ps=1.21999u
    I_MXI0_I1602_MN9 (XI0_I1602_sn XI0_I1602_con XI0_I1602_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1602_MN12_1 (XI0_I1602_n5 I0_pp15_17 XI0_I1602_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1659_MN12 (XI0_I1659_sn I0_cm134_0 XI0_I1659_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1659_MN25 (I0_fa298_0 XI0_I1659_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1659_MN5 (XI0_I1659_con I0_cm134_0 XI0_I1659_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1659_MN2 (XI0_I1659_n1 I0_cm133_1 XI0_I1659_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1659_MN1 (VSS I0_fa246_1 XI0_I1659_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1659_MN3 (XI0_I1659_n2 I0_fa246_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1659_MN4 (VSS I0_cm133_1 XI0_I1659_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1659_MN27 (I0_fa298_1 XI0_I1659_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1659_MN10 (XI0_I1659_n4 I0_fa246_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.67999u ps=1.15999u
    I_MXI0_I1659_MN11 (XI0_I1659_n5 I0_cm133_1 XI0_I1659_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1659_MN11_1 (XI0_I1659_n4 I0_cm133_1 XI0_I1659_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1659_MN10_1 (VSS I0_fa246_1 XI0_I1659_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1659_MN6 (XI0_I1659_n3 I0_fa246_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1659_MN7 (VSS I0_cm133_1 XI0_I1659_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.21999u ps=0.67999u
    I_MXI0_I1659_MN8 (XI0_I1659_n3 I0_cm134_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.67999u ps=1.21999u
    I_MXI0_I1659_MN9 (XI0_I1659_sn XI0_I1659_con XI0_I1659_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1659_MN12_1 (XI0_I1659_n5 I0_cm134_0 XI0_I1659_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1603_MN12 (XI0_I1603_sn I0_pp15_18 XI0_I1603_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1603_MN25 (I0_fa242_0 XI0_I1603_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1603_MN5 (XI0_I1603_con I0_pp15_18 XI0_I1603_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1603_MN2 (XI0_I1603_n1 I0_cm198_0 XI0_I1603_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1603_MN1 (VSS I0_cm197_1 XI0_I1603_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1603_MN3 (XI0_I1603_n2 I0_cm197_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1603_MN4 (VSS I0_cm198_0 XI0_I1603_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1603_MN27 (I0_fa242_1 XI0_I1603_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1603_MN10 (XI0_I1603_n4 I0_cm197_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.67999u ps=1.15999u
    I_MXI0_I1603_MN11 (XI0_I1603_n5 I0_cm198_0 XI0_I1603_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1603_MN11_1 (XI0_I1603_n4 I0_cm198_0 XI0_I1603_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1603_MN10_1 (VSS I0_cm197_1 XI0_I1603_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1603_MN6 (XI0_I1603_n3 I0_cm197_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1603_MN7 (VSS I0_cm198_0 XI0_I1603_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.21999u ps=0.67999u
    I_MXI0_I1603_MN8 (XI0_I1603_n3 I0_pp15_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.67999u ps=1.21999u
    I_MXI0_I1603_MN9 (XI0_I1603_sn XI0_I1603_con XI0_I1603_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1603_MN12_1 (XI0_I1603_n5 I0_pp15_18 XI0_I1603_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1496_MN12 (XI0_I1496_sn I0_pp15_29 XI0_I1496_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1496_MN25 (I0_fa135_0 XI0_I1496_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1496_MN5 (XI0_I1496_con I0_pp15_29 XI0_I1496_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1496_MN2 (XI0_I1496_n1 I0_pp14_31 XI0_I1496_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1496_MN1 (VSS I0_sn13 XI0_I1496_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1496_MN3 (XI0_I1496_n2 I0_sn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1496_MN4 (VSS I0_pp14_31 XI0_I1496_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1496_MN27 (I0_fa135_1 XI0_I1496_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1496_MN10 (XI0_I1496_n4 I0_sn13 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.67999u ps=1.15999u
    I_MXI0_I1496_MN11 (XI0_I1496_n5 I0_pp14_31 XI0_I1496_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1496_MN11_1 (XI0_I1496_n4 I0_pp14_31 XI0_I1496_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1496_MN10_1 (VSS I0_sn13 XI0_I1496_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1496_MN6 (XI0_I1496_n3 I0_sn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1496_MN7 (VSS I0_pp14_31 XI0_I1496_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.21999u ps=0.67999u
    I_MXI0_I1496_MN8 (XI0_I1496_n3 I0_pp15_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.67999u ps=1.21999u
    I_MXI0_I1496_MN9 (XI0_I1496_sn XI0_I1496_con XI0_I1496_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1496_MN12_1 (XI0_I1496_n5 I0_pp15_29 XI0_I1496_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1654_MN12 (XI0_I1654_sn I0_cm199_0 XI0_I1654_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1654_MN25 (I0_fa293_0 XI0_I1654_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1654_MN5 (XI0_I1654_con I0_cm199_0 XI0_I1654_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1654_MN2 (XI0_I1654_n1 I0_cm198_1 XI0_I1654_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1654_MN1 (VSS I0_fa242_1 XI0_I1654_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1654_MN3 (XI0_I1654_n2 I0_fa242_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1654_MN4 (VSS I0_cm198_1 XI0_I1654_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1654_MN27 (I0_fa293_1 XI0_I1654_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1654_MN10 (XI0_I1654_n4 I0_fa242_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.67999u ps=1.15999u
    I_MXI0_I1654_MN11 (XI0_I1654_n5 I0_cm198_1 XI0_I1654_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1654_MN11_1 (XI0_I1654_n4 I0_cm198_1 XI0_I1654_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1654_MN10_1 (VSS I0_fa242_1 XI0_I1654_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1654_MN6 (XI0_I1654_n3 I0_fa242_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1654_MN7 (VSS I0_cm198_1 XI0_I1654_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.21999u ps=0.67999u
    I_MXI0_I1654_MN8 (XI0_I1654_n3 I0_cm199_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.67999u ps=1.21999u
    I_MXI0_I1654_MN9 (XI0_I1654_sn XI0_I1654_con XI0_I1654_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1654_MN12_1 (XI0_I1654_n5 I0_cm199_0 XI0_I1654_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1568_MN12 (XI0_I1568_sn I0_cm134_2 XI0_I1568_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1568_MN25 (I0_fa207_0 XI0_I1568_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1568_MN5 (XI0_I1568_con I0_cm134_2 XI0_I1568_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1568_MN2 (XI0_I1568_n1 I0_fa135_0 XI0_I1568_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1568_MN1 (VSS I0_cm134_1 XI0_I1568_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1568_MN3 (XI0_I1568_n2 I0_cm134_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1568_MN4 (VSS I0_fa135_0 XI0_I1568_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1568_MN27 (I0_fa207_1 XI0_I1568_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1568_MN10 (XI0_I1568_n4 I0_cm134_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.67999u ps=1.15999u
    I_MXI0_I1568_MN11 (XI0_I1568_n5 I0_fa135_0 XI0_I1568_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1568_MN11_1 (XI0_I1568_n4 I0_fa135_0 XI0_I1568_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1568_MN10_1 (VSS I0_cm134_1 XI0_I1568_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1568_MN6 (XI0_I1568_n3 I0_cm134_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1568_MN7 (VSS I0_fa135_0 XI0_I1568_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.21999u ps=0.67999u
    I_MXI0_I1568_MN8 (XI0_I1568_n3 I0_cm134_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.67999u ps=1.21999u
    I_MXI0_I1568_MN9 (XI0_I1568_sn XI0_I1568_con XI0_I1568_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1568_MN12_1 (XI0_I1568_n5 I0_cm134_2 XI0_I1568_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1658_MN12 (XI0_I1658_sn I0_fa206_0 XI0_I1658_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1658_MN25 (I0_fa297_0 XI0_I1658_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1658_MN5 (XI0_I1658_con I0_fa206_0 XI0_I1658_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1658_MN2 (XI0_I1658_n1 I0_fa205_1 XI0_I1658_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1658_MN1 (VSS I0_fa245_1 XI0_I1658_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1658_MN3 (XI0_I1658_n2 I0_fa245_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1658_MN4 (VSS I0_fa205_1 XI0_I1658_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1658_MN27 (I0_fa297_1 XI0_I1658_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1658_MN10 (XI0_I1658_n4 I0_fa245_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.67999u ps=1.15999u
    I_MXI0_I1658_MN11 (XI0_I1658_n5 I0_fa205_1 XI0_I1658_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1658_MN11_1 (XI0_I1658_n4 I0_fa205_1 XI0_I1658_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1658_MN10_1 (VSS I0_fa245_1 XI0_I1658_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1658_MN6 (XI0_I1658_n3 I0_fa245_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1658_MN7 (VSS I0_fa205_1 XI0_I1658_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.21999u ps=0.67999u
    I_MXI0_I1658_MN8 (XI0_I1658_n3 I0_fa206_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.67999u ps=1.21999u
    I_MXI0_I1658_MN9 (XI0_I1658_sn XI0_I1658_con XI0_I1658_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1658_MN12_1 (XI0_I1658_n5 I0_fa206_0 XI0_I1658_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1566_MN12 (XI0_I1566_sn I0_pp15_25 XI0_I1566_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1566_MN25 (I0_fa205_0 XI0_I1566_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1566_MN5 (XI0_I1566_con I0_pp15_25 XI0_I1566_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1566_MN2 (XI0_I1566_n1 I0_cm131_0 XI0_I1566_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1566_MN1 (VSS I0_cm130_1 XI0_I1566_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1566_MN3 (XI0_I1566_n2 I0_cm130_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1566_MN4 (VSS I0_cm131_0 XI0_I1566_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1566_MN27 (I0_fa205_1 XI0_I1566_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1566_MN10 (XI0_I1566_n4 I0_cm130_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.67999u ps=1.15999u
    I_MXI0_I1566_MN11 (XI0_I1566_n5 I0_cm131_0 XI0_I1566_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1566_MN11_1 (XI0_I1566_n4 I0_cm131_0 XI0_I1566_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1566_MN10_1 (VSS I0_cm130_1 XI0_I1566_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1566_MN6 (XI0_I1566_n3 I0_cm130_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1566_MN7 (VSS I0_cm131_0 XI0_I1566_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.21999u ps=0.67999u
    I_MXI0_I1566_MN8 (XI0_I1566_n3 I0_pp15_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.67999u ps=1.21999u
    I_MXI0_I1566_MN9 (XI0_I1566_sn XI0_I1566_con XI0_I1566_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1566_MN12_1 (XI0_I1566_n5 I0_pp15_25 XI0_I1566_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1487_MN12 (XI0_I1487_sn I0_pp15_21 XI0_I1487_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1487_MN25 (I0_fa126_0 XI0_I1487_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1487_MN5 (XI0_I1487_con I0_pp15_21 XI0_I1487_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1487_MN2 (XI0_I1487_n1 I0_pp14_23 XI0_I1487_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1487_MN1 (VSS I0_pp13_25 XI0_I1487_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1487_MN3 (XI0_I1487_n2 I0_pp13_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1487_MN4 (VSS I0_pp14_23 XI0_I1487_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1487_MN27 (I0_fa126_1 XI0_I1487_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1487_MN10 (XI0_I1487_n4 I0_pp13_25 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.67999u ps=1.15999u
    I_MXI0_I1487_MN11 (XI0_I1487_n5 I0_pp14_23 XI0_I1487_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1487_MN11_1 (XI0_I1487_n4 I0_pp14_23 XI0_I1487_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1487_MN10_1 (VSS I0_pp13_25 XI0_I1487_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1487_MN6 (XI0_I1487_n3 I0_pp13_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1487_MN7 (VSS I0_pp14_23 XI0_I1487_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.21999u ps=0.67999u
    I_MXI0_I1487_MN8 (XI0_I1487_n3 I0_pp15_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.67999u ps=1.21999u
    I_MXI0_I1487_MN9 (XI0_I1487_sn XI0_I1487_con XI0_I1487_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1487_MN12_1 (XI0_I1487_n5 I0_pp15_21 XI0_I1487_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1489_MN12 (XI0_I1489_sn I0_pp15_22 XI0_I1489_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1489_MN25 (I0_fa128_0 XI0_I1489_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1489_MN5 (XI0_I1489_con I0_pp15_22 XI0_I1489_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1489_MN2 (XI0_I1489_n1 I0_pp14_24 XI0_I1489_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1489_MN1 (VSS I0_pp13_26 XI0_I1489_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1489_MN3 (XI0_I1489_n2 I0_pp13_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1489_MN4 (VSS I0_pp14_24 XI0_I1489_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1489_MN27 (I0_fa128_1 XI0_I1489_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1489_MN10 (XI0_I1489_n4 I0_pp13_26 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.67999u ps=1.15999u
    I_MXI0_I1489_MN11 (XI0_I1489_n5 I0_pp14_24 XI0_I1489_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1489_MN11_1 (XI0_I1489_n4 I0_pp14_24 XI0_I1489_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1489_MN10_1 (VSS I0_pp13_26 XI0_I1489_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1489_MN6 (XI0_I1489_n3 I0_pp13_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1489_MN7 (VSS I0_pp14_24 XI0_I1489_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.21999u ps=0.67999u
    I_MXI0_I1489_MN8 (XI0_I1489_n3 I0_pp15_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.67999u ps=1.21999u
    I_MXI0_I1489_MN9 (XI0_I1489_sn XI0_I1489_con XI0_I1489_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1489_MN12_1 (XI0_I1489_n5 I0_pp15_22 XI0_I1489_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1608_MN12 (XI0_I1608_sn I0_fa136_0 XI0_I1608_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1608_MN25 (I0_fa247_0 XI0_I1608_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1608_MN5 (XI0_I1608_con I0_fa136_0 XI0_I1608_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1608_MN2 (XI0_I1608_n1 I0_fa135_1 XI0_I1608_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1608_MN1 (VSS I0_fa207_1 XI0_I1608_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1608_MN3 (XI0_I1608_n2 I0_fa207_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1608_MN4 (VSS I0_fa135_1 XI0_I1608_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1608_MN27 (I0_fa247_1 XI0_I1608_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1608_MN10 (XI0_I1608_n4 I0_fa207_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.67999u ps=1.15999u
    I_MXI0_I1608_MN11 (XI0_I1608_n5 I0_fa135_1 XI0_I1608_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1608_MN11_1 (XI0_I1608_n4 I0_fa135_1 XI0_I1608_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1608_MN10_1 (VSS I0_fa207_1 XI0_I1608_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1608_MN6 (XI0_I1608_n3 I0_fa207_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1608_MN7 (VSS I0_fa135_1 XI0_I1608_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.21999u ps=0.67999u
    I_MXI0_I1608_MN8 (XI0_I1608_n3 I0_fa136_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.67999u ps=1.21999u
    I_MXI0_I1608_MN9 (XI0_I1608_sn XI0_I1608_con XI0_I1608_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1608_MN12_1 (XI0_I1608_n5 I0_fa136_0 XI0_I1608_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1606_MN12 (XI0_I1606_sn I0_cm204_2 XI0_I1606_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1606_MN25 (I0_fa245_0 XI0_I1606_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1606_MN5 (XI0_I1606_con I0_cm204_2 XI0_I1606_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1606_MN2 (XI0_I1606_n1 I0_fa205_0 XI0_I1606_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1606_MN1 (VSS I0_cm204_1 XI0_I1606_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1606_MN3 (XI0_I1606_n2 I0_cm204_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1606_MN4 (VSS I0_fa205_0 XI0_I1606_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1606_MN27 (I0_fa245_1 XI0_I1606_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1606_MN10 (XI0_I1606_n4 I0_cm204_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.67999u ps=1.15999u
    I_MXI0_I1606_MN11 (XI0_I1606_n5 I0_fa205_0 XI0_I1606_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1606_MN11_1 (XI0_I1606_n4 I0_fa205_0 XI0_I1606_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1606_MN10_1 (VSS I0_cm204_1 XI0_I1606_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1606_MN6 (XI0_I1606_n3 I0_cm204_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1606_MN7 (VSS I0_fa205_0 XI0_I1606_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.21999u ps=0.67999u
    I_MXI0_I1606_MN8 (XI0_I1606_n3 I0_cm204_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.67999u ps=1.21999u
    I_MXI0_I1606_MN9 (XI0_I1606_sn XI0_I1606_con XI0_I1606_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1606_MN12_1 (XI0_I1606_n5 I0_cm204_2 XI0_I1606_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1604_MN12 (XI0_I1604_sn I0_cm124_2 XI0_I1604_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1604_MN25 (I0_fa243_0 XI0_I1604_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1604_MN5 (XI0_I1604_con I0_cm124_2 XI0_I1604_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1604_MN2 (XI0_I1604_n1 I0_cm201_0 XI0_I1604_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1604_MN1 (VSS I0_cm200_1 XI0_I1604_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1604_MN3 (XI0_I1604_n2 I0_cm200_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1604_MN4 (VSS I0_cm201_0 XI0_I1604_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1604_MN27 (I0_fa243_1 XI0_I1604_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1604_MN10 (XI0_I1604_n4 I0_cm200_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.67999u ps=1.15999u
    I_MXI0_I1604_MN11 (XI0_I1604_n5 I0_cm201_0 XI0_I1604_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1604_MN11_1 (XI0_I1604_n4 I0_cm201_0 XI0_I1604_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1604_MN10_1 (VSS I0_cm200_1 XI0_I1604_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1604_MN6 (XI0_I1604_n3 I0_cm200_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1604_MN7 (VSS I0_cm201_0 XI0_I1604_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.21999u ps=0.67999u
    I_MXI0_I1604_MN8 (XI0_I1604_n3 I0_cm124_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.67999u ps=1.21999u
    I_MXI0_I1604_MN9 (XI0_I1604_sn XI0_I1604_con XI0_I1604_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1604_MN12_1 (XI0_I1604_n5 I0_cm124_2 XI0_I1604_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1609_MN12 (XI0_I1609_sn I0_pp15_32 XI0_I1609_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1609_MN25 (I0_fa248_0 XI0_I1609_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1609_MN5 (XI0_I1609_con I0_pp15_32 XI0_I1609_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1609_MN2 (XI0_I1609_n1 VDD XI0_I1609_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1609_MN1 (VSS I0_fa208_1 XI0_I1609_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1609_MN3 (XI0_I1609_n2 I0_fa208_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1609_MN4 (VSS VDD XI0_I1609_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1609_MN27 (I0_fa248_1 XI0_I1609_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1609_MN10 (XI0_I1609_n4 I0_fa208_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.67999u ps=1.15999u
    I_MXI0_I1609_MN11 (XI0_I1609_n5 VDD XI0_I1609_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1609_MN11_1 (XI0_I1609_n4 VDD XI0_I1609_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1609_MN10_1 (VSS I0_fa208_1 XI0_I1609_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1609_MN6 (XI0_I1609_n3 I0_fa208_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1609_MN7 (VSS VDD XI0_I1609_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.21999u ps=0.67999u
    I_MXI0_I1609_MN8 (XI0_I1609_n3 I0_pp15_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.67999u ps=1.21999u
    I_MXI0_I1609_MN9 (XI0_I1609_sn XI0_I1609_con XI0_I1609_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1609_MN12_1 (XI0_I1609_n5 I0_pp15_32 XI0_I1609_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1569_MN12 (XI0_I1569_sn I0_pp15_31 XI0_I1569_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1569_MN25 (I0_fa208_0 XI0_I1569_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1569_MN5 (XI0_I1569_con I0_pp15_31 XI0_I1569_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1569_MN2 (XI0_I1569_n1 I0_sn14 XI0_I1569_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1569_MN1 (VSS I0_fa136_1 XI0_I1569_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1569_MN3 (XI0_I1569_n2 I0_fa136_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1569_MN4 (VSS I0_sn14 XI0_I1569_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1569_MN27 (I0_fa208_1 XI0_I1569_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1569_MN10 (XI0_I1569_n4 I0_fa136_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.67999u ps=1.15999u
    I_MXI0_I1569_MN11 (XI0_I1569_n5 I0_sn14 XI0_I1569_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1569_MN11_1 (XI0_I1569_n4 I0_sn14 XI0_I1569_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1569_MN10_1 (VSS I0_fa136_1 XI0_I1569_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1569_MN6 (XI0_I1569_n3 I0_fa136_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1569_MN7 (VSS I0_sn14 XI0_I1569_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.21999u ps=0.67999u
    I_MXI0_I1569_MN8 (XI0_I1569_n3 I0_pp15_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.67999u ps=1.21999u
    I_MXI0_I1569_MN9 (XI0_I1569_sn XI0_I1569_con XI0_I1569_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1569_MN12_1 (XI0_I1569_n5 I0_pp15_31 XI0_I1569_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1497_MN12 (XI0_I1497_sn I0_pp15_30 XI0_I1497_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1497_MN25 (I0_fa136_0 XI0_I1497_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1497_MN5 (XI0_I1497_con I0_pp15_30 XI0_I1497_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1497_MN2 (XI0_I1497_n1 I0_pp14_32 XI0_I1497_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1497_MN1 (VSS VDD XI0_I1497_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1497_MN3 (XI0_I1497_n2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1497_MN4 (VSS I0_pp14_32 XI0_I1497_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1497_MN27 (I0_fa136_1 XI0_I1497_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1497_MN10 (XI0_I1497_n4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.67999u ps=1.15999u
    I_MXI0_I1497_MN11 (XI0_I1497_n5 I0_pp14_32 XI0_I1497_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1497_MN11_1 (XI0_I1497_n4 I0_pp14_32 XI0_I1497_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1497_MN10_1 (VSS VDD XI0_I1497_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1497_MN6 (XI0_I1497_n3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1497_MN7 (VSS I0_pp14_32 XI0_I1497_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.21999u ps=0.67999u
    I_MXI0_I1497_MN8 (XI0_I1497_n3 I0_pp15_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.67999u ps=1.21999u
    I_MXI0_I1497_MN9 (XI0_I1497_sn XI0_I1497_con XI0_I1497_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1497_MN12_1 (XI0_I1497_n5 I0_pp15_30 XI0_I1497_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1605_MN12 (XI0_I1605_sn I0_pp15_23 XI0_I1605_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1605_MN25 (I0_fa244_0 XI0_I1605_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1605_MN5 (XI0_I1605_con I0_pp15_23 XI0_I1605_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1605_MN2 (XI0_I1605_n1 I0_cm203_0 XI0_I1605_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1605_MN1 (VSS I0_cm202_1 XI0_I1605_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1605_MN3 (XI0_I1605_n2 I0_cm202_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1605_MN4 (VSS I0_cm203_0 XI0_I1605_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1605_MN27 (I0_fa244_1 XI0_I1605_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1605_MN10 (XI0_I1605_n4 I0_cm202_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.67999u ps=1.15999u
    I_MXI0_I1605_MN11 (XI0_I1605_n5 I0_cm203_0 XI0_I1605_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1605_MN11_1 (XI0_I1605_n4 I0_cm203_0 XI0_I1605_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1605_MN10_1 (VSS I0_cm202_1 XI0_I1605_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1605_MN6 (XI0_I1605_n3 I0_cm202_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1605_MN7 (VSS I0_cm203_0 XI0_I1605_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.21999u ps=0.67999u
    I_MXI0_I1605_MN8 (XI0_I1605_n3 I0_pp15_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.67999u ps=1.21999u
    I_MXI0_I1605_MN9 (XI0_I1605_sn XI0_I1605_con XI0_I1605_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1605_MN12_1 (XI0_I1605_n5 I0_pp15_23 XI0_I1605_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1657_MN12 (XI0_I1657_sn I0_cm204_0 XI0_I1657_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1657_MN25 (I0_fa296_0 XI0_I1657_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1657_MN5 (XI0_I1657_con I0_cm204_0 XI0_I1657_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1657_MN2 (XI0_I1657_n1 I0_cm203_1 XI0_I1657_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1657_MN1 (VSS I0_fa244_1 XI0_I1657_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1657_MN3 (XI0_I1657_n2 I0_fa244_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1657_MN4 (VSS I0_cm203_1 XI0_I1657_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1657_MN27 (I0_fa296_1 XI0_I1657_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1657_MN10 (XI0_I1657_n4 I0_fa244_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.67999u ps=1.15999u
    I_MXI0_I1657_MN11 (XI0_I1657_n5 I0_cm203_1 XI0_I1657_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1657_MN11_1 (XI0_I1657_n4 I0_cm203_1 XI0_I1657_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1657_MN10_1 (VSS I0_fa244_1 XI0_I1657_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1657_MN6 (XI0_I1657_n3 I0_fa244_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1657_MN7 (VSS I0_cm203_1 XI0_I1657_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.21999u ps=0.67999u
    I_MXI0_I1657_MN8 (XI0_I1657_n3 I0_cm204_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.67999u ps=1.21999u
    I_MXI0_I1657_MN9 (XI0_I1657_sn XI0_I1657_con XI0_I1657_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1657_MN12_1 (XI0_I1657_n5 I0_cm204_0 XI0_I1657_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1656_MN12 (XI0_I1656_sn I0_cm202_0 XI0_I1656_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1656_MN25 (I0_fa295_0 XI0_I1656_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I1656_MN5 (XI0_I1656_con I0_cm202_0 XI0_I1656_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1656_MN2 (XI0_I1656_n1 I0_cm201_1 XI0_I1656_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1656_MN1 (VSS I0_fa243_1 XI0_I1656_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1656_MN3 (XI0_I1656_n2 I0_fa243_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1656_MN4 (VSS I0_cm201_1 XI0_I1656_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1656_MN27 (I0_fa295_1 XI0_I1656_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15999u ps=0.67999u
    I_MXI0_I1656_MN10 (XI0_I1656_n4 I0_fa243_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.07558p pd=0.67999u ps=1.15999u
    I_MXI0_I1656_MN11 (XI0_I1656_n5 I0_cm201_1 XI0_I1656_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1656_MN11_1 (XI0_I1656_n4 I0_cm201_1 XI0_I1656_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1656_MN10_1 (VSS I0_fa243_1 XI0_I1656_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67999u ps=0.67999u
    I_MXI0_I1656_MN6 (XI0_I1656_n3 I0_fa243_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI0_I1656_MN7 (VSS I0_cm201_1 XI0_I1656_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.11758p as=0.05278p pd=1.21999u ps=0.67999u
    I_MXI0_I1656_MN8 (XI0_I1656_n3 I0_cm202_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.11758p pd=0.67999u ps=1.21999u
    I_MXI0_I1656_MN9 (XI0_I1656_sn XI0_I1656_con XI0_I1656_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1656_MN12_1 (XI0_I1656_n5 I0_cm202_0 XI0_I1656_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I96_XG_MN2 (XI1_I1344_I96_XG_n1 I1_I1344_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I96_XG_MN0 (I1_I1344_G30_29 I1_I1344_pn30 XI1_I1344_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I96_XG_MN1 (XI1_I1344_I96_XG_n1 I1_I1344_gn29 I1_I1344_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I97_XG_MN2 (XI1_I1344_I97_XG_n1 I1_I1344_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I97_XG_MN0 (I1_I1344_G31_30 I1_I1344_pn31 XI1_I1344_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I97_XG_MN1 (XI1_I1344_I97_XG_n1 I1_I1344_gn30 I1_I1344_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I156_XG_MN2 (XI1_I1344_I156_XG_n1 I1_I1344_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I156_XG_MN0 (I1_I1344_G31_24 I1_I1344_P31_28n XI1_I1344_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I156_XG_MN1 (XI1_I1344_I156_XG_n1 I1_I1344_G27_24n I1_I1344_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I202_XG_MN2 (XI1_I1344_I202_XG_n1 I1_I1344_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I202_XG_MN0 (I1_c17_o I1_I1344_P31_16n XI1_I1344_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I202_XG_MN1 (XI1_I1344_I202_XG_n1 I1_I1344_G15_0n I1_c17_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I202_XG_MN2 (XI1_I1298_I202_XG_n1 I1_I1298_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I202_XG_MN0 (I1_c16_o I1_I1298_P31_16n XI1_I1298_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I202_XG_MN1 (XI1_I1298_I202_XG_n1 I1_I1298_G15_0n I1_c16_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I156_XG_MN2 (XI1_I1298_I156_XG_n1 I1_I1298_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I156_XG_MN0 (I1_I1298_G31_24 I1_I1298_P31_28n XI1_I1298_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I156_XG_MN1 (XI1_I1298_I156_XG_n1 I1_I1298_G27_24n I1_I1298_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I95_XG_MN2 (XI1_I1298_I95_XG_n1 I1_I1298_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I95_XG_MN0 (I1_I1298_G29_28 I1_I1298_pn29 XI1_I1298_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I95_XG_MN1 (XI1_I1298_I95_XG_n1 I1_I1298_gn28 I1_I1298_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I95_XG_MN2 (XI1_I1252_I95_XG_n1 I1_I1252_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I95_XG_MN0 (I1_I1252_G29_28 I1_I1252_pn29 XI1_I1252_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I95_XG_MN1 (XI1_I1252_I95_XG_n1 I1_I1252_gn28 I1_I1252_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I94_XG_MN2 (XI1_I1252_I94_XG_n1 I1_I1252_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I94_XG_MN0 (I1_I1252_G28_27 I1_I1252_pn28 XI1_I1252_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I94_XG_MN1 (XI1_I1252_I94_XG_n1 I1_I1252_gn27 I1_I1252_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I96_XG_MN2 (XI1_I1252_I96_XG_n1 I1_I1252_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I96_XG_MN0 (I1_I1252_G30_29 I1_I1252_pn30 XI1_I1252_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I96_XG_MN1 (XI1_I1252_I96_XG_n1 I1_I1252_gn29 I1_I1252_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I97_XG_MN2 (XI1_I1252_I97_XG_n1 I1_I1252_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I97_XG_MN0 (I1_I1252_G31_30 I1_I1252_pn31 XI1_I1252_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I97_XG_MN1 (XI1_I1252_I97_XG_n1 I1_I1252_gn30 I1_I1252_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I95_XG_MN2 (XI1_I1206_I95_XG_n1 I1_I1206_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I95_XG_MN0 (I1_I1206_G29_28 I1_I1206_pn29 XI1_I1206_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I95_XG_MN1 (XI1_I1206_I95_XG_n1 I1_I1206_gn28 I1_I1206_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I94_XG_MN2 (XI1_I1206_I94_XG_n1 I1_I1206_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I94_XG_MN0 (I1_I1206_G28_27 I1_I1206_pn28 XI1_I1206_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I94_XG_MN1 (XI1_I1206_I94_XG_n1 I1_I1206_gn27 I1_I1206_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I97_XG_MN2 (XI1_I838_I97_XG_n1 I1_I838_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I97_XG_MN0 (I1_I838_G31_30 I1_I838_pn31 XI1_I838_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I97_XG_MN1 (XI1_I838_I97_XG_n1 I1_I838_gn30 I1_I838_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I156_XG_MN2 (XI1_I838_I156_XG_n1 I1_I838_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I156_XG_MN0 (I1_I838_G31_24 I1_I838_P31_28n XI1_I838_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I156_XG_MN1 (XI1_I838_I156_XG_n1 I1_I838_G27_24n I1_I838_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I154_XG_MN2 (XI1_I838_I154_XG_n1 I1_I838_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I154_XG_MN0 (I1_I838_G29_22 I1_I838_P29_26n XI1_I838_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I154_XG_MN1 (XI1_I838_I154_XG_n1 I1_I838_G25_22n I1_I838_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I152_XG_MN2 (XI1_I838_I152_XG_n1 I1_I838_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I152_XG_MN0 (I1_I838_G27_20 I1_I838_P27_24n XI1_I838_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I152_XG_MN1 (XI1_I838_I152_XG_n1 I1_I838_G23_20n I1_I838_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I202_XG_MN2 (XI1_I838_I202_XG_n1 I1_I838_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I202_XG_MN0 (I1_c6_o I1_I838_P31_16n XI1_I838_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I202_XG_MN1 (XI1_I838_I202_XG_n1 I1_I838_G15_0n I1_c6_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I194_XG_MN2 (XI1_I838_I194_XG_n1 I1_I838_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I194_XG_MN0 (I1_I838_G23_0 I1_I838_P23_8n XI1_I838_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I194_XG_MN1 (XI1_I838_I194_XG_n1 I1_I838_G7_0n I1_I838_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I144_XG_MN2 (XI1_I838_I144_XG_n1 I1_I838_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I144_XG_MN0 (I1_I838_G19_12 I1_I838_P19_16n XI1_I838_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I144_XG_MN1 (XI1_I838_I144_XG_n1 I1_I838_G15_12n I1_I838_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I140_XG_MN2 (XI1_I838_I140_XG_n1 I1_I838_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I140_XG_MN0 (I1_I838_G15_8 I1_I838_P15_12n XI1_I838_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I140_XG_MN1 (XI1_I838_I140_XG_n1 I1_I838_G11_8n I1_I838_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I190_XG_MN2 (XI1_I838_I190_XG_n1 I1_I838_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I190_XG_MN0 (I1_I838_G21_0 I1_I838_P21_6n XI1_I838_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I190_XG_MN1 (XI1_I838_I190_XG_n1 I1_I838_G5_0n I1_I838_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I186_XG_MN2 (XI1_I838_I186_XG_n1 I1_I838_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I186_XG_MN0 (I1_I838_G19_0 I1_I838_P19_4n XI1_I838_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I186_XG_MN1 (XI1_I838_I186_XG_n1 I1_I838_G3_0n I1_I838_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I136_XG_MN2 (XI1_I838_I136_XG_n1 I1_I838_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I136_XG_MN0 (I1_I838_G11_4 I1_I838_P11_8n XI1_I838_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I136_XG_MN1 (XI1_I838_I136_XG_n1 I1_I838_G7_4n I1_I838_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I200_XG_MN2 (XI1_I792_I200_XG_n1 I1_I792_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I200_XG_MN0 (I1_I792_G29_0 I1_I792_P29_14n XI1_I792_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I200_XG_MN1 (XI1_I792_I200_XG_n1 I1_I792_G13_0n I1_I792_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I198_XG_MN2 (XI1_I792_I198_XG_n1 I1_I792_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I198_XG_MN0 (I1_I792_G27_0 I1_I792_P27_12n XI1_I792_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I198_XG_MN1 (XI1_I792_I198_XG_n1 I1_I792_G11_0n I1_I792_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I202_XG_MN2 (XI1_I792_I202_XG_n1 I1_I792_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I202_XG_MN0 (I1_c5_o I1_I792_P31_16n XI1_I792_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I202_XG_MN1 (XI1_I792_I202_XG_n1 I1_I792_G15_0n I1_c5_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I154_XG_MN2 (XI1_I792_I154_XG_n1 I1_I792_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I154_XG_MN0 (I1_I792_G29_22 I1_I792_P29_26n XI1_I792_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I154_XG_MN1 (XI1_I792_I154_XG_n1 I1_I792_G25_22n I1_I792_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I152_XG_MN2 (XI1_I792_I152_XG_n1 I1_I792_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I152_XG_MN0 (I1_I792_G27_20 I1_I792_P27_24n XI1_I792_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I152_XG_MN1 (XI1_I792_I152_XG_n1 I1_I792_G23_20n I1_I792_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I156_XG_MN2 (XI1_I792_I156_XG_n1 I1_I792_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I156_XG_MN0 (I1_I792_G31_24 I1_I792_P31_28n XI1_I792_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I156_XG_MN1 (XI1_I792_I156_XG_n1 I1_I792_G27_24n I1_I792_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I201_XG_MN2 (XI1_I792_I201_XG_n1 I1_I792_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I201_XG_MN0 (I1_c5_m I1_I792_P30_15n XI1_I792_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I201_XG_MN1 (XI1_I792_I201_XG_n1 I1_I792_G14_0n I1_c5_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I155_XG_MN2 (XI1_I792_I155_XG_n1 I1_I792_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I155_XG_MN0 (I1_I792_G30_23 I1_I792_P30_27n XI1_I792_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I155_XG_MN1 (XI1_I792_I155_XG_n1 I1_I792_G26_23n I1_I792_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I91_XG_MN2 (XI1_I792_I91_XG_n1 I1_I792_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I91_XG_MN0 (I1_I792_G25_24 I1_I792_pn25 XI1_I792_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I91_XG_MN1 (XI1_I792_I91_XG_n1 I1_I792_gn24 I1_I792_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I93_XG_MN2 (XI1_I792_I93_XG_n1 I1_I792_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I93_XG_MN0 (I1_I792_G27_26 I1_I792_pn27 XI1_I792_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I93_XG_MN1 (XI1_I792_I93_XG_n1 I1_I792_gn26 I1_I792_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I94_XG_MN2 (XI1_I792_I94_XG_n1 I1_I792_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I94_XG_MN0 (I1_I792_G28_27 I1_I792_pn28 XI1_I792_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I94_XG_MN1 (XI1_I792_I94_XG_n1 I1_I792_gn27 I1_I792_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I95_XG_MN2 (XI1_I792_I95_XG_n1 I1_I792_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I95_XG_MN0 (I1_I792_G29_28 I1_I792_pn29 XI1_I792_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I95_XG_MN1 (XI1_I792_I95_XG_n1 I1_I792_gn28 I1_I792_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I96_XG_MN2 (XI1_I792_I96_XG_n1 I1_I792_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I96_XG_MN0 (I1_I792_G30_29 I1_I792_pn30 XI1_I792_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I96_XG_MN1 (XI1_I792_I96_XG_n1 I1_I792_gn29 I1_I792_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I97_XG_MN2 (XI1_I792_I97_XG_n1 I1_I792_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I97_XG_MN0 (I1_I792_G31_30 I1_I792_pn31 XI1_I792_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I97_XG_MN1 (XI1_I792_I97_XG_n1 I1_I792_gn30 I1_I792_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I95_XG_MN2 (XI1_I1344_I95_XG_n1 I1_I1344_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I95_XG_MN0 (I1_I1344_G29_28 I1_I1344_pn29 XI1_I1344_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I95_XG_MN1 (XI1_I1344_I95_XG_n1 I1_I1344_gn28 I1_I1344_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I152_XG_MN2 (XI1_I1344_I152_XG_n1 I1_I1344_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I152_XG_MN0 (I1_I1344_G27_20 I1_I1344_P27_24n XI1_I1344_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I152_XG_MN1 (XI1_I1344_I152_XG_n1 I1_I1344_G23_20n I1_I1344_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I148_XG_MN2 (XI1_I1344_I148_XG_n1 I1_I1344_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I148_XG_MN0 (I1_I1344_G23_16 I1_I1344_P23_20n XI1_I1344_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I148_XG_MN1 (XI1_I1344_I148_XG_n1 I1_I1344_G19_16n I1_I1344_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I194_XG_MN2 (XI1_I1344_I194_XG_n1 I1_I1344_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I194_XG_MN0 (I1_I1344_G23_0 I1_I1344_P23_8n XI1_I1344_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I194_XG_MN1 (XI1_I1344_I194_XG_n1 I1_I1344_G7_0n I1_I1344_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I198_XG_MN2 (XI1_I1298_I198_XG_n1 I1_I1298_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I198_XG_MN0 (I1_I1298_G27_0 I1_I1298_P27_12n XI1_I1298_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I198_XG_MN1 (XI1_I1298_I198_XG_n1 I1_I1298_G11_0n I1_I1298_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I152_XG_MN2 (XI1_I1298_I152_XG_n1 I1_I1298_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I152_XG_MN0 (I1_I1298_G27_20 I1_I1298_P27_24n XI1_I1298_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I152_XG_MN1 (XI1_I1298_I152_XG_n1 I1_I1298_G23_20n I1_I1298_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I200_XG_MN2 (XI1_I1298_I200_XG_n1 I1_I1298_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I200_XG_MN0 (I1_I1298_G29_0 I1_I1298_P29_14n XI1_I1298_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I200_XG_MN1 (XI1_I1298_I200_XG_n1 I1_I1298_G13_0n I1_I1298_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I155_XG_MN2 (XI1_I1298_I155_XG_n1 I1_I1298_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I155_XG_MN0 (I1_I1298_G30_23 I1_I1298_P30_27n XI1_I1298_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I155_XG_MN1 (XI1_I1298_I155_XG_n1 I1_I1298_G26_23n I1_I1298_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I92_XG_MN2 (XI1_I1298_I92_XG_n1 I1_I1298_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I92_XG_MN0 (I1_I1298_G26_25 I1_I1298_pn26 XI1_I1298_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I92_XG_MN1 (XI1_I1298_I92_XG_n1 I1_I1298_gn25 I1_I1298_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I201_XG_MN2 (XI1_I1252_I201_XG_n1 I1_I1252_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I201_XG_MN0 (I1_c15_m I1_I1252_P30_15n XI1_I1252_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I201_XG_MN1 (XI1_I1252_I201_XG_n1 I1_I1252_G14_0n I1_c15_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I155_XG_MN2 (XI1_I1252_I155_XG_n1 I1_I1252_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I155_XG_MN0 (I1_I1252_G30_23 I1_I1252_P30_27n XI1_I1252_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I155_XG_MN1 (XI1_I1252_I155_XG_n1 I1_I1252_G26_23n I1_I1252_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I202_XG_MN2 (XI1_I1252_I202_XG_n1 I1_I1252_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I202_XG_MN0 (I1_c15_o I1_I1252_P31_16n XI1_I1252_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I202_XG_MN1 (XI1_I1252_I202_XG_n1 I1_I1252_G15_0n I1_c15_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I156_XG_MN2 (XI1_I1252_I156_XG_n1 I1_I1252_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I156_XG_MN0 (I1_I1252_G31_24 I1_I1252_P31_28n XI1_I1252_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I156_XG_MN1 (XI1_I1252_I156_XG_n1 I1_I1252_G27_24n I1_I1252_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I93_XG_MN2 (XI1_I1252_I93_XG_n1 I1_I1252_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I93_XG_MN0 (I1_I1252_G27_26 I1_I1252_pn27 XI1_I1252_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I93_XG_MN1 (XI1_I1252_I93_XG_n1 I1_I1252_gn26 I1_I1252_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I92_XG_MN2 (XI1_I1252_I92_XG_n1 I1_I1252_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I92_XG_MN0 (I1_I1252_G26_25 I1_I1252_pn26 XI1_I1252_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I92_XG_MN1 (XI1_I1252_I92_XG_n1 I1_I1252_gn25 I1_I1252_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I97_XG_MN2 (XI1_I1206_I97_XG_n1 I1_I1206_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I97_XG_MN0 (I1_I1206_G31_30 I1_I1206_pn31 XI1_I1206_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I97_XG_MN1 (XI1_I1206_I97_XG_n1 I1_I1206_gn30 I1_I1206_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I96_XG_MN2 (XI1_I1206_I96_XG_n1 I1_I1206_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I96_XG_MN0 (I1_I1206_G30_29 I1_I1206_pn30 XI1_I1206_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I96_XG_MN1 (XI1_I1206_I96_XG_n1 I1_I1206_gn29 I1_I1206_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I93_XG_MN2 (XI1_I1206_I93_XG_n1 I1_I1206_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I93_XG_MN0 (I1_I1206_G27_26 I1_I1206_pn27 XI1_I1206_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I93_XG_MN1 (XI1_I1206_I93_XG_n1 I1_I1206_gn26 I1_I1206_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I92_XG_MN2 (XI1_I1206_I92_XG_n1 I1_I1206_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I92_XG_MN0 (I1_I1206_G26_25 I1_I1206_pn26 XI1_I1206_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I92_XG_MN1 (XI1_I1206_I92_XG_n1 I1_I1206_gn25 I1_I1206_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I95_XG_MN2 (XI1_I838_I95_XG_n1 I1_I838_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I95_XG_MN0 (I1_I838_G29_28 I1_I838_pn29 XI1_I838_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I95_XG_MN1 (XI1_I838_I95_XG_n1 I1_I838_gn28 I1_I838_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I96_XG_MN2 (XI1_I838_I96_XG_n1 I1_I838_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I96_XG_MN0 (I1_I838_G30_29 I1_I838_pn30 XI1_I838_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I96_XG_MN1 (XI1_I838_I96_XG_n1 I1_I838_gn29 I1_I838_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I91_XG_MN2 (XI1_I838_I91_XG_n1 I1_I838_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I91_XG_MN0 (I1_I838_G25_24 I1_I838_pn25 XI1_I838_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I91_XG_MN1 (XI1_I838_I91_XG_n1 I1_I838_gn24 I1_I838_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I89_XG_MN2 (XI1_I838_I89_XG_n1 I1_I838_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I89_XG_MN0 (I1_I838_G23_22 I1_I838_pn23 XI1_I838_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I89_XG_MN1 (XI1_I838_I89_XG_n1 I1_I838_gn22 I1_I838_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I200_XG_MN2 (XI1_I838_I200_XG_n1 I1_I838_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I200_XG_MN0 (I1_I838_G29_0 I1_I838_P29_14n XI1_I838_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I200_XG_MN1 (XI1_I838_I200_XG_n1 I1_I838_G13_0n I1_I838_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I87_XG_MN2 (XI1_I838_I87_XG_n1 I1_I838_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I87_XG_MN0 (I1_I838_G21_20 I1_I838_pn21 XI1_I838_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I87_XG_MN1 (XI1_I838_I87_XG_n1 I1_I838_gn20 I1_I838_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I150_XG_MN2 (XI1_I838_I150_XG_n1 I1_I838_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I150_XG_MN0 (I1_I838_G25_18 I1_I838_P25_22n XI1_I838_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I150_XG_MN1 (XI1_I838_I150_XG_n1 I1_I838_G21_18n I1_I838_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I146_XG_MN2 (XI1_I838_I146_XG_n1 I1_I838_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I146_XG_MN0 (I1_I838_G21_14 I1_I838_P21_18n XI1_I838_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I146_XG_MN1 (XI1_I838_I146_XG_n1 I1_I838_G17_14n I1_I838_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I142_XG_MN2 (XI1_I838_I142_XG_n1 I1_I838_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I142_XG_MN0 (I1_I838_G17_10 I1_I838_P17_14n XI1_I838_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I142_XG_MN1 (XI1_I838_I142_XG_n1 I1_I838_G13_10n I1_I838_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I134_XG_MN2 (XI1_I838_I134_XG_n1 I1_I838_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I134_XG_MN0 (I1_I838_G9_2 I1_I838_P9_6n XI1_I838_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I134_XG_MN1 (XI1_I838_I134_XG_n1 I1_I838_G5_2n I1_I838_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I132_XG_MN2 (XI1_I838_I132_XG_n1 I1_I838_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I132_XG_MN0 (I1_I838_G7_0 I1_I838_P7_4n XI1_I838_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I132_XG_MN1 (XI1_I838_I132_XG_n1 I1_I838_G3_0n I1_I838_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I196_XG_MN2 (XI1_I792_I196_XG_n1 I1_I792_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I196_XG_MN0 (I1_I792_G25_0 I1_I792_P25_10n XI1_I792_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I196_XG_MN1 (XI1_I792_I196_XG_n1 I1_I792_G9_0n I1_I792_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I194_XG_MN2 (XI1_I792_I194_XG_n1 I1_I792_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I194_XG_MN0 (I1_I792_G23_0 I1_I792_P23_8n XI1_I792_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I194_XG_MN1 (XI1_I792_I194_XG_n1 I1_I792_G7_0n I1_I792_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I146_XG_MN2 (XI1_I792_I146_XG_n1 I1_I792_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I146_XG_MN0 (I1_I792_G21_14 I1_I792_P21_18n XI1_I792_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I146_XG_MN1 (XI1_I792_I146_XG_n1 I1_I792_G17_14n I1_I792_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I199_XG_MN2 (XI1_I792_I199_XG_n1 I1_I792_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I199_XG_MN0 (I1_I792_G28_0 I1_I792_P28_13n XI1_I792_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I199_XG_MN1 (XI1_I792_I199_XG_n1 I1_I792_G12_0n I1_I792_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I151_XG_MN2 (XI1_I792_I151_XG_n1 I1_I792_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I151_XG_MN0 (I1_I792_G26_19 I1_I792_P26_23n XI1_I792_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I151_XG_MN1 (XI1_I792_I151_XG_n1 I1_I792_G22_19n I1_I792_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I153_XG_MN2 (XI1_I792_I153_XG_n1 I1_I792_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I153_XG_MN0 (I1_I792_G28_21 I1_I792_P28_25n XI1_I792_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I153_XG_MN1 (XI1_I792_I153_XG_n1 I1_I792_G24_21n I1_I792_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I89_XG_MN2 (XI1_I792_I89_XG_n1 I1_I792_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I89_XG_MN0 (I1_I792_G23_22 I1_I792_pn23 XI1_I792_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I89_XG_MN1 (XI1_I792_I89_XG_n1 I1_I792_gn22 I1_I792_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I90_XG_MN2 (XI1_I792_I90_XG_n1 I1_I792_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I90_XG_MN0 (I1_I792_G24_23 I1_I792_pn24 XI1_I792_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I90_XG_MN1 (XI1_I792_I90_XG_n1 I1_I792_gn23 I1_I792_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I92_XG_MN2 (XI1_I792_I92_XG_n1 I1_I792_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I92_XG_MN0 (I1_I792_G26_25 I1_I792_pn26 XI1_I792_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I92_XG_MN1 (XI1_I792_I92_XG_n1 I1_I792_gn25 I1_I792_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I94_XG_MN2 (XI1_I1344_I94_XG_n1 I1_I1344_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I94_XG_MN0 (I1_I1344_G28_27 I1_I1344_pn28 XI1_I1344_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I94_XG_MN1 (XI1_I1344_I94_XG_n1 I1_I1344_gn27 I1_I1344_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I154_XG_MN2 (XI1_I1344_I154_XG_n1 I1_I1344_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I154_XG_MN0 (I1_I1344_G29_22 I1_I1344_P29_26n XI1_I1344_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I154_XG_MN1 (XI1_I1344_I154_XG_n1 I1_I1344_G25_22n I1_I1344_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I150_XG_MN2 (XI1_I1344_I150_XG_n1 I1_I1344_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I150_XG_MN0 (I1_I1344_G25_18 I1_I1344_P25_22n XI1_I1344_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I150_XG_MN1 (XI1_I1344_I150_XG_n1 I1_I1344_G21_18n I1_I1344_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I200_XG_MN2 (XI1_I1344_I200_XG_n1 I1_I1344_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I200_XG_MN0 (I1_I1344_G29_0 I1_I1344_P29_14n XI1_I1344_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I200_XG_MN1 (XI1_I1344_I200_XG_n1 I1_I1344_G13_0n I1_I1344_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I154_XG_MN2 (XI1_I1298_I154_XG_n1 I1_I1298_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I154_XG_MN0 (I1_I1298_G29_22 I1_I1298_P29_26n XI1_I1298_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I154_XG_MN1 (XI1_I1298_I154_XG_n1 I1_I1298_G25_22n I1_I1298_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I201_XG_MN2 (XI1_I1298_I201_XG_n1 I1_I1298_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I201_XG_MN0 (I1_c16_m I1_I1298_P30_15n XI1_I1298_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I201_XG_MN1 (XI1_I1298_I201_XG_n1 I1_I1298_G14_0n I1_c16_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I90_XG_MN2 (XI1_I1298_I90_XG_n1 I1_I1298_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I90_XG_MN0 (I1_I1298_G24_23 I1_I1298_pn24 XI1_I1298_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I90_XG_MN1 (XI1_I1298_I90_XG_n1 I1_I1298_gn23 I1_I1298_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I91_XG_MN2 (XI1_I1298_I91_XG_n1 I1_I1298_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I91_XG_MN0 (I1_I1298_G25_24 I1_I1298_pn25 XI1_I1298_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I91_XG_MN1 (XI1_I1298_I91_XG_n1 I1_I1298_gn24 I1_I1298_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I199_XG_MN2 (XI1_I1252_I199_XG_n1 I1_I1252_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I199_XG_MN0 (I1_I1252_G28_0 I1_I1252_P28_13n XI1_I1252_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I199_XG_MN1 (XI1_I1252_I199_XG_n1 I1_I1252_G12_0n I1_I1252_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I153_XG_MN2 (XI1_I1252_I153_XG_n1 I1_I1252_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I153_XG_MN0 (I1_I1252_G28_21 I1_I1252_P28_25n XI1_I1252_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I153_XG_MN1 (XI1_I1252_I153_XG_n1 I1_I1252_G24_21n I1_I1252_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I200_XG_MN2 (XI1_I1252_I200_XG_n1 I1_I1252_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I200_XG_MN0 (I1_I1252_G29_0 I1_I1252_P29_14n XI1_I1252_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I200_XG_MN1 (XI1_I1252_I200_XG_n1 I1_I1252_G13_0n I1_I1252_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I154_XG_MN2 (XI1_I1252_I154_XG_n1 I1_I1252_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I154_XG_MN0 (I1_I1252_G29_22 I1_I1252_P29_26n XI1_I1252_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I154_XG_MN1 (XI1_I1252_I154_XG_n1 I1_I1252_G25_22n I1_I1252_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I90_XG_MN2 (XI1_I1252_I90_XG_n1 I1_I1252_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I90_XG_MN0 (I1_I1252_G24_23 I1_I1252_pn24 XI1_I1252_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I90_XG_MN1 (XI1_I1252_I90_XG_n1 I1_I1252_gn23 I1_I1252_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I91_XG_MN2 (XI1_I1252_I91_XG_n1 I1_I1252_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I91_XG_MN0 (I1_I1252_G25_24 I1_I1252_pn25 XI1_I1252_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I91_XG_MN1 (XI1_I1252_I91_XG_n1 I1_I1252_gn24 I1_I1252_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I90_XG_MN2 (XI1_I1206_I90_XG_n1 I1_I1206_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I90_XG_MN0 (I1_I1206_G24_23 I1_I1206_pn24 XI1_I1206_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I90_XG_MN1 (XI1_I1206_I90_XG_n1 I1_I1206_gn23 I1_I1206_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I156_XG_MN2 (XI1_I1206_I156_XG_n1 I1_I1206_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I156_XG_MN0 (I1_I1206_G31_24 I1_I1206_P31_28n XI1_I1206_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I156_XG_MN1 (XI1_I1206_I156_XG_n1 I1_I1206_G27_24n I1_I1206_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I91_XG_MN2 (XI1_I1206_I91_XG_n1 I1_I1206_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I91_XG_MN0 (I1_I1206_G25_24 I1_I1206_pn25 XI1_I1206_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I91_XG_MN1 (XI1_I1206_I91_XG_n1 I1_I1206_gn24 I1_I1206_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I155_XG_MN2 (XI1_I1206_I155_XG_n1 I1_I1206_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I155_XG_MN0 (I1_I1206_G30_23 I1_I1206_P30_27n XI1_I1206_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I155_XG_MN1 (XI1_I1206_I155_XG_n1 I1_I1206_G26_23n I1_I1206_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I94_XG_MN2 (XI1_I838_I94_XG_n1 I1_I838_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I94_XG_MN0 (I1_I838_G28_27 I1_I838_pn28 XI1_I838_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I94_XG_MN1 (XI1_I838_I94_XG_n1 I1_I838_gn27 I1_I838_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I90_XG_MN2 (XI1_I838_I90_XG_n1 I1_I838_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I90_XG_MN0 (I1_I838_G24_23 I1_I838_pn24 XI1_I838_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I90_XG_MN1 (XI1_I838_I90_XG_n1 I1_I838_gn23 I1_I838_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I88_XG_MN2 (XI1_I838_I88_XG_n1 I1_I838_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I88_XG_MN0 (I1_I838_G22_21 I1_I838_pn22 XI1_I838_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I88_XG_MN1 (XI1_I838_I88_XG_n1 I1_I838_gn21 I1_I838_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I86_XG_MN2 (XI1_I838_I86_XG_n1 I1_I838_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I86_XG_MN0 (I1_I838_G20_19 I1_I838_pn20 XI1_I838_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I86_XG_MN1 (XI1_I838_I86_XG_n1 I1_I838_gn19 I1_I838_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I85_XG_MN2 (XI1_I838_I85_XG_n1 I1_I838_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I85_XG_MN0 (I1_I838_G19_18 I1_I838_pn19 XI1_I838_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I85_XG_MN1 (XI1_I838_I85_XG_n1 I1_I838_gn18 I1_I838_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I83_XG_MN2 (XI1_I838_I83_XG_n1 I1_I838_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I83_XG_MN0 (I1_I838_G17_16 I1_I838_pn17 XI1_I838_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I83_XG_MN1 (XI1_I838_I83_XG_n1 I1_I838_gn16 I1_I838_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I196_XG_MN2 (XI1_I838_I196_XG_n1 I1_I838_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I196_XG_MN0 (I1_I838_G25_0 I1_I838_P25_10n XI1_I838_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I196_XG_MN1 (XI1_I838_I196_XG_n1 I1_I838_G9_0n I1_I838_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I138_XG_MN2 (XI1_I838_I138_XG_n1 I1_I838_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I138_XG_MN0 (I1_I838_G13_6 I1_I838_P13_10n XI1_I838_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I138_XG_MN1 (XI1_I838_I138_XG_n1 I1_I838_G9_6n I1_I838_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I184_XG_MN2 (XI1_I838_I184_XG_n1 I1_I838_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I184_XG_MN0 (I1_I838_G17_0 I1_I838_P17_2n XI1_I838_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I184_XG_MN1 (XI1_I838_I184_XG_n1 I1_I838_G1_0n I1_I838_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I130_XG_MN2 (XI1_I838_I130_XG_n1 I1_I838_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I130_XG_MN0 (I1_I838_G5_0 I1_I838_P5_2n XI1_I838_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I130_XG_MN1 (XI1_I838_I130_XG_n1 I1_I838_G1_0n I1_I838_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I190_XG_MN2 (XI1_I792_I190_XG_n1 I1_I792_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I190_XG_MN0 (I1_I792_G21_0 I1_I792_P21_6n XI1_I792_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I190_XG_MN1 (XI1_I792_I190_XG_n1 I1_I792_G5_0n I1_I792_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I186_XG_MN2 (XI1_I792_I186_XG_n1 I1_I792_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I186_XG_MN0 (I1_I792_G19_0 I1_I792_P19_4n XI1_I792_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I186_XG_MN1 (XI1_I792_I186_XG_n1 I1_I792_G3_0n I1_I792_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I144_XG_MN2 (XI1_I792_I144_XG_n1 I1_I792_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I144_XG_MN0 (I1_I792_G19_12 I1_I792_P19_16n XI1_I792_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I144_XG_MN1 (XI1_I792_I144_XG_n1 I1_I792_G15_12n I1_I792_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I192_XG_MN2 (XI1_I792_I192_XG_n1 I1_I792_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I192_XG_MN0 (I1_I792_G22_0 I1_I792_P22_7n XI1_I792_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I192_XG_MN1 (XI1_I792_I192_XG_n1 I1_I792_G6_0n I1_I792_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I197_XG_MN2 (XI1_I792_I197_XG_n1 I1_I792_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I197_XG_MN0 (I1_I792_G26_0 I1_I792_P26_11n XI1_I792_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I197_XG_MN1 (XI1_I792_I197_XG_n1 I1_I792_G10_0n I1_I792_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I147_XG_MN2 (XI1_I792_I147_XG_n1 I1_I792_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I147_XG_MN0 (I1_I792_G22_15 I1_I792_P22_19n XI1_I792_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I147_XG_MN1 (XI1_I792_I147_XG_n1 I1_I792_G18_15n I1_I792_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I149_XG_MN2 (XI1_I792_I149_XG_n1 I1_I792_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I149_XG_MN0 (I1_I792_G24_17 I1_I792_P24_21n XI1_I792_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I149_XG_MN1 (XI1_I792_I149_XG_n1 I1_I792_G20_17n I1_I792_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I87_XG_MN2 (XI1_I792_I87_XG_n1 I1_I792_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I87_XG_MN0 (I1_I792_G21_20 I1_I792_pn21 XI1_I792_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I87_XG_MN1 (XI1_I792_I87_XG_n1 I1_I792_gn20 I1_I792_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I88_XG_MN2 (XI1_I792_I88_XG_n1 I1_I792_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I88_XG_MN0 (I1_I792_G22_21 I1_I792_pn22 XI1_I792_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I88_XG_MN1 (XI1_I792_I88_XG_n1 I1_I792_gn21 I1_I792_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I92_XG_MN2 (XI1_I1344_I92_XG_n1 I1_I1344_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I92_XG_MN0 (I1_I1344_G26_25 I1_I1344_pn26 XI1_I1344_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I92_XG_MN1 (XI1_I1344_I92_XG_n1 I1_I1344_gn25 I1_I1344_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I93_XG_MN2 (XI1_I1344_I93_XG_n1 I1_I1344_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I93_XG_MN0 (I1_I1344_G27_26 I1_I1344_pn27 XI1_I1344_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I93_XG_MN1 (XI1_I1344_I93_XG_n1 I1_I1344_gn26 I1_I1344_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I91_XG_MN2 (XI1_I1344_I91_XG_n1 I1_I1344_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I91_XG_MN0 (I1_I1344_G25_24 I1_I1344_pn25 XI1_I1344_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I91_XG_MN1 (XI1_I1344_I91_XG_n1 I1_I1344_gn24 I1_I1344_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I90_XG_MN2 (XI1_I1344_I90_XG_n1 I1_I1344_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I90_XG_MN0 (I1_I1344_G24_23 I1_I1344_pn24 XI1_I1344_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I90_XG_MN1 (XI1_I1344_I90_XG_n1 I1_I1344_gn23 I1_I1344_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I89_XG_MN2 (XI1_I1344_I89_XG_n1 I1_I1344_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I89_XG_MN0 (I1_I1344_G23_22 I1_I1344_pn23 XI1_I1344_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I89_XG_MN1 (XI1_I1344_I89_XG_n1 I1_I1344_gn22 I1_I1344_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I146_XG_MN2 (XI1_I1344_I146_XG_n1 I1_I1344_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I146_XG_MN0 (I1_I1344_G21_14 I1_I1344_P21_18n XI1_I1344_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I146_XG_MN1 (XI1_I1344_I146_XG_n1 I1_I1344_G17_14n I1_I1344_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I140_XG_MN2 (XI1_I1344_I140_XG_n1 I1_I1344_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I140_XG_MN0 (I1_I1344_G15_8 I1_I1344_P15_12n XI1_I1344_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I140_XG_MN1 (XI1_I1344_I140_XG_n1 I1_I1344_G11_8n I1_I1344_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I186_XG_MN2 (XI1_I1344_I186_XG_n1 I1_I1344_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I186_XG_MN0 (I1_I1344_G19_0 I1_I1344_P19_4n XI1_I1344_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I186_XG_MN1 (XI1_I1344_I186_XG_n1 I1_I1344_G3_0n I1_I1344_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I136_XG_MN2 (XI1_I1344_I136_XG_n1 I1_I1344_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I136_XG_MN0 (I1_I1344_G11_4 I1_I1344_P11_8n XI1_I1344_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I136_XG_MN1 (XI1_I1344_I136_XG_n1 I1_I1344_G7_4n I1_I1344_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I132_XG_MN2 (XI1_I1344_I132_XG_n1 I1_I1344_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I132_XG_MN0 (I1_I1344_G7_0 I1_I1344_P7_4n XI1_I1344_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I132_XG_MN1 (XI1_I1344_I132_XG_n1 I1_I1344_G3_0n I1_I1344_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I194_XG_MN2 (XI1_I1298_I194_XG_n1 I1_I1298_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I194_XG_MN0 (I1_I1298_G23_0 I1_I1298_P23_8n XI1_I1298_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I194_XG_MN1 (XI1_I1298_I194_XG_n1 I1_I1298_G7_0n I1_I1298_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I148_XG_MN2 (XI1_I1298_I148_XG_n1 I1_I1298_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I148_XG_MN0 (I1_I1298_G23_16 I1_I1298_P23_20n XI1_I1298_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I148_XG_MN1 (XI1_I1298_I148_XG_n1 I1_I1298_G19_16n I1_I1298_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I196_XG_MN2 (XI1_I1298_I196_XG_n1 I1_I1298_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I196_XG_MN0 (I1_I1298_G25_0 I1_I1298_P25_10n XI1_I1298_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I196_XG_MN1 (XI1_I1298_I196_XG_n1 I1_I1298_G9_0n I1_I1298_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I150_XG_MN2 (XI1_I1298_I150_XG_n1 I1_I1298_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I150_XG_MN0 (I1_I1298_G25_18 I1_I1298_P25_22n XI1_I1298_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I150_XG_MN1 (XI1_I1298_I150_XG_n1 I1_I1298_G21_18n I1_I1298_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I199_XG_MN2 (XI1_I1298_I199_XG_n1 I1_I1298_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I199_XG_MN0 (I1_I1298_G28_0 I1_I1298_P28_13n XI1_I1298_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I199_XG_MN1 (XI1_I1298_I199_XG_n1 I1_I1298_G12_0n I1_I1298_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I153_XG_MN2 (XI1_I1298_I153_XG_n1 I1_I1298_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I153_XG_MN0 (I1_I1298_G28_21 I1_I1298_P28_25n XI1_I1298_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I153_XG_MN1 (XI1_I1298_I153_XG_n1 I1_I1298_G24_21n I1_I1298_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I88_XG_MN2 (XI1_I1298_I88_XG_n1 I1_I1298_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I88_XG_MN0 (I1_I1298_G22_21 I1_I1298_pn22 XI1_I1298_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I88_XG_MN1 (XI1_I1298_I88_XG_n1 I1_I1298_gn21 I1_I1298_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I89_XG_MN2 (XI1_I1298_I89_XG_n1 I1_I1298_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I89_XG_MN0 (I1_I1298_G23_22 I1_I1298_pn23 XI1_I1298_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I89_XG_MN1 (XI1_I1298_I89_XG_n1 I1_I1298_gn22 I1_I1298_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I197_XG_MN2 (XI1_I1252_I197_XG_n1 I1_I1252_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I197_XG_MN0 (I1_I1252_G26_0 I1_I1252_P26_11n XI1_I1252_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I197_XG_MN1 (XI1_I1252_I197_XG_n1 I1_I1252_G10_0n I1_I1252_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I151_XG_MN2 (XI1_I1252_I151_XG_n1 I1_I1252_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I151_XG_MN0 (I1_I1252_G26_19 I1_I1252_P26_23n XI1_I1252_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I151_XG_MN1 (XI1_I1252_I151_XG_n1 I1_I1252_G22_19n I1_I1252_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I194_XG_MN2 (XI1_I1252_I194_XG_n1 I1_I1252_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I194_XG_MN0 (I1_I1252_G23_0 I1_I1252_P23_8n XI1_I1252_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I194_XG_MN1 (XI1_I1252_I194_XG_n1 I1_I1252_G7_0n I1_I1252_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I152_XG_MN2 (XI1_I1252_I152_XG_n1 I1_I1252_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I152_XG_MN0 (I1_I1252_G27_20 I1_I1252_P27_24n XI1_I1252_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I152_XG_MN1 (XI1_I1252_I152_XG_n1 I1_I1252_G23_20n I1_I1252_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I148_XG_MN2 (XI1_I1252_I148_XG_n1 I1_I1252_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I148_XG_MN0 (I1_I1252_G23_16 I1_I1252_P23_20n XI1_I1252_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I148_XG_MN1 (XI1_I1252_I148_XG_n1 I1_I1252_G19_16n I1_I1252_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I89_XG_MN2 (XI1_I1252_I89_XG_n1 I1_I1252_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I89_XG_MN0 (I1_I1252_G23_22 I1_I1252_pn23 XI1_I1252_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I89_XG_MN1 (XI1_I1252_I89_XG_n1 I1_I1252_gn22 I1_I1252_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I89_XG_MN2 (XI1_I1206_I89_XG_n1 I1_I1206_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I89_XG_MN0 (I1_I1206_G23_22 I1_I1206_pn23 XI1_I1206_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I89_XG_MN1 (XI1_I1206_I89_XG_n1 I1_I1206_gn22 I1_I1206_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I152_XG_MN2 (XI1_I1206_I152_XG_n1 I1_I1206_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I152_XG_MN0 (I1_I1206_G27_20 I1_I1206_P27_24n XI1_I1206_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I152_XG_MN1 (XI1_I1206_I152_XG_n1 I1_I1206_G23_20n I1_I1206_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I154_XG_MN2 (XI1_I1206_I154_XG_n1 I1_I1206_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I154_XG_MN0 (I1_I1206_G29_22 I1_I1206_P29_26n XI1_I1206_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I154_XG_MN1 (XI1_I1206_I154_XG_n1 I1_I1206_G25_22n I1_I1206_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I201_XG_MN2 (XI1_I1206_I201_XG_n1 I1_I1206_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I201_XG_MN0 (I1_c14_m I1_I1206_P30_15n XI1_I1206_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I201_XG_MN1 (XI1_I1206_I201_XG_n1 I1_I1206_G14_0n I1_c14_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I153_XG_MN2 (XI1_I1206_I153_XG_n1 I1_I1206_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I153_XG_MN0 (I1_I1206_G28_21 I1_I1206_P28_25n XI1_I1206_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I153_XG_MN1 (XI1_I1206_I153_XG_n1 I1_I1206_G24_21n I1_I1206_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I155_XG_MN2 (XI1_I838_I155_XG_n1 I1_I838_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I155_XG_MN0 (I1_I838_G30_23 I1_I838_P30_27n XI1_I838_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I155_XG_MN1 (XI1_I838_I155_XG_n1 I1_I838_G26_23n I1_I838_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I151_XG_MN2 (XI1_I838_I151_XG_n1 I1_I838_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I151_XG_MN0 (I1_I838_G26_19 I1_I838_P26_23n XI1_I838_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I151_XG_MN1 (XI1_I838_I151_XG_n1 I1_I838_G22_19n I1_I838_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I84_XG_MN2 (XI1_I838_I84_XG_n1 I1_I838_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I84_XG_MN0 (I1_I838_G18_17 I1_I838_pn18 XI1_I838_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I84_XG_MN1 (XI1_I838_I84_XG_n1 I1_I838_gn17 I1_I838_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I80_XG_MN2 (XI1_I838_I80_XG_n1 I1_I838_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I80_XG_MN0 (I1_I838_G14_13 I1_I838_pn14 XI1_I838_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I80_XG_MN1 (XI1_I838_I80_XG_n1 I1_I838_gn13 I1_I838_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I79_XG_MN2 (XI1_I838_I79_XG_n1 I1_I838_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I79_XG_MN0 (I1_I838_G13_12 I1_I838_pn13 XI1_I838_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I79_XG_MN1 (XI1_I838_I79_XG_n1 I1_I838_gn12 I1_I838_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I142_XG_MN2 (XI1_I792_I142_XG_n1 I1_I792_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I142_XG_MN0 (I1_I792_G17_10 I1_I792_P17_14n XI1_I792_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I142_XG_MN1 (XI1_I792_I142_XG_n1 I1_I792_G13_10n I1_I792_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I136_XG_MN2 (XI1_I792_I136_XG_n1 I1_I792_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I136_XG_MN0 (I1_I792_G11_4 I1_I792_P11_8n XI1_I792_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I136_XG_MN1 (XI1_I792_I136_XG_n1 I1_I792_G7_4n I1_I792_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I140_XG_MN2 (XI1_I792_I140_XG_n1 I1_I792_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I140_XG_MN0 (I1_I792_G15_8 I1_I792_P15_12n XI1_I792_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I140_XG_MN1 (XI1_I792_I140_XG_n1 I1_I792_G11_8n I1_I792_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I188_XG_MN2 (XI1_I792_I188_XG_n1 I1_I792_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I188_XG_MN0 (I1_I792_G20_0 I1_I792_P20_5n XI1_I792_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I188_XG_MN1 (XI1_I792_I188_XG_n1 I1_I792_G4_0n I1_I792_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I143_XG_MN2 (XI1_I792_I143_XG_n1 I1_I792_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I143_XG_MN0 (I1_I792_G18_11 I1_I792_P18_15n XI1_I792_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I143_XG_MN1 (XI1_I792_I143_XG_n1 I1_I792_G14_11n I1_I792_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I145_XG_MN2 (XI1_I792_I145_XG_n1 I1_I792_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I145_XG_MN0 (I1_I792_G20_13 I1_I792_P20_17n XI1_I792_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I145_XG_MN1 (XI1_I792_I145_XG_n1 I1_I792_G16_13n I1_I792_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I85_XG_MN2 (XI1_I792_I85_XG_n1 I1_I792_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I85_XG_MN0 (I1_I792_G19_18 I1_I792_pn19 XI1_I792_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I85_XG_MN1 (XI1_I792_I85_XG_n1 I1_I792_gn18 I1_I792_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I86_XG_MN2 (XI1_I792_I86_XG_n1 I1_I792_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I86_XG_MN0 (I1_I792_G20_19 I1_I792_pn20 XI1_I792_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I86_XG_MN1 (XI1_I792_I86_XG_n1 I1_I792_gn19 I1_I792_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I192_XG_MN2 (XI1_I746_I192_XG_n1 I1_I746_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I192_XG_MN0 (I1_I746_G22_0 I1_I746_P22_7n XI1_I746_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I192_XG_MN1 (XI1_I746_I192_XG_n1 I1_I746_G6_0n I1_I746_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I201_XG_MN2 (XI1_I746_I201_XG_n1 I1_I746_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I201_XG_MN0 (I1_c4_m I1_I746_P30_15n XI1_I746_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I201_XG_MN1 (XI1_I746_I201_XG_n1 I1_I746_G14_0n I1_c4_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I155_XG_MN2 (XI1_I746_I155_XG_n1 I1_I746_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I155_XG_MN0 (I1_I746_G30_23 I1_I746_P30_27n XI1_I746_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I155_XG_MN1 (XI1_I746_I155_XG_n1 I1_I746_G26_23n I1_I746_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I92_XG_MN2 (XI1_I746_I92_XG_n1 I1_I746_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I92_XG_MN0 (I1_I746_G26_25 I1_I746_pn26 XI1_I746_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I92_XG_MN1 (XI1_I746_I92_XG_n1 I1_I746_gn25 I1_I746_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I93_XG_MN2 (XI1_I746_I93_XG_n1 I1_I746_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I93_XG_MN0 (I1_I746_G27_26 I1_I746_pn27 XI1_I746_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I93_XG_MN1 (XI1_I746_I93_XG_n1 I1_I746_gn26 I1_I746_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I87_XG_MN2 (XI1_I1344_I87_XG_n1 I1_I1344_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I87_XG_MN0 (I1_I1344_G21_20 I1_I1344_pn21 XI1_I1344_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I87_XG_MN1 (XI1_I1344_I87_XG_n1 I1_I1344_gn20 I1_I1344_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I196_XG_MN2 (XI1_I1344_I196_XG_n1 I1_I1344_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I196_XG_MN0 (I1_I1344_G25_0 I1_I1344_P25_10n XI1_I1344_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I196_XG_MN1 (XI1_I1344_I196_XG_n1 I1_I1344_G9_0n I1_I1344_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I190_XG_MN2 (XI1_I1344_I190_XG_n1 I1_I1344_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I190_XG_MN0 (I1_I1344_G21_0 I1_I1344_P21_6n XI1_I1344_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I190_XG_MN1 (XI1_I1344_I190_XG_n1 I1_I1344_G5_0n I1_I1344_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I142_XG_MN2 (XI1_I1344_I142_XG_n1 I1_I1344_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I142_XG_MN0 (I1_I1344_G17_10 I1_I1344_P17_14n XI1_I1344_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I142_XG_MN1 (XI1_I1344_I142_XG_n1 I1_I1344_G13_10n I1_I1344_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I138_XG_MN2 (XI1_I1344_I138_XG_n1 I1_I1344_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I138_XG_MN0 (I1_I1344_G13_6 I1_I1344_P13_10n XI1_I1344_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I138_XG_MN1 (XI1_I1344_I138_XG_n1 I1_I1344_G9_6n I1_I1344_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I190_XG_MN2 (XI1_I1298_I190_XG_n1 I1_I1298_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I190_XG_MN0 (I1_I1298_G21_0 I1_I1298_P21_6n XI1_I1298_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I190_XG_MN1 (XI1_I1298_I190_XG_n1 I1_I1298_G5_0n I1_I1298_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I146_XG_MN2 (XI1_I1298_I146_XG_n1 I1_I1298_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I146_XG_MN0 (I1_I1298_G21_14 I1_I1298_P21_18n XI1_I1298_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I146_XG_MN1 (XI1_I1298_I146_XG_n1 I1_I1298_G17_14n I1_I1298_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I197_XG_MN2 (XI1_I1298_I197_XG_n1 I1_I1298_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I197_XG_MN0 (I1_I1298_G26_0 I1_I1298_P26_11n XI1_I1298_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I197_XG_MN1 (XI1_I1298_I197_XG_n1 I1_I1298_G10_0n I1_I1298_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I192_XG_MN2 (XI1_I1298_I192_XG_n1 I1_I1298_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I192_XG_MN0 (I1_I1298_G22_0 I1_I1298_P22_7n XI1_I1298_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I192_XG_MN1 (XI1_I1298_I192_XG_n1 I1_I1298_G6_0n I1_I1298_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I147_XG_MN2 (XI1_I1298_I147_XG_n1 I1_I1298_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I147_XG_MN0 (I1_I1298_G22_15 I1_I1298_P22_19n XI1_I1298_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I147_XG_MN1 (XI1_I1298_I147_XG_n1 I1_I1298_G18_15n I1_I1298_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I151_XG_MN2 (XI1_I1298_I151_XG_n1 I1_I1298_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I151_XG_MN0 (I1_I1298_G26_19 I1_I1298_P26_23n XI1_I1298_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I151_XG_MN1 (XI1_I1298_I151_XG_n1 I1_I1298_G22_19n I1_I1298_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I87_XG_MN2 (XI1_I1298_I87_XG_n1 I1_I1298_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I87_XG_MN0 (I1_I1298_G21_20 I1_I1298_pn21 XI1_I1298_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I87_XG_MN1 (XI1_I1298_I87_XG_n1 I1_I1298_gn20 I1_I1298_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I192_XG_MN2 (XI1_I1252_I192_XG_n1 I1_I1252_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I192_XG_MN0 (I1_I1252_G22_0 I1_I1252_P22_7n XI1_I1252_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I192_XG_MN1 (XI1_I1252_I192_XG_n1 I1_I1252_G6_0n I1_I1252_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I147_XG_MN2 (XI1_I1252_I147_XG_n1 I1_I1252_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I147_XG_MN0 (I1_I1252_G22_15 I1_I1252_P22_19n XI1_I1252_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I147_XG_MN1 (XI1_I1252_I147_XG_n1 I1_I1252_G18_15n I1_I1252_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I198_XG_MN2 (XI1_I1252_I198_XG_n1 I1_I1252_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I198_XG_MN0 (I1_I1252_G27_0 I1_I1252_P27_12n XI1_I1252_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I198_XG_MN1 (XI1_I1252_I198_XG_n1 I1_I1252_G11_0n I1_I1252_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I150_XG_MN2 (XI1_I1252_I150_XG_n1 I1_I1252_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I150_XG_MN0 (I1_I1252_G25_18 I1_I1252_P25_22n XI1_I1252_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I150_XG_MN1 (XI1_I1252_I150_XG_n1 I1_I1252_G21_18n I1_I1252_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I87_XG_MN2 (XI1_I1252_I87_XG_n1 I1_I1252_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I87_XG_MN0 (I1_I1252_G21_20 I1_I1252_pn21 XI1_I1252_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I87_XG_MN1 (XI1_I1252_I87_XG_n1 I1_I1252_gn20 I1_I1252_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I88_XG_MN2 (XI1_I1252_I88_XG_n1 I1_I1252_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I88_XG_MN0 (I1_I1252_G22_21 I1_I1252_pn22 XI1_I1252_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I88_XG_MN1 (XI1_I1252_I88_XG_n1 I1_I1252_gn21 I1_I1252_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I87_XG_MN2 (XI1_I1206_I87_XG_n1 I1_I1206_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I87_XG_MN0 (I1_I1206_G21_20 I1_I1206_pn21 XI1_I1206_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I87_XG_MN1 (XI1_I1206_I87_XG_n1 I1_I1206_gn20 I1_I1206_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I88_XG_MN2 (XI1_I1206_I88_XG_n1 I1_I1206_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I88_XG_MN0 (I1_I1206_G22_21 I1_I1206_pn22 XI1_I1206_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I88_XG_MN1 (XI1_I1206_I88_XG_n1 I1_I1206_gn21 I1_I1206_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I198_XG_MN2 (XI1_I1206_I198_XG_n1 I1_I1206_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I198_XG_MN0 (I1_I1206_G27_0 I1_I1206_P27_12n XI1_I1206_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I198_XG_MN1 (XI1_I1206_I198_XG_n1 I1_I1206_G11_0n I1_I1206_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I200_XG_MN2 (XI1_I1206_I200_XG_n1 I1_I1206_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I200_XG_MN0 (I1_I1206_G29_0 I1_I1206_P29_14n XI1_I1206_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I200_XG_MN1 (XI1_I1206_I200_XG_n1 I1_I1206_G13_0n I1_I1206_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I147_XG_MN2 (XI1_I1206_I147_XG_n1 I1_I1206_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I147_XG_MN0 (I1_I1206_G22_15 I1_I1206_P22_19n XI1_I1206_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I147_XG_MN1 (XI1_I1206_I147_XG_n1 I1_I1206_G18_15n I1_I1206_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I151_XG_MN2 (XI1_I1206_I151_XG_n1 I1_I1206_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I151_XG_MN0 (I1_I1206_G26_19 I1_I1206_P26_23n XI1_I1206_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I151_XG_MN1 (XI1_I1206_I151_XG_n1 I1_I1206_G22_19n I1_I1206_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I199_XG_MN2 (XI1_I1206_I199_XG_n1 I1_I1206_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I199_XG_MN0 (I1_I1206_G28_0 I1_I1206_P28_13n XI1_I1206_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I199_XG_MN1 (XI1_I1206_I199_XG_n1 I1_I1206_G12_0n I1_I1206_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I153_XG_MN2 (XI1_I838_I153_XG_n1 I1_I838_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I153_XG_MN0 (I1_I838_G28_21 I1_I838_P28_25n XI1_I838_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I153_XG_MN1 (XI1_I838_I153_XG_n1 I1_I838_G24_21n I1_I838_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I147_XG_MN2 (XI1_I838_I147_XG_n1 I1_I838_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I147_XG_MN0 (I1_I838_G22_15 I1_I838_P22_19n XI1_I838_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I147_XG_MN1 (XI1_I838_I147_XG_n1 I1_I838_G18_15n I1_I838_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I149_XG_MN2 (XI1_I838_I149_XG_n1 I1_I838_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I149_XG_MN0 (I1_I838_G24_17 I1_I838_P24_21n XI1_I838_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I149_XG_MN1 (XI1_I838_I149_XG_n1 I1_I838_G20_17n I1_I838_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I145_XG_MN2 (XI1_I838_I145_XG_n1 I1_I838_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I145_XG_MN0 (I1_I838_G20_13 I1_I838_P20_17n XI1_I838_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I145_XG_MN1 (XI1_I838_I145_XG_n1 I1_I838_G16_13n I1_I838_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I143_XG_MN2 (XI1_I838_I143_XG_n1 I1_I838_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I143_XG_MN0 (I1_I838_G18_11 I1_I838_P18_15n XI1_I838_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I143_XG_MN1 (XI1_I838_I143_XG_n1 I1_I838_G14_11n I1_I838_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I139_XG_MN2 (XI1_I838_I139_XG_n1 I1_I838_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I139_XG_MN0 (I1_I838_G14_7 I1_I838_P14_11n XI1_I838_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I139_XG_MN1 (XI1_I838_I139_XG_n1 I1_I838_G10_7n I1_I838_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I78_XG_MN2 (XI1_I838_I78_XG_n1 I1_I838_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I78_XG_MN0 (I1_I838_G12_11 I1_I838_pn12 XI1_I838_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I78_XG_MN1 (XI1_I838_I78_XG_n1 I1_I838_gn11 I1_I838_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I77_XG_MN2 (XI1_I838_I77_XG_n1 I1_I838_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I77_XG_MN0 (I1_I838_G11_10 I1_I838_pn11 XI1_I838_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I77_XG_MN1 (XI1_I838_I77_XG_n1 I1_I838_gn10 I1_I838_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I76_XG_MN2 (XI1_I838_I76_XG_n1 I1_I838_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I76_XG_MN0 (I1_I838_G10_9 I1_I838_pn10 XI1_I838_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I76_XG_MN1 (XI1_I838_I76_XG_n1 I1_I838_gn9 I1_I838_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I75_XG_MN2 (XI1_I838_I75_XG_n1 I1_I838_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I75_XG_MN0 (I1_I838_G9_8 I1_I838_pn9 XI1_I838_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I75_XG_MN1 (XI1_I838_I75_XG_n1 I1_I838_gn8 I1_I838_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I138_XG_MN2 (XI1_I792_I138_XG_n1 I1_I792_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I138_XG_MN0 (I1_I792_G13_6 I1_I792_P13_10n XI1_I792_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I138_XG_MN1 (XI1_I792_I138_XG_n1 I1_I792_G9_6n I1_I792_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I132_XG_MN2 (XI1_I792_I132_XG_n1 I1_I792_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I132_XG_MN0 (I1_I792_G7_0 I1_I792_P7_4n XI1_I792_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I132_XG_MN1 (XI1_I792_I132_XG_n1 I1_I792_G3_0n I1_I792_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I185_XG_MN2 (XI1_I792_I185_XG_n1 I1_I792_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I185_XG_MN0 (I1_I792_G18_0 I1_I792_P18_3n XI1_I792_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I185_XG_MN1 (XI1_I792_I185_XG_n1 I1_I792_G2_0n I1_I792_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I195_XG_MN2 (XI1_I792_I195_XG_n1 I1_I792_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I195_XG_MN0 (I1_I792_G24_0 I1_I792_P24_9n XI1_I792_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I195_XG_MN1 (XI1_I792_I195_XG_n1 I1_I792_G8_0n I1_I792_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I82_XG_MN2 (XI1_I792_I82_XG_n1 I1_I792_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I82_XG_MN0 (I1_I792_G16_15 I1_I792_pn16 XI1_I792_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I82_XG_MN1 (XI1_I792_I82_XG_n1 I1_I792_gn15 I1_I792_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I83_XG_MN2 (XI1_I792_I83_XG_n1 I1_I792_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I83_XG_MN0 (I1_I792_G17_16 I1_I792_pn17 XI1_I792_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I83_XG_MN1 (XI1_I792_I83_XG_n1 I1_I792_gn16 I1_I792_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I84_XG_MN2 (XI1_I792_I84_XG_n1 I1_I792_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I84_XG_MN0 (I1_I792_G18_17 I1_I792_pn18 XI1_I792_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I84_XG_MN1 (XI1_I792_I84_XG_n1 I1_I792_gn17 I1_I792_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I199_XG_MN2 (XI1_I746_I199_XG_n1 I1_I746_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I199_XG_MN0 (I1_I746_G28_0 I1_I746_P28_13n XI1_I746_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I199_XG_MN1 (XI1_I746_I199_XG_n1 I1_I746_G12_0n I1_I746_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I197_XG_MN2 (XI1_I746_I197_XG_n1 I1_I746_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I197_XG_MN0 (I1_I746_G26_0 I1_I746_P26_11n XI1_I746_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I197_XG_MN1 (XI1_I746_I197_XG_n1 I1_I746_G10_0n I1_I746_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I147_XG_MN2 (XI1_I746_I147_XG_n1 I1_I746_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I147_XG_MN0 (I1_I746_G22_15 I1_I746_P22_19n XI1_I746_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I147_XG_MN1 (XI1_I746_I147_XG_n1 I1_I746_G18_15n I1_I746_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I151_XG_MN2 (XI1_I746_I151_XG_n1 I1_I746_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I151_XG_MN0 (I1_I746_G26_19 I1_I746_P26_23n XI1_I746_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I151_XG_MN1 (XI1_I746_I151_XG_n1 I1_I746_G22_19n I1_I746_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I153_XG_MN2 (XI1_I746_I153_XG_n1 I1_I746_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I153_XG_MN0 (I1_I746_G28_21 I1_I746_P28_25n XI1_I746_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I153_XG_MN1 (XI1_I746_I153_XG_n1 I1_I746_G24_21n I1_I746_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I94_XG_MN2 (XI1_I746_I94_XG_n1 I1_I746_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I94_XG_MN0 (I1_I746_G28_27 I1_I746_pn28 XI1_I746_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I94_XG_MN1 (XI1_I746_I94_XG_n1 I1_I746_gn27 I1_I746_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I155_XG_MN2 (XI1_I1344_I155_XG_n1 I1_I1344_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I155_XG_MN0 (I1_I1344_G30_23 I1_I1344_P30_27n XI1_I1344_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I155_XG_MN1 (XI1_I1344_I155_XG_n1 I1_I1344_G26_23n I1_I1344_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I88_XG_MN2 (XI1_I1344_I88_XG_n1 I1_I1344_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I88_XG_MN0 (I1_I1344_G22_21 I1_I1344_pn22 XI1_I1344_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I88_XG_MN1 (XI1_I1344_I88_XG_n1 I1_I1344_gn21 I1_I1344_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I85_XG_MN2 (XI1_I1344_I85_XG_n1 I1_I1344_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I85_XG_MN0 (I1_I1344_G19_18 I1_I1344_pn19 XI1_I1344_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I85_XG_MN1 (XI1_I1344_I85_XG_n1 I1_I1344_gn18 I1_I1344_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I84_XG_MN2 (XI1_I1344_I84_XG_n1 I1_I1344_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I84_XG_MN0 (I1_I1344_G18_17 I1_I1344_pn18 XI1_I1344_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I84_XG_MN1 (XI1_I1344_I84_XG_n1 I1_I1344_gn17 I1_I1344_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I83_XG_MN2 (XI1_I1344_I83_XG_n1 I1_I1344_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I83_XG_MN0 (I1_I1344_G17_16 I1_I1344_pn17 XI1_I1344_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I83_XG_MN1 (XI1_I1344_I83_XG_n1 I1_I1344_gn16 I1_I1344_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I134_XG_MN2 (XI1_I1344_I134_XG_n1 I1_I1344_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I134_XG_MN0 (I1_I1344_G9_2 I1_I1344_P9_6n XI1_I1344_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I134_XG_MN1 (XI1_I1344_I134_XG_n1 I1_I1344_G5_2n I1_I1344_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I186_XG_MN2 (XI1_I1298_I186_XG_n1 I1_I1298_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I186_XG_MN0 (I1_I1298_G19_0 I1_I1298_P19_4n XI1_I1298_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I186_XG_MN1 (XI1_I1298_I186_XG_n1 I1_I1298_G3_0n I1_I1298_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I144_XG_MN2 (XI1_I1298_I144_XG_n1 I1_I1298_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I144_XG_MN0 (I1_I1298_G19_12 I1_I1298_P19_16n XI1_I1298_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I144_XG_MN1 (XI1_I1298_I144_XG_n1 I1_I1298_G15_12n I1_I1298_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I188_XG_MN2 (XI1_I1298_I188_XG_n1 I1_I1298_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I188_XG_MN0 (I1_I1298_G20_0 I1_I1298_P20_5n XI1_I1298_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I188_XG_MN1 (XI1_I1298_I188_XG_n1 I1_I1298_G4_0n I1_I1298_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I149_XG_MN2 (XI1_I1298_I149_XG_n1 I1_I1298_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I149_XG_MN0 (I1_I1298_G24_17 I1_I1298_P24_21n XI1_I1298_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I149_XG_MN1 (XI1_I1298_I149_XG_n1 I1_I1298_G20_17n I1_I1298_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I85_XG_MN2 (XI1_I1298_I85_XG_n1 I1_I1298_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I85_XG_MN0 (I1_I1298_G19_18 I1_I1298_pn19 XI1_I1298_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I85_XG_MN1 (XI1_I1298_I85_XG_n1 I1_I1298_gn18 I1_I1298_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I86_XG_MN2 (XI1_I1298_I86_XG_n1 I1_I1298_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I86_XG_MN0 (I1_I1298_G20_19 I1_I1298_pn20 XI1_I1298_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I86_XG_MN1 (XI1_I1298_I86_XG_n1 I1_I1298_gn19 I1_I1298_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I195_XG_MN2 (XI1_I1252_I195_XG_n1 I1_I1252_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I195_XG_MN0 (I1_I1252_G24_0 I1_I1252_P24_9n XI1_I1252_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I195_XG_MN1 (XI1_I1252_I195_XG_n1 I1_I1252_G8_0n I1_I1252_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I149_XG_MN2 (XI1_I1252_I149_XG_n1 I1_I1252_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I149_XG_MN0 (I1_I1252_G24_17 I1_I1252_P24_21n XI1_I1252_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I149_XG_MN1 (XI1_I1252_I149_XG_n1 I1_I1252_G20_17n I1_I1252_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I190_XG_MN2 (XI1_I1252_I190_XG_n1 I1_I1252_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I190_XG_MN0 (I1_I1252_G21_0 I1_I1252_P21_6n XI1_I1252_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I190_XG_MN1 (XI1_I1252_I190_XG_n1 I1_I1252_G5_0n I1_I1252_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I144_XG_MN2 (XI1_I1252_I144_XG_n1 I1_I1252_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I144_XG_MN0 (I1_I1252_G19_12 I1_I1252_P19_16n XI1_I1252_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I144_XG_MN1 (XI1_I1252_I144_XG_n1 I1_I1252_G15_12n I1_I1252_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I146_XG_MN2 (XI1_I1252_I146_XG_n1 I1_I1252_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I146_XG_MN0 (I1_I1252_G21_14 I1_I1252_P21_18n XI1_I1252_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I146_XG_MN1 (XI1_I1252_I146_XG_n1 I1_I1252_G17_14n I1_I1252_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I85_XG_MN2 (XI1_I1252_I85_XG_n1 I1_I1252_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I85_XG_MN0 (I1_I1252_G19_18 I1_I1252_pn19 XI1_I1252_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I85_XG_MN1 (XI1_I1252_I85_XG_n1 I1_I1252_gn18 I1_I1252_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I86_XG_MN2 (XI1_I1252_I86_XG_n1 I1_I1252_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I86_XG_MN0 (I1_I1252_G20_19 I1_I1252_pn20 XI1_I1252_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I86_XG_MN1 (XI1_I1252_I86_XG_n1 I1_I1252_gn19 I1_I1252_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I86_XG_MN2 (XI1_I1206_I86_XG_n1 I1_I1206_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I86_XG_MN0 (I1_I1206_G20_19 I1_I1206_pn20 XI1_I1206_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I86_XG_MN1 (XI1_I1206_I86_XG_n1 I1_I1206_gn19 I1_I1206_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I148_XG_MN2 (XI1_I1206_I148_XG_n1 I1_I1206_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I148_XG_MN0 (I1_I1206_G23_16 I1_I1206_P23_20n XI1_I1206_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I148_XG_MN1 (XI1_I1206_I148_XG_n1 I1_I1206_G19_16n I1_I1206_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I194_XG_MN2 (XI1_I1206_I194_XG_n1 I1_I1206_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I194_XG_MN0 (I1_I1206_G23_0 I1_I1206_P23_8n XI1_I1206_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I194_XG_MN1 (XI1_I1206_I194_XG_n1 I1_I1206_G7_0n I1_I1206_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I150_XG_MN2 (XI1_I1206_I150_XG_n1 I1_I1206_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I150_XG_MN0 (I1_I1206_G25_18 I1_I1206_P25_22n XI1_I1206_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I150_XG_MN1 (XI1_I1206_I150_XG_n1 I1_I1206_G21_18n I1_I1206_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I192_XG_MN2 (XI1_I1206_I192_XG_n1 I1_I1206_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I192_XG_MN0 (I1_I1206_G22_0 I1_I1206_P22_7n XI1_I1206_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I192_XG_MN1 (XI1_I1206_I192_XG_n1 I1_I1206_G6_0n I1_I1206_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I197_XG_MN2 (XI1_I1206_I197_XG_n1 I1_I1206_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I197_XG_MN0 (I1_I1206_G26_0 I1_I1206_P26_11n XI1_I1206_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I197_XG_MN1 (XI1_I1206_I197_XG_n1 I1_I1206_G10_0n I1_I1206_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I145_XG_MN2 (XI1_I1206_I145_XG_n1 I1_I1206_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I145_XG_MN0 (I1_I1206_G20_13 I1_I1206_P20_17n XI1_I1206_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I145_XG_MN1 (XI1_I1206_I145_XG_n1 I1_I1206_G16_13n I1_I1206_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I149_XG_MN2 (XI1_I1206_I149_XG_n1 I1_I1206_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I149_XG_MN0 (I1_I1206_G24_17 I1_I1206_P24_21n XI1_I1206_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I149_XG_MN1 (XI1_I1206_I149_XG_n1 I1_I1206_G20_17n I1_I1206_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I201_XG_MN2 (XI1_I838_I201_XG_n1 I1_I838_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I201_XG_MN0 (I1_c6_m I1_I838_P30_15n XI1_I838_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I201_XG_MN1 (XI1_I838_I201_XG_n1 I1_I838_G14_0n I1_c6_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I199_XG_MN2 (XI1_I838_I199_XG_n1 I1_I838_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I199_XG_MN0 (I1_I838_G28_0 I1_I838_P28_13n XI1_I838_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I199_XG_MN1 (XI1_I838_I199_XG_n1 I1_I838_G12_0n I1_I838_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I197_XG_MN2 (XI1_I838_I197_XG_n1 I1_I838_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I197_XG_MN0 (I1_I838_G26_0 I1_I838_P26_11n XI1_I838_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I197_XG_MN1 (XI1_I838_I197_XG_n1 I1_I838_G10_0n I1_I838_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I192_XG_MN2 (XI1_I838_I192_XG_n1 I1_I838_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I192_XG_MN0 (I1_I838_G22_0 I1_I838_P22_7n XI1_I838_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I192_XG_MN1 (XI1_I838_I192_XG_n1 I1_I838_G6_0n I1_I838_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I195_XG_MN2 (XI1_I838_I195_XG_n1 I1_I838_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I195_XG_MN0 (I1_I838_G24_0 I1_I838_P24_9n XI1_I838_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I195_XG_MN1 (XI1_I838_I195_XG_n1 I1_I838_G8_0n I1_I838_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I141_XG_MN2 (XI1_I838_I141_XG_n1 I1_I838_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I141_XG_MN0 (I1_I838_G16_9 I1_I838_P16_13n XI1_I838_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I141_XG_MN1 (XI1_I838_I141_XG_n1 I1_I838_G12_9n I1_I838_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I185_XG_MN2 (XI1_I838_I185_XG_n1 I1_I838_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I185_XG_MN0 (I1_I838_G18_0 I1_I838_P18_3n XI1_I838_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I185_XG_MN1 (XI1_I838_I185_XG_n1 I1_I838_G2_0n I1_I838_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I135_XG_MN2 (XI1_I838_I135_XG_n1 I1_I838_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I135_XG_MN0 (I1_I838_G10_3 I1_I838_P10_7n XI1_I838_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I135_XG_MN1 (XI1_I838_I135_XG_n1 I1_I838_G6_3n I1_I838_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I74_XG_MN2 (XI1_I838_I74_XG_n1 I1_I838_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I74_XG_MN0 (I1_I838_G8_7 I1_I838_pn8 XI1_I838_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I74_XG_MN1 (XI1_I838_I74_XG_n1 I1_I838_gn7 I1_I838_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I184_XG_MN2 (XI1_I792_I184_XG_n1 I1_I792_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I184_XG_MN0 (I1_I792_G17_0 I1_I792_P17_2n XI1_I792_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I184_XG_MN1 (XI1_I792_I184_XG_n1 I1_I792_G1_0n I1_I792_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I134_XG_MN2 (XI1_I792_I134_XG_n1 I1_I792_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I134_XG_MN0 (I1_I792_G9_2 I1_I792_P9_6n XI1_I792_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I134_XG_MN1 (XI1_I792_I134_XG_n1 I1_I792_G5_2n I1_I792_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I131_XG_MN2 (XI1_I792_I131_XG_n1 I1_I792_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I131_XG_MN0 (I1_I792_G6_0 I1_I792_P6_3n XI1_I792_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I131_XG_MN1 (XI1_I792_I131_XG_n1 I1_I792_G2_0n I1_I792_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I135_XG_MN2 (XI1_I792_I135_XG_n1 I1_I792_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I135_XG_MN0 (I1_I792_G10_3 I1_I792_P10_7n XI1_I792_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I135_XG_MN1 (XI1_I792_I135_XG_n1 I1_I792_G6_3n I1_I792_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I137_XG_MN2 (XI1_I792_I137_XG_n1 I1_I792_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I137_XG_MN0 (I1_I792_G12_5 I1_I792_P12_9n XI1_I792_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I137_XG_MN1 (XI1_I792_I137_XG_n1 I1_I792_G8_5n I1_I792_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I141_XG_MN2 (XI1_I792_I141_XG_n1 I1_I792_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I141_XG_MN0 (I1_I792_G16_9 I1_I792_P16_13n XI1_I792_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I141_XG_MN1 (XI1_I792_I141_XG_n1 I1_I792_G12_9n I1_I792_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I139_XG_MN2 (XI1_I792_I139_XG_n1 I1_I792_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I139_XG_MN0 (I1_I792_G14_7 I1_I792_P14_11n XI1_I792_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I139_XG_MN1 (XI1_I792_I139_XG_n1 I1_I792_G10_7n I1_I792_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I81_XG_MN2 (XI1_I792_I81_XG_n1 I1_I792_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I81_XG_MN0 (I1_I792_G15_14 I1_I792_pn15 XI1_I792_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I81_XG_MN1 (XI1_I792_I81_XG_n1 I1_I792_gn14 I1_I792_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I185_XG_MN2 (XI1_I746_I185_XG_n1 I1_I746_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I185_XG_MN0 (I1_I746_G18_0 I1_I746_P18_3n XI1_I746_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I185_XG_MN1 (XI1_I746_I185_XG_n1 I1_I746_G2_0n I1_I746_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I195_XG_MN2 (XI1_I746_I195_XG_n1 I1_I746_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I195_XG_MN0 (I1_I746_G24_0 I1_I746_P24_9n XI1_I746_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I195_XG_MN1 (XI1_I746_I195_XG_n1 I1_I746_G8_0n I1_I746_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I188_XG_MN2 (XI1_I746_I188_XG_n1 I1_I746_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I188_XG_MN0 (I1_I746_G20_0 I1_I746_P20_5n XI1_I746_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I188_XG_MN1 (XI1_I746_I188_XG_n1 I1_I746_G4_0n I1_I746_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I139_XG_MN2 (XI1_I746_I139_XG_n1 I1_I746_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I139_XG_MN0 (I1_I746_G14_7 I1_I746_P14_11n XI1_I746_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I139_XG_MN1 (XI1_I746_I139_XG_n1 I1_I746_G10_7n I1_I746_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I145_XG_MN2 (XI1_I746_I145_XG_n1 I1_I746_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I145_XG_MN0 (I1_I746_G20_13 I1_I746_P20_17n XI1_I746_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I145_XG_MN1 (XI1_I746_I145_XG_n1 I1_I746_G16_13n I1_I746_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I143_XG_MN2 (XI1_I746_I143_XG_n1 I1_I746_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I143_XG_MN0 (I1_I746_G18_11 I1_I746_P18_15n XI1_I746_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I143_XG_MN1 (XI1_I746_I143_XG_n1 I1_I746_G14_11n I1_I746_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I149_XG_MN2 (XI1_I746_I149_XG_n1 I1_I746_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I149_XG_MN0 (I1_I746_G24_17 I1_I746_P24_21n XI1_I746_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I149_XG_MN1 (XI1_I746_I149_XG_n1 I1_I746_G20_17n I1_I746_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I90_XG_MN2 (XI1_I746_I90_XG_n1 I1_I746_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I90_XG_MN0 (I1_I746_G24_23 I1_I746_pn24 XI1_I746_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I90_XG_MN1 (XI1_I746_I90_XG_n1 I1_I746_gn23 I1_I746_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I91_XG_MN2 (XI1_I746_I91_XG_n1 I1_I746_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I91_XG_MN0 (I1_I746_G25_24 I1_I746_pn25 XI1_I746_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I91_XG_MN1 (XI1_I746_I91_XG_n1 I1_I746_gn24 I1_I746_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I95_XG_MN2 (XI1_I746_I95_XG_n1 I1_I746_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I95_XG_MN0 (I1_I746_G29_28 I1_I746_pn29 XI1_I746_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I95_XG_MN1 (XI1_I746_I95_XG_n1 I1_I746_gn28 I1_I746_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I96_XG_MN2 (XI1_I746_I96_XG_n1 I1_I746_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I96_XG_MN0 (I1_I746_G30_29 I1_I746_pn30 XI1_I746_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I96_XG_MN1 (XI1_I746_I96_XG_n1 I1_I746_gn29 I1_I746_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I147_XG_MN2 (XI1_I1344_I147_XG_n1 I1_I1344_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I147_XG_MN0 (I1_I1344_G22_15 I1_I1344_P22_19n XI1_I1344_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I147_XG_MN1 (XI1_I1344_I147_XG_n1 I1_I1344_G18_15n I1_I1344_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I86_XG_MN2 (XI1_I1344_I86_XG_n1 I1_I1344_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I86_XG_MN0 (I1_I1344_G20_19 I1_I1344_pn20 XI1_I1344_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I86_XG_MN1 (XI1_I1344_I86_XG_n1 I1_I1344_gn19 I1_I1344_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I82_XG_MN2 (XI1_I1344_I82_XG_n1 I1_I1344_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I82_XG_MN0 (I1_I1344_G16_15 I1_I1344_pn16 XI1_I1344_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I82_XG_MN1 (XI1_I1344_I82_XG_n1 I1_I1344_gn15 I1_I1344_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I81_XG_MN2 (XI1_I1344_I81_XG_n1 I1_I1344_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I81_XG_MN0 (I1_I1344_G15_14 I1_I1344_pn15 XI1_I1344_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I81_XG_MN1 (XI1_I1344_I81_XG_n1 I1_I1344_gn14 I1_I1344_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I184_XG_MN2 (XI1_I1344_I184_XG_n1 I1_I1344_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I184_XG_MN0 (I1_I1344_G17_0 I1_I1344_P17_2n XI1_I1344_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I184_XG_MN1 (XI1_I1344_I184_XG_n1 I1_I1344_G1_0n I1_I1344_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I130_XG_MN2 (XI1_I1344_I130_XG_n1 I1_I1344_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I130_XG_MN0 (I1_I1344_G5_0 I1_I1344_P5_2n XI1_I1344_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I130_XG_MN1 (XI1_I1344_I130_XG_n1 I1_I1344_G1_0n I1_I1344_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I140_XG_MN2 (XI1_I1298_I140_XG_n1 I1_I1298_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I140_XG_MN0 (I1_I1298_G15_8 I1_I1298_P15_12n XI1_I1298_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I140_XG_MN1 (XI1_I1298_I140_XG_n1 I1_I1298_G11_8n I1_I1298_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I142_XG_MN2 (XI1_I1298_I142_XG_n1 I1_I1298_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I142_XG_MN0 (I1_I1298_G17_10 I1_I1298_P17_14n XI1_I1298_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I142_XG_MN1 (XI1_I1298_I142_XG_n1 I1_I1298_G13_10n I1_I1298_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I143_XG_MN2 (XI1_I1298_I143_XG_n1 I1_I1298_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I143_XG_MN0 (I1_I1298_G18_11 I1_I1298_P18_15n XI1_I1298_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I143_XG_MN1 (XI1_I1298_I143_XG_n1 I1_I1298_G14_11n I1_I1298_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I145_XG_MN2 (XI1_I1298_I145_XG_n1 I1_I1298_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I145_XG_MN0 (I1_I1298_G20_13 I1_I1298_P20_17n XI1_I1298_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I145_XG_MN1 (XI1_I1298_I145_XG_n1 I1_I1298_G16_13n I1_I1298_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I84_XG_MN2 (XI1_I1298_I84_XG_n1 I1_I1298_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I84_XG_MN0 (I1_I1298_G18_17 I1_I1298_pn18 XI1_I1298_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I84_XG_MN1 (XI1_I1298_I84_XG_n1 I1_I1298_gn17 I1_I1298_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I83_XG_MN2 (XI1_I1298_I83_XG_n1 I1_I1298_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I83_XG_MN0 (I1_I1298_G17_16 I1_I1298_pn17 XI1_I1298_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I83_XG_MN1 (XI1_I1298_I83_XG_n1 I1_I1298_gn16 I1_I1298_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I188_XG_MN2 (XI1_I1252_I188_XG_n1 I1_I1252_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I188_XG_MN0 (I1_I1252_G20_0 I1_I1252_P20_5n XI1_I1252_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I188_XG_MN1 (XI1_I1252_I188_XG_n1 I1_I1252_G4_0n I1_I1252_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I143_XG_MN2 (XI1_I1252_I143_XG_n1 I1_I1252_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I143_XG_MN0 (I1_I1252_G18_11 I1_I1252_P18_15n XI1_I1252_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I143_XG_MN1 (XI1_I1252_I143_XG_n1 I1_I1252_G14_11n I1_I1252_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I145_XG_MN2 (XI1_I1252_I145_XG_n1 I1_I1252_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I145_XG_MN0 (I1_I1252_G20_13 I1_I1252_P20_17n XI1_I1252_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I145_XG_MN1 (XI1_I1252_I145_XG_n1 I1_I1252_G16_13n I1_I1252_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I196_XG_MN2 (XI1_I1252_I196_XG_n1 I1_I1252_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I196_XG_MN0 (I1_I1252_G25_0 I1_I1252_P25_10n XI1_I1252_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I196_XG_MN1 (XI1_I1252_I196_XG_n1 I1_I1252_G9_0n I1_I1252_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I84_XG_MN2 (XI1_I1252_I84_XG_n1 I1_I1252_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I84_XG_MN0 (I1_I1252_G18_17 I1_I1252_pn18 XI1_I1252_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I84_XG_MN1 (XI1_I1252_I84_XG_n1 I1_I1252_gn17 I1_I1252_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I83_XG_MN2 (XI1_I1252_I83_XG_n1 I1_I1252_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I83_XG_MN0 (I1_I1252_G17_16 I1_I1252_pn17 XI1_I1252_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I83_XG_MN1 (XI1_I1252_I83_XG_n1 I1_I1252_gn16 I1_I1252_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I84_XG_MN2 (XI1_I1206_I84_XG_n1 I1_I1206_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I84_XG_MN0 (I1_I1206_G18_17 I1_I1206_pn18 XI1_I1206_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I84_XG_MN1 (XI1_I1206_I84_XG_n1 I1_I1206_gn17 I1_I1206_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I85_XG_MN2 (XI1_I1206_I85_XG_n1 I1_I1206_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I85_XG_MN0 (I1_I1206_G19_18 I1_I1206_pn19 XI1_I1206_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I85_XG_MN1 (XI1_I1206_I85_XG_n1 I1_I1206_gn18 I1_I1206_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I202_XG_MN2 (XI1_I1206_I202_XG_n1 I1_I1206_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I202_XG_MN0 (I1_c14_o I1_I1206_P31_16n XI1_I1206_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I202_XG_MN1 (XI1_I1206_I202_XG_n1 I1_I1206_G15_0n I1_c14_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I196_XG_MN2 (XI1_I1206_I196_XG_n1 I1_I1206_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I196_XG_MN0 (I1_I1206_G25_0 I1_I1206_P25_10n XI1_I1206_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I196_XG_MN1 (XI1_I1206_I196_XG_n1 I1_I1206_G9_0n I1_I1206_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I143_XG_MN2 (XI1_I1206_I143_XG_n1 I1_I1206_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I143_XG_MN0 (I1_I1206_G18_11 I1_I1206_P18_15n XI1_I1206_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I143_XG_MN1 (XI1_I1206_I143_XG_n1 I1_I1206_G14_11n I1_I1206_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I195_XG_MN2 (XI1_I1206_I195_XG_n1 I1_I1206_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I195_XG_MN0 (I1_I1206_G24_0 I1_I1206_P24_9n XI1_I1206_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I195_XG_MN1 (XI1_I1206_I195_XG_n1 I1_I1206_G8_0n I1_I1206_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I188_XG_MN2 (XI1_I838_I188_XG_n1 I1_I838_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I188_XG_MN0 (I1_I838_G20_0 I1_I838_P20_5n XI1_I838_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I188_XG_MN1 (XI1_I838_I188_XG_n1 I1_I838_G4_0n I1_I838_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I137_XG_MN2 (XI1_I838_I137_XG_n1 I1_I838_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I137_XG_MN0 (I1_I838_G12_5 I1_I838_P12_9n XI1_I838_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I137_XG_MN1 (XI1_I838_I137_XG_n1 I1_I838_G8_5n I1_I838_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I133_XG_MN2 (XI1_I838_I133_XG_n1 I1_I838_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I133_XG_MN0 (I1_I838_G8_1 I1_I838_P8_5n XI1_I838_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I133_XG_MN1 (XI1_I838_I133_XG_n1 I1_I838_G4_1n I1_I838_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I131_XG_MN2 (XI1_I838_I131_XG_n1 I1_I838_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I131_XG_MN0 (I1_I838_G6_0 I1_I838_P6_3n XI1_I838_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I131_XG_MN1 (XI1_I838_I131_XG_n1 I1_I838_G2_0n I1_I838_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I73_XG_MN2 (XI1_I838_I73_XG_n1 I1_I838_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I73_XG_MN0 (I1_I838_G7_6 I1_I838_pn7 XI1_I838_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I73_XG_MN1 (XI1_I838_I73_XG_n1 I1_I838_gn6 I1_I838_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I130_XG_MN2 (XI1_I792_I130_XG_n1 I1_I792_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I130_XG_MN0 (I1_I792_G5_0 I1_I792_P5_2n XI1_I792_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I130_XG_MN1 (XI1_I792_I130_XG_n1 I1_I792_G1_0n I1_I792_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I183_XG_MN2 (XI1_I792_I183_XG_n1 I1_I792_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I183_XG_MN0 (I1_I792_G16_0 I1_I792_P16_1n XI1_I792_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I183_XG_MN1 (XI1_I792_I183_XG_n1 I1_I792_G0_0n I1_I792_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I133_XG_MN2 (XI1_I792_I133_XG_n1 I1_I792_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I133_XG_MN0 (I1_I792_G8_1 I1_I792_P8_5n XI1_I792_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I133_XG_MN1 (XI1_I792_I133_XG_n1 I1_I792_G4_1n I1_I792_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I78_XG_MN2 (XI1_I792_I78_XG_n1 I1_I792_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I78_XG_MN0 (I1_I792_G12_11 I1_I792_pn12 XI1_I792_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I78_XG_MN1 (XI1_I792_I78_XG_n1 I1_I792_gn11 I1_I792_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I79_XG_MN2 (XI1_I792_I79_XG_n1 I1_I792_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I79_XG_MN0 (I1_I792_G13_12 I1_I792_pn13 XI1_I792_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I79_XG_MN1 (XI1_I792_I79_XG_n1 I1_I792_gn12 I1_I792_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I80_XG_MN2 (XI1_I792_I80_XG_n1 I1_I792_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I80_XG_MN0 (I1_I792_G14_13 I1_I792_pn14 XI1_I792_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I80_XG_MN1 (XI1_I792_I80_XG_n1 I1_I792_gn13 I1_I792_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I183_XG_MN2 (XI1_I746_I183_XG_n1 I1_I746_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I183_XG_MN0 (I1_I746_G16_0 I1_I746_P16_1n XI1_I746_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I183_XG_MN1 (XI1_I746_I183_XG_n1 I1_I746_G0_0n I1_I746_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I135_XG_MN2 (XI1_I746_I135_XG_n1 I1_I746_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I135_XG_MN0 (I1_I746_G10_3 I1_I746_P10_7n XI1_I746_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I135_XG_MN1 (XI1_I746_I135_XG_n1 I1_I746_G6_3n I1_I746_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I137_XG_MN2 (XI1_I746_I137_XG_n1 I1_I746_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I137_XG_MN0 (I1_I746_G12_5 I1_I746_P12_9n XI1_I746_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I137_XG_MN1 (XI1_I746_I137_XG_n1 I1_I746_G8_5n I1_I746_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I141_XG_MN2 (XI1_I746_I141_XG_n1 I1_I746_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I141_XG_MN0 (I1_I746_G16_9 I1_I746_P16_13n XI1_I746_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I141_XG_MN1 (XI1_I746_I141_XG_n1 I1_I746_G12_9n I1_I746_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I190_XG_MN2 (XI1_I746_I190_XG_n1 I1_I746_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I190_XG_MN0 (I1_I746_G21_0 I1_I746_P21_6n XI1_I746_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I190_XG_MN1 (XI1_I746_I190_XG_n1 I1_I746_G5_0n I1_I746_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I200_XG_MN2 (XI1_I746_I200_XG_n1 I1_I746_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I200_XG_MN0 (I1_I746_G29_0 I1_I746_P29_14n XI1_I746_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I200_XG_MN1 (XI1_I746_I200_XG_n1 I1_I746_G13_0n I1_I746_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I201_XG_MN2 (XI1_I1344_I201_XG_n1 I1_I1344_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I201_XG_MN0 (I1_c17_m I1_I1344_P30_15n XI1_I1344_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I201_XG_MN1 (XI1_I1344_I201_XG_n1 I1_I1344_G14_0n I1_c17_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I199_XG_MN2 (XI1_I1344_I199_XG_n1 I1_I1344_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I199_XG_MN0 (I1_I1344_G28_0 I1_I1344_P28_13n XI1_I1344_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I199_XG_MN1 (XI1_I1344_I199_XG_n1 I1_I1344_G12_0n I1_I1344_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I149_XG_MN2 (XI1_I1344_I149_XG_n1 I1_I1344_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I149_XG_MN0 (I1_I1344_G24_17 I1_I1344_P24_21n XI1_I1344_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I149_XG_MN1 (XI1_I1344_I149_XG_n1 I1_I1344_G20_17n I1_I1344_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I145_XG_MN2 (XI1_I1344_I145_XG_n1 I1_I1344_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I145_XG_MN0 (I1_I1344_G20_13 I1_I1344_P20_17n XI1_I1344_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I145_XG_MN1 (XI1_I1344_I145_XG_n1 I1_I1344_G16_13n I1_I1344_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I80_XG_MN2 (XI1_I1344_I80_XG_n1 I1_I1344_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I80_XG_MN0 (I1_I1344_G14_13 I1_I1344_pn14 XI1_I1344_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I80_XG_MN1 (XI1_I1344_I80_XG_n1 I1_I1344_gn13 I1_I1344_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I79_XG_MN2 (XI1_I1344_I79_XG_n1 I1_I1344_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I79_XG_MN0 (I1_I1344_G13_12 I1_I1344_pn13 XI1_I1344_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I79_XG_MN1 (XI1_I1344_I79_XG_n1 I1_I1344_gn12 I1_I1344_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I136_XG_MN2 (XI1_I1298_I136_XG_n1 I1_I1298_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I136_XG_MN0 (I1_I1298_G11_4 I1_I1298_P11_8n XI1_I1298_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I136_XG_MN1 (XI1_I1298_I136_XG_n1 I1_I1298_G7_4n I1_I1298_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I138_XG_MN2 (XI1_I1298_I138_XG_n1 I1_I1298_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I138_XG_MN0 (I1_I1298_G13_6 I1_I1298_P13_10n XI1_I1298_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I138_XG_MN1 (XI1_I1298_I138_XG_n1 I1_I1298_G9_6n I1_I1298_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I139_XG_MN2 (XI1_I1298_I139_XG_n1 I1_I1298_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I139_XG_MN0 (I1_I1298_G14_7 I1_I1298_P14_11n XI1_I1298_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I139_XG_MN1 (XI1_I1298_I139_XG_n1 I1_I1298_G10_7n I1_I1298_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I82_XG_MN2 (XI1_I1298_I82_XG_n1 I1_I1298_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I82_XG_MN0 (I1_I1298_G16_15 I1_I1298_pn16 XI1_I1298_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I82_XG_MN1 (XI1_I1298_I82_XG_n1 I1_I1298_gn15 I1_I1298_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I80_XG_MN2 (XI1_I1298_I80_XG_n1 I1_I1298_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I80_XG_MN0 (I1_I1298_G14_13 I1_I1298_pn14 XI1_I1298_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I80_XG_MN1 (XI1_I1298_I80_XG_n1 I1_I1298_gn13 I1_I1298_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I81_XG_MN2 (XI1_I1298_I81_XG_n1 I1_I1298_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I81_XG_MN0 (I1_I1298_G15_14 I1_I1298_pn15 XI1_I1298_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I81_XG_MN1 (XI1_I1298_I81_XG_n1 I1_I1298_gn14 I1_I1298_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I185_XG_MN2 (XI1_I1252_I185_XG_n1 I1_I1252_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I185_XG_MN0 (I1_I1252_G18_0 I1_I1252_P18_3n XI1_I1252_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I185_XG_MN1 (XI1_I1252_I185_XG_n1 I1_I1252_G2_0n I1_I1252_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I139_XG_MN2 (XI1_I1252_I139_XG_n1 I1_I1252_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I139_XG_MN0 (I1_I1252_G14_7 I1_I1252_P14_11n XI1_I1252_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I139_XG_MN1 (XI1_I1252_I139_XG_n1 I1_I1252_G10_7n I1_I1252_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I186_XG_MN2 (XI1_I1252_I186_XG_n1 I1_I1252_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I186_XG_MN0 (I1_I1252_G19_0 I1_I1252_P19_4n XI1_I1252_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I186_XG_MN1 (XI1_I1252_I186_XG_n1 I1_I1252_G3_0n I1_I1252_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I140_XG_MN2 (XI1_I1252_I140_XG_n1 I1_I1252_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I140_XG_MN0 (I1_I1252_G15_8 I1_I1252_P15_12n XI1_I1252_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I140_XG_MN1 (XI1_I1252_I140_XG_n1 I1_I1252_G11_8n I1_I1252_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I81_XG_MN2 (XI1_I1252_I81_XG_n1 I1_I1252_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I81_XG_MN0 (I1_I1252_G15_14 I1_I1252_pn15 XI1_I1252_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I81_XG_MN1 (XI1_I1252_I81_XG_n1 I1_I1252_gn14 I1_I1252_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I82_XG_MN2 (XI1_I1252_I82_XG_n1 I1_I1252_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I82_XG_MN0 (I1_I1252_G16_15 I1_I1252_pn16 XI1_I1252_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I82_XG_MN1 (XI1_I1252_I82_XG_n1 I1_I1252_gn15 I1_I1252_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I83_XG_MN2 (XI1_I1206_I83_XG_n1 I1_I1206_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I83_XG_MN0 (I1_I1206_G17_16 I1_I1206_pn17 XI1_I1206_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I83_XG_MN1 (XI1_I1206_I83_XG_n1 I1_I1206_gn16 I1_I1206_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I144_XG_MN2 (XI1_I1206_I144_XG_n1 I1_I1206_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I144_XG_MN0 (I1_I1206_G19_12 I1_I1206_P19_16n XI1_I1206_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I144_XG_MN1 (XI1_I1206_I144_XG_n1 I1_I1206_G15_12n I1_I1206_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I140_XG_MN2 (XI1_I1206_I140_XG_n1 I1_I1206_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I140_XG_MN0 (I1_I1206_G15_8 I1_I1206_P15_12n XI1_I1206_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I140_XG_MN1 (XI1_I1206_I140_XG_n1 I1_I1206_G11_8n I1_I1206_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I186_XG_MN2 (XI1_I1206_I186_XG_n1 I1_I1206_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I186_XG_MN0 (I1_I1206_G19_0 I1_I1206_P19_4n XI1_I1206_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I186_XG_MN1 (XI1_I1206_I186_XG_n1 I1_I1206_G3_0n I1_I1206_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I142_XG_MN2 (XI1_I1206_I142_XG_n1 I1_I1206_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I142_XG_MN0 (I1_I1206_G17_10 I1_I1206_P17_14n XI1_I1206_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I142_XG_MN1 (XI1_I1206_I142_XG_n1 I1_I1206_G13_10n I1_I1206_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I184_XG_MN2 (XI1_I1206_I184_XG_n1 I1_I1206_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I184_XG_MN0 (I1_I1206_G17_0 I1_I1206_P17_2n XI1_I1206_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I184_XG_MN1 (XI1_I1206_I184_XG_n1 I1_I1206_G1_0n I1_I1206_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I185_XG_MN2 (XI1_I1206_I185_XG_n1 I1_I1206_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I185_XG_MN0 (I1_I1206_G18_0 I1_I1206_P18_3n XI1_I1206_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I185_XG_MN1 (XI1_I1206_I185_XG_n1 I1_I1206_G2_0n I1_I1206_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I188_XG_MN2 (XI1_I1206_I188_XG_n1 I1_I1206_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I188_XG_MN0 (I1_I1206_G20_0 I1_I1206_P20_5n XI1_I1206_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I188_XG_MN1 (XI1_I1206_I188_XG_n1 I1_I1206_G4_0n I1_I1206_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I93_XG_MN2 (XI1_I884_I93_XG_n1 I1_I884_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I93_XG_MN0 (I1_I884_G27_26 I1_I884_pn27 XI1_I884_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I93_XG_MN1 (XI1_I884_I93_XG_n1 I1_I884_gn26 I1_I884_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I89_XG_MN2 (XI1_I884_I89_XG_n1 I1_I884_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I89_XG_MN0 (I1_I884_G23_22 I1_I884_pn23 XI1_I884_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I89_XG_MN1 (XI1_I884_I89_XG_n1 I1_I884_gn22 I1_I884_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I183_XG_MN2 (XI1_I838_I183_XG_n1 I1_I838_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I183_XG_MN0 (I1_I838_G16_0 I1_I838_P16_1n XI1_I838_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I183_XG_MN1 (XI1_I838_I183_XG_n1 I1_I838_G0_0n I1_I838_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I128_XG_MN2 (XI1_I838_I128_XG_n1 I1_I838_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I128_XG_MN0 (I1_I838_G4_0 I1_I838_P4_1n XI1_I838_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I128_XG_MN1 (XI1_I838_I128_XG_n1 I1_I838_G0_0n I1_I838_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I72_XG_MN2 (XI1_I838_I72_XG_n1 I1_I838_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I72_XG_MN0 (I1_I838_G6_5 I1_I838_pn6 XI1_I838_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I72_XG_MN1 (XI1_I838_I72_XG_n1 I1_I838_gn5 I1_I838_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I71_XG_MN2 (XI1_I838_I71_XG_n1 I1_I838_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I71_XG_MN0 (I1_I838_G5_4 I1_I838_pn5 XI1_I838_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I71_XG_MN1 (XI1_I838_I71_XG_n1 I1_I838_gn4 I1_I838_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I128_XG_MN2 (XI1_I792_I128_XG_n1 I1_I792_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I128_XG_MN0 (I1_I792_G4_0 I1_I792_P4_1n XI1_I792_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I128_XG_MN1 (XI1_I792_I128_XG_n1 I1_I792_G0_0n I1_I792_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I74_XG_MN2 (XI1_I792_I74_XG_n1 I1_I792_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I74_XG_MN0 (I1_I792_G8_7 I1_I792_pn8 XI1_I792_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I74_XG_MN1 (XI1_I792_I74_XG_n1 I1_I792_gn7 I1_I792_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I75_XG_MN2 (XI1_I792_I75_XG_n1 I1_I792_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I75_XG_MN0 (I1_I792_G9_8 I1_I792_pn9 XI1_I792_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I75_XG_MN1 (XI1_I792_I75_XG_n1 I1_I792_gn8 I1_I792_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I131_XG_MN2 (XI1_I746_I131_XG_n1 I1_I746_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I131_XG_MN0 (I1_I746_G6_0 I1_I746_P6_3n XI1_I746_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I131_XG_MN1 (XI1_I746_I131_XG_n1 I1_I746_G2_0n I1_I746_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I196_XG_MN2 (XI1_I746_I196_XG_n1 I1_I746_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I196_XG_MN0 (I1_I746_G25_0 I1_I746_P25_10n XI1_I746_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I196_XG_MN1 (XI1_I746_I196_XG_n1 I1_I746_G9_0n I1_I746_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I146_XG_MN2 (XI1_I746_I146_XG_n1 I1_I746_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I146_XG_MN0 (I1_I746_G21_14 I1_I746_P21_18n XI1_I746_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I146_XG_MN1 (XI1_I746_I146_XG_n1 I1_I746_G17_14n I1_I746_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I150_XG_MN2 (XI1_I746_I150_XG_n1 I1_I746_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I150_XG_MN0 (I1_I746_G25_18 I1_I746_P25_22n XI1_I746_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I150_XG_MN1 (XI1_I746_I150_XG_n1 I1_I746_G21_18n I1_I746_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I154_XG_MN2 (XI1_I746_I154_XG_n1 I1_I746_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I154_XG_MN0 (I1_I746_G29_22 I1_I746_P29_26n XI1_I746_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I154_XG_MN1 (XI1_I746_I154_XG_n1 I1_I746_G25_22n I1_I746_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I152_XG_MN2 (XI1_I746_I152_XG_n1 I1_I746_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I152_XG_MN0 (I1_I746_G27_20 I1_I746_P27_24n XI1_I746_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I152_XG_MN1 (XI1_I746_I152_XG_n1 I1_I746_G23_20n I1_I746_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I156_XG_MN2 (XI1_I746_I156_XG_n1 I1_I746_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I156_XG_MN0 (I1_I746_G31_24 I1_I746_P31_28n XI1_I746_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I156_XG_MN1 (XI1_I746_I156_XG_n1 I1_I746_G27_24n I1_I746_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I97_XG_MN2 (XI1_I746_I97_XG_n1 I1_I746_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I97_XG_MN0 (I1_I746_G31_30 I1_I746_pn31 XI1_I746_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I97_XG_MN1 (XI1_I746_I97_XG_n1 I1_I746_gn30 I1_I746_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I197_XG_MN2 (XI1_I1344_I197_XG_n1 I1_I1344_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I197_XG_MN0 (I1_I1344_G26_0 I1_I1344_P26_11n XI1_I1344_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I197_XG_MN1 (XI1_I1344_I197_XG_n1 I1_I1344_G10_0n I1_I1344_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I195_XG_MN2 (XI1_I1344_I195_XG_n1 I1_I1344_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I195_XG_MN0 (I1_I1344_G24_0 I1_I1344_P24_9n XI1_I1344_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I195_XG_MN1 (XI1_I1344_I195_XG_n1 I1_I1344_G8_0n I1_I1344_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I143_XG_MN2 (XI1_I1344_I143_XG_n1 I1_I1344_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I143_XG_MN0 (I1_I1344_G18_11 I1_I1344_P18_15n XI1_I1344_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I143_XG_MN1 (XI1_I1344_I143_XG_n1 I1_I1344_G14_11n I1_I1344_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I139_XG_MN2 (XI1_I1344_I139_XG_n1 I1_I1344_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I139_XG_MN0 (I1_I1344_G14_7 I1_I1344_P14_11n XI1_I1344_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I139_XG_MN1 (XI1_I1344_I139_XG_n1 I1_I1344_G10_7n I1_I1344_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I141_XG_MN2 (XI1_I1344_I141_XG_n1 I1_I1344_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I141_XG_MN0 (I1_I1344_G16_9 I1_I1344_P16_13n XI1_I1344_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I141_XG_MN1 (XI1_I1344_I141_XG_n1 I1_I1344_G12_9n I1_I1344_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I137_XG_MN2 (XI1_I1344_I137_XG_n1 I1_I1344_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I137_XG_MN0 (I1_I1344_G12_5 I1_I1344_P12_9n XI1_I1344_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I137_XG_MN1 (XI1_I1344_I137_XG_n1 I1_I1344_G8_5n I1_I1344_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I78_XG_MN2 (XI1_I1344_I78_XG_n1 I1_I1344_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I78_XG_MN0 (I1_I1344_G12_11 I1_I1344_pn12 XI1_I1344_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I78_XG_MN1 (XI1_I1344_I78_XG_n1 I1_I1344_gn11 I1_I1344_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I77_XG_MN2 (XI1_I1344_I77_XG_n1 I1_I1344_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I77_XG_MN0 (I1_I1344_G11_10 I1_I1344_pn11 XI1_I1344_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I77_XG_MN1 (XI1_I1344_I77_XG_n1 I1_I1344_gn10 I1_I1344_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I132_XG_MN2 (XI1_I1298_I132_XG_n1 I1_I1298_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I132_XG_MN0 (I1_I1298_G7_0 I1_I1298_P7_4n XI1_I1298_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I132_XG_MN1 (XI1_I1298_I132_XG_n1 I1_I1298_G3_0n I1_I1298_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I184_XG_MN2 (XI1_I1298_I184_XG_n1 I1_I1298_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I184_XG_MN0 (I1_I1298_G17_0 I1_I1298_P17_2n XI1_I1298_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I184_XG_MN1 (XI1_I1298_I184_XG_n1 I1_I1298_G1_0n I1_I1298_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I185_XG_MN2 (XI1_I1298_I185_XG_n1 I1_I1298_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I185_XG_MN0 (I1_I1298_G18_0 I1_I1298_P18_3n XI1_I1298_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I185_XG_MN1 (XI1_I1298_I185_XG_n1 I1_I1298_G2_0n I1_I1298_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I195_XG_MN2 (XI1_I1298_I195_XG_n1 I1_I1298_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I195_XG_MN0 (I1_I1298_G24_0 I1_I1298_P24_9n XI1_I1298_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I195_XG_MN1 (XI1_I1298_I195_XG_n1 I1_I1298_G8_0n I1_I1298_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I141_XG_MN2 (XI1_I1298_I141_XG_n1 I1_I1298_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I141_XG_MN0 (I1_I1298_G16_9 I1_I1298_P16_13n XI1_I1298_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I141_XG_MN1 (XI1_I1298_I141_XG_n1 I1_I1298_G12_9n I1_I1298_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I78_XG_MN2 (XI1_I1298_I78_XG_n1 I1_I1298_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I78_XG_MN0 (I1_I1298_G12_11 I1_I1298_pn12 XI1_I1298_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I78_XG_MN1 (XI1_I1298_I78_XG_n1 I1_I1298_gn11 I1_I1298_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I79_XG_MN2 (XI1_I1298_I79_XG_n1 I1_I1298_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I79_XG_MN0 (I1_I1298_G13_12 I1_I1298_pn13 XI1_I1298_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I79_XG_MN1 (XI1_I1298_I79_XG_n1 I1_I1298_gn12 I1_I1298_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I141_XG_MN2 (XI1_I1252_I141_XG_n1 I1_I1252_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I141_XG_MN0 (I1_I1252_G16_9 I1_I1252_P16_13n XI1_I1252_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I141_XG_MN1 (XI1_I1252_I141_XG_n1 I1_I1252_G12_9n I1_I1252_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I184_XG_MN2 (XI1_I1252_I184_XG_n1 I1_I1252_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I184_XG_MN0 (I1_I1252_G17_0 I1_I1252_P17_2n XI1_I1252_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I184_XG_MN1 (XI1_I1252_I184_XG_n1 I1_I1252_G1_0n I1_I1252_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I138_XG_MN2 (XI1_I1252_I138_XG_n1 I1_I1252_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I138_XG_MN0 (I1_I1252_G13_6 I1_I1252_P13_10n XI1_I1252_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I138_XG_MN1 (XI1_I1252_I138_XG_n1 I1_I1252_G9_6n I1_I1252_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I142_XG_MN2 (XI1_I1252_I142_XG_n1 I1_I1252_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I142_XG_MN0 (I1_I1252_G17_10 I1_I1252_P17_14n XI1_I1252_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I142_XG_MN1 (XI1_I1252_I142_XG_n1 I1_I1252_G13_10n I1_I1252_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I79_XG_MN2 (XI1_I1252_I79_XG_n1 I1_I1252_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I79_XG_MN0 (I1_I1252_G13_12 I1_I1252_pn13 XI1_I1252_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I79_XG_MN1 (XI1_I1252_I79_XG_n1 I1_I1252_gn12 I1_I1252_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I80_XG_MN2 (XI1_I1252_I80_XG_n1 I1_I1252_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I80_XG_MN0 (I1_I1252_G14_13 I1_I1252_pn14 XI1_I1252_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I80_XG_MN1 (XI1_I1252_I80_XG_n1 I1_I1252_gn13 I1_I1252_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I82_XG_MN2 (XI1_I1206_I82_XG_n1 I1_I1206_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I82_XG_MN0 (I1_I1206_G16_15 I1_I1206_pn16 XI1_I1206_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I82_XG_MN1 (XI1_I1206_I82_XG_n1 I1_I1206_gn15 I1_I1206_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I81_XG_MN2 (XI1_I1206_I81_XG_n1 I1_I1206_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I81_XG_MN0 (I1_I1206_G15_14 I1_I1206_pn15 XI1_I1206_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I81_XG_MN1 (XI1_I1206_I81_XG_n1 I1_I1206_gn14 I1_I1206_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I139_XG_MN2 (XI1_I1206_I139_XG_n1 I1_I1206_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I139_XG_MN0 (I1_I1206_G14_7 I1_I1206_P14_11n XI1_I1206_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I139_XG_MN1 (XI1_I1206_I139_XG_n1 I1_I1206_G10_7n I1_I1206_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I95_XG_MN2 (XI1_I884_I95_XG_n1 I1_I884_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I95_XG_MN0 (I1_I884_G29_28 I1_I884_pn29 XI1_I884_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I95_XG_MN1 (XI1_I884_I95_XG_n1 I1_I884_gn28 I1_I884_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I94_XG_MN2 (XI1_I884_I94_XG_n1 I1_I884_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I94_XG_MN0 (I1_I884_G28_27 I1_I884_pn28 XI1_I884_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I94_XG_MN1 (XI1_I884_I94_XG_n1 I1_I884_gn27 I1_I884_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I92_XG_MN2 (XI1_I884_I92_XG_n1 I1_I884_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I92_XG_MN0 (I1_I884_G26_25 I1_I884_pn26 XI1_I884_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I92_XG_MN1 (XI1_I884_I92_XG_n1 I1_I884_gn25 I1_I884_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I91_XG_MN2 (XI1_I884_I91_XG_n1 I1_I884_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I91_XG_MN0 (I1_I884_G25_24 I1_I884_pn25 XI1_I884_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I91_XG_MN1 (XI1_I884_I91_XG_n1 I1_I884_gn24 I1_I884_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I90_XG_MN2 (XI1_I884_I90_XG_n1 I1_I884_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I90_XG_MN0 (I1_I884_G24_23 I1_I884_pn24 XI1_I884_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I90_XG_MN1 (XI1_I884_I90_XG_n1 I1_I884_gn23 I1_I884_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I86_XG_MN2 (XI1_I884_I86_XG_n1 I1_I884_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I86_XG_MN0 (I1_I884_G20_19 I1_I884_pn20 XI1_I884_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I86_XG_MN1 (XI1_I884_I86_XG_n1 I1_I884_gn19 I1_I884_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I85_XG_MN2 (XI1_I884_I85_XG_n1 I1_I884_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I85_XG_MN0 (I1_I884_G19_18 I1_I884_pn19 XI1_I884_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I85_XG_MN1 (XI1_I884_I85_XG_n1 I1_I884_gn18 I1_I884_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I84_XG_MN2 (XI1_I884_I84_XG_n1 I1_I884_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I84_XG_MN0 (I1_I884_G18_17 I1_I884_pn18 XI1_I884_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I84_XG_MN1 (XI1_I884_I84_XG_n1 I1_I884_gn17 I1_I884_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I83_XG_MN2 (XI1_I884_I83_XG_n1 I1_I884_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I83_XG_MN0 (I1_I884_G17_16 I1_I884_pn17 XI1_I884_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I83_XG_MN1 (XI1_I884_I83_XG_n1 I1_I884_gn16 I1_I884_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I82_XG_MN2 (XI1_I884_I82_XG_n1 I1_I884_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I82_XG_MN0 (I1_I884_G16_15 I1_I884_pn16 XI1_I884_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I82_XG_MN1 (XI1_I884_I82_XG_n1 I1_I884_gn15 I1_I884_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I70_XG_MN2 (XI1_I838_I70_XG_n1 I1_I838_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I70_XG_MN0 (I1_I838_G4_3 I1_I838_pn4 XI1_I838_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I70_XG_MN1 (XI1_I838_I70_XG_n1 I1_I838_gn3 I1_I838_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I128_XG_MN2 (XI1_I746_I128_XG_n1 I1_I746_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I128_XG_MN0 (I1_I746_G4_0 I1_I746_P4_1n XI1_I746_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I128_XG_MN1 (XI1_I746_I128_XG_n1 I1_I746_G0_0n I1_I746_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I133_XG_MN2 (XI1_I746_I133_XG_n1 I1_I746_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I133_XG_MN0 (I1_I746_G8_1 I1_I746_P8_5n XI1_I746_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I133_XG_MN1 (XI1_I746_I133_XG_n1 I1_I746_G4_1n I1_I746_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I134_XG_MN2 (XI1_I746_I134_XG_n1 I1_I746_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I134_XG_MN0 (I1_I746_G9_2 I1_I746_P9_6n XI1_I746_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I134_XG_MN1 (XI1_I746_I134_XG_n1 I1_I746_G5_2n I1_I746_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I184_XG_MN2 (XI1_I746_I184_XG_n1 I1_I746_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I184_XG_MN0 (I1_I746_G17_0 I1_I746_P17_2n XI1_I746_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I184_XG_MN1 (XI1_I746_I184_XG_n1 I1_I746_G1_0n I1_I746_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I186_XG_MN2 (XI1_I746_I186_XG_n1 I1_I746_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I186_XG_MN0 (I1_I746_G19_0 I1_I746_P19_4n XI1_I746_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I186_XG_MN1 (XI1_I746_I186_XG_n1 I1_I746_G3_0n I1_I746_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I138_XG_MN2 (XI1_I746_I138_XG_n1 I1_I746_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I138_XG_MN0 (I1_I746_G13_6 I1_I746_P13_10n XI1_I746_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I138_XG_MN1 (XI1_I746_I138_XG_n1 I1_I746_G9_6n I1_I746_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I142_XG_MN2 (XI1_I746_I142_XG_n1 I1_I746_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I142_XG_MN0 (I1_I746_G17_10 I1_I746_P17_14n XI1_I746_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I142_XG_MN1 (XI1_I746_I142_XG_n1 I1_I746_G13_10n I1_I746_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I144_XG_MN2 (XI1_I746_I144_XG_n1 I1_I746_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I144_XG_MN0 (I1_I746_G19_12 I1_I746_P19_16n XI1_I746_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I144_XG_MN1 (XI1_I746_I144_XG_n1 I1_I746_G15_12n I1_I746_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I198_XG_MN2 (XI1_I746_I198_XG_n1 I1_I746_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I198_XG_MN0 (I1_I746_G27_0 I1_I746_P27_12n XI1_I746_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I198_XG_MN1 (XI1_I746_I198_XG_n1 I1_I746_G11_0n I1_I746_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I89_XG_MN2 (XI1_I746_I89_XG_n1 I1_I746_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I89_XG_MN0 (I1_I746_G23_22 I1_I746_pn23 XI1_I746_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I89_XG_MN1 (XI1_I746_I89_XG_n1 I1_I746_gn22 I1_I746_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I148_XG_MN2 (XI1_I746_I148_XG_n1 I1_I746_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I148_XG_MN0 (I1_I746_G23_16 I1_I746_P23_20n XI1_I746_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I148_XG_MN1 (XI1_I746_I148_XG_n1 I1_I746_G19_16n I1_I746_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I192_XG_MN2 (XI1_I1344_I192_XG_n1 I1_I1344_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I192_XG_MN0 (I1_I1344_G22_0 I1_I1344_P22_7n XI1_I1344_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I192_XG_MN1 (XI1_I1344_I192_XG_n1 I1_I1344_G6_0n I1_I1344_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I188_XG_MN2 (XI1_I1344_I188_XG_n1 I1_I1344_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I188_XG_MN0 (I1_I1344_G20_0 I1_I1344_P20_5n XI1_I1344_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I188_XG_MN1 (XI1_I1344_I188_XG_n1 I1_I1344_G4_0n I1_I1344_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I135_XG_MN2 (XI1_I1344_I135_XG_n1 I1_I1344_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I135_XG_MN0 (I1_I1344_G10_3 I1_I1344_P10_7n XI1_I1344_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I135_XG_MN1 (XI1_I1344_I135_XG_n1 I1_I1344_G6_3n I1_I1344_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I76_XG_MN2 (XI1_I1344_I76_XG_n1 I1_I1344_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I76_XG_MN0 (I1_I1344_G10_9 I1_I1344_pn10 XI1_I1344_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I76_XG_MN1 (XI1_I1344_I76_XG_n1 I1_I1344_gn9 I1_I1344_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I75_XG_MN2 (XI1_I1344_I75_XG_n1 I1_I1344_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I75_XG_MN0 (I1_I1344_G9_8 I1_I1344_pn9 XI1_I1344_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I75_XG_MN1 (XI1_I1344_I75_XG_n1 I1_I1344_gn8 I1_I1344_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I134_XG_MN2 (XI1_I1298_I134_XG_n1 I1_I1298_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I134_XG_MN0 (I1_I1298_G9_2 I1_I1298_P9_6n XI1_I1298_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I134_XG_MN1 (XI1_I1298_I134_XG_n1 I1_I1298_G5_2n I1_I1298_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I135_XG_MN2 (XI1_I1298_I135_XG_n1 I1_I1298_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I135_XG_MN0 (I1_I1298_G10_3 I1_I1298_P10_7n XI1_I1298_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I135_XG_MN1 (XI1_I1298_I135_XG_n1 I1_I1298_G6_3n I1_I1298_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I137_XG_MN2 (XI1_I1298_I137_XG_n1 I1_I1298_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I137_XG_MN0 (I1_I1298_G12_5 I1_I1298_P12_9n XI1_I1298_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I137_XG_MN1 (XI1_I1298_I137_XG_n1 I1_I1298_G8_5n I1_I1298_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I77_XG_MN2 (XI1_I1298_I77_XG_n1 I1_I1298_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I77_XG_MN0 (I1_I1298_G11_10 I1_I1298_pn11 XI1_I1298_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I77_XG_MN1 (XI1_I1298_I77_XG_n1 I1_I1298_gn10 I1_I1298_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I183_XG_MN2 (XI1_I1252_I183_XG_n1 I1_I1252_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I183_XG_MN0 (I1_I1252_G16_0 I1_I1252_P16_1n XI1_I1252_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I183_XG_MN1 (XI1_I1252_I183_XG_n1 I1_I1252_G0_0n I1_I1252_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I135_XG_MN2 (XI1_I1252_I135_XG_n1 I1_I1252_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I135_XG_MN0 (I1_I1252_G10_3 I1_I1252_P10_7n XI1_I1252_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I135_XG_MN1 (XI1_I1252_I135_XG_n1 I1_I1252_G6_3n I1_I1252_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I137_XG_MN2 (XI1_I1252_I137_XG_n1 I1_I1252_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I137_XG_MN0 (I1_I1252_G12_5 I1_I1252_P12_9n XI1_I1252_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I137_XG_MN1 (XI1_I1252_I137_XG_n1 I1_I1252_G8_5n I1_I1252_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I134_XG_MN2 (XI1_I1252_I134_XG_n1 I1_I1252_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I134_XG_MN0 (I1_I1252_G9_2 I1_I1252_P9_6n XI1_I1252_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I134_XG_MN1 (XI1_I1252_I134_XG_n1 I1_I1252_G5_2n I1_I1252_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I136_XG_MN2 (XI1_I1252_I136_XG_n1 I1_I1252_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I136_XG_MN0 (I1_I1252_G11_4 I1_I1252_P11_8n XI1_I1252_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I136_XG_MN1 (XI1_I1252_I136_XG_n1 I1_I1252_G7_4n I1_I1252_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I77_XG_MN2 (XI1_I1252_I77_XG_n1 I1_I1252_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I77_XG_MN0 (I1_I1252_G11_10 I1_I1252_pn11 XI1_I1252_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I77_XG_MN1 (XI1_I1252_I77_XG_n1 I1_I1252_gn10 I1_I1252_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I78_XG_MN2 (XI1_I1252_I78_XG_n1 I1_I1252_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I78_XG_MN0 (I1_I1252_G12_11 I1_I1252_pn12 XI1_I1252_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I78_XG_MN1 (XI1_I1252_I78_XG_n1 I1_I1252_gn11 I1_I1252_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I80_XG_MN2 (XI1_I1206_I80_XG_n1 I1_I1206_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I80_XG_MN0 (I1_I1206_G14_13 I1_I1206_pn14 XI1_I1206_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I80_XG_MN1 (XI1_I1206_I80_XG_n1 I1_I1206_gn13 I1_I1206_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I132_XG_MN2 (XI1_I1206_I132_XG_n1 I1_I1206_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I132_XG_MN0 (I1_I1206_G7_0 I1_I1206_P7_4n XI1_I1206_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I132_XG_MN1 (XI1_I1206_I132_XG_n1 I1_I1206_G3_0n I1_I1206_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I134_XG_MN2 (XI1_I1206_I134_XG_n1 I1_I1206_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I134_XG_MN0 (I1_I1206_G9_2 I1_I1206_P9_6n XI1_I1206_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I134_XG_MN1 (XI1_I1206_I134_XG_n1 I1_I1206_G5_2n I1_I1206_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I135_XG_MN2 (XI1_I1206_I135_XG_n1 I1_I1206_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I135_XG_MN0 (I1_I1206_G10_3 I1_I1206_P10_7n XI1_I1206_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I135_XG_MN1 (XI1_I1206_I135_XG_n1 I1_I1206_G6_3n I1_I1206_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I141_XG_MN2 (XI1_I1206_I141_XG_n1 I1_I1206_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I141_XG_MN0 (I1_I1206_G16_9 I1_I1206_P16_13n XI1_I1206_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I141_XG_MN1 (XI1_I1206_I141_XG_n1 I1_I1206_G12_9n I1_I1206_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I137_XG_MN2 (XI1_I1206_I137_XG_n1 I1_I1206_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I137_XG_MN0 (I1_I1206_G12_5 I1_I1206_P12_9n XI1_I1206_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I137_XG_MN1 (XI1_I1206_I137_XG_n1 I1_I1206_G8_5n I1_I1206_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I97_XG_MN2 (XI1_I884_I97_XG_n1 I1_I884_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I97_XG_MN0 (I1_I884_G31_30 I1_I884_pn31 XI1_I884_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I97_XG_MN1 (XI1_I884_I97_XG_n1 I1_I884_gn30 I1_I884_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I96_XG_MN2 (XI1_I884_I96_XG_n1 I1_I884_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I96_XG_MN0 (I1_I884_G30_29 I1_I884_pn30 XI1_I884_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I96_XG_MN1 (XI1_I884_I96_XG_n1 I1_I884_gn29 I1_I884_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I156_XG_MN2 (XI1_I884_I156_XG_n1 I1_I884_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I156_XG_MN0 (I1_I884_G31_24 I1_I884_P31_28n XI1_I884_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I156_XG_MN1 (XI1_I884_I156_XG_n1 I1_I884_G27_24n I1_I884_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I154_XG_MN2 (XI1_I884_I154_XG_n1 I1_I884_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I154_XG_MN0 (I1_I884_G29_22 I1_I884_P29_26n XI1_I884_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I154_XG_MN1 (XI1_I884_I154_XG_n1 I1_I884_G25_22n I1_I884_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I152_XG_MN2 (XI1_I884_I152_XG_n1 I1_I884_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I152_XG_MN0 (I1_I884_G27_20 I1_I884_P27_24n XI1_I884_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I152_XG_MN1 (XI1_I884_I152_XG_n1 I1_I884_G23_20n I1_I884_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I148_XG_MN2 (XI1_I884_I148_XG_n1 I1_I884_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I148_XG_MN0 (I1_I884_G23_16 I1_I884_P23_20n XI1_I884_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I148_XG_MN1 (XI1_I884_I148_XG_n1 I1_I884_G19_16n I1_I884_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I150_XG_MN2 (XI1_I884_I150_XG_n1 I1_I884_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I150_XG_MN0 (I1_I884_G25_18 I1_I884_P25_22n XI1_I884_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I150_XG_MN1 (XI1_I884_I150_XG_n1 I1_I884_G21_18n I1_I884_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I142_XG_MN2 (XI1_I884_I142_XG_n1 I1_I884_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I142_XG_MN0 (I1_I884_G17_10 I1_I884_P17_14n XI1_I884_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I142_XG_MN1 (XI1_I884_I142_XG_n1 I1_I884_G13_10n I1_I884_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I81_XG_MN2 (XI1_I884_I81_XG_n1 I1_I884_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I81_XG_MN0 (I1_I884_G15_14 I1_I884_pn15 XI1_I884_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I81_XG_MN1 (XI1_I884_I81_XG_n1 I1_I884_gn14 I1_I884_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I80_XG_MN2 (XI1_I884_I80_XG_n1 I1_I884_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I80_XG_MN0 (I1_I884_G14_13 I1_I884_pn14 XI1_I884_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I80_XG_MN1 (XI1_I884_I80_XG_n1 I1_I884_gn13 I1_I884_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I79_XG_MN2 (XI1_I884_I79_XG_n1 I1_I884_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I79_XG_MN0 (I1_I884_G13_12 I1_I884_pn13 XI1_I884_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I79_XG_MN1 (XI1_I884_I79_XG_n1 I1_I884_gn12 I1_I884_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I78_XG_MN2 (XI1_I884_I78_XG_n1 I1_I884_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I78_XG_MN0 (I1_I884_G12_11 I1_I884_pn12 XI1_I884_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I78_XG_MN1 (XI1_I884_I78_XG_n1 I1_I884_gn11 I1_I884_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I77_XG_MN2 (XI1_I884_I77_XG_n1 I1_I884_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I77_XG_MN0 (I1_I884_G11_10 I1_I884_pn11 XI1_I884_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I77_XG_MN1 (XI1_I884_I77_XG_n1 I1_I884_gn10 I1_I884_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I76_XG_MN2 (XI1_I884_I76_XG_n1 I1_I884_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I76_XG_MN0 (I1_I884_G10_9 I1_I884_pn10 XI1_I884_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I76_XG_MN1 (XI1_I884_I76_XG_n1 I1_I884_gn9 I1_I884_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I67_XG_MN2 (XI1_I838_I67_XG_n1 I1_I838_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I67_XG_MN0 (I1_I838_G1_0 I1_I838_pn1 XI1_I838_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I67_XG_MN1 (XI1_I838_I67_XG_n1 I1_I838_G0_0n I1_I838_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I69_XG_MN2 (XI1_I838_I69_XG_n1 I1_I838_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I69_XG_MN0 (I1_I838_G3_2 I1_I838_pn3 XI1_I838_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I69_XG_MN1 (XI1_I838_I69_XG_n1 I1_I838_gn2 I1_I838_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I68_XG_MN2 (XI1_I838_I68_XG_n1 I1_I838_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I68_XG_MN0 (I1_I838_G2_1 I1_I838_pn2 XI1_I838_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I68_XG_MN1 (XI1_I838_I68_XG_n1 I1_I838_gn1 I1_I838_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I70_XG_MN2 (XI1_I792_I70_XG_n1 I1_I792_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I70_XG_MN0 (I1_I792_G4_3 I1_I792_pn4 XI1_I792_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I70_XG_MN1 (XI1_I792_I70_XG_n1 I1_I792_gn3 I1_I792_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I71_XG_MN2 (XI1_I792_I71_XG_n1 I1_I792_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I71_XG_MN0 (I1_I792_G5_4 I1_I792_pn5 XI1_I792_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I71_XG_MN1 (XI1_I792_I71_XG_n1 I1_I792_gn4 I1_I792_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I130_XG_MN2 (XI1_I746_I130_XG_n1 I1_I746_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I130_XG_MN0 (I1_I746_G5_0 I1_I746_P5_2n XI1_I746_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I130_XG_MN1 (XI1_I746_I130_XG_n1 I1_I746_G1_0n I1_I746_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I132_XG_MN2 (XI1_I746_I132_XG_n1 I1_I746_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I132_XG_MN0 (I1_I746_G7_0 I1_I746_P7_4n XI1_I746_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I132_XG_MN1 (XI1_I746_I132_XG_n1 I1_I746_G3_0n I1_I746_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I136_XG_MN2 (XI1_I746_I136_XG_n1 I1_I746_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I136_XG_MN0 (I1_I746_G11_4 I1_I746_P11_8n XI1_I746_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I136_XG_MN1 (XI1_I746_I136_XG_n1 I1_I746_G7_4n I1_I746_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I81_XG_MN2 (XI1_I746_I81_XG_n1 I1_I746_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I81_XG_MN0 (I1_I746_G15_14 I1_I746_pn15 XI1_I746_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I81_XG_MN1 (XI1_I746_I81_XG_n1 I1_I746_gn14 I1_I746_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I83_XG_MN2 (XI1_I746_I83_XG_n1 I1_I746_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I83_XG_MN0 (I1_I746_G17_16 I1_I746_pn17 XI1_I746_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I83_XG_MN1 (XI1_I746_I83_XG_n1 I1_I746_gn16 I1_I746_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I140_XG_MN2 (XI1_I746_I140_XG_n1 I1_I746_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I140_XG_MN0 (I1_I746_G15_8 I1_I746_P15_12n XI1_I746_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I140_XG_MN1 (XI1_I746_I140_XG_n1 I1_I746_G11_8n I1_I746_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I84_XG_MN2 (XI1_I746_I84_XG_n1 I1_I746_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I84_XG_MN0 (I1_I746_G18_17 I1_I746_pn18 XI1_I746_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I84_XG_MN1 (XI1_I746_I84_XG_n1 I1_I746_gn17 I1_I746_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I85_XG_MN2 (XI1_I746_I85_XG_n1 I1_I746_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I85_XG_MN0 (I1_I746_G19_18 I1_I746_pn19 XI1_I746_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I85_XG_MN1 (XI1_I746_I85_XG_n1 I1_I746_gn18 I1_I746_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I88_XG_MN2 (XI1_I746_I88_XG_n1 I1_I746_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I88_XG_MN0 (I1_I746_G22_21 I1_I746_pn22 XI1_I746_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I88_XG_MN1 (XI1_I746_I88_XG_n1 I1_I746_gn21 I1_I746_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I194_XG_MN2 (XI1_I746_I194_XG_n1 I1_I746_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I194_XG_MN0 (I1_I746_G23_0 I1_I746_P23_8n XI1_I746_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I194_XG_MN1 (XI1_I746_I194_XG_n1 I1_I746_G7_0n I1_I746_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I202_XG_MN2 (XI1_I746_I202_XG_n1 I1_I746_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I202_XG_MN0 (I1_c4_o I1_I746_P31_16n XI1_I746_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I202_XG_MN1 (XI1_I746_I202_XG_n1 I1_I746_G15_0n I1_c4_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I185_XG_MN2 (XI1_I1344_I185_XG_n1 I1_I1344_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I185_XG_MN0 (I1_I1344_G18_0 I1_I1344_P18_3n XI1_I1344_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I185_XG_MN1 (XI1_I1344_I185_XG_n1 I1_I1344_G2_0n I1_I1344_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I131_XG_MN2 (XI1_I1344_I131_XG_n1 I1_I1344_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I131_XG_MN0 (I1_I1344_G6_0 I1_I1344_P6_3n XI1_I1344_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I131_XG_MN1 (XI1_I1344_I131_XG_n1 I1_I1344_G2_0n I1_I1344_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I130_XG_MN2 (XI1_I1298_I130_XG_n1 I1_I1298_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I130_XG_MN0 (I1_I1298_G5_0 I1_I1298_P5_2n XI1_I1298_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I130_XG_MN1 (XI1_I1298_I130_XG_n1 I1_I1298_G1_0n I1_I1298_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I183_XG_MN2 (XI1_I1298_I183_XG_n1 I1_I1298_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I183_XG_MN0 (I1_I1298_G16_0 I1_I1298_P16_1n XI1_I1298_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I183_XG_MN1 (XI1_I1298_I183_XG_n1 I1_I1298_G0_0n I1_I1298_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I75_XG_MN2 (XI1_I1298_I75_XG_n1 I1_I1298_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I75_XG_MN0 (I1_I1298_G9_8 I1_I1298_pn9 XI1_I1298_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I75_XG_MN1 (XI1_I1298_I75_XG_n1 I1_I1298_gn8 I1_I1298_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I76_XG_MN2 (XI1_I1298_I76_XG_n1 I1_I1298_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I76_XG_MN0 (I1_I1298_G10_9 I1_I1298_pn10 XI1_I1298_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I76_XG_MN1 (XI1_I1298_I76_XG_n1 I1_I1298_gn9 I1_I1298_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I131_XG_MN2 (XI1_I1252_I131_XG_n1 I1_I1252_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I131_XG_MN0 (I1_I1252_G6_0 I1_I1252_P6_3n XI1_I1252_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I131_XG_MN1 (XI1_I1252_I131_XG_n1 I1_I1252_G2_0n I1_I1252_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I132_XG_MN2 (XI1_I1252_I132_XG_n1 I1_I1252_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I132_XG_MN0 (I1_I1252_G7_0 I1_I1252_P7_4n XI1_I1252_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I132_XG_MN1 (XI1_I1252_I132_XG_n1 I1_I1252_G3_0n I1_I1252_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I74_XG_MN2 (XI1_I1252_I74_XG_n1 I1_I1252_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I74_XG_MN0 (I1_I1252_G8_7 I1_I1252_pn8 XI1_I1252_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I74_XG_MN1 (XI1_I1252_I74_XG_n1 I1_I1252_gn7 I1_I1252_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I75_XG_MN2 (XI1_I1252_I75_XG_n1 I1_I1252_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I75_XG_MN0 (I1_I1252_G9_8 I1_I1252_pn9 XI1_I1252_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I75_XG_MN1 (XI1_I1252_I75_XG_n1 I1_I1252_gn8 I1_I1252_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I76_XG_MN2 (XI1_I1252_I76_XG_n1 I1_I1252_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I76_XG_MN0 (I1_I1252_G10_9 I1_I1252_pn10 XI1_I1252_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I76_XG_MN1 (XI1_I1252_I76_XG_n1 I1_I1252_gn9 I1_I1252_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I79_XG_MN2 (XI1_I1206_I79_XG_n1 I1_I1206_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I79_XG_MN0 (I1_I1206_G13_12 I1_I1206_pn13 XI1_I1206_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I79_XG_MN1 (XI1_I1206_I79_XG_n1 I1_I1206_gn12 I1_I1206_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I78_XG_MN2 (XI1_I1206_I78_XG_n1 I1_I1206_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I78_XG_MN0 (I1_I1206_G12_11 I1_I1206_pn12 XI1_I1206_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I78_XG_MN1 (XI1_I1206_I78_XG_n1 I1_I1206_gn11 I1_I1206_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I77_XG_MN2 (XI1_I1206_I77_XG_n1 I1_I1206_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I77_XG_MN0 (I1_I1206_G11_10 I1_I1206_pn11 XI1_I1206_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I77_XG_MN1 (XI1_I1206_I77_XG_n1 I1_I1206_gn10 I1_I1206_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I76_XG_MN2 (XI1_I1206_I76_XG_n1 I1_I1206_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I76_XG_MN0 (I1_I1206_G10_9 I1_I1206_pn10 XI1_I1206_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I76_XG_MN1 (XI1_I1206_I76_XG_n1 I1_I1206_gn9 I1_I1206_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I130_XG_MN2 (XI1_I1206_I130_XG_n1 I1_I1206_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I130_XG_MN0 (I1_I1206_G5_0 I1_I1206_P5_2n XI1_I1206_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I130_XG_MN1 (XI1_I1206_I130_XG_n1 I1_I1206_G1_0n I1_I1206_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I131_XG_MN2 (XI1_I1206_I131_XG_n1 I1_I1206_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I131_XG_MN0 (I1_I1206_G6_0 I1_I1206_P6_3n XI1_I1206_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I131_XG_MN1 (XI1_I1206_I131_XG_n1 I1_I1206_G2_0n I1_I1206_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I133_XG_MN2 (XI1_I1206_I133_XG_n1 I1_I1206_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I133_XG_MN0 (I1_I1206_G8_1 I1_I1206_P8_5n XI1_I1206_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I133_XG_MN1 (XI1_I1206_I133_XG_n1 I1_I1206_G4_1n I1_I1206_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I183_XG_MN2 (XI1_I1206_I183_XG_n1 I1_I1206_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I183_XG_MN0 (I1_I1206_G16_0 I1_I1206_P16_1n XI1_I1206_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I183_XG_MN1 (XI1_I1206_I183_XG_n1 I1_I1206_G0_0n I1_I1206_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I202_XG_MN2 (XI1_I884_I202_XG_n1 I1_I884_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I202_XG_MN0 (I1_c7_o I1_I884_P31_16n XI1_I884_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I202_XG_MN1 (XI1_I884_I202_XG_n1 I1_I884_G15_0n I1_c7_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I200_XG_MN2 (XI1_I884_I200_XG_n1 I1_I884_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I200_XG_MN0 (I1_I884_G29_0 I1_I884_P29_14n XI1_I884_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I200_XG_MN1 (XI1_I884_I200_XG_n1 I1_I884_G13_0n I1_I884_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I198_XG_MN2 (XI1_I884_I198_XG_n1 I1_I884_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I198_XG_MN0 (I1_I884_G27_0 I1_I884_P27_12n XI1_I884_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I198_XG_MN1 (XI1_I884_I198_XG_n1 I1_I884_G11_0n I1_I884_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I190_XG_MN2 (XI1_I884_I190_XG_n1 I1_I884_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I190_XG_MN0 (I1_I884_G21_0 I1_I884_P21_6n XI1_I884_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I190_XG_MN1 (XI1_I884_I190_XG_n1 I1_I884_G5_0n I1_I884_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I140_XG_MN2 (XI1_I884_I140_XG_n1 I1_I884_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I140_XG_MN0 (I1_I884_G15_8 I1_I884_P15_12n XI1_I884_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I140_XG_MN1 (XI1_I884_I140_XG_n1 I1_I884_G11_8n I1_I884_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I138_XG_MN2 (XI1_I884_I138_XG_n1 I1_I884_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I138_XG_MN0 (I1_I884_G13_6 I1_I884_P13_10n XI1_I884_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I138_XG_MN1 (XI1_I884_I138_XG_n1 I1_I884_G9_6n I1_I884_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I136_XG_MN2 (XI1_I884_I136_XG_n1 I1_I884_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I136_XG_MN0 (I1_I884_G11_4 I1_I884_P11_8n XI1_I884_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I136_XG_MN1 (XI1_I884_I136_XG_n1 I1_I884_G7_4n I1_I884_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I75_XG_MN2 (XI1_I884_I75_XG_n1 I1_I884_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I75_XG_MN0 (I1_I884_G9_8 I1_I884_pn9 XI1_I884_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I75_XG_MN1 (XI1_I884_I75_XG_n1 I1_I884_gn8 I1_I884_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I68_XG_MN2 (XI1_I792_I68_XG_n1 I1_I792_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I68_XG_MN0 (I1_I792_G2_1 I1_I792_pn2 XI1_I792_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I68_XG_MN1 (XI1_I792_I68_XG_n1 I1_I792_gn1 I1_I792_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I67_XG_MN2 (XI1_I746_I67_XG_n1 I1_I746_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I67_XG_MN0 (I1_I746_G1_0 I1_I746_pn1 XI1_I746_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I67_XG_MN1 (XI1_I746_I67_XG_n1 I1_I746_G0_0n I1_I746_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I75_XG_MN2 (XI1_I746_I75_XG_n1 I1_I746_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I75_XG_MN0 (I1_I746_G9_8 I1_I746_pn9 XI1_I746_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I75_XG_MN1 (XI1_I746_I75_XG_n1 I1_I746_gn8 I1_I746_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I76_XG_MN2 (XI1_I746_I76_XG_n1 I1_I746_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I76_XG_MN0 (I1_I746_G10_9 I1_I746_pn10 XI1_I746_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I76_XG_MN1 (XI1_I746_I76_XG_n1 I1_I746_gn9 I1_I746_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I77_XG_MN2 (XI1_I746_I77_XG_n1 I1_I746_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I77_XG_MN0 (I1_I746_G11_10 I1_I746_pn11 XI1_I746_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I77_XG_MN1 (XI1_I746_I77_XG_n1 I1_I746_gn10 I1_I746_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I80_XG_MN2 (XI1_I746_I80_XG_n1 I1_I746_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I80_XG_MN0 (I1_I746_G14_13 I1_I746_pn14 XI1_I746_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I80_XG_MN1 (XI1_I746_I80_XG_n1 I1_I746_gn13 I1_I746_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I82_XG_MN2 (XI1_I746_I82_XG_n1 I1_I746_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I82_XG_MN0 (I1_I746_G16_15 I1_I746_pn16 XI1_I746_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I82_XG_MN1 (XI1_I746_I82_XG_n1 I1_I746_gn15 I1_I746_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I94_XG_MN2 (XI1_I1390_I94_XG_n1 I1_I1390_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I94_XG_MN0 (I1_I1390_G28_27 I1_I1390_pn28 XI1_I1390_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I94_XG_MN1 (XI1_I1390_I94_XG_n1 I1_I1390_gn27 I1_I1390_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I91_XG_MN2 (XI1_I1390_I91_XG_n1 I1_I1390_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I91_XG_MN0 (I1_I1390_G25_24 I1_I1390_pn25 XI1_I1390_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I91_XG_MN1 (XI1_I1390_I91_XG_n1 I1_I1390_gn24 I1_I1390_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I183_XG_MN2 (XI1_I1344_I183_XG_n1 I1_I1344_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I183_XG_MN0 (I1_I1344_G16_0 I1_I1344_P16_1n XI1_I1344_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I183_XG_MN1 (XI1_I1344_I183_XG_n1 I1_I1344_G0_0n I1_I1344_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I133_XG_MN2 (XI1_I1344_I133_XG_n1 I1_I1344_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I133_XG_MN0 (I1_I1344_G8_1 I1_I1344_P8_5n XI1_I1344_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I133_XG_MN1 (XI1_I1344_I133_XG_n1 I1_I1344_G4_1n I1_I1344_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I74_XG_MN2 (XI1_I1344_I74_XG_n1 I1_I1344_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I74_XG_MN0 (I1_I1344_G8_7 I1_I1344_pn8 XI1_I1344_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I74_XG_MN1 (XI1_I1344_I74_XG_n1 I1_I1344_gn7 I1_I1344_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I73_XG_MN2 (XI1_I1344_I73_XG_n1 I1_I1344_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I73_XG_MN0 (I1_I1344_G7_6 I1_I1344_pn7 XI1_I1344_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I73_XG_MN1 (XI1_I1344_I73_XG_n1 I1_I1344_gn6 I1_I1344_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I131_XG_MN2 (XI1_I1298_I131_XG_n1 I1_I1298_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I131_XG_MN0 (I1_I1298_G6_0 I1_I1298_P6_3n XI1_I1298_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I131_XG_MN1 (XI1_I1298_I131_XG_n1 I1_I1298_G2_0n I1_I1298_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I133_XG_MN2 (XI1_I1298_I133_XG_n1 I1_I1298_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I133_XG_MN0 (I1_I1298_G8_1 I1_I1298_P8_5n XI1_I1298_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I133_XG_MN1 (XI1_I1298_I133_XG_n1 I1_I1298_G4_1n I1_I1298_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I74_XG_MN2 (XI1_I1298_I74_XG_n1 I1_I1298_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I74_XG_MN0 (I1_I1298_G8_7 I1_I1298_pn8 XI1_I1298_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I74_XG_MN1 (XI1_I1298_I74_XG_n1 I1_I1298_gn7 I1_I1298_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I73_XG_MN2 (XI1_I1298_I73_XG_n1 I1_I1298_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I73_XG_MN0 (I1_I1298_G7_6 I1_I1298_pn7 XI1_I1298_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I73_XG_MN1 (XI1_I1298_I73_XG_n1 I1_I1298_gn6 I1_I1298_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I128_XG_MN2 (XI1_I1252_I128_XG_n1 I1_I1252_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I128_XG_MN0 (I1_I1252_G4_0 I1_I1252_P4_1n XI1_I1252_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I128_XG_MN1 (XI1_I1252_I128_XG_n1 I1_I1252_G0_0n I1_I1252_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I133_XG_MN2 (XI1_I1252_I133_XG_n1 I1_I1252_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I133_XG_MN0 (I1_I1252_G8_1 I1_I1252_P8_5n XI1_I1252_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I133_XG_MN1 (XI1_I1252_I133_XG_n1 I1_I1252_G4_1n I1_I1252_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I130_XG_MN2 (XI1_I1252_I130_XG_n1 I1_I1252_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I130_XG_MN0 (I1_I1252_G5_0 I1_I1252_P5_2n XI1_I1252_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I130_XG_MN1 (XI1_I1252_I130_XG_n1 I1_I1252_G1_0n I1_I1252_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I73_XG_MN2 (XI1_I1252_I73_XG_n1 I1_I1252_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I73_XG_MN0 (I1_I1252_G7_6 I1_I1252_pn7 XI1_I1252_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I73_XG_MN1 (XI1_I1252_I73_XG_n1 I1_I1252_gn6 I1_I1252_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I73_XG_MN2 (XI1_I1206_I73_XG_n1 I1_I1206_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I73_XG_MN0 (I1_I1206_G7_6 I1_I1206_pn7 XI1_I1206_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I73_XG_MN1 (XI1_I1206_I73_XG_n1 I1_I1206_gn6 I1_I1206_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I128_XG_MN2 (XI1_I1206_I128_XG_n1 I1_I1206_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I128_XG_MN0 (I1_I1206_G4_0 I1_I1206_P4_1n XI1_I1206_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I128_XG_MN1 (XI1_I1206_I128_XG_n1 I1_I1206_G0_0n I1_I1206_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I155_XG_MN2 (XI1_I884_I155_XG_n1 I1_I884_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I155_XG_MN0 (I1_I884_G30_23 I1_I884_P30_27n XI1_I884_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I155_XG_MN1 (XI1_I884_I155_XG_n1 I1_I884_G26_23n I1_I884_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I194_XG_MN2 (XI1_I884_I194_XG_n1 I1_I884_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I194_XG_MN0 (I1_I884_G23_0 I1_I884_P23_8n XI1_I884_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I194_XG_MN1 (XI1_I884_I194_XG_n1 I1_I884_G7_0n I1_I884_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I196_XG_MN2 (XI1_I884_I196_XG_n1 I1_I884_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I196_XG_MN0 (I1_I884_G25_0 I1_I884_P25_10n XI1_I884_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I196_XG_MN1 (XI1_I884_I196_XG_n1 I1_I884_G9_0n I1_I884_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I186_XG_MN2 (XI1_I884_I186_XG_n1 I1_I884_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I186_XG_MN0 (I1_I884_G19_0 I1_I884_P19_4n XI1_I884_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I186_XG_MN1 (XI1_I884_I186_XG_n1 I1_I884_G3_0n I1_I884_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I184_XG_MN2 (XI1_I884_I184_XG_n1 I1_I884_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I184_XG_MN0 (I1_I884_G17_0 I1_I884_P17_2n XI1_I884_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I184_XG_MN1 (XI1_I884_I184_XG_n1 I1_I884_G1_0n I1_I884_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I134_XG_MN2 (XI1_I884_I134_XG_n1 I1_I884_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I134_XG_MN0 (I1_I884_G9_2 I1_I884_P9_6n XI1_I884_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I134_XG_MN1 (XI1_I884_I134_XG_n1 I1_I884_G5_2n I1_I884_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I130_XG_MN2 (XI1_I884_I130_XG_n1 I1_I884_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I130_XG_MN0 (I1_I884_G5_0 I1_I884_P5_2n XI1_I884_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I130_XG_MN1 (XI1_I884_I130_XG_n1 I1_I884_G1_0n I1_I884_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I132_XG_MN2 (XI1_I884_I132_XG_n1 I1_I884_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I132_XG_MN0 (I1_I884_G7_0 I1_I884_P7_4n XI1_I884_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I132_XG_MN1 (XI1_I884_I132_XG_n1 I1_I884_G3_0n I1_I884_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I68_XG_MN2 (XI1_I746_I68_XG_n1 I1_I746_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I68_XG_MN0 (I1_I746_G2_1 I1_I746_pn2 XI1_I746_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I68_XG_MN1 (XI1_I746_I68_XG_n1 I1_I746_gn1 I1_I746_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I69_XG_MN2 (XI1_I746_I69_XG_n1 I1_I746_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I69_XG_MN0 (I1_I746_G3_2 I1_I746_pn3 XI1_I746_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I69_XG_MN1 (XI1_I746_I69_XG_n1 I1_I746_gn2 I1_I746_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I70_XG_MN2 (XI1_I746_I70_XG_n1 I1_I746_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I70_XG_MN0 (I1_I746_G4_3 I1_I746_pn4 XI1_I746_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I70_XG_MN1 (XI1_I746_I70_XG_n1 I1_I746_gn3 I1_I746_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I71_XG_MN2 (XI1_I746_I71_XG_n1 I1_I746_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I71_XG_MN0 (I1_I746_G5_4 I1_I746_pn5 XI1_I746_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I71_XG_MN1 (XI1_I746_I71_XG_n1 I1_I746_gn4 I1_I746_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I74_XG_MN2 (XI1_I746_I74_XG_n1 I1_I746_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I74_XG_MN0 (I1_I746_G8_7 I1_I746_pn8 XI1_I746_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I74_XG_MN1 (XI1_I746_I74_XG_n1 I1_I746_gn7 I1_I746_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I194_XG_MN2 (XI1_I700_I194_XG_n1 I1_I700_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I194_XG_MN0 (I1_I700_G23_0 I1_I700_P23_8n XI1_I700_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I194_XG_MN1 (XI1_I700_I194_XG_n1 I1_I700_G7_0n I1_I700_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I202_XG_MN2 (XI1_I700_I202_XG_n1 I1_I700_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I202_XG_MN0 (I1_c3_o I1_I700_P31_16n XI1_I700_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I202_XG_MN1 (XI1_I700_I202_XG_n1 I1_I700_G15_0n I1_c3_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I97_XG_MN2 (XI1_I1390_I97_XG_n1 I1_I1390_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I97_XG_MN0 (I1_I1390_G31_30 I1_I1390_pn31 XI1_I1390_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I97_XG_MN1 (XI1_I1390_I97_XG_n1 I1_I1390_gn30 I1_I1390_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I96_XG_MN2 (XI1_I1390_I96_XG_n1 I1_I1390_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I96_XG_MN0 (I1_I1390_G30_29 I1_I1390_pn30 XI1_I1390_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I96_XG_MN1 (XI1_I1390_I96_XG_n1 I1_I1390_gn29 I1_I1390_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I95_XG_MN2 (XI1_I1390_I95_XG_n1 I1_I1390_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I95_XG_MN0 (I1_I1390_G29_28 I1_I1390_pn29 XI1_I1390_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I95_XG_MN1 (XI1_I1390_I95_XG_n1 I1_I1390_gn28 I1_I1390_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I93_XG_MN2 (XI1_I1390_I93_XG_n1 I1_I1390_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I93_XG_MN0 (I1_I1390_G27_26 I1_I1390_pn27 XI1_I1390_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I93_XG_MN1 (XI1_I1390_I93_XG_n1 I1_I1390_gn26 I1_I1390_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I89_XG_MN2 (XI1_I1390_I89_XG_n1 I1_I1390_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I89_XG_MN0 (I1_I1390_G23_22 I1_I1390_pn23 XI1_I1390_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I89_XG_MN1 (XI1_I1390_I89_XG_n1 I1_I1390_gn22 I1_I1390_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I88_XG_MN2 (XI1_I1390_I88_XG_n1 I1_I1390_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I88_XG_MN0 (I1_I1390_G22_21 I1_I1390_pn22 XI1_I1390_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I88_XG_MN1 (XI1_I1390_I88_XG_n1 I1_I1390_gn21 I1_I1390_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I87_XG_MN2 (XI1_I1390_I87_XG_n1 I1_I1390_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I87_XG_MN0 (I1_I1390_G21_20 I1_I1390_pn21 XI1_I1390_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I87_XG_MN1 (XI1_I1390_I87_XG_n1 I1_I1390_gn20 I1_I1390_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I86_XG_MN2 (XI1_I1390_I86_XG_n1 I1_I1390_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I86_XG_MN0 (I1_I1390_G20_19 I1_I1390_pn20 XI1_I1390_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I86_XG_MN1 (XI1_I1390_I86_XG_n1 I1_I1390_gn19 I1_I1390_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I85_XG_MN2 (XI1_I1390_I85_XG_n1 I1_I1390_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I85_XG_MN0 (I1_I1390_G19_18 I1_I1390_pn19 XI1_I1390_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I85_XG_MN1 (XI1_I1390_I85_XG_n1 I1_I1390_gn18 I1_I1390_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I84_XG_MN2 (XI1_I1390_I84_XG_n1 I1_I1390_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I84_XG_MN0 (I1_I1390_G18_17 I1_I1390_pn18 XI1_I1390_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I84_XG_MN1 (XI1_I1390_I84_XG_n1 I1_I1390_gn17 I1_I1390_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I128_XG_MN2 (XI1_I1344_I128_XG_n1 I1_I1344_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I128_XG_MN0 (I1_I1344_G4_0 I1_I1344_P4_1n XI1_I1344_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I128_XG_MN1 (XI1_I1344_I128_XG_n1 I1_I1344_G0_0n I1_I1344_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I72_XG_MN2 (XI1_I1344_I72_XG_n1 I1_I1344_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I72_XG_MN0 (I1_I1344_G6_5 I1_I1344_pn6 XI1_I1344_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I72_XG_MN1 (XI1_I1344_I72_XG_n1 I1_I1344_gn5 I1_I1344_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I71_XG_MN2 (XI1_I1344_I71_XG_n1 I1_I1344_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I71_XG_MN0 (I1_I1344_G5_4 I1_I1344_pn5 XI1_I1344_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I71_XG_MN1 (XI1_I1344_I71_XG_n1 I1_I1344_gn4 I1_I1344_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I128_XG_MN2 (XI1_I1298_I128_XG_n1 I1_I1298_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I128_XG_MN0 (I1_I1298_G4_0 I1_I1298_P4_1n XI1_I1298_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I128_XG_MN1 (XI1_I1298_I128_XG_n1 I1_I1298_G0_0n I1_I1298_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I72_XG_MN2 (XI1_I1298_I72_XG_n1 I1_I1298_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I72_XG_MN0 (I1_I1298_G6_5 I1_I1298_pn6 XI1_I1298_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I72_XG_MN1 (XI1_I1298_I72_XG_n1 I1_I1298_gn5 I1_I1298_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I70_XG_MN2 (XI1_I1252_I70_XG_n1 I1_I1252_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I70_XG_MN0 (I1_I1252_G4_3 I1_I1252_pn4 XI1_I1252_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I70_XG_MN1 (XI1_I1252_I70_XG_n1 I1_I1252_gn3 I1_I1252_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I71_XG_MN2 (XI1_I1252_I71_XG_n1 I1_I1252_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I71_XG_MN0 (I1_I1252_G5_4 I1_I1252_pn5 XI1_I1252_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I71_XG_MN1 (XI1_I1252_I71_XG_n1 I1_I1252_gn4 I1_I1252_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I72_XG_MN2 (XI1_I1252_I72_XG_n1 I1_I1252_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I72_XG_MN0 (I1_I1252_G6_5 I1_I1252_pn6 XI1_I1252_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I72_XG_MN1 (XI1_I1252_I72_XG_n1 I1_I1252_gn5 I1_I1252_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I198_XG_MN2 (XI1_I1160_I198_XG_n1 I1_I1160_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I198_XG_MN0 (I1_I1160_G27_0 I1_I1160_P27_12n XI1_I1160_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I198_XG_MN1 (XI1_I1160_I198_XG_n1 I1_I1160_G11_0n I1_I1160_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I186_XG_MN2 (XI1_I1160_I186_XG_n1 I1_I1160_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I186_XG_MN0 (I1_I1160_G19_0 I1_I1160_P19_4n XI1_I1160_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I186_XG_MN1 (XI1_I1160_I186_XG_n1 I1_I1160_G3_0n I1_I1160_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I72_XG_MN2 (XI1_I1206_I72_XG_n1 I1_I1206_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I72_XG_MN0 (I1_I1206_G6_5 I1_I1206_pn6 XI1_I1206_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I72_XG_MN1 (XI1_I1206_I72_XG_n1 I1_I1206_gn5 I1_I1206_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I153_XG_MN2 (XI1_I884_I153_XG_n1 I1_I884_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I153_XG_MN0 (I1_I884_G28_21 I1_I884_P28_25n XI1_I884_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I153_XG_MN1 (XI1_I884_I153_XG_n1 I1_I884_G24_21n I1_I884_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I151_XG_MN2 (XI1_I884_I151_XG_n1 I1_I884_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I151_XG_MN0 (I1_I884_G26_19 I1_I884_P26_23n XI1_I884_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I151_XG_MN1 (XI1_I884_I151_XG_n1 I1_I884_G22_19n I1_I884_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I147_XG_MN2 (XI1_I884_I147_XG_n1 I1_I884_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I147_XG_MN0 (I1_I884_G22_15 I1_I884_P22_19n XI1_I884_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I147_XG_MN1 (XI1_I884_I147_XG_n1 I1_I884_G18_15n I1_I884_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I149_XG_MN2 (XI1_I884_I149_XG_n1 I1_I884_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I149_XG_MN0 (I1_I884_G24_17 I1_I884_P24_21n XI1_I884_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I149_XG_MN1 (XI1_I884_I149_XG_n1 I1_I884_G20_17n I1_I884_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I145_XG_MN2 (XI1_I884_I145_XG_n1 I1_I884_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I145_XG_MN0 (I1_I884_G20_13 I1_I884_P20_17n XI1_I884_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I145_XG_MN1 (XI1_I884_I145_XG_n1 I1_I884_G16_13n I1_I884_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I143_XG_MN2 (XI1_I884_I143_XG_n1 I1_I884_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I143_XG_MN0 (I1_I884_G18_11 I1_I884_P18_15n XI1_I884_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I143_XG_MN1 (XI1_I884_I143_XG_n1 I1_I884_G14_11n I1_I884_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I139_XG_MN2 (XI1_I884_I139_XG_n1 I1_I884_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I139_XG_MN0 (I1_I884_G14_7 I1_I884_P14_11n XI1_I884_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I139_XG_MN1 (XI1_I884_I139_XG_n1 I1_I884_G10_7n I1_I884_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I141_XG_MN2 (XI1_I884_I141_XG_n1 I1_I884_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I141_XG_MN0 (I1_I884_G16_9 I1_I884_P16_13n XI1_I884_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I141_XG_MN1 (XI1_I884_I141_XG_n1 I1_I884_G12_9n I1_I884_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I137_XG_MN2 (XI1_I884_I137_XG_n1 I1_I884_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I137_XG_MN0 (I1_I884_G12_5 I1_I884_P12_9n XI1_I884_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I137_XG_MN1 (XI1_I884_I137_XG_n1 I1_I884_G8_5n I1_I884_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I70_XG_MN2 (XI1_I884_I70_XG_n1 I1_I884_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I70_XG_MN0 (I1_I884_G4_3 I1_I884_pn4 XI1_I884_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I70_XG_MN1 (XI1_I884_I70_XG_n1 I1_I884_gn3 I1_I884_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I132_XG_MN2 (XI1_I700_I132_XG_n1 I1_I700_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I132_XG_MN0 (I1_I700_G7_0 I1_I700_P7_4n XI1_I700_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I132_XG_MN1 (XI1_I700_I132_XG_n1 I1_I700_G3_0n I1_I700_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I136_XG_MN2 (XI1_I700_I136_XG_n1 I1_I700_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I136_XG_MN0 (I1_I700_G11_4 I1_I700_P11_8n XI1_I700_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I136_XG_MN1 (XI1_I700_I136_XG_n1 I1_I700_G7_4n I1_I700_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I140_XG_MN2 (XI1_I700_I140_XG_n1 I1_I700_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I140_XG_MN0 (I1_I700_G15_8 I1_I700_P15_12n XI1_I700_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I140_XG_MN1 (XI1_I700_I140_XG_n1 I1_I700_G11_8n I1_I700_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I186_XG_MN2 (XI1_I700_I186_XG_n1 I1_I700_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I186_XG_MN0 (I1_I700_G19_0 I1_I700_P19_4n XI1_I700_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I186_XG_MN1 (XI1_I700_I186_XG_n1 I1_I700_G3_0n I1_I700_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I190_XG_MN2 (XI1_I700_I190_XG_n1 I1_I700_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I190_XG_MN0 (I1_I700_G21_0 I1_I700_P21_6n XI1_I700_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I190_XG_MN1 (XI1_I700_I190_XG_n1 I1_I700_G5_0n I1_I700_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I196_XG_MN2 (XI1_I700_I196_XG_n1 I1_I700_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I196_XG_MN0 (I1_I700_G25_0 I1_I700_P25_10n XI1_I700_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I196_XG_MN1 (XI1_I700_I196_XG_n1 I1_I700_G9_0n I1_I700_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I198_XG_MN2 (XI1_I700_I198_XG_n1 I1_I700_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I198_XG_MN0 (I1_I700_G27_0 I1_I700_P27_12n XI1_I700_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I198_XG_MN1 (XI1_I700_I198_XG_n1 I1_I700_G11_0n I1_I700_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I200_XG_MN2 (XI1_I700_I200_XG_n1 I1_I700_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I200_XG_MN0 (I1_I700_G29_0 I1_I700_P29_14n XI1_I700_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I200_XG_MN1 (XI1_I700_I200_XG_n1 I1_I700_G13_0n I1_I700_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I156_XG_MN2 (XI1_I700_I156_XG_n1 I1_I700_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I156_XG_MN0 (I1_I700_G31_24 I1_I700_P31_28n XI1_I700_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I156_XG_MN1 (XI1_I700_I156_XG_n1 I1_I700_G27_24n I1_I700_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I156_XG_MN2 (XI1_I1390_I156_XG_n1 I1_I1390_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I156_XG_MN0 (I1_I1390_G31_24 I1_I1390_P31_28n XI1_I1390_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I156_XG_MN1 (XI1_I1390_I156_XG_n1 I1_I1390_G27_24n I1_I1390_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I154_XG_MN2 (XI1_I1390_I154_XG_n1 I1_I1390_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I154_XG_MN0 (I1_I1390_G29_22 I1_I1390_P29_26n XI1_I1390_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I154_XG_MN1 (XI1_I1390_I154_XG_n1 I1_I1390_G25_22n I1_I1390_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I152_XG_MN2 (XI1_I1390_I152_XG_n1 I1_I1390_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I152_XG_MN0 (I1_I1390_G27_20 I1_I1390_P27_24n XI1_I1390_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I152_XG_MN1 (XI1_I1390_I152_XG_n1 I1_I1390_G23_20n I1_I1390_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I148_XG_MN2 (XI1_I1390_I148_XG_n1 I1_I1390_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I148_XG_MN0 (I1_I1390_G23_16 I1_I1390_P23_20n XI1_I1390_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I148_XG_MN1 (XI1_I1390_I148_XG_n1 I1_I1390_G19_16n I1_I1390_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I150_XG_MN2 (XI1_I1390_I150_XG_n1 I1_I1390_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I150_XG_MN0 (I1_I1390_G25_18 I1_I1390_P25_22n XI1_I1390_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I150_XG_MN1 (XI1_I1390_I150_XG_n1 I1_I1390_G21_18n I1_I1390_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I146_XG_MN2 (XI1_I1390_I146_XG_n1 I1_I1390_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I146_XG_MN0 (I1_I1390_G21_14 I1_I1390_P21_18n XI1_I1390_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I146_XG_MN1 (XI1_I1390_I146_XG_n1 I1_I1390_G17_14n I1_I1390_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I144_XG_MN2 (XI1_I1390_I144_XG_n1 I1_I1390_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I144_XG_MN0 (I1_I1390_G19_12 I1_I1390_P19_16n XI1_I1390_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I144_XG_MN1 (XI1_I1390_I144_XG_n1 I1_I1390_G15_12n I1_I1390_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I83_XG_MN2 (XI1_I1390_I83_XG_n1 I1_I1390_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I83_XG_MN0 (I1_I1390_G17_16 I1_I1390_pn17 XI1_I1390_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I83_XG_MN1 (XI1_I1390_I83_XG_n1 I1_I1390_gn16 I1_I1390_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I82_XG_MN2 (XI1_I1390_I82_XG_n1 I1_I1390_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I82_XG_MN0 (I1_I1390_G16_15 I1_I1390_pn16 XI1_I1390_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I82_XG_MN1 (XI1_I1390_I82_XG_n1 I1_I1390_gn15 I1_I1390_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I81_XG_MN2 (XI1_I1390_I81_XG_n1 I1_I1390_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I81_XG_MN0 (I1_I1390_G15_14 I1_I1390_pn15 XI1_I1390_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I81_XG_MN1 (XI1_I1390_I81_XG_n1 I1_I1390_gn14 I1_I1390_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I70_XG_MN2 (XI1_I1344_I70_XG_n1 I1_I1344_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I70_XG_MN0 (I1_I1344_G4_3 I1_I1344_pn4 XI1_I1344_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I70_XG_MN1 (XI1_I1344_I70_XG_n1 I1_I1344_gn3 I1_I1344_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I71_XG_MN2 (XI1_I1298_I71_XG_n1 I1_I1298_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I71_XG_MN0 (I1_I1298_G5_4 I1_I1298_pn5 XI1_I1298_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I71_XG_MN1 (XI1_I1298_I71_XG_n1 I1_I1298_gn4 I1_I1298_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I70_XG_MN2 (XI1_I1298_I70_XG_n1 I1_I1298_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I70_XG_MN0 (I1_I1298_G4_3 I1_I1298_pn4 XI1_I1298_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I70_XG_MN1 (XI1_I1298_I70_XG_n1 I1_I1298_gn3 I1_I1298_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I69_XG_MN2 (XI1_I1252_I69_XG_n1 I1_I1252_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I69_XG_MN0 (I1_I1252_G3_2 I1_I1252_pn3 XI1_I1252_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I69_XG_MN1 (XI1_I1252_I69_XG_n1 I1_I1252_gn2 I1_I1252_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I202_XG_MN2 (XI1_I1160_I202_XG_n1 I1_I1160_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I202_XG_MN0 (I1_c13_o I1_I1160_P31_16n XI1_I1160_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I202_XG_MN1 (XI1_I1160_I202_XG_n1 I1_I1160_G15_0n I1_c13_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I194_XG_MN2 (XI1_I1160_I194_XG_n1 I1_I1160_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I194_XG_MN0 (I1_I1160_G23_0 I1_I1160_P23_8n XI1_I1160_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I194_XG_MN1 (XI1_I1160_I194_XG_n1 I1_I1160_G7_0n I1_I1160_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I200_XG_MN2 (XI1_I1160_I200_XG_n1 I1_I1160_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I200_XG_MN0 (I1_I1160_G29_0 I1_I1160_P29_14n XI1_I1160_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I200_XG_MN1 (XI1_I1160_I200_XG_n1 I1_I1160_G13_0n I1_I1160_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I190_XG_MN2 (XI1_I1160_I190_XG_n1 I1_I1160_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I190_XG_MN0 (I1_I1160_G21_0 I1_I1160_P21_6n XI1_I1160_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I190_XG_MN1 (XI1_I1160_I190_XG_n1 I1_I1160_G5_0n I1_I1160_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I196_XG_MN2 (XI1_I1160_I196_XG_n1 I1_I1160_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I196_XG_MN0 (I1_I1160_G25_0 I1_I1160_P25_10n XI1_I1160_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I196_XG_MN1 (XI1_I1160_I196_XG_n1 I1_I1160_G9_0n I1_I1160_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I136_XG_MN2 (XI1_I1160_I136_XG_n1 I1_I1160_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I136_XG_MN0 (I1_I1160_G11_4 I1_I1160_P11_8n XI1_I1160_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I136_XG_MN1 (XI1_I1160_I136_XG_n1 I1_I1160_G7_4n I1_I1160_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I132_XG_MN2 (XI1_I1160_I132_XG_n1 I1_I1160_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I132_XG_MN0 (I1_I1160_G7_0 I1_I1160_P7_4n XI1_I1160_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I132_XG_MN1 (XI1_I1160_I132_XG_n1 I1_I1160_G3_0n I1_I1160_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I71_XG_MN2 (XI1_I1206_I71_XG_n1 I1_I1206_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I71_XG_MN0 (I1_I1206_G5_4 I1_I1206_pn5 XI1_I1206_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I71_XG_MN1 (XI1_I1206_I71_XG_n1 I1_I1206_gn4 I1_I1206_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I70_XG_MN2 (XI1_I1206_I70_XG_n1 I1_I1206_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I70_XG_MN0 (I1_I1206_G4_3 I1_I1206_pn4 XI1_I1206_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I70_XG_MN1 (XI1_I1206_I70_XG_n1 I1_I1206_gn3 I1_I1206_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I69_XG_MN2 (XI1_I1206_I69_XG_n1 I1_I1206_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I69_XG_MN0 (I1_I1206_G3_2 I1_I1206_pn3 XI1_I1206_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I69_XG_MN1 (XI1_I1206_I69_XG_n1 I1_I1206_gn2 I1_I1206_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I68_XG_MN2 (XI1_I1206_I68_XG_n1 I1_I1206_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I68_XG_MN0 (I1_I1206_G2_1 I1_I1206_pn2 XI1_I1206_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I68_XG_MN1 (XI1_I1206_I68_XG_n1 I1_I1206_gn1 I1_I1206_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I67_XG_MN2 (XI1_I1206_I67_XG_n1 I1_I1206_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I67_XG_MN0 (I1_I1206_G1_0 I1_I1206_pn1 XI1_I1206_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I67_XG_MN1 (XI1_I1206_I67_XG_n1 I1_I1206_G0_0n I1_I1206_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I201_XG_MN2 (XI1_I884_I201_XG_n1 I1_I884_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I201_XG_MN0 (I1_c7_m I1_I884_P30_15n XI1_I884_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I201_XG_MN1 (XI1_I884_I201_XG_n1 I1_I884_G14_0n I1_c7_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I199_XG_MN2 (XI1_I884_I199_XG_n1 I1_I884_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I199_XG_MN0 (I1_I884_G28_0 I1_I884_P28_13n XI1_I884_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I199_XG_MN1 (XI1_I884_I199_XG_n1 I1_I884_G12_0n I1_I884_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I197_XG_MN2 (XI1_I884_I197_XG_n1 I1_I884_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I197_XG_MN0 (I1_I884_G26_0 I1_I884_P26_11n XI1_I884_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I197_XG_MN1 (XI1_I884_I197_XG_n1 I1_I884_G10_0n I1_I884_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I192_XG_MN2 (XI1_I884_I192_XG_n1 I1_I884_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I192_XG_MN0 (I1_I884_G22_0 I1_I884_P22_7n XI1_I884_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I192_XG_MN1 (XI1_I884_I192_XG_n1 I1_I884_G6_0n I1_I884_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I195_XG_MN2 (XI1_I884_I195_XG_n1 I1_I884_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I195_XG_MN0 (I1_I884_G24_0 I1_I884_P24_9n XI1_I884_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I195_XG_MN1 (XI1_I884_I195_XG_n1 I1_I884_G8_0n I1_I884_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
