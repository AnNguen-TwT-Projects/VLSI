    I_MXI0_I1392_MP19 (XI0_I1392_ap3 I0_pp1_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1392_MP20 (VDD I0_pp2_17 XI0_I1392_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1395_MP50 (VDD XI0_I1395_s1 XI0_I1395_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1395_MP47 (XI0_I1395_bp3 I0_pp3_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1395_MP49 (XI0_I1395_bsn XI0_I1395_bcon XI0_I1395_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1395_MP52 (XI0_I1395_bp5 I0_cm31_2 XI0_I1395_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1395_MP51 (XI0_I1395_bp4 I0_pp3_16 XI0_I1395_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1395_MP51_1 (XI0_I1395_bp5 I0_pp3_16 XI0_I1395_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1395_MP52_1 (XI0_I1395_bsn I0_cm31_2 XI0_I1395_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1395_MP54 (VDD XI0_I1395_bsn I0_cm34_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1395_MP41 (XI0_I1395_bp1 XI0_I1395_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1395_MP42 (XI0_I1395_bcon I0_pp3_16 XI0_I1395_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1395_MP45 (XI0_I1395_bp2 I0_cm31_2 XI0_I1395_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1395_MP43 (VDD XI0_I1395_s1 XI0_I1395_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1395_MP44 (XI0_I1395_bp2 I0_pp3_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1395_MP56 (VDD XI0_I1395_bcon I0_cm34_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1395_MP46 (XI0_I1395_bp3 XI0_I1395_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1395_MP48 (VDD I0_cm31_2 XI0_I1395_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1395_MP50_1 (XI0_I1395_bp4 XI0_I1395_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1395_MP26 (VDD XI0_I1395_asn XI0_I1395_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1395_MP18 (XI0_I1395_ap3 I0_pp0_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1395_MP21 (XI0_I1395_asn XI0_I1395_acon XI0_I1395_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1395_MP24 (XI0_I1395_ap5 I0_pp2_18 XI0_I1395_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1395_MP23 (XI0_I1395_ap4 I0_pp1_20 XI0_I1395_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1395_MP22 (VDD I0_pp0_22 XI0_I1395_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1395_MP22_1 (XI0_I1395_ap4 I0_pp0_22 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1395_MP23_1 (XI0_I1395_ap5 I0_pp1_20 XI0_I1395_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1395_MP24_1 (XI0_I1395_asn I0_pp2_18 XI0_I1395_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1395_MP17 (XI0_I1395_acon I0_pp2_18 XI0_I1395_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1395_MP14 (XI0_I1395_ap1 I0_pp1_20 XI0_I1395_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1395_MP13 (VDD I0_pp0_22 XI0_I1395_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1395_MP15 (XI0_I1395_ap2 I0_pp0_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1395_MP16 (VDD I0_pp1_20 XI0_I1395_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1395_MP28 (I0_cm34_2 XI0_I1395_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1395_MP19 (XI0_I1395_ap3 I0_pp1_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1395_MP20 (VDD I0_pp2_18 XI0_I1395_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1414_MP50 (VDD XI0_I1414_s1 XI0_I1414_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1414_MP47 (XI0_I1414_bp3 I0_pp3_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1414_MP49 (XI0_I1414_bsn XI0_I1414_bcon XI0_I1414_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1414_MP52 (XI0_I1414_bp5 I0_cm50_2 XI0_I1414_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1414_MP51 (XI0_I1414_bp4 I0_pp3_22 XI0_I1414_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1414_MP51_1 (XI0_I1414_bp5 I0_pp3_22 XI0_I1414_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1414_MP52_1 (XI0_I1414_bsn I0_cm50_2 XI0_I1414_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1414_MP54 (VDD XI0_I1414_bsn I0_cm53_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1414_MP41 (XI0_I1414_bp1 XI0_I1414_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1414_MP42 (XI0_I1414_bcon I0_pp3_22 XI0_I1414_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1414_MP45 (XI0_I1414_bp2 I0_cm50_2 XI0_I1414_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1414_MP43 (VDD XI0_I1414_s1 XI0_I1414_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1414_MP44 (XI0_I1414_bp2 I0_pp3_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1414_MP56 (VDD XI0_I1414_bcon I0_cm53_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1414_MP46 (XI0_I1414_bp3 XI0_I1414_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1414_MP48 (VDD I0_cm50_2 XI0_I1414_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1414_MP50_1 (XI0_I1414_bp4 XI0_I1414_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1414_MP26 (VDD XI0_I1414_asn XI0_I1414_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1414_MP18 (XI0_I1414_ap3 I0_pp0_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1414_MP21 (XI0_I1414_asn XI0_I1414_acon XI0_I1414_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1414_MP24 (XI0_I1414_ap5 I0_pp2_24 XI0_I1414_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1414_MP23 (XI0_I1414_ap4 I0_pp1_26 XI0_I1414_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1414_MP22 (VDD I0_pp0_28 XI0_I1414_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1414_MP22_1 (XI0_I1414_ap4 I0_pp0_28 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1414_MP23_1 (XI0_I1414_ap5 I0_pp1_26 XI0_I1414_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1414_MP24_1 (XI0_I1414_asn I0_pp2_24 XI0_I1414_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1414_MP17 (XI0_I1414_acon I0_pp2_24 XI0_I1414_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1414_MP14 (XI0_I1414_ap1 I0_pp1_26 XI0_I1414_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1414_MP13 (VDD I0_pp0_28 XI0_I1414_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1414_MP15 (XI0_I1414_ap2 I0_pp0_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1414_MP16 (VDD I0_pp1_26 XI0_I1414_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1414_MP28 (I0_cm53_2 XI0_I1414_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1414_MP19 (XI0_I1414_ap3 I0_pp1_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1414_MP20 (VDD I0_pp2_24 XI0_I1414_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1450_MP50 (VDD XI0_I1450_s1 XI0_I1450_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1450_MP47 (XI0_I1450_bp3 I0_pp5_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1450_MP49 (XI0_I1450_bsn XI0_I1450_bcon XI0_I1450_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1450_MP52 (XI0_I1450_bp5 I0_cm85_2 XI0_I1450_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1450_MP51 (XI0_I1450_bp4 I0_pp5_27 XI0_I1450_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1450_MP51_1 (XI0_I1450_bp5 I0_pp5_27 XI0_I1450_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1450_MP52_1 (XI0_I1450_bsn I0_cm85_2 XI0_I1450_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1450_MP54 (VDD XI0_I1450_bsn I0_cm89_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1450_MP41 (XI0_I1450_bp1 XI0_I1450_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1450_MP42 (XI0_I1450_bcon I0_pp5_27 XI0_I1450_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1450_MP45 (XI0_I1450_bp2 I0_cm85_2 XI0_I1450_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1450_MP43 (VDD XI0_I1450_s1 XI0_I1450_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1450_MP44 (XI0_I1450_bp2 I0_pp5_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1450_MP56 (VDD XI0_I1450_bcon I0_cm89_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1450_MP46 (XI0_I1450_bp3 XI0_I1450_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1450_MP48 (VDD I0_cm85_2 XI0_I1450_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1450_MP50_1 (XI0_I1450_bp4 XI0_I1450_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1450_MP26 (VDD XI0_I1450_asn XI0_I1450_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1450_MP18 (XI0_I1450_ap3 I0_sn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1450_MP21 (XI0_I1450_asn XI0_I1450_acon XI0_I1450_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1450_MP24 (XI0_I1450_ap5 I0_pp4_29 XI0_I1450_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1450_MP23 (XI0_I1450_ap4 I0_pp3_31 XI0_I1450_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1450_MP22 (VDD I0_sn2 XI0_I1450_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1450_MP22_1 (XI0_I1450_ap4 I0_sn2 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1450_MP23_1 (XI0_I1450_ap5 I0_pp3_31 XI0_I1450_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1450_MP24_1 (XI0_I1450_asn I0_pp4_29 XI0_I1450_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1450_MP17 (XI0_I1450_acon I0_pp4_29 XI0_I1450_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1450_MP14 (XI0_I1450_ap1 I0_pp3_31 XI0_I1450_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1450_MP13 (VDD I0_sn2 XI0_I1450_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1450_MP15 (XI0_I1450_ap2 I0_sn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1450_MP16 (VDD I0_pp3_31 XI0_I1450_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1450_MP28 (I0_cm89_2 XI0_I1450_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1450_MP19 (XI0_I1450_ap3 I0_pp3_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1450_MP20 (VDD I0_pp4_29 XI0_I1450_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1382_MP50 (VDD XI0_I1382_s1 XI0_I1382_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1382_MP47 (XI0_I1382_bp3 I0_pp3_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1382_MP49 (XI0_I1382_bsn XI0_I1382_bcon XI0_I1382_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1382_MP52 (XI0_I1382_bp5 I0_cm19_2 XI0_I1382_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1382_MP51 (XI0_I1382_bp4 I0_pp3_11 XI0_I1382_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1382_MP51_1 (XI0_I1382_bp5 I0_pp3_11 XI0_I1382_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1382_MP52_1 (XI0_I1382_bsn I0_cm19_2 XI0_I1382_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1382_MP54 (VDD XI0_I1382_bsn I0_cm21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1382_MP41 (XI0_I1382_bp1 XI0_I1382_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1382_MP42 (XI0_I1382_bcon I0_pp3_11 XI0_I1382_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1382_MP45 (XI0_I1382_bp2 I0_cm19_2 XI0_I1382_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1382_MP43 (VDD XI0_I1382_s1 XI0_I1382_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1382_MP44 (XI0_I1382_bp2 I0_pp3_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1382_MP56 (VDD XI0_I1382_bcon I0_cm21_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1382_MP46 (XI0_I1382_bp3 XI0_I1382_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1382_MP48 (VDD I0_cm19_2 XI0_I1382_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1382_MP50_1 (XI0_I1382_bp4 XI0_I1382_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1382_MP26 (VDD XI0_I1382_asn XI0_I1382_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1382_MP18 (XI0_I1382_ap3 I0_pp0_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1382_MP21 (XI0_I1382_asn XI0_I1382_acon XI0_I1382_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1382_MP24 (XI0_I1382_ap5 I0_pp2_13 XI0_I1382_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1382_MP23 (XI0_I1382_ap4 I0_pp1_15 XI0_I1382_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1382_MP22 (VDD I0_pp0_17 XI0_I1382_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1382_MP22_1 (XI0_I1382_ap4 I0_pp0_17 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1382_MP23_1 (XI0_I1382_ap5 I0_pp1_15 XI0_I1382_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1382_MP24_1 (XI0_I1382_asn I0_pp2_13 XI0_I1382_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1382_MP17 (XI0_I1382_acon I0_pp2_13 XI0_I1382_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1382_MP14 (XI0_I1382_ap1 I0_pp1_15 XI0_I1382_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1382_MP13 (VDD I0_pp0_17 XI0_I1382_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1382_MP15 (XI0_I1382_ap2 I0_pp0_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1382_MP16 (VDD I0_pp1_15 XI0_I1382_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1382_MP28 (I0_cm21_2 XI0_I1382_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1382_MP19 (XI0_I1382_ap3 I0_pp1_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1382_MP20 (VDD I0_pp2_13 XI0_I1382_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1398_MP50 (VDD XI0_I1398_s1 XI0_I1398_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1398_MP47 (XI0_I1398_bp3 I0_pp3_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1398_MP49 (XI0_I1398_bsn XI0_I1398_bcon XI0_I1398_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1398_MP52 (XI0_I1398_bp5 I0_cm34_2 XI0_I1398_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1398_MP51 (XI0_I1398_bp4 I0_pp3_17 XI0_I1398_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1398_MP51_1 (XI0_I1398_bp5 I0_pp3_17 XI0_I1398_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1398_MP52_1 (XI0_I1398_bsn I0_cm34_2 XI0_I1398_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1398_MP54 (VDD XI0_I1398_bsn I0_cm37_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1398_MP41 (XI0_I1398_bp1 XI0_I1398_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1398_MP42 (XI0_I1398_bcon I0_pp3_17 XI0_I1398_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1398_MP45 (XI0_I1398_bp2 I0_cm34_2 XI0_I1398_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1398_MP43 (VDD XI0_I1398_s1 XI0_I1398_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1398_MP44 (XI0_I1398_bp2 I0_pp3_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1398_MP56 (VDD XI0_I1398_bcon I0_cm37_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1398_MP46 (XI0_I1398_bp3 XI0_I1398_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1398_MP48 (VDD I0_cm34_2 XI0_I1398_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1398_MP50_1 (XI0_I1398_bp4 XI0_I1398_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1398_MP26 (VDD XI0_I1398_asn XI0_I1398_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1398_MP18 (XI0_I1398_ap3 I0_pp0_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1398_MP21 (XI0_I1398_asn XI0_I1398_acon XI0_I1398_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1398_MP24 (XI0_I1398_ap5 I0_pp2_19 XI0_I1398_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1398_MP23 (XI0_I1398_ap4 I0_pp1_21 XI0_I1398_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1398_MP22 (VDD I0_pp0_23 XI0_I1398_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1398_MP22_1 (XI0_I1398_ap4 I0_pp0_23 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1398_MP23_1 (XI0_I1398_ap5 I0_pp1_21 XI0_I1398_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1398_MP24_1 (XI0_I1398_asn I0_pp2_19 XI0_I1398_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1398_MP17 (XI0_I1398_acon I0_pp2_19 XI0_I1398_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1398_MP14 (XI0_I1398_ap1 I0_pp1_21 XI0_I1398_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1398_MP13 (VDD I0_pp0_23 XI0_I1398_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1398_MP15 (XI0_I1398_ap2 I0_pp0_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1398_MP16 (VDD I0_pp1_21 XI0_I1398_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1398_MP28 (I0_cm37_2 XI0_I1398_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1398_MP19 (XI0_I1398_ap3 I0_pp1_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1398_MP20 (VDD I0_pp2_19 XI0_I1398_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1401_MP50 (VDD XI0_I1401_s1 XI0_I1401_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1401_MP47 (XI0_I1401_bp3 I0_pp3_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1401_MP49 (XI0_I1401_bsn XI0_I1401_bcon XI0_I1401_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1401_MP52 (XI0_I1401_bp5 I0_cm37_2 XI0_I1401_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1401_MP51 (XI0_I1401_bp4 I0_pp3_18 XI0_I1401_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1401_MP51_1 (XI0_I1401_bp5 I0_pp3_18 XI0_I1401_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1401_MP52_1 (XI0_I1401_bsn I0_cm37_2 XI0_I1401_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1401_MP54 (VDD XI0_I1401_bsn I0_cm40_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1401_MP41 (XI0_I1401_bp1 XI0_I1401_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1401_MP42 (XI0_I1401_bcon I0_pp3_18 XI0_I1401_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1401_MP45 (XI0_I1401_bp2 I0_cm37_2 XI0_I1401_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1401_MP43 (VDD XI0_I1401_s1 XI0_I1401_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1401_MP44 (XI0_I1401_bp2 I0_pp3_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1401_MP56 (VDD XI0_I1401_bcon I0_cm40_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1401_MP46 (XI0_I1401_bp3 XI0_I1401_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1401_MP48 (VDD I0_cm37_2 XI0_I1401_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1401_MP50_1 (XI0_I1401_bp4 XI0_I1401_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1401_MP26 (VDD XI0_I1401_asn XI0_I1401_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1401_MP18 (XI0_I1401_ap3 I0_pp0_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1401_MP21 (XI0_I1401_asn XI0_I1401_acon XI0_I1401_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1401_MP24 (XI0_I1401_ap5 I0_pp2_20 XI0_I1401_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1401_MP23 (XI0_I1401_ap4 I0_pp1_22 XI0_I1401_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1401_MP22 (VDD I0_pp0_24 XI0_I1401_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1401_MP22_1 (XI0_I1401_ap4 I0_pp0_24 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1401_MP23_1 (XI0_I1401_ap5 I0_pp1_22 XI0_I1401_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1401_MP24_1 (XI0_I1401_asn I0_pp2_20 XI0_I1401_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1401_MP17 (XI0_I1401_acon I0_pp2_20 XI0_I1401_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1401_MP14 (XI0_I1401_ap1 I0_pp1_22 XI0_I1401_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1401_MP13 (VDD I0_pp0_24 XI0_I1401_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1401_MP15 (XI0_I1401_ap2 I0_pp0_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1401_MP16 (VDD I0_pp1_22 XI0_I1401_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1401_MP28 (I0_cm40_2 XI0_I1401_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1401_MP19 (XI0_I1401_ap3 I0_pp1_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1401_MP20 (VDD I0_pp2_20 XI0_I1401_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1456_MP50 (VDD XI0_I1456_s1 XI0_I1456_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1456_MP47 (XI0_I1456_bp3 I0_pp6_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1456_MP49 (XI0_I1456_bsn XI0_I1456_bcon XI0_I1456_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1456_MP52 (XI0_I1456_bp5 I0_cm92_2 XI0_I1456_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1456_MP51 (XI0_I1456_bp4 I0_pp6_27 XI0_I1456_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1456_MP51_1 (XI0_I1456_bp5 I0_pp6_27 XI0_I1456_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1456_MP52_1 (XI0_I1456_bsn I0_cm92_2 XI0_I1456_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1456_MP54 (VDD XI0_I1456_bsn I0_cm95_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1456_MP41 (XI0_I1456_bp1 XI0_I1456_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1456_MP42 (XI0_I1456_bcon I0_pp6_27 XI0_I1456_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1456_MP45 (XI0_I1456_bp2 I0_cm92_2 XI0_I1456_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1456_MP43 (VDD XI0_I1456_s1 XI0_I1456_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1456_MP44 (XI0_I1456_bp2 I0_pp6_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1456_MP56 (VDD XI0_I1456_bcon I0_cm95_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1456_MP46 (XI0_I1456_bp3 XI0_I1456_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1456_MP48 (VDD I0_cm92_2 XI0_I1456_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1456_MP50_1 (XI0_I1456_bp4 XI0_I1456_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1456_MP26 (VDD XI0_I1456_asn XI0_I1456_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1456_MP18 (XI0_I1456_ap3 I0_sn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1456_MP21 (XI0_I1456_asn XI0_I1456_acon XI0_I1456_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1456_MP24 (XI0_I1456_ap5 I0_pp5_29 XI0_I1456_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1456_MP23 (XI0_I1456_ap4 I0_pp4_31 XI0_I1456_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1456_MP22 (VDD I0_sn3 XI0_I1456_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1456_MP22_1 (XI0_I1456_ap4 I0_sn3 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1456_MP23_1 (XI0_I1456_ap5 I0_pp4_31 XI0_I1456_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1456_MP24_1 (XI0_I1456_asn I0_pp5_29 XI0_I1456_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1456_MP17 (XI0_I1456_acon I0_pp5_29 XI0_I1456_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1456_MP14 (XI0_I1456_ap1 I0_pp4_31 XI0_I1456_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1456_MP13 (VDD I0_sn3 XI0_I1456_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1456_MP15 (XI0_I1456_ap2 I0_sn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1456_MP16 (VDD I0_pp4_31 XI0_I1456_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1456_MP28 (I0_cm95_2 XI0_I1456_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1456_MP19 (XI0_I1456_ap3 I0_pp4_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1456_MP20 (VDD I0_pp5_29 XI0_I1456_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1378_MP50 (VDD XI0_I1378_s1 XI0_I1378_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1378_MP47 (XI0_I1378_bp3 I0_pp3_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1378_MP49 (XI0_I1378_bsn XI0_I1378_bcon XI0_I1378_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1378_MP52 (XI0_I1378_bp5 I0_cm15_2 XI0_I1378_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1378_MP51 (XI0_I1378_bp4 I0_pp3_9 XI0_I1378_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1378_MP51_1 (XI0_I1378_bp5 I0_pp3_9 XI0_I1378_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1378_MP52_1 (XI0_I1378_bsn I0_cm15_2 XI0_I1378_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1378_MP54 (VDD XI0_I1378_bsn I0_cm17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1378_MP41 (XI0_I1378_bp1 XI0_I1378_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1378_MP42 (XI0_I1378_bcon I0_pp3_9 XI0_I1378_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1378_MP45 (XI0_I1378_bp2 I0_cm15_2 XI0_I1378_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1378_MP43 (VDD XI0_I1378_s1 XI0_I1378_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1378_MP44 (XI0_I1378_bp2 I0_pp3_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1378_MP56 (VDD XI0_I1378_bcon I0_cm17_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1378_MP46 (XI0_I1378_bp3 XI0_I1378_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1378_MP48 (VDD I0_cm15_2 XI0_I1378_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1378_MP50_1 (XI0_I1378_bp4 XI0_I1378_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1378_MP26 (VDD XI0_I1378_asn XI0_I1378_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1378_MP18 (XI0_I1378_ap3 I0_pp0_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1378_MP21 (XI0_I1378_asn XI0_I1378_acon XI0_I1378_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1378_MP24 (XI0_I1378_ap5 I0_pp2_11 XI0_I1378_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1378_MP23 (XI0_I1378_ap4 I0_pp1_13 XI0_I1378_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1378_MP22 (VDD I0_pp0_15 XI0_I1378_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1378_MP22_1 (XI0_I1378_ap4 I0_pp0_15 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1378_MP23_1 (XI0_I1378_ap5 I0_pp1_13 XI0_I1378_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1378_MP24_1 (XI0_I1378_asn I0_pp2_11 XI0_I1378_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1378_MP17 (XI0_I1378_acon I0_pp2_11 XI0_I1378_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1378_MP14 (XI0_I1378_ap1 I0_pp1_13 XI0_I1378_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1378_MP13 (VDD I0_pp0_15 XI0_I1378_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1378_MP15 (XI0_I1378_ap2 I0_pp0_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1378_MP16 (VDD I0_pp1_13 XI0_I1378_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1378_MP28 (I0_cm17_2 XI0_I1378_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1378_MP19 (XI0_I1378_ap3 I0_pp1_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1378_MP20 (VDD I0_pp2_11 XI0_I1378_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1376_MP50 (VDD XI0_I1376_s1 XI0_I1376_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1376_MP47 (XI0_I1376_bp3 I0_pp3_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1376_MP49 (XI0_I1376_bsn XI0_I1376_bcon XI0_I1376_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1376_MP52 (XI0_I1376_bp5 I0_cm13_2 XI0_I1376_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1376_MP51 (XI0_I1376_bp4 I0_pp3_8 XI0_I1376_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1376_MP51_1 (XI0_I1376_bp5 I0_pp3_8 XI0_I1376_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1376_MP52_1 (XI0_I1376_bsn I0_cm13_2 XI0_I1376_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1376_MP54 (VDD XI0_I1376_bsn I0_cm15_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1376_MP41 (XI0_I1376_bp1 XI0_I1376_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1376_MP42 (XI0_I1376_bcon I0_pp3_8 XI0_I1376_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1376_MP45 (XI0_I1376_bp2 I0_cm13_2 XI0_I1376_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1376_MP43 (VDD XI0_I1376_s1 XI0_I1376_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1376_MP44 (XI0_I1376_bp2 I0_pp3_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1376_MP56 (VDD XI0_I1376_bcon I0_cm15_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1376_MP46 (XI0_I1376_bp3 XI0_I1376_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1376_MP48 (VDD I0_cm13_2 XI0_I1376_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1376_MP50_1 (XI0_I1376_bp4 XI0_I1376_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1376_MP26 (VDD XI0_I1376_asn XI0_I1376_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1376_MP18 (XI0_I1376_ap3 I0_pp0_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1376_MP21 (XI0_I1376_asn XI0_I1376_acon XI0_I1376_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1376_MP24 (XI0_I1376_ap5 I0_pp2_10 XI0_I1376_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1376_MP23 (XI0_I1376_ap4 I0_pp1_12 XI0_I1376_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1376_MP22 (VDD I0_pp0_14 XI0_I1376_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1376_MP22_1 (XI0_I1376_ap4 I0_pp0_14 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1376_MP23_1 (XI0_I1376_ap5 I0_pp1_12 XI0_I1376_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1376_MP24_1 (XI0_I1376_asn I0_pp2_10 XI0_I1376_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1376_MP17 (XI0_I1376_acon I0_pp2_10 XI0_I1376_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1376_MP14 (XI0_I1376_ap1 I0_pp1_12 XI0_I1376_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1376_MP13 (VDD I0_pp0_14 XI0_I1376_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1376_MP15 (XI0_I1376_ap2 I0_pp0_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1376_MP16 (VDD I0_pp1_12 XI0_I1376_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1376_MP28 (I0_cm15_2 XI0_I1376_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1376_MP19 (XI0_I1376_ap3 I0_pp1_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1376_MP20 (VDD I0_pp2_10 XI0_I1376_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1423_MP50 (VDD XI0_I1423_s1 XI0_I1423_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1423_MP47 (XI0_I1423_bp3 I0_pp7_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1423_MP49 (XI0_I1423_bsn XI0_I1423_bcon XI0_I1423_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1423_MP52 (XI0_I1423_bp5 I0_cm58_2 XI0_I1423_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1423_MP51 (XI0_I1423_bp4 I0_pp7_16 XI0_I1423_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1423_MP51_1 (XI0_I1423_bp5 I0_pp7_16 XI0_I1423_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1423_MP52_1 (XI0_I1423_bsn I0_cm58_2 XI0_I1423_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1423_MP54 (VDD XI0_I1423_bsn I0_cm62_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1423_MP41 (XI0_I1423_bp1 XI0_I1423_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1423_MP42 (XI0_I1423_bcon I0_pp7_16 XI0_I1423_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1423_MP45 (XI0_I1423_bp2 I0_cm58_2 XI0_I1423_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1423_MP43 (VDD XI0_I1423_s1 XI0_I1423_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1423_MP44 (XI0_I1423_bp2 I0_pp7_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1423_MP56 (VDD XI0_I1423_bcon I0_cm62_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1423_MP46 (XI0_I1423_bp3 XI0_I1423_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1423_MP48 (VDD I0_cm58_2 XI0_I1423_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1423_MP50_1 (XI0_I1423_bp4 XI0_I1423_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1423_MP26 (VDD XI0_I1423_asn XI0_I1423_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1423_MP18 (XI0_I1423_ap3 I0_pp4_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1423_MP21 (XI0_I1423_asn XI0_I1423_acon XI0_I1423_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1423_MP24 (XI0_I1423_ap5 I0_pp6_18 XI0_I1423_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1423_MP23 (XI0_I1423_ap4 I0_pp5_20 XI0_I1423_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1423_MP22 (VDD I0_pp4_22 XI0_I1423_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1423_MP22_1 (XI0_I1423_ap4 I0_pp4_22 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1423_MP23_1 (XI0_I1423_ap5 I0_pp5_20 XI0_I1423_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1423_MP24_1 (XI0_I1423_asn I0_pp6_18 XI0_I1423_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1423_MP17 (XI0_I1423_acon I0_pp6_18 XI0_I1423_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1423_MP14 (XI0_I1423_ap1 I0_pp5_20 XI0_I1423_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1423_MP13 (VDD I0_pp4_22 XI0_I1423_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1423_MP15 (XI0_I1423_ap2 I0_pp4_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1423_MP16 (VDD I0_pp5_20 XI0_I1423_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1423_MP28 (I0_cm62_2 XI0_I1423_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1423_MP19 (XI0_I1423_ap3 I0_pp5_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1423_MP20 (VDD I0_pp6_18 XI0_I1423_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1459_MP50 (VDD XI0_I1459_s1 XI0_I1459_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1459_MP47 (XI0_I1459_bp3 I0_pp6_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1459_MP49 (XI0_I1459_bsn XI0_I1459_bcon XI0_I1459_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1459_MP52 (XI0_I1459_bp5 I0_cm95_2 XI0_I1459_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1459_MP51 (XI0_I1459_bp4 I0_pp6_28 XI0_I1459_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1459_MP51_1 (XI0_I1459_bp5 I0_pp6_28 XI0_I1459_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1459_MP52_1 (XI0_I1459_bsn I0_cm95_2 XI0_I1459_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1459_MP54 (VDD XI0_I1459_bsn I0_cm98_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1459_MP41 (XI0_I1459_bp1 XI0_I1459_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1459_MP42 (XI0_I1459_bcon I0_pp6_28 XI0_I1459_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1459_MP45 (XI0_I1459_bp2 I0_cm95_2 XI0_I1459_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1459_MP43 (VDD XI0_I1459_s1 XI0_I1459_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1459_MP44 (XI0_I1459_bp2 I0_pp6_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1459_MP56 (VDD XI0_I1459_bcon I0_cm98_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1459_MP46 (XI0_I1459_bp3 XI0_I1459_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1459_MP48 (VDD I0_cm95_2 XI0_I1459_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1459_MP50_1 (XI0_I1459_bp4 XI0_I1459_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1459_MP26 (VDD XI0_I1459_asn XI0_I1459_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1459_MP18 (XI0_I1459_ap3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1459_MP21 (XI0_I1459_asn XI0_I1459_acon XI0_I1459_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1459_MP24 (XI0_I1459_ap5 I0_pp5_30 XI0_I1459_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1459_MP23 (XI0_I1459_ap4 I0_pp4_32 XI0_I1459_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1459_MP22 (VDD VDD XI0_I1459_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1459_MP22_1 (XI0_I1459_ap4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1459_MP23_1 (XI0_I1459_ap5 I0_pp4_32 XI0_I1459_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1459_MP24_1 (XI0_I1459_asn I0_pp5_30 XI0_I1459_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1459_MP17 (XI0_I1459_acon I0_pp5_30 XI0_I1459_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1459_MP14 (XI0_I1459_ap1 I0_pp4_32 XI0_I1459_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1459_MP13 (VDD VDD XI0_I1459_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1459_MP15 (XI0_I1459_ap2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1459_MP16 (VDD I0_pp4_32 XI0_I1459_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1459_MP28 (I0_cm98_2 XI0_I1459_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1459_MP19 (XI0_I1459_ap3 I0_pp4_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1459_MP20 (VDD I0_pp5_30 XI0_I1459_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1374_MP50 (VDD XI0_I1374_s1 XI0_I1374_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1374_MP47 (XI0_I1374_bp3 I0_pp3_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1374_MP49 (XI0_I1374_bsn XI0_I1374_bcon XI0_I1374_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1374_MP52 (XI0_I1374_bp5 I0_cm11_2 XI0_I1374_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1374_MP51 (XI0_I1374_bp4 I0_pp3_7 XI0_I1374_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1374_MP51_1 (XI0_I1374_bp5 I0_pp3_7 XI0_I1374_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1374_MP52_1 (XI0_I1374_bsn I0_cm11_2 XI0_I1374_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1374_MP54 (VDD XI0_I1374_bsn I0_cm13_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1374_MP41 (XI0_I1374_bp1 XI0_I1374_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1374_MP42 (XI0_I1374_bcon I0_pp3_7 XI0_I1374_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1374_MP45 (XI0_I1374_bp2 I0_cm11_2 XI0_I1374_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1374_MP43 (VDD XI0_I1374_s1 XI0_I1374_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1374_MP44 (XI0_I1374_bp2 I0_pp3_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1374_MP56 (VDD XI0_I1374_bcon I0_cm13_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1374_MP46 (XI0_I1374_bp3 XI0_I1374_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1374_MP48 (VDD I0_cm11_2 XI0_I1374_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1374_MP50_1 (XI0_I1374_bp4 XI0_I1374_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1374_MP26 (VDD XI0_I1374_asn XI0_I1374_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1374_MP18 (XI0_I1374_ap3 I0_pp0_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1374_MP21 (XI0_I1374_asn XI0_I1374_acon XI0_I1374_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1374_MP24 (XI0_I1374_ap5 I0_pp2_9 XI0_I1374_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1374_MP23 (XI0_I1374_ap4 I0_pp1_11 XI0_I1374_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1374_MP22 (VDD I0_pp0_13 XI0_I1374_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1374_MP22_1 (XI0_I1374_ap4 I0_pp0_13 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1374_MP23_1 (XI0_I1374_ap5 I0_pp1_11 XI0_I1374_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1374_MP24_1 (XI0_I1374_asn I0_pp2_9 XI0_I1374_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1374_MP17 (XI0_I1374_acon I0_pp2_9 XI0_I1374_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1374_MP14 (XI0_I1374_ap1 I0_pp1_11 XI0_I1374_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1374_MP13 (VDD I0_pp0_13 XI0_I1374_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1374_MP15 (XI0_I1374_ap2 I0_pp0_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1374_MP16 (VDD I0_pp1_11 XI0_I1374_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1374_MP28 (I0_cm13_2 XI0_I1374_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1374_MP19 (XI0_I1374_ap3 I0_pp1_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1374_MP20 (VDD I0_pp2_9 XI0_I1374_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1380_MP50 (VDD XI0_I1380_s1 XI0_I1380_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1380_MP47 (XI0_I1380_bp3 I0_pp3_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1380_MP49 (XI0_I1380_bsn XI0_I1380_bcon XI0_I1380_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1380_MP52 (XI0_I1380_bp5 I0_cm17_2 XI0_I1380_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1380_MP51 (XI0_I1380_bp4 I0_pp3_10 XI0_I1380_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1380_MP51_1 (XI0_I1380_bp5 I0_pp3_10 XI0_I1380_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1380_MP52_1 (XI0_I1380_bsn I0_cm17_2 XI0_I1380_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1380_MP54 (VDD XI0_I1380_bsn I0_cm19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1380_MP41 (XI0_I1380_bp1 XI0_I1380_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1380_MP42 (XI0_I1380_bcon I0_pp3_10 XI0_I1380_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1380_MP45 (XI0_I1380_bp2 I0_cm17_2 XI0_I1380_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1380_MP43 (VDD XI0_I1380_s1 XI0_I1380_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1380_MP44 (XI0_I1380_bp2 I0_pp3_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1380_MP56 (VDD XI0_I1380_bcon I0_cm19_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1380_MP46 (XI0_I1380_bp3 XI0_I1380_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1380_MP48 (VDD I0_cm17_2 XI0_I1380_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1380_MP50_1 (XI0_I1380_bp4 XI0_I1380_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1380_MP26 (VDD XI0_I1380_asn XI0_I1380_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1380_MP18 (XI0_I1380_ap3 I0_pp0_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1380_MP21 (XI0_I1380_asn XI0_I1380_acon XI0_I1380_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1380_MP24 (XI0_I1380_ap5 I0_pp2_12 XI0_I1380_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1380_MP23 (XI0_I1380_ap4 I0_pp1_14 XI0_I1380_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1380_MP22 (VDD I0_pp0_16 XI0_I1380_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1380_MP22_1 (XI0_I1380_ap4 I0_pp0_16 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1380_MP23_1 (XI0_I1380_ap5 I0_pp1_14 XI0_I1380_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1380_MP24_1 (XI0_I1380_asn I0_pp2_12 XI0_I1380_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1380_MP17 (XI0_I1380_acon I0_pp2_12 XI0_I1380_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1380_MP14 (XI0_I1380_ap1 I0_pp1_14 XI0_I1380_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1380_MP13 (VDD I0_pp0_16 XI0_I1380_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1380_MP15 (XI0_I1380_ap2 I0_pp0_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1380_MP16 (VDD I0_pp1_14 XI0_I1380_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1380_MP28 (I0_cm19_2 XI0_I1380_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1380_MP19 (XI0_I1380_ap3 I0_pp1_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1380_MP20 (VDD I0_pp2_12 XI0_I1380_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1412_MP50 (VDD XI0_I1412_s1 XI0_I1412_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1412_MP47 (XI0_I1412_bp3 I0_pp7_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1412_MP49 (XI0_I1412_bsn XI0_I1412_bcon XI0_I1412_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1412_MP52 (XI0_I1412_bp5 I0_cm47_2 XI0_I1412_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1412_MP51 (XI0_I1412_bp4 I0_pp7_13 XI0_I1412_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1412_MP51_1 (XI0_I1412_bp5 I0_pp7_13 XI0_I1412_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1412_MP52_1 (XI0_I1412_bsn I0_cm47_2 XI0_I1412_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1412_MP54 (VDD XI0_I1412_bsn I0_cm51_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1412_MP41 (XI0_I1412_bp1 XI0_I1412_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1412_MP42 (XI0_I1412_bcon I0_pp7_13 XI0_I1412_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1412_MP45 (XI0_I1412_bp2 I0_cm47_2 XI0_I1412_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1412_MP43 (VDD XI0_I1412_s1 XI0_I1412_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1412_MP44 (XI0_I1412_bp2 I0_pp7_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1412_MP56 (VDD XI0_I1412_bcon I0_cm51_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1412_MP46 (XI0_I1412_bp3 XI0_I1412_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1412_MP48 (VDD I0_cm47_2 XI0_I1412_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1412_MP50_1 (XI0_I1412_bp4 XI0_I1412_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1412_MP26 (VDD XI0_I1412_asn XI0_I1412_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1412_MP18 (XI0_I1412_ap3 I0_pp4_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1412_MP21 (XI0_I1412_asn XI0_I1412_acon XI0_I1412_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1412_MP24 (XI0_I1412_ap5 I0_pp6_15 XI0_I1412_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1412_MP23 (XI0_I1412_ap4 I0_pp5_17 XI0_I1412_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1412_MP22 (VDD I0_pp4_19 XI0_I1412_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1412_MP22_1 (XI0_I1412_ap4 I0_pp4_19 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1412_MP23_1 (XI0_I1412_ap5 I0_pp5_17 XI0_I1412_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1412_MP24_1 (XI0_I1412_asn I0_pp6_15 XI0_I1412_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1412_MP17 (XI0_I1412_acon I0_pp6_15 XI0_I1412_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1412_MP14 (XI0_I1412_ap1 I0_pp5_17 XI0_I1412_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1412_MP13 (VDD I0_pp4_19 XI0_I1412_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1412_MP15 (XI0_I1412_ap2 I0_pp4_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1412_MP16 (VDD I0_pp5_17 XI0_I1412_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1412_MP28 (I0_cm51_2 XI0_I1412_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1412_MP19 (XI0_I1412_ap3 I0_pp5_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1412_MP20 (VDD I0_pp6_15 XI0_I1412_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1415_MP50 (VDD XI0_I1415_s1 XI0_I1415_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1415_MP47 (XI0_I1415_bp3 I0_pp7_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1415_MP49 (XI0_I1415_bsn XI0_I1415_bcon XI0_I1415_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1415_MP52 (XI0_I1415_bp5 I0_cm51_2 XI0_I1415_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1415_MP51 (XI0_I1415_bp4 I0_pp7_14 XI0_I1415_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1415_MP51_1 (XI0_I1415_bp5 I0_pp7_14 XI0_I1415_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1415_MP52_1 (XI0_I1415_bsn I0_cm51_2 XI0_I1415_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1415_MP54 (VDD XI0_I1415_bsn I0_cm54_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1415_MP41 (XI0_I1415_bp1 XI0_I1415_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1415_MP42 (XI0_I1415_bcon I0_pp7_14 XI0_I1415_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1415_MP45 (XI0_I1415_bp2 I0_cm51_2 XI0_I1415_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1415_MP43 (VDD XI0_I1415_s1 XI0_I1415_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1415_MP44 (XI0_I1415_bp2 I0_pp7_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1415_MP56 (VDD XI0_I1415_bcon I0_cm54_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1415_MP46 (XI0_I1415_bp3 XI0_I1415_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1415_MP48 (VDD I0_cm51_2 XI0_I1415_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1415_MP50_1 (XI0_I1415_bp4 XI0_I1415_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1415_MP26 (VDD XI0_I1415_asn XI0_I1415_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1415_MP18 (XI0_I1415_ap3 I0_pp4_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1415_MP21 (XI0_I1415_asn XI0_I1415_acon XI0_I1415_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1415_MP24 (XI0_I1415_ap5 I0_pp6_16 XI0_I1415_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1415_MP23 (XI0_I1415_ap4 I0_pp5_18 XI0_I1415_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1415_MP22 (VDD I0_pp4_20 XI0_I1415_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1415_MP22_1 (XI0_I1415_ap4 I0_pp4_20 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1415_MP23_1 (XI0_I1415_ap5 I0_pp5_18 XI0_I1415_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1415_MP24_1 (XI0_I1415_asn I0_pp6_16 XI0_I1415_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1415_MP17 (XI0_I1415_acon I0_pp6_16 XI0_I1415_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1415_MP14 (XI0_I1415_ap1 I0_pp5_18 XI0_I1415_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1415_MP13 (VDD I0_pp4_20 XI0_I1415_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1415_MP15 (XI0_I1415_ap2 I0_pp4_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1415_MP16 (VDD I0_pp5_18 XI0_I1415_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1415_MP28 (I0_cm54_2 XI0_I1415_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1415_MP19 (XI0_I1415_ap3 I0_pp5_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1415_MP20 (VDD I0_pp6_16 XI0_I1415_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1419_MP50 (VDD XI0_I1419_s1 XI0_I1419_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1419_MP47 (XI0_I1419_bp3 I0_pp7_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1419_MP49 (XI0_I1419_bsn XI0_I1419_bcon XI0_I1419_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1419_MP52 (XI0_I1419_bp5 I0_cm54_2 XI0_I1419_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1419_MP51 (XI0_I1419_bp4 I0_pp7_15 XI0_I1419_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1419_MP51_1 (XI0_I1419_bp5 I0_pp7_15 XI0_I1419_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1419_MP52_1 (XI0_I1419_bsn I0_cm54_2 XI0_I1419_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1419_MP54 (VDD XI0_I1419_bsn I0_cm58_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1419_MP41 (XI0_I1419_bp1 XI0_I1419_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1419_MP42 (XI0_I1419_bcon I0_pp7_15 XI0_I1419_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1419_MP45 (XI0_I1419_bp2 I0_cm54_2 XI0_I1419_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1419_MP43 (VDD XI0_I1419_s1 XI0_I1419_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1419_MP44 (XI0_I1419_bp2 I0_pp7_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1419_MP56 (VDD XI0_I1419_bcon I0_cm58_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1419_MP46 (XI0_I1419_bp3 XI0_I1419_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1419_MP48 (VDD I0_cm54_2 XI0_I1419_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1419_MP50_1 (XI0_I1419_bp4 XI0_I1419_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1419_MP26 (VDD XI0_I1419_asn XI0_I1419_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1419_MP18 (XI0_I1419_ap3 I0_pp4_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1419_MP21 (XI0_I1419_asn XI0_I1419_acon XI0_I1419_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1419_MP24 (XI0_I1419_ap5 I0_pp6_17 XI0_I1419_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1419_MP23 (XI0_I1419_ap4 I0_pp5_19 XI0_I1419_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1419_MP22 (VDD I0_pp4_21 XI0_I1419_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1419_MP22_1 (XI0_I1419_ap4 I0_pp4_21 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1419_MP23_1 (XI0_I1419_ap5 I0_pp5_19 XI0_I1419_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1419_MP24_1 (XI0_I1419_asn I0_pp6_17 XI0_I1419_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1419_MP17 (XI0_I1419_acon I0_pp6_17 XI0_I1419_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1419_MP14 (XI0_I1419_ap1 I0_pp5_19 XI0_I1419_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1419_MP13 (VDD I0_pp4_21 XI0_I1419_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1419_MP15 (XI0_I1419_ap2 I0_pp4_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1419_MP16 (VDD I0_pp5_19 XI0_I1419_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1419_MP28 (I0_cm58_2 XI0_I1419_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1419_MP19 (XI0_I1419_ap3 I0_pp5_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1419_MP20 (VDD I0_pp6_17 XI0_I1419_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1427_MP50 (VDD XI0_I1427_s1 XI0_I1427_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1427_MP47 (XI0_I1427_bp3 I0_pp7_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1427_MP49 (XI0_I1427_bsn XI0_I1427_bcon XI0_I1427_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1427_MP52 (XI0_I1427_bp5 I0_cm62_2 XI0_I1427_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1427_MP51 (XI0_I1427_bp4 I0_pp7_17 XI0_I1427_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1427_MP51_1 (XI0_I1427_bp5 I0_pp7_17 XI0_I1427_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1427_MP52_1 (XI0_I1427_bsn I0_cm62_2 XI0_I1427_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1427_MP54 (VDD XI0_I1427_bsn I0_cm66_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1427_MP41 (XI0_I1427_bp1 XI0_I1427_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1427_MP42 (XI0_I1427_bcon I0_pp7_17 XI0_I1427_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1427_MP45 (XI0_I1427_bp2 I0_cm62_2 XI0_I1427_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1427_MP43 (VDD XI0_I1427_s1 XI0_I1427_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1427_MP44 (XI0_I1427_bp2 I0_pp7_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1427_MP56 (VDD XI0_I1427_bcon I0_cm66_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1427_MP46 (XI0_I1427_bp3 XI0_I1427_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1427_MP48 (VDD I0_cm62_2 XI0_I1427_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1427_MP50_1 (XI0_I1427_bp4 XI0_I1427_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1427_MP26 (VDD XI0_I1427_asn XI0_I1427_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1427_MP18 (XI0_I1427_ap3 I0_pp4_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1427_MP21 (XI0_I1427_asn XI0_I1427_acon XI0_I1427_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1427_MP24 (XI0_I1427_ap5 I0_pp6_19 XI0_I1427_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1427_MP23 (XI0_I1427_ap4 I0_pp5_21 XI0_I1427_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1427_MP22 (VDD I0_pp4_23 XI0_I1427_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1427_MP22_1 (XI0_I1427_ap4 I0_pp4_23 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1427_MP23_1 (XI0_I1427_ap5 I0_pp5_21 XI0_I1427_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1427_MP24_1 (XI0_I1427_asn I0_pp6_19 XI0_I1427_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1427_MP17 (XI0_I1427_acon I0_pp6_19 XI0_I1427_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1427_MP14 (XI0_I1427_ap1 I0_pp5_21 XI0_I1427_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1427_MP13 (VDD I0_pp4_23 XI0_I1427_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1427_MP15 (XI0_I1427_ap2 I0_pp4_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1427_MP16 (VDD I0_pp5_21 XI0_I1427_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1427_MP28 (I0_cm66_2 XI0_I1427_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1427_MP19 (XI0_I1427_ap3 I0_pp5_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1427_MP20 (VDD I0_pp6_19 XI0_I1427_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1435_MP50 (VDD XI0_I1435_s1 XI0_I1435_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1435_MP47 (XI0_I1435_bp3 I0_pp7_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1435_MP49 (XI0_I1435_bsn XI0_I1435_bcon XI0_I1435_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1435_MP52 (XI0_I1435_bp5 I0_cm70_2 XI0_I1435_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1435_MP51 (XI0_I1435_bp4 I0_pp7_19 XI0_I1435_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1435_MP51_1 (XI0_I1435_bp5 I0_pp7_19 XI0_I1435_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1435_MP52_1 (XI0_I1435_bsn I0_cm70_2 XI0_I1435_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1435_MP54 (VDD XI0_I1435_bsn I0_cm74_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1435_MP41 (XI0_I1435_bp1 XI0_I1435_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1435_MP42 (XI0_I1435_bcon I0_pp7_19 XI0_I1435_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1435_MP45 (XI0_I1435_bp2 I0_cm70_2 XI0_I1435_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1435_MP43 (VDD XI0_I1435_s1 XI0_I1435_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1435_MP44 (XI0_I1435_bp2 I0_pp7_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1435_MP56 (VDD XI0_I1435_bcon I0_cm74_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1435_MP46 (XI0_I1435_bp3 XI0_I1435_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1435_MP48 (VDD I0_cm70_2 XI0_I1435_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1435_MP50_1 (XI0_I1435_bp4 XI0_I1435_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1435_MP26 (VDD XI0_I1435_asn XI0_I1435_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1435_MP18 (XI0_I1435_ap3 I0_pp4_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1435_MP21 (XI0_I1435_asn XI0_I1435_acon XI0_I1435_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1435_MP24 (XI0_I1435_ap5 I0_pp6_21 XI0_I1435_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1435_MP23 (XI0_I1435_ap4 I0_pp5_23 XI0_I1435_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1435_MP22 (VDD I0_pp4_25 XI0_I1435_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1435_MP22_1 (XI0_I1435_ap4 I0_pp4_25 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1435_MP23_1 (XI0_I1435_ap5 I0_pp5_23 XI0_I1435_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1435_MP24_1 (XI0_I1435_asn I0_pp6_21 XI0_I1435_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1435_MP17 (XI0_I1435_acon I0_pp6_21 XI0_I1435_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1435_MP14 (XI0_I1435_ap1 I0_pp5_23 XI0_I1435_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1435_MP13 (VDD I0_pp4_25 XI0_I1435_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1435_MP15 (XI0_I1435_ap2 I0_pp4_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1435_MP16 (VDD I0_pp5_23 XI0_I1435_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1435_MP28 (I0_cm74_2 XI0_I1435_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1435_MP19 (XI0_I1435_ap3 I0_pp5_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1435_MP20 (VDD I0_pp6_21 XI0_I1435_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1439_MP50 (VDD XI0_I1439_s1 XI0_I1439_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1439_MP47 (XI0_I1439_bp3 I0_pp7_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1439_MP49 (XI0_I1439_bsn XI0_I1439_bcon XI0_I1439_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1439_MP52 (XI0_I1439_bp5 I0_cm74_2 XI0_I1439_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1439_MP51 (XI0_I1439_bp4 I0_pp7_20 XI0_I1439_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1439_MP51_1 (XI0_I1439_bp5 I0_pp7_20 XI0_I1439_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1439_MP52_1 (XI0_I1439_bsn I0_cm74_2 XI0_I1439_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1439_MP54 (VDD XI0_I1439_bsn I0_cm78_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1439_MP41 (XI0_I1439_bp1 XI0_I1439_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1439_MP42 (XI0_I1439_bcon I0_pp7_20 XI0_I1439_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1439_MP45 (XI0_I1439_bp2 I0_cm74_2 XI0_I1439_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1439_MP43 (VDD XI0_I1439_s1 XI0_I1439_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1439_MP44 (XI0_I1439_bp2 I0_pp7_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1439_MP56 (VDD XI0_I1439_bcon I0_cm78_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1439_MP46 (XI0_I1439_bp3 XI0_I1439_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1439_MP48 (VDD I0_cm74_2 XI0_I1439_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1439_MP50_1 (XI0_I1439_bp4 XI0_I1439_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1439_MP26 (VDD XI0_I1439_asn XI0_I1439_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1439_MP18 (XI0_I1439_ap3 I0_pp4_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1439_MP21 (XI0_I1439_asn XI0_I1439_acon XI0_I1439_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1439_MP24 (XI0_I1439_ap5 I0_pp6_22 XI0_I1439_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1439_MP23 (XI0_I1439_ap4 I0_pp5_24 XI0_I1439_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1439_MP22 (VDD I0_pp4_26 XI0_I1439_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1439_MP22_1 (XI0_I1439_ap4 I0_pp4_26 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1439_MP23_1 (XI0_I1439_ap5 I0_pp5_24 XI0_I1439_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1439_MP24_1 (XI0_I1439_asn I0_pp6_22 XI0_I1439_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1439_MP17 (XI0_I1439_acon I0_pp6_22 XI0_I1439_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1439_MP14 (XI0_I1439_ap1 I0_pp5_24 XI0_I1439_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1439_MP13 (VDD I0_pp4_26 XI0_I1439_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1439_MP15 (XI0_I1439_ap2 I0_pp4_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1439_MP16 (VDD I0_pp5_24 XI0_I1439_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1439_MP28 (I0_cm78_2 XI0_I1439_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1439_MP19 (XI0_I1439_ap3 I0_pp5_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1439_MP20 (VDD I0_pp6_22 XI0_I1439_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1443_MP50 (VDD XI0_I1443_s1 XI0_I1443_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1443_MP47 (XI0_I1443_bp3 I0_pp7_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1443_MP49 (XI0_I1443_bsn XI0_I1443_bcon XI0_I1443_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1443_MP52 (XI0_I1443_bp5 I0_cm78_2 XI0_I1443_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1443_MP51 (XI0_I1443_bp4 I0_pp7_21 XI0_I1443_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1443_MP51_1 (XI0_I1443_bp5 I0_pp7_21 XI0_I1443_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1443_MP52_1 (XI0_I1443_bsn I0_cm78_2 XI0_I1443_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1443_MP54 (VDD XI0_I1443_bsn I0_cm82_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1443_MP41 (XI0_I1443_bp1 XI0_I1443_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1443_MP42 (XI0_I1443_bcon I0_pp7_21 XI0_I1443_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1443_MP45 (XI0_I1443_bp2 I0_cm78_2 XI0_I1443_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1443_MP43 (VDD XI0_I1443_s1 XI0_I1443_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1443_MP44 (XI0_I1443_bp2 I0_pp7_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1443_MP56 (VDD XI0_I1443_bcon I0_cm82_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1443_MP46 (XI0_I1443_bp3 XI0_I1443_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1443_MP48 (VDD I0_cm78_2 XI0_I1443_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1443_MP50_1 (XI0_I1443_bp4 XI0_I1443_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1443_MP26 (VDD XI0_I1443_asn XI0_I1443_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1443_MP18 (XI0_I1443_ap3 I0_pp4_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1443_MP21 (XI0_I1443_asn XI0_I1443_acon XI0_I1443_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1443_MP24 (XI0_I1443_ap5 I0_pp6_23 XI0_I1443_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1443_MP23 (XI0_I1443_ap4 I0_pp5_25 XI0_I1443_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1443_MP22 (VDD I0_pp4_27 XI0_I1443_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1443_MP22_1 (XI0_I1443_ap4 I0_pp4_27 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1443_MP23_1 (XI0_I1443_ap5 I0_pp5_25 XI0_I1443_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1443_MP24_1 (XI0_I1443_asn I0_pp6_23 XI0_I1443_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1443_MP17 (XI0_I1443_acon I0_pp6_23 XI0_I1443_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1443_MP14 (XI0_I1443_ap1 I0_pp5_25 XI0_I1443_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1443_MP13 (VDD I0_pp4_27 XI0_I1443_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1443_MP15 (XI0_I1443_ap2 I0_pp4_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1443_MP16 (VDD I0_pp5_25 XI0_I1443_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1443_MP28 (I0_cm82_2 XI0_I1443_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1443_MP19 (XI0_I1443_ap3 I0_pp5_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1443_MP20 (VDD I0_pp6_23 XI0_I1443_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1462_MP50 (VDD XI0_I1462_s1 XI0_I1462_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1462_MP47 (XI0_I1462_bp3 I0_pp7_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1462_MP49 (XI0_I1462_bsn XI0_I1462_bcon XI0_I1462_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1462_MP52 (XI0_I1462_bp5 I0_cm98_2 XI0_I1462_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1462_MP51 (XI0_I1462_bp4 I0_pp7_27 XI0_I1462_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1462_MP51_1 (XI0_I1462_bp5 I0_pp7_27 XI0_I1462_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1462_MP52_1 (XI0_I1462_bsn I0_cm98_2 XI0_I1462_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1462_MP54 (VDD XI0_I1462_bsn I0_cm101_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1462_MP41 (XI0_I1462_bp1 XI0_I1462_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1462_MP42 (XI0_I1462_bcon I0_pp7_27 XI0_I1462_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1462_MP45 (XI0_I1462_bp2 I0_cm98_2 XI0_I1462_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1462_MP43 (VDD XI0_I1462_s1 XI0_I1462_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1462_MP44 (XI0_I1462_bp2 I0_pp7_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1462_MP56 (VDD XI0_I1462_bcon I0_cm101_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1462_MP46 (XI0_I1462_bp3 XI0_I1462_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1462_MP48 (VDD I0_cm98_2 XI0_I1462_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1462_MP50_1 (XI0_I1462_bp4 XI0_I1462_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1462_MP26 (VDD XI0_I1462_asn XI0_I1462_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1462_MP18 (XI0_I1462_ap3 I0_sn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1462_MP21 (XI0_I1462_asn XI0_I1462_acon XI0_I1462_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1462_MP24 (XI0_I1462_ap5 I0_pp6_29 XI0_I1462_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1462_MP23 (XI0_I1462_ap4 I0_pp5_31 XI0_I1462_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1462_MP22 (VDD I0_sn4 XI0_I1462_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1462_MP22_1 (XI0_I1462_ap4 I0_sn4 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1462_MP23_1 (XI0_I1462_ap5 I0_pp5_31 XI0_I1462_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1462_MP24_1 (XI0_I1462_asn I0_pp6_29 XI0_I1462_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1462_MP17 (XI0_I1462_acon I0_pp6_29 XI0_I1462_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1462_MP14 (XI0_I1462_ap1 I0_pp5_31 XI0_I1462_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1462_MP13 (VDD I0_sn4 XI0_I1462_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1462_MP15 (XI0_I1462_ap2 I0_sn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1462_MP16 (VDD I0_pp5_31 XI0_I1462_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1462_MP28 (I0_cm101_2 XI0_I1462_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1462_MP19 (XI0_I1462_ap3 I0_pp5_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1462_MP20 (VDD I0_pp6_29 XI0_I1462_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1372_MP50 (VDD XI0_I1372_s1 XI0_I1372_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1372_MP47 (XI0_I1372_bp3 I0_pp3_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1372_MP49 (XI0_I1372_bsn XI0_I1372_bcon XI0_I1372_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1372_MP52 (XI0_I1372_bp5 I0_cm10_2 XI0_I1372_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1372_MP51 (XI0_I1372_bp4 I0_pp3_6 XI0_I1372_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1372_MP51_1 (XI0_I1372_bp5 I0_pp3_6 XI0_I1372_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1372_MP52_1 (XI0_I1372_bsn I0_cm10_2 XI0_I1372_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1372_MP54 (VDD XI0_I1372_bsn I0_cm11_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1372_MP41 (XI0_I1372_bp1 XI0_I1372_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1372_MP42 (XI0_I1372_bcon I0_pp3_6 XI0_I1372_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1372_MP45 (XI0_I1372_bp2 I0_cm10_2 XI0_I1372_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1372_MP43 (VDD XI0_I1372_s1 XI0_I1372_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1372_MP44 (XI0_I1372_bp2 I0_pp3_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1372_MP56 (VDD XI0_I1372_bcon I0_cm11_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1372_MP46 (XI0_I1372_bp3 XI0_I1372_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1372_MP48 (VDD I0_cm10_2 XI0_I1372_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1372_MP50_1 (XI0_I1372_bp4 XI0_I1372_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1372_MP26 (VDD XI0_I1372_asn XI0_I1372_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1372_MP18 (XI0_I1372_ap3 I0_pp0_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1372_MP21 (XI0_I1372_asn XI0_I1372_acon XI0_I1372_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1372_MP24 (XI0_I1372_ap5 I0_pp2_8 XI0_I1372_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1372_MP23 (XI0_I1372_ap4 I0_pp1_10 XI0_I1372_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1372_MP22 (VDD I0_pp0_12 XI0_I1372_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1372_MP22_1 (XI0_I1372_ap4 I0_pp0_12 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1372_MP23_1 (XI0_I1372_ap5 I0_pp1_10 XI0_I1372_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1372_MP24_1 (XI0_I1372_asn I0_pp2_8 XI0_I1372_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1372_MP17 (XI0_I1372_acon I0_pp2_8 XI0_I1372_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1372_MP14 (XI0_I1372_ap1 I0_pp1_10 XI0_I1372_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1372_MP13 (VDD I0_pp0_12 XI0_I1372_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1372_MP15 (XI0_I1372_ap2 I0_pp0_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1372_MP16 (VDD I0_pp1_10 XI0_I1372_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1372_MP28 (I0_cm11_2 XI0_I1372_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1372_MP19 (XI0_I1372_ap3 I0_pp1_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1372_MP20 (VDD I0_pp2_8 XI0_I1372_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1405_MP50 (VDD XI0_I1405_s1 XI0_I1405_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1405_MP47 (XI0_I1405_bp3 I0_pp7_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1405_MP49 (XI0_I1405_bsn XI0_I1405_bcon XI0_I1405_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1405_MP52 (XI0_I1405_bp5 I0_cm41_2 XI0_I1405_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1405_MP51 (XI0_I1405_bp4 I0_pp7_11 XI0_I1405_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1405_MP51_1 (XI0_I1405_bp5 I0_pp7_11 XI0_I1405_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1405_MP52_1 (XI0_I1405_bsn I0_cm41_2 XI0_I1405_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1405_MP54 (VDD XI0_I1405_bsn I0_cm44_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1405_MP41 (XI0_I1405_bp1 XI0_I1405_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1405_MP42 (XI0_I1405_bcon I0_pp7_11 XI0_I1405_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1405_MP45 (XI0_I1405_bp2 I0_cm41_2 XI0_I1405_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1405_MP43 (VDD XI0_I1405_s1 XI0_I1405_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1405_MP44 (XI0_I1405_bp2 I0_pp7_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1405_MP56 (VDD XI0_I1405_bcon I0_cm44_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1405_MP46 (XI0_I1405_bp3 XI0_I1405_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1405_MP48 (VDD I0_cm41_2 XI0_I1405_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1405_MP50_1 (XI0_I1405_bp4 XI0_I1405_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1405_MP26 (VDD XI0_I1405_asn XI0_I1405_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1405_MP18 (XI0_I1405_ap3 I0_pp4_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1405_MP21 (XI0_I1405_asn XI0_I1405_acon XI0_I1405_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1405_MP24 (XI0_I1405_ap5 I0_pp6_13 XI0_I1405_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1405_MP23 (XI0_I1405_ap4 I0_pp5_15 XI0_I1405_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1405_MP22 (VDD I0_pp4_17 XI0_I1405_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1405_MP22_1 (XI0_I1405_ap4 I0_pp4_17 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1405_MP23_1 (XI0_I1405_ap5 I0_pp5_15 XI0_I1405_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1405_MP24_1 (XI0_I1405_asn I0_pp6_13 XI0_I1405_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1405_MP17 (XI0_I1405_acon I0_pp6_13 XI0_I1405_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1405_MP14 (XI0_I1405_ap1 I0_pp5_15 XI0_I1405_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1405_MP13 (VDD I0_pp4_17 XI0_I1405_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1405_MP15 (XI0_I1405_ap2 I0_pp4_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1405_MP16 (VDD I0_pp5_15 XI0_I1405_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1405_MP28 (I0_cm44_2 XI0_I1405_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1405_MP19 (XI0_I1405_ap3 I0_pp5_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1405_MP20 (VDD I0_pp6_13 XI0_I1405_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1524_MP50 (VDD XI0_I1524_s1 XI0_I1524_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1524_MP47 (XI0_I1524_bp3 I0_cm53_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1524_MP49 (XI0_I1524_bsn XI0_I1524_bcon XI0_I1524_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1524_MP52 (XI0_I1524_bp5 I0_cm161_2 XI0_I1524_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1524_MP51 (XI0_I1524_bp4 I0_cm53_0 XI0_I1524_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1524_MP51_1 (XI0_I1524_bp5 I0_cm53_0 XI0_I1524_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1524_MP52_1 (XI0_I1524_bsn I0_cm161_2 XI0_I1524_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1524_MP54 (VDD XI0_I1524_bsn I0_cm163_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1524_MP41 (XI0_I1524_bp1 XI0_I1524_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1524_MP42 (XI0_I1524_bcon I0_cm53_0 XI0_I1524_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1524_MP45 (XI0_I1524_bp2 I0_cm161_2 XI0_I1524_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1524_MP43 (VDD XI0_I1524_s1 XI0_I1524_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1524_MP44 (XI0_I1524_bp2 I0_cm53_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1524_MP56 (VDD XI0_I1524_bcon I0_cm163_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1524_MP46 (XI0_I1524_bp3 XI0_I1524_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1524_MP48 (VDD I0_cm161_2 XI0_I1524_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1524_MP50_1 (XI0_I1524_bp4 XI0_I1524_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1524_MP26 (VDD XI0_I1524_asn XI0_I1524_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1524_MP18 (XI0_I1524_ap3 I0_cm50_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1524_MP21 (XI0_I1524_asn XI0_I1524_acon XI0_I1524_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1524_MP24 (XI0_I1524_ap5 I0_cm52_1 XI0_I1524_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1524_MP23 (XI0_I1524_ap4 I0_cm51_1 XI0_I1524_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1524_MP22 (VDD I0_cm50_1 XI0_I1524_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1524_MP22_1 (XI0_I1524_ap4 I0_cm50_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1524_MP23_1 (XI0_I1524_ap5 I0_cm51_1 XI0_I1524_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1524_MP24_1 (XI0_I1524_asn I0_cm52_1 XI0_I1524_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1524_MP17 (XI0_I1524_acon I0_cm52_1 XI0_I1524_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1524_MP14 (XI0_I1524_ap1 I0_cm51_1 XI0_I1524_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1524_MP13 (VDD I0_cm50_1 XI0_I1524_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1524_MP15 (XI0_I1524_ap2 I0_cm50_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1524_MP16 (VDD I0_cm51_1 XI0_I1524_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1524_MP28 (I0_cm163_2 XI0_I1524_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1524_MP19 (XI0_I1524_ap3 I0_cm51_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1524_MP20 (VDD I0_cm52_1 XI0_I1524_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1526_MP50 (VDD XI0_I1526_s1 XI0_I1526_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1526_MP47 (XI0_I1526_bp3 I0_fa56_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1526_MP49 (XI0_I1526_bsn XI0_I1526_bcon XI0_I1526_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1526_MP52 (XI0_I1526_bp5 I0_cm163_2 XI0_I1526_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1526_MP51 (XI0_I1526_bp4 I0_fa56_1 XI0_I1526_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1526_MP51_1 (XI0_I1526_bp5 I0_fa56_1 XI0_I1526_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1526_MP52_1 (XI0_I1526_bsn I0_cm163_2 XI0_I1526_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1526_MP54 (VDD XI0_I1526_bsn I0_cm165_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1526_MP41 (XI0_I1526_bp1 XI0_I1526_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1526_MP42 (XI0_I1526_bcon I0_fa56_1 XI0_I1526_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1526_MP45 (XI0_I1526_bp2 I0_cm163_2 XI0_I1526_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1526_MP43 (VDD XI0_I1526_s1 XI0_I1526_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1526_MP44 (XI0_I1526_bp2 I0_fa56_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1526_MP56 (VDD XI0_I1526_bcon I0_cm165_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1526_MP46 (XI0_I1526_bp3 XI0_I1526_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1526_MP48 (VDD I0_cm163_2 XI0_I1526_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1526_MP50_1 (XI0_I1526_bp4 XI0_I1526_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1526_MP26 (VDD XI0_I1526_asn XI0_I1526_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1526_MP18 (XI0_I1526_ap3 I0_cm53_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1526_MP21 (XI0_I1526_asn XI0_I1526_acon XI0_I1526_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1526_MP24 (XI0_I1526_ap5 I0_cm55_1 XI0_I1526_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1526_MP23 (XI0_I1526_ap4 I0_cm54_1 XI0_I1526_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1526_MP22 (VDD I0_cm53_1 XI0_I1526_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1526_MP22_1 (XI0_I1526_ap4 I0_cm53_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1526_MP23_1 (XI0_I1526_ap5 I0_cm54_1 XI0_I1526_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1526_MP24_1 (XI0_I1526_asn I0_cm55_1 XI0_I1526_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1526_MP17 (XI0_I1526_acon I0_cm55_1 XI0_I1526_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1526_MP14 (XI0_I1526_ap1 I0_cm54_1 XI0_I1526_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1526_MP13 (VDD I0_cm53_1 XI0_I1526_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1526_MP15 (XI0_I1526_ap2 I0_cm53_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1526_MP16 (VDD I0_cm54_1 XI0_I1526_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1526_MP28 (I0_cm165_2 XI0_I1526_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1526_MP19 (XI0_I1526_ap3 I0_cm54_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1526_MP20 (VDD I0_cm55_1 XI0_I1526_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1528_MP50 (VDD XI0_I1528_s1 XI0_I1528_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1528_MP47 (XI0_I1528_bp3 I0_fa60_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1528_MP49 (XI0_I1528_bsn XI0_I1528_bcon XI0_I1528_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1528_MP52 (XI0_I1528_bp5 I0_cm165_2 XI0_I1528_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1528_MP51 (XI0_I1528_bp4 I0_fa60_1 XI0_I1528_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1528_MP51_1 (XI0_I1528_bp5 I0_fa60_1 XI0_I1528_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1528_MP52_1 (XI0_I1528_bsn I0_cm165_2 XI0_I1528_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1528_MP54 (VDD XI0_I1528_bsn I0_cm167_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1528_MP41 (XI0_I1528_bp1 XI0_I1528_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1528_MP42 (XI0_I1528_bcon I0_fa60_1 XI0_I1528_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1528_MP45 (XI0_I1528_bp2 I0_cm165_2 XI0_I1528_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1528_MP43 (VDD XI0_I1528_s1 XI0_I1528_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1528_MP44 (XI0_I1528_bp2 I0_fa60_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1528_MP56 (VDD XI0_I1528_bcon I0_cm167_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1528_MP46 (XI0_I1528_bp3 XI0_I1528_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1528_MP48 (VDD I0_cm165_2 XI0_I1528_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1528_MP50_1 (XI0_I1528_bp4 XI0_I1528_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1528_MP26 (VDD XI0_I1528_asn XI0_I1528_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1528_MP18 (XI0_I1528_ap3 I0_cm57_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1528_MP21 (XI0_I1528_asn XI0_I1528_acon XI0_I1528_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1528_MP24 (XI0_I1528_ap5 I0_cm59_1 XI0_I1528_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1528_MP23 (XI0_I1528_ap4 I0_cm58_1 XI0_I1528_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1528_MP22 (VDD I0_cm57_1 XI0_I1528_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1528_MP22_1 (XI0_I1528_ap4 I0_cm57_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1528_MP23_1 (XI0_I1528_ap5 I0_cm58_1 XI0_I1528_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1528_MP24_1 (XI0_I1528_asn I0_cm59_1 XI0_I1528_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1528_MP17 (XI0_I1528_acon I0_cm59_1 XI0_I1528_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1528_MP14 (XI0_I1528_ap1 I0_cm58_1 XI0_I1528_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1528_MP13 (VDD I0_cm57_1 XI0_I1528_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1528_MP15 (XI0_I1528_ap2 I0_cm57_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1528_MP16 (VDD I0_cm58_1 XI0_I1528_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1528_MP28 (I0_cm167_2 XI0_I1528_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1528_MP19 (XI0_I1528_ap3 I0_cm58_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1528_MP20 (VDD I0_cm59_1 XI0_I1528_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1431_MP50 (VDD XI0_I1431_s1 XI0_I1431_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1431_MP47 (XI0_I1431_bp3 I0_pp7_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1431_MP49 (XI0_I1431_bsn XI0_I1431_bcon XI0_I1431_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1431_MP52 (XI0_I1431_bp5 I0_cm66_2 XI0_I1431_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1431_MP51 (XI0_I1431_bp4 I0_pp7_18 XI0_I1431_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1431_MP51_1 (XI0_I1431_bp5 I0_pp7_18 XI0_I1431_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1431_MP52_1 (XI0_I1431_bsn I0_cm66_2 XI0_I1431_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1431_MP54 (VDD XI0_I1431_bsn I0_cm70_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1431_MP41 (XI0_I1431_bp1 XI0_I1431_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1431_MP42 (XI0_I1431_bcon I0_pp7_18 XI0_I1431_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1431_MP45 (XI0_I1431_bp2 I0_cm66_2 XI0_I1431_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1431_MP43 (VDD XI0_I1431_s1 XI0_I1431_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1431_MP44 (XI0_I1431_bp2 I0_pp7_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1431_MP56 (VDD XI0_I1431_bcon I0_cm70_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1431_MP46 (XI0_I1431_bp3 XI0_I1431_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1431_MP48 (VDD I0_cm66_2 XI0_I1431_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1431_MP50_1 (XI0_I1431_bp4 XI0_I1431_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1431_MP26 (VDD XI0_I1431_asn XI0_I1431_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1431_MP18 (XI0_I1431_ap3 I0_pp4_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1431_MP21 (XI0_I1431_asn XI0_I1431_acon XI0_I1431_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1431_MP24 (XI0_I1431_ap5 I0_pp6_20 XI0_I1431_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1431_MP23 (XI0_I1431_ap4 I0_pp5_22 XI0_I1431_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1431_MP22 (VDD I0_pp4_24 XI0_I1431_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1431_MP22_1 (XI0_I1431_ap4 I0_pp4_24 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1431_MP23_1 (XI0_I1431_ap5 I0_pp5_22 XI0_I1431_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1431_MP24_1 (XI0_I1431_asn I0_pp6_20 XI0_I1431_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1431_MP17 (XI0_I1431_acon I0_pp6_20 XI0_I1431_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1431_MP14 (XI0_I1431_ap1 I0_pp5_22 XI0_I1431_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1431_MP13 (VDD I0_pp4_24 XI0_I1431_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1431_MP15 (XI0_I1431_ap2 I0_pp4_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1431_MP16 (VDD I0_pp5_22 XI0_I1431_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1431_MP28 (I0_cm70_2 XI0_I1431_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1431_MP19 (XI0_I1431_ap3 I0_pp5_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1431_MP20 (VDD I0_pp6_20 XI0_I1431_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1534_MP50 (VDD XI0_I1534_s1 XI0_I1534_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1534_MP47 (XI0_I1534_bp3 I0_cm72_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1534_MP49 (XI0_I1534_bsn XI0_I1534_bcon XI0_I1534_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1534_MP52 (XI0_I1534_bp5 I0_cm171_2 XI0_I1534_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1534_MP51 (XI0_I1534_bp4 I0_cm72_1 XI0_I1534_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1534_MP51_1 (XI0_I1534_bp5 I0_cm72_1 XI0_I1534_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1534_MP52_1 (XI0_I1534_bsn I0_cm171_2 XI0_I1534_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1534_MP54 (VDD XI0_I1534_bsn I0_cm173_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1534_MP41 (XI0_I1534_bp1 XI0_I1534_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1534_MP42 (XI0_I1534_bcon I0_cm72_1 XI0_I1534_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1534_MP45 (XI0_I1534_bp2 I0_cm171_2 XI0_I1534_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1534_MP43 (VDD XI0_I1534_s1 XI0_I1534_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1534_MP44 (XI0_I1534_bp2 I0_cm72_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1534_MP56 (VDD XI0_I1534_bcon I0_cm173_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1534_MP46 (XI0_I1534_bp3 XI0_I1534_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1534_MP48 (VDD I0_cm171_2 XI0_I1534_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1534_MP50_1 (XI0_I1534_bp4 XI0_I1534_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1534_MP26 (VDD XI0_I1534_asn XI0_I1534_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1534_MP18 (XI0_I1534_ap3 I0_cm69_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1534_MP21 (XI0_I1534_asn XI0_I1534_acon XI0_I1534_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1534_MP24 (XI0_I1534_ap5 I0_cm71_1 XI0_I1534_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1534_MP23 (XI0_I1534_ap4 I0_cm70_1 XI0_I1534_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1534_MP22 (VDD I0_cm69_1 XI0_I1534_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1534_MP22_1 (XI0_I1534_ap4 I0_cm69_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1534_MP23_1 (XI0_I1534_ap5 I0_cm70_1 XI0_I1534_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1534_MP24_1 (XI0_I1534_asn I0_cm71_1 XI0_I1534_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1534_MP17 (XI0_I1534_acon I0_cm71_1 XI0_I1534_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1534_MP14 (XI0_I1534_ap1 I0_cm70_1 XI0_I1534_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1534_MP13 (VDD I0_cm69_1 XI0_I1534_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1534_MP15 (XI0_I1534_ap2 I0_cm69_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1534_MP16 (VDD I0_cm70_1 XI0_I1534_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1534_MP28 (I0_cm173_2 XI0_I1534_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1534_MP19 (XI0_I1534_ap3 I0_cm70_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1534_MP20 (VDD I0_cm71_1 XI0_I1534_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1465_MP50 (VDD XI0_I1465_s1 XI0_I1465_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1465_MP47 (XI0_I1465_bp3 I0_pp7_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1465_MP49 (XI0_I1465_bsn XI0_I1465_bcon XI0_I1465_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1465_MP52 (XI0_I1465_bp5 I0_cm101_2 XI0_I1465_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1465_MP51 (XI0_I1465_bp4 I0_pp7_28 XI0_I1465_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1465_MP51_1 (XI0_I1465_bp5 I0_pp7_28 XI0_I1465_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1465_MP52_1 (XI0_I1465_bsn I0_cm101_2 XI0_I1465_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1465_MP54 (VDD XI0_I1465_bsn I0_cm104_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1465_MP41 (XI0_I1465_bp1 XI0_I1465_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1465_MP42 (XI0_I1465_bcon I0_pp7_28 XI0_I1465_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1465_MP45 (XI0_I1465_bp2 I0_cm101_2 XI0_I1465_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1465_MP43 (VDD XI0_I1465_s1 XI0_I1465_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1465_MP44 (XI0_I1465_bp2 I0_pp7_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1465_MP56 (VDD XI0_I1465_bcon I0_cm104_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1465_MP46 (XI0_I1465_bp3 XI0_I1465_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1465_MP48 (VDD I0_cm101_2 XI0_I1465_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1465_MP50_1 (XI0_I1465_bp4 XI0_I1465_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1465_MP26 (VDD XI0_I1465_asn XI0_I1465_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1465_MP18 (XI0_I1465_ap3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1465_MP21 (XI0_I1465_asn XI0_I1465_acon XI0_I1465_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1465_MP24 (XI0_I1465_ap5 I0_pp6_30 XI0_I1465_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1465_MP23 (XI0_I1465_ap4 I0_pp5_32 XI0_I1465_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1465_MP22 (VDD VDD XI0_I1465_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1465_MP22_1 (XI0_I1465_ap4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1465_MP23_1 (XI0_I1465_ap5 I0_pp5_32 XI0_I1465_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1465_MP24_1 (XI0_I1465_asn I0_pp6_30 XI0_I1465_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1465_MP17 (XI0_I1465_acon I0_pp6_30 XI0_I1465_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1465_MP14 (XI0_I1465_ap1 I0_pp5_32 XI0_I1465_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1465_MP13 (VDD VDD XI0_I1465_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1465_MP15 (XI0_I1465_ap2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1465_MP16 (VDD I0_pp5_32 XI0_I1465_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1465_MP28 (I0_cm104_2 XI0_I1465_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1465_MP19 (XI0_I1465_ap3 I0_pp5_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1465_MP20 (VDD I0_pp6_30 XI0_I1465_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1402_MP50 (VDD XI0_I1402_s1 XI0_I1402_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1402_MP47 (XI0_I1402_bp3 I0_pp7_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1402_MP49 (XI0_I1402_bsn XI0_I1402_bcon XI0_I1402_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1402_MP52 (XI0_I1402_bp5 I0_cm38_2 XI0_I1402_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1402_MP51 (XI0_I1402_bp4 I0_pp7_10 XI0_I1402_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1402_MP51_1 (XI0_I1402_bp5 I0_pp7_10 XI0_I1402_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1402_MP52_1 (XI0_I1402_bsn I0_cm38_2 XI0_I1402_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1402_MP54 (VDD XI0_I1402_bsn I0_cm41_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1402_MP41 (XI0_I1402_bp1 XI0_I1402_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1402_MP42 (XI0_I1402_bcon I0_pp7_10 XI0_I1402_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1402_MP45 (XI0_I1402_bp2 I0_cm38_2 XI0_I1402_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1402_MP43 (VDD XI0_I1402_s1 XI0_I1402_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1402_MP44 (XI0_I1402_bp2 I0_pp7_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1402_MP56 (VDD XI0_I1402_bcon I0_cm41_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1402_MP46 (XI0_I1402_bp3 XI0_I1402_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1402_MP48 (VDD I0_cm38_2 XI0_I1402_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1402_MP50_1 (XI0_I1402_bp4 XI0_I1402_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1402_MP26 (VDD XI0_I1402_asn XI0_I1402_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1402_MP18 (XI0_I1402_ap3 I0_pp4_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1402_MP21 (XI0_I1402_asn XI0_I1402_acon XI0_I1402_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1402_MP24 (XI0_I1402_ap5 I0_pp6_12 XI0_I1402_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1402_MP23 (XI0_I1402_ap4 I0_pp5_14 XI0_I1402_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1402_MP22 (VDD I0_pp4_16 XI0_I1402_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1402_MP22_1 (XI0_I1402_ap4 I0_pp4_16 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1402_MP23_1 (XI0_I1402_ap5 I0_pp5_14 XI0_I1402_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1402_MP24_1 (XI0_I1402_asn I0_pp6_12 XI0_I1402_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1402_MP17 (XI0_I1402_acon I0_pp6_12 XI0_I1402_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1402_MP14 (XI0_I1402_ap1 I0_pp5_14 XI0_I1402_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1402_MP13 (VDD I0_pp4_16 XI0_I1402_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1402_MP15 (XI0_I1402_ap2 I0_pp4_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1402_MP16 (VDD I0_pp5_14 XI0_I1402_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1402_MP28 (I0_cm41_2 XI0_I1402_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1402_MP19 (XI0_I1402_ap3 I0_pp5_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1402_MP20 (VDD I0_pp6_12 XI0_I1402_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1396_MP50 (VDD XI0_I1396_s1 XI0_I1396_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1396_MP47 (XI0_I1396_bp3 I0_pp7_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1396_MP49 (XI0_I1396_bsn XI0_I1396_bcon XI0_I1396_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1396_MP52 (XI0_I1396_bp5 I0_cm32_2 XI0_I1396_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1396_MP51 (XI0_I1396_bp4 I0_pp7_8 XI0_I1396_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1396_MP51_1 (XI0_I1396_bp5 I0_pp7_8 XI0_I1396_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1396_MP52_1 (XI0_I1396_bsn I0_cm32_2 XI0_I1396_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1396_MP54 (VDD XI0_I1396_bsn I0_cm35_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1396_MP41 (XI0_I1396_bp1 XI0_I1396_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1396_MP42 (XI0_I1396_bcon I0_pp7_8 XI0_I1396_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1396_MP45 (XI0_I1396_bp2 I0_cm32_2 XI0_I1396_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1396_MP43 (VDD XI0_I1396_s1 XI0_I1396_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1396_MP44 (XI0_I1396_bp2 I0_pp7_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1396_MP56 (VDD XI0_I1396_bcon I0_cm35_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1396_MP46 (XI0_I1396_bp3 XI0_I1396_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1396_MP48 (VDD I0_cm32_2 XI0_I1396_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1396_MP50_1 (XI0_I1396_bp4 XI0_I1396_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1396_MP26 (VDD XI0_I1396_asn XI0_I1396_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1396_MP18 (XI0_I1396_ap3 I0_pp4_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1396_MP21 (XI0_I1396_asn XI0_I1396_acon XI0_I1396_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1396_MP24 (XI0_I1396_ap5 I0_pp6_10 XI0_I1396_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1396_MP23 (XI0_I1396_ap4 I0_pp5_12 XI0_I1396_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1396_MP22 (VDD I0_pp4_14 XI0_I1396_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1396_MP22_1 (XI0_I1396_ap4 I0_pp4_14 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1396_MP23_1 (XI0_I1396_ap5 I0_pp5_12 XI0_I1396_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1396_MP24_1 (XI0_I1396_asn I0_pp6_10 XI0_I1396_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1396_MP17 (XI0_I1396_acon I0_pp6_10 XI0_I1396_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1396_MP14 (XI0_I1396_ap1 I0_pp5_12 XI0_I1396_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1396_MP13 (VDD I0_pp4_14 XI0_I1396_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1396_MP15 (XI0_I1396_ap2 I0_pp4_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1396_MP16 (VDD I0_pp5_12 XI0_I1396_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1396_MP28 (I0_cm35_2 XI0_I1396_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1396_MP19 (XI0_I1396_ap3 I0_pp5_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1396_MP20 (VDD I0_pp6_10 XI0_I1396_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1520_MP50 (VDD XI0_I1520_s1 XI0_I1520_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1520_MP47 (XI0_I1520_bp3 I0_cm46_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1520_MP49 (XI0_I1520_bsn XI0_I1520_bcon XI0_I1520_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1520_MP52 (XI0_I1520_bp5 I0_cm157_2 XI0_I1520_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1520_MP51 (XI0_I1520_bp4 I0_cm46_0 XI0_I1520_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1520_MP51_1 (XI0_I1520_bp5 I0_cm46_0 XI0_I1520_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1520_MP52_1 (XI0_I1520_bsn I0_cm157_2 XI0_I1520_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1520_MP54 (VDD XI0_I1520_bsn I0_cm159_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1520_MP41 (XI0_I1520_bp1 XI0_I1520_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1520_MP42 (XI0_I1520_bcon I0_cm46_0 XI0_I1520_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1520_MP45 (XI0_I1520_bp2 I0_cm157_2 XI0_I1520_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1520_MP43 (VDD XI0_I1520_s1 XI0_I1520_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1520_MP44 (XI0_I1520_bp2 I0_cm46_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1520_MP56 (VDD XI0_I1520_bcon I0_cm159_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1520_MP46 (XI0_I1520_bp3 XI0_I1520_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1520_MP48 (VDD I0_cm157_2 XI0_I1520_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1520_MP50_1 (XI0_I1520_bp4 XI0_I1520_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1520_MP26 (VDD XI0_I1520_asn XI0_I1520_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1520_MP18 (XI0_I1520_ap3 I0_cm43_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1520_MP21 (XI0_I1520_asn XI0_I1520_acon XI0_I1520_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1520_MP24 (XI0_I1520_ap5 I0_cm45_1 XI0_I1520_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1520_MP23 (XI0_I1520_ap4 I0_cm44_1 XI0_I1520_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1520_MP22 (VDD I0_cm43_1 XI0_I1520_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1520_MP22_1 (XI0_I1520_ap4 I0_cm43_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1520_MP23_1 (XI0_I1520_ap5 I0_cm44_1 XI0_I1520_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1520_MP24_1 (XI0_I1520_asn I0_cm45_1 XI0_I1520_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1520_MP17 (XI0_I1520_acon I0_cm45_1 XI0_I1520_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1520_MP14 (XI0_I1520_ap1 I0_cm44_1 XI0_I1520_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1520_MP13 (VDD I0_cm43_1 XI0_I1520_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1520_MP15 (XI0_I1520_ap2 I0_cm43_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1520_MP16 (VDD I0_cm44_1 XI0_I1520_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1520_MP28 (I0_cm159_2 XI0_I1520_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1520_MP19 (XI0_I1520_ap3 I0_cm44_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1520_MP20 (VDD I0_cm45_1 XI0_I1520_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1584_MP50 (VDD XI0_I1584_s1 XI0_I1584_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1584_MP47 (XI0_I1584_bp3 I0_cm166_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1584_MP49 (XI0_I1584_bsn XI0_I1584_bcon XI0_I1584_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1584_MP52 (XI0_I1584_bp5 I0_cm222_2 XI0_I1584_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1584_MP51 (XI0_I1584_bp4 I0_cm166_0 XI0_I1584_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1584_MP51_1 (XI0_I1584_bp5 I0_cm166_0 XI0_I1584_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1584_MP52_1 (XI0_I1584_bsn I0_cm222_2 XI0_I1584_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1584_MP54 (VDD XI0_I1584_bsn I0_cm223_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1584_MP41 (XI0_I1584_bp1 XI0_I1584_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1584_MP42 (XI0_I1584_bcon I0_cm166_0 XI0_I1584_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1584_MP45 (XI0_I1584_bp2 I0_cm222_2 XI0_I1584_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1584_MP43 (VDD XI0_I1584_s1 XI0_I1584_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1584_MP44 (XI0_I1584_bp2 I0_cm166_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1584_MP56 (VDD XI0_I1584_bcon I0_cm223_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1584_MP46 (XI0_I1584_bp3 XI0_I1584_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1584_MP48 (VDD I0_cm222_2 XI0_I1584_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1584_MP50_1 (XI0_I1584_bp4 XI0_I1584_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1584_MP26 (VDD XI0_I1584_asn XI0_I1584_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1584_MP18 (XI0_I1584_ap3 I0_cm163_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1584_MP21 (XI0_I1584_asn XI0_I1584_acon XI0_I1584_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1584_MP24 (XI0_I1584_ap5 I0_cm165_0 XI0_I1584_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1584_MP23 (XI0_I1584_ap4 I0_cm164_1 XI0_I1584_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1584_MP22 (VDD I0_cm163_1 XI0_I1584_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1584_MP22_1 (XI0_I1584_ap4 I0_cm163_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1584_MP23_1 (XI0_I1584_ap5 I0_cm164_1 XI0_I1584_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1584_MP24_1 (XI0_I1584_asn I0_cm165_0 XI0_I1584_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1584_MP17 (XI0_I1584_acon I0_cm165_0 XI0_I1584_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1584_MP14 (XI0_I1584_ap1 I0_cm164_1 XI0_I1584_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1584_MP13 (VDD I0_cm163_1 XI0_I1584_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1584_MP15 (XI0_I1584_ap2 I0_cm163_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1584_MP16 (VDD I0_cm164_1 XI0_I1584_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1584_MP28 (I0_cm223_2 XI0_I1584_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1584_MP19 (XI0_I1584_ap3 I0_cm164_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1584_MP20 (VDD I0_cm165_0 XI0_I1584_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1408_MP50 (VDD XI0_I1408_s1 XI0_I1408_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1408_MP47 (XI0_I1408_bp3 I0_pp7_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1408_MP49 (XI0_I1408_bsn XI0_I1408_bcon XI0_I1408_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1408_MP52 (XI0_I1408_bp5 I0_cm44_2 XI0_I1408_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1408_MP51 (XI0_I1408_bp4 I0_pp7_12 XI0_I1408_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1408_MP51_1 (XI0_I1408_bp5 I0_pp7_12 XI0_I1408_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1408_MP52_1 (XI0_I1408_bsn I0_cm44_2 XI0_I1408_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1408_MP54 (VDD XI0_I1408_bsn I0_cm47_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1408_MP41 (XI0_I1408_bp1 XI0_I1408_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1408_MP42 (XI0_I1408_bcon I0_pp7_12 XI0_I1408_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1408_MP45 (XI0_I1408_bp2 I0_cm44_2 XI0_I1408_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1408_MP43 (VDD XI0_I1408_s1 XI0_I1408_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1408_MP44 (XI0_I1408_bp2 I0_pp7_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1408_MP56 (VDD XI0_I1408_bcon I0_cm47_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1408_MP46 (XI0_I1408_bp3 XI0_I1408_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1408_MP48 (VDD I0_cm44_2 XI0_I1408_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1408_MP50_1 (XI0_I1408_bp4 XI0_I1408_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1408_MP26 (VDD XI0_I1408_asn XI0_I1408_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1408_MP18 (XI0_I1408_ap3 I0_pp4_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1408_MP21 (XI0_I1408_asn XI0_I1408_acon XI0_I1408_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1408_MP24 (XI0_I1408_ap5 I0_pp6_14 XI0_I1408_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1408_MP23 (XI0_I1408_ap4 I0_pp5_16 XI0_I1408_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1408_MP22 (VDD I0_pp4_18 XI0_I1408_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1408_MP22_1 (XI0_I1408_ap4 I0_pp4_18 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1408_MP23_1 (XI0_I1408_ap5 I0_pp5_16 XI0_I1408_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1408_MP24_1 (XI0_I1408_asn I0_pp6_14 XI0_I1408_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1408_MP17 (XI0_I1408_acon I0_pp6_14 XI0_I1408_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1408_MP14 (XI0_I1408_ap1 I0_pp5_16 XI0_I1408_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1408_MP13 (VDD I0_pp4_18 XI0_I1408_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1408_MP15 (XI0_I1408_ap2 I0_pp4_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1408_MP16 (VDD I0_pp5_16 XI0_I1408_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1408_MP28 (I0_cm47_2 XI0_I1408_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1408_MP19 (XI0_I1408_ap3 I0_pp5_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1408_MP20 (VDD I0_pp6_14 XI0_I1408_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1532_MP50 (VDD XI0_I1532_s1 XI0_I1532_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1532_MP47 (XI0_I1532_bp3 I0_cm68_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1532_MP49 (XI0_I1532_bsn XI0_I1532_bcon XI0_I1532_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1532_MP52 (XI0_I1532_bp5 I0_cm169_2 XI0_I1532_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1532_MP51 (XI0_I1532_bp4 I0_cm68_1 XI0_I1532_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1532_MP51_1 (XI0_I1532_bp5 I0_cm68_1 XI0_I1532_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1532_MP52_1 (XI0_I1532_bsn I0_cm169_2 XI0_I1532_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1532_MP54 (VDD XI0_I1532_bsn I0_cm171_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1532_MP41 (XI0_I1532_bp1 XI0_I1532_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1532_MP42 (XI0_I1532_bcon I0_cm68_1 XI0_I1532_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1532_MP45 (XI0_I1532_bp2 I0_cm169_2 XI0_I1532_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1532_MP43 (VDD XI0_I1532_s1 XI0_I1532_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1532_MP44 (XI0_I1532_bp2 I0_cm68_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1532_MP56 (VDD XI0_I1532_bcon I0_cm171_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1532_MP46 (XI0_I1532_bp3 XI0_I1532_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1532_MP48 (VDD I0_cm169_2 XI0_I1532_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1532_MP50_1 (XI0_I1532_bp4 XI0_I1532_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1532_MP26 (VDD XI0_I1532_asn XI0_I1532_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1532_MP18 (XI0_I1532_ap3 I0_cm65_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1532_MP21 (XI0_I1532_asn XI0_I1532_acon XI0_I1532_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1532_MP24 (XI0_I1532_ap5 I0_cm67_1 XI0_I1532_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1532_MP23 (XI0_I1532_ap4 I0_cm66_1 XI0_I1532_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1532_MP22 (VDD I0_cm65_1 XI0_I1532_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1532_MP22_1 (XI0_I1532_ap4 I0_cm65_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1532_MP23_1 (XI0_I1532_ap5 I0_cm66_1 XI0_I1532_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1532_MP24_1 (XI0_I1532_asn I0_cm67_1 XI0_I1532_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1532_MP17 (XI0_I1532_acon I0_cm67_1 XI0_I1532_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1532_MP14 (XI0_I1532_ap1 I0_cm66_1 XI0_I1532_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1532_MP13 (VDD I0_cm65_1 XI0_I1532_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1532_MP15 (XI0_I1532_ap2 I0_cm65_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1532_MP16 (VDD I0_cm66_1 XI0_I1532_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1532_MP28 (I0_cm171_2 XI0_I1532_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1532_MP19 (XI0_I1532_ap3 I0_cm66_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1532_MP20 (VDD I0_cm67_1 XI0_I1532_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1530_MP50 (VDD XI0_I1530_s1 XI0_I1530_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1530_MP47 (XI0_I1530_bp3 I0_cm64_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1530_MP49 (XI0_I1530_bsn XI0_I1530_bcon XI0_I1530_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1530_MP52 (XI0_I1530_bp5 I0_cm167_2 XI0_I1530_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1530_MP51 (XI0_I1530_bp4 I0_cm64_1 XI0_I1530_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1530_MP51_1 (XI0_I1530_bp5 I0_cm64_1 XI0_I1530_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1530_MP52_1 (XI0_I1530_bsn I0_cm167_2 XI0_I1530_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1530_MP54 (VDD XI0_I1530_bsn I0_cm169_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1530_MP41 (XI0_I1530_bp1 XI0_I1530_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1530_MP42 (XI0_I1530_bcon I0_cm64_1 XI0_I1530_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1530_MP45 (XI0_I1530_bp2 I0_cm167_2 XI0_I1530_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1530_MP43 (VDD XI0_I1530_s1 XI0_I1530_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1530_MP44 (XI0_I1530_bp2 I0_cm64_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1530_MP56 (VDD XI0_I1530_bcon I0_cm169_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1530_MP46 (XI0_I1530_bp3 XI0_I1530_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1530_MP48 (VDD I0_cm167_2 XI0_I1530_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1530_MP50_1 (XI0_I1530_bp4 XI0_I1530_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1530_MP26 (VDD XI0_I1530_asn XI0_I1530_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1530_MP18 (XI0_I1530_ap3 I0_cm61_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1530_MP21 (XI0_I1530_asn XI0_I1530_acon XI0_I1530_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1530_MP24 (XI0_I1530_ap5 I0_cm63_1 XI0_I1530_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1530_MP23 (XI0_I1530_ap4 I0_cm62_1 XI0_I1530_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1530_MP22 (VDD I0_cm61_1 XI0_I1530_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1530_MP22_1 (XI0_I1530_ap4 I0_cm61_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1530_MP23_1 (XI0_I1530_ap5 I0_cm62_1 XI0_I1530_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1530_MP24_1 (XI0_I1530_asn I0_cm63_1 XI0_I1530_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1530_MP17 (XI0_I1530_acon I0_cm63_1 XI0_I1530_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1530_MP14 (XI0_I1530_ap1 I0_cm62_1 XI0_I1530_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1530_MP13 (VDD I0_cm61_1 XI0_I1530_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1530_MP15 (XI0_I1530_ap2 I0_cm61_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1530_MP16 (VDD I0_cm62_1 XI0_I1530_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1530_MP28 (I0_cm169_2 XI0_I1530_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1530_MP19 (XI0_I1530_ap3 I0_cm62_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1530_MP20 (VDD I0_cm63_1 XI0_I1530_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1529_MP50 (VDD XI0_I1529_s1 XI0_I1529_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1529_MP47 (XI0_I1529_bp3 I0_cm64_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1529_MP49 (XI0_I1529_bsn XI0_I1529_bcon XI0_I1529_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1529_MP52 (XI0_I1529_bp5 I0_cm166_2 XI0_I1529_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1529_MP51 (XI0_I1529_bp4 I0_cm64_0 XI0_I1529_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1529_MP51_1 (XI0_I1529_bp5 I0_cm64_0 XI0_I1529_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1529_MP52_1 (XI0_I1529_bsn I0_cm166_2 XI0_I1529_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1529_MP54 (VDD XI0_I1529_bsn I0_cm168_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1529_MP41 (XI0_I1529_bp1 XI0_I1529_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1529_MP42 (XI0_I1529_bcon I0_cm64_0 XI0_I1529_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1529_MP45 (XI0_I1529_bp2 I0_cm166_2 XI0_I1529_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1529_MP43 (VDD XI0_I1529_s1 XI0_I1529_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1529_MP44 (XI0_I1529_bp2 I0_cm64_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1529_MP56 (VDD XI0_I1529_bcon I0_cm168_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1529_MP46 (XI0_I1529_bp3 XI0_I1529_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1529_MP48 (VDD I0_cm166_2 XI0_I1529_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1529_MP50_1 (XI0_I1529_bp4 XI0_I1529_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1529_MP26 (VDD XI0_I1529_asn XI0_I1529_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1529_MP18 (XI0_I1529_ap3 I0_cm61_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1529_MP21 (XI0_I1529_asn XI0_I1529_acon XI0_I1529_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1529_MP24 (XI0_I1529_ap5 I0_cm63_0 XI0_I1529_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1529_MP23 (XI0_I1529_ap4 I0_cm62_0 XI0_I1529_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1529_MP22 (VDD I0_cm61_0 XI0_I1529_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1529_MP22_1 (XI0_I1529_ap4 I0_cm61_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1529_MP23_1 (XI0_I1529_ap5 I0_cm62_0 XI0_I1529_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1529_MP24_1 (XI0_I1529_asn I0_cm63_0 XI0_I1529_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1529_MP17 (XI0_I1529_acon I0_cm63_0 XI0_I1529_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1529_MP14 (XI0_I1529_ap1 I0_cm62_0 XI0_I1529_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1529_MP13 (VDD I0_cm61_0 XI0_I1529_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1529_MP15 (XI0_I1529_ap2 I0_cm61_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1529_MP16 (VDD I0_cm62_0 XI0_I1529_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1529_MP28 (I0_cm168_2 XI0_I1529_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1529_MP19 (XI0_I1529_ap3 I0_cm62_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1529_MP20 (VDD I0_cm63_0 XI0_I1529_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1536_MP50 (VDD XI0_I1536_s1 XI0_I1536_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1536_MP47 (XI0_I1536_bp3 I0_cm76_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1536_MP49 (XI0_I1536_bsn XI0_I1536_bcon XI0_I1536_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1536_MP52 (XI0_I1536_bp5 I0_cm173_2 XI0_I1536_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1536_MP51 (XI0_I1536_bp4 I0_cm76_1 XI0_I1536_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1536_MP51_1 (XI0_I1536_bp5 I0_cm76_1 XI0_I1536_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1536_MP52_1 (XI0_I1536_bsn I0_cm173_2 XI0_I1536_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1536_MP54 (VDD XI0_I1536_bsn I0_cm175_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1536_MP41 (XI0_I1536_bp1 XI0_I1536_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1536_MP42 (XI0_I1536_bcon I0_cm76_1 XI0_I1536_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1536_MP45 (XI0_I1536_bp2 I0_cm173_2 XI0_I1536_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1536_MP43 (VDD XI0_I1536_s1 XI0_I1536_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1536_MP44 (XI0_I1536_bp2 I0_cm76_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1536_MP56 (VDD XI0_I1536_bcon I0_cm175_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1536_MP46 (XI0_I1536_bp3 XI0_I1536_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1536_MP48 (VDD I0_cm173_2 XI0_I1536_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1536_MP50_1 (XI0_I1536_bp4 XI0_I1536_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1536_MP26 (VDD XI0_I1536_asn XI0_I1536_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1536_MP18 (XI0_I1536_ap3 I0_cm73_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1536_MP21 (XI0_I1536_asn XI0_I1536_acon XI0_I1536_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1536_MP24 (XI0_I1536_ap5 I0_cm75_1 XI0_I1536_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1536_MP23 (XI0_I1536_ap4 I0_cm74_1 XI0_I1536_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1536_MP22 (VDD I0_cm73_1 XI0_I1536_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1536_MP22_1 (XI0_I1536_ap4 I0_cm73_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1536_MP23_1 (XI0_I1536_ap5 I0_cm74_1 XI0_I1536_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1536_MP24_1 (XI0_I1536_asn I0_cm75_1 XI0_I1536_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1536_MP17 (XI0_I1536_acon I0_cm75_1 XI0_I1536_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1536_MP14 (XI0_I1536_ap1 I0_cm74_1 XI0_I1536_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1536_MP13 (VDD I0_cm73_1 XI0_I1536_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1536_MP15 (XI0_I1536_ap2 I0_cm73_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1536_MP16 (VDD I0_cm74_1 XI0_I1536_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1536_MP28 (I0_cm175_2 XI0_I1536_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1536_MP19 (XI0_I1536_ap3 I0_cm74_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1536_MP20 (VDD I0_cm75_1 XI0_I1536_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1447_MP50 (VDD XI0_I1447_s1 XI0_I1447_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1447_MP47 (XI0_I1447_bp3 I0_pp8_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1447_MP49 (XI0_I1447_bsn XI0_I1447_bcon XI0_I1447_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1447_MP52 (XI0_I1447_bp5 I0_cm82_2 XI0_I1447_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1447_MP51 (XI0_I1447_bp4 I0_pp8_20 XI0_I1447_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1447_MP51_1 (XI0_I1447_bp5 I0_pp8_20 XI0_I1447_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1447_MP52_1 (XI0_I1447_bsn I0_cm82_2 XI0_I1447_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1447_MP54 (VDD XI0_I1447_bsn I0_cm86_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1447_MP41 (XI0_I1447_bp1 XI0_I1447_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1447_MP42 (XI0_I1447_bcon I0_pp8_20 XI0_I1447_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1447_MP45 (XI0_I1447_bp2 I0_cm82_2 XI0_I1447_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1447_MP43 (VDD XI0_I1447_s1 XI0_I1447_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1447_MP44 (XI0_I1447_bp2 I0_pp8_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1447_MP56 (VDD XI0_I1447_bcon I0_cm86_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1447_MP46 (XI0_I1447_bp3 XI0_I1447_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1447_MP48 (VDD I0_cm82_2 XI0_I1447_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1447_MP50_1 (XI0_I1447_bp4 XI0_I1447_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1447_MP26 (VDD XI0_I1447_asn XI0_I1447_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1447_MP18 (XI0_I1447_ap3 I0_pp5_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1447_MP21 (XI0_I1447_asn XI0_I1447_acon XI0_I1447_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1447_MP24 (XI0_I1447_ap5 I0_pp7_22 XI0_I1447_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1447_MP23 (XI0_I1447_ap4 I0_pp6_24 XI0_I1447_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1447_MP22 (VDD I0_pp5_26 XI0_I1447_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1447_MP22_1 (XI0_I1447_ap4 I0_pp5_26 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1447_MP23_1 (XI0_I1447_ap5 I0_pp6_24 XI0_I1447_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1447_MP24_1 (XI0_I1447_asn I0_pp7_22 XI0_I1447_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1447_MP17 (XI0_I1447_acon I0_pp7_22 XI0_I1447_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1447_MP14 (XI0_I1447_ap1 I0_pp6_24 XI0_I1447_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1447_MP13 (VDD I0_pp5_26 XI0_I1447_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1447_MP15 (XI0_I1447_ap2 I0_pp5_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1447_MP16 (VDD I0_pp6_24 XI0_I1447_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1447_MP28 (I0_cm86_2 XI0_I1447_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1447_MP19 (XI0_I1447_ap3 I0_pp6_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1447_MP20 (VDD I0_pp7_22 XI0_I1447_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1368_MP50 (VDD XI0_I1368_s1 XI0_I1368_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1368_MP47 (XI0_I1368_bp3 I0_pp3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1368_MP49 (XI0_I1368_bsn XI0_I1368_bcon XI0_I1368_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1368_MP52 (XI0_I1368_bp5 I0_cm6_2 XI0_I1368_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1368_MP51 (XI0_I1368_bp4 I0_pp3_3 XI0_I1368_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1368_MP51_1 (XI0_I1368_bp5 I0_pp3_3 XI0_I1368_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1368_MP52_1 (XI0_I1368_bsn I0_cm6_2 XI0_I1368_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1368_MP54 (VDD XI0_I1368_bsn I0_cm7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1368_MP41 (XI0_I1368_bp1 XI0_I1368_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1368_MP42 (XI0_I1368_bcon I0_pp3_3 XI0_I1368_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1368_MP45 (XI0_I1368_bp2 I0_cm6_2 XI0_I1368_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1368_MP43 (VDD XI0_I1368_s1 XI0_I1368_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1368_MP44 (XI0_I1368_bp2 I0_pp3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1368_MP56 (VDD XI0_I1368_bcon I0_cm7_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1368_MP46 (XI0_I1368_bp3 XI0_I1368_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1368_MP48 (VDD I0_cm6_2 XI0_I1368_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1368_MP50_1 (XI0_I1368_bp4 XI0_I1368_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1368_MP26 (VDD XI0_I1368_asn XI0_I1368_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1368_MP18 (XI0_I1368_ap3 I0_pp0_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1368_MP21 (XI0_I1368_asn XI0_I1368_acon XI0_I1368_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1368_MP24 (XI0_I1368_ap5 I0_pp2_5 XI0_I1368_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1368_MP23 (XI0_I1368_ap4 I0_pp1_7 XI0_I1368_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1368_MP22 (VDD I0_pp0_9 XI0_I1368_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1368_MP22_1 (XI0_I1368_ap4 I0_pp0_9 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1368_MP23_1 (XI0_I1368_ap5 I0_pp1_7 XI0_I1368_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1368_MP24_1 (XI0_I1368_asn I0_pp2_5 XI0_I1368_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1368_MP17 (XI0_I1368_acon I0_pp2_5 XI0_I1368_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1368_MP14 (XI0_I1368_ap1 I0_pp1_7 XI0_I1368_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1368_MP13 (VDD I0_pp0_9 XI0_I1368_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1368_MP15 (XI0_I1368_ap2 I0_pp0_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1368_MP16 (VDD I0_pp1_7 XI0_I1368_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1368_MP28 (I0_cm7_2 XI0_I1368_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1368_MP19 (XI0_I1368_ap3 I0_pp1_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1368_MP20 (VDD I0_pp2_5 XI0_I1368_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1371_MP50 (VDD XI0_I1371_s1 XI0_I1371_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1371_MP47 (XI0_I1371_bp3 I0_pp3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1371_MP49 (XI0_I1371_bsn XI0_I1371_bcon XI0_I1371_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1371_MP52 (XI0_I1371_bp5 I0_cm8_2 XI0_I1371_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1371_MP51 (XI0_I1371_bp4 I0_pp3_5 XI0_I1371_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1371_MP51_1 (XI0_I1371_bp5 I0_pp3_5 XI0_I1371_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1371_MP52_1 (XI0_I1371_bsn I0_cm8_2 XI0_I1371_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1371_MP54 (VDD XI0_I1371_bsn I0_cm10_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1371_MP41 (XI0_I1371_bp1 XI0_I1371_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1371_MP42 (XI0_I1371_bcon I0_pp3_5 XI0_I1371_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1371_MP45 (XI0_I1371_bp2 I0_cm8_2 XI0_I1371_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1371_MP43 (VDD XI0_I1371_s1 XI0_I1371_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1371_MP44 (XI0_I1371_bp2 I0_pp3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1371_MP56 (VDD XI0_I1371_bcon I0_cm10_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1371_MP46 (XI0_I1371_bp3 XI0_I1371_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1371_MP48 (VDD I0_cm8_2 XI0_I1371_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1371_MP50_1 (XI0_I1371_bp4 XI0_I1371_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1371_MP26 (VDD XI0_I1371_asn XI0_I1371_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1371_MP18 (XI0_I1371_ap3 I0_pp0_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1371_MP21 (XI0_I1371_asn XI0_I1371_acon XI0_I1371_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1371_MP24 (XI0_I1371_ap5 I0_pp2_7 XI0_I1371_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1371_MP23 (XI0_I1371_ap4 I0_pp1_9 XI0_I1371_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1371_MP22 (VDD I0_pp0_11 XI0_I1371_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1371_MP22_1 (XI0_I1371_ap4 I0_pp0_11 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1371_MP23_1 (XI0_I1371_ap5 I0_pp1_9 XI0_I1371_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1371_MP24_1 (XI0_I1371_asn I0_pp2_7 XI0_I1371_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1371_MP17 (XI0_I1371_acon I0_pp2_7 XI0_I1371_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1371_MP14 (XI0_I1371_ap1 I0_pp1_9 XI0_I1371_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1371_MP13 (VDD I0_pp0_11 XI0_I1371_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1371_MP15 (XI0_I1371_ap2 I0_pp0_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1371_MP16 (VDD I0_pp1_9 XI0_I1371_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1371_MP28 (I0_cm10_2 XI0_I1371_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1371_MP19 (XI0_I1371_ap3 I0_pp1_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1371_MP20 (VDD I0_pp2_7 XI0_I1371_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1393_MP50 (VDD XI0_I1393_s1 XI0_I1393_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1393_MP47 (XI0_I1393_bp3 I0_pp7_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1393_MP49 (XI0_I1393_bsn XI0_I1393_bcon XI0_I1393_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1393_MP52 (XI0_I1393_bp5 I0_cm29_2 XI0_I1393_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1393_MP51 (XI0_I1393_bp4 I0_pp7_7 XI0_I1393_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1393_MP51_1 (XI0_I1393_bp5 I0_pp7_7 XI0_I1393_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1393_MP52_1 (XI0_I1393_bsn I0_cm29_2 XI0_I1393_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1393_MP54 (VDD XI0_I1393_bsn I0_cm32_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1393_MP41 (XI0_I1393_bp1 XI0_I1393_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1393_MP42 (XI0_I1393_bcon I0_pp7_7 XI0_I1393_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1393_MP45 (XI0_I1393_bp2 I0_cm29_2 XI0_I1393_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1393_MP43 (VDD XI0_I1393_s1 XI0_I1393_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1393_MP44 (XI0_I1393_bp2 I0_pp7_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1393_MP56 (VDD XI0_I1393_bcon I0_cm32_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1393_MP46 (XI0_I1393_bp3 XI0_I1393_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1393_MP48 (VDD I0_cm29_2 XI0_I1393_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1393_MP50_1 (XI0_I1393_bp4 XI0_I1393_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1393_MP26 (VDD XI0_I1393_asn XI0_I1393_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1393_MP18 (XI0_I1393_ap3 I0_pp4_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1393_MP21 (XI0_I1393_asn XI0_I1393_acon XI0_I1393_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1393_MP24 (XI0_I1393_ap5 I0_pp6_9 XI0_I1393_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1393_MP23 (XI0_I1393_ap4 I0_pp5_11 XI0_I1393_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1393_MP22 (VDD I0_pp4_13 XI0_I1393_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1393_MP22_1 (XI0_I1393_ap4 I0_pp4_13 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1393_MP23_1 (XI0_I1393_ap5 I0_pp5_11 XI0_I1393_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1393_MP24_1 (XI0_I1393_asn I0_pp6_9 XI0_I1393_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1393_MP17 (XI0_I1393_acon I0_pp6_9 XI0_I1393_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1393_MP14 (XI0_I1393_ap1 I0_pp5_11 XI0_I1393_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1393_MP13 (VDD I0_pp4_13 XI0_I1393_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1393_MP15 (XI0_I1393_ap2 I0_pp4_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1393_MP16 (VDD I0_pp5_11 XI0_I1393_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1393_MP28 (I0_cm32_2 XI0_I1393_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1393_MP19 (XI0_I1393_ap3 I0_pp5_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1393_MP20 (VDD I0_pp6_9 XI0_I1393_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1518_MP50 (VDD XI0_I1518_s1 XI0_I1518_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1518_MP47 (XI0_I1518_bp3 I0_cm43_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1518_MP49 (XI0_I1518_bsn XI0_I1518_bcon XI0_I1518_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1518_MP52 (XI0_I1518_bp5 I0_cm155_2 XI0_I1518_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1518_MP51 (XI0_I1518_bp4 I0_cm43_0 XI0_I1518_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1518_MP51_1 (XI0_I1518_bp5 I0_cm43_0 XI0_I1518_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1518_MP52_1 (XI0_I1518_bsn I0_cm155_2 XI0_I1518_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1518_MP54 (VDD XI0_I1518_bsn I0_cm157_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1518_MP41 (XI0_I1518_bp1 XI0_I1518_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1518_MP42 (XI0_I1518_bcon I0_cm43_0 XI0_I1518_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1518_MP45 (XI0_I1518_bp2 I0_cm155_2 XI0_I1518_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1518_MP43 (VDD XI0_I1518_s1 XI0_I1518_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1518_MP44 (XI0_I1518_bp2 I0_cm43_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1518_MP56 (VDD XI0_I1518_bcon I0_cm157_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1518_MP46 (XI0_I1518_bp3 XI0_I1518_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1518_MP48 (VDD I0_cm155_2 XI0_I1518_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1518_MP50_1 (XI0_I1518_bp4 XI0_I1518_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1518_MP26 (VDD XI0_I1518_asn XI0_I1518_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1518_MP18 (XI0_I1518_ap3 I0_cm40_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1518_MP21 (XI0_I1518_asn XI0_I1518_acon XI0_I1518_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1518_MP24 (XI0_I1518_ap5 I0_cm42_1 XI0_I1518_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1518_MP23 (XI0_I1518_ap4 I0_cm41_1 XI0_I1518_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1518_MP22 (VDD I0_cm40_1 XI0_I1518_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1518_MP22_1 (XI0_I1518_ap4 I0_cm40_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1518_MP23_1 (XI0_I1518_ap5 I0_cm41_1 XI0_I1518_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1518_MP24_1 (XI0_I1518_asn I0_cm42_1 XI0_I1518_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1518_MP17 (XI0_I1518_acon I0_cm42_1 XI0_I1518_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1518_MP14 (XI0_I1518_ap1 I0_cm41_1 XI0_I1518_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1518_MP13 (VDD I0_cm40_1 XI0_I1518_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1518_MP15 (XI0_I1518_ap2 I0_cm40_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1518_MP16 (VDD I0_cm41_1 XI0_I1518_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1518_MP28 (I0_cm157_2 XI0_I1518_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1518_MP19 (XI0_I1518_ap3 I0_cm41_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1518_MP20 (VDD I0_cm42_1 XI0_I1518_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1399_MP50 (VDD XI0_I1399_s1 XI0_I1399_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1399_MP47 (XI0_I1399_bp3 I0_pp7_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1399_MP49 (XI0_I1399_bsn XI0_I1399_bcon XI0_I1399_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1399_MP52 (XI0_I1399_bp5 I0_cm35_2 XI0_I1399_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1399_MP51 (XI0_I1399_bp4 I0_pp7_9 XI0_I1399_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1399_MP51_1 (XI0_I1399_bp5 I0_pp7_9 XI0_I1399_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1399_MP52_1 (XI0_I1399_bsn I0_cm35_2 XI0_I1399_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1399_MP54 (VDD XI0_I1399_bsn I0_cm38_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1399_MP41 (XI0_I1399_bp1 XI0_I1399_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1399_MP42 (XI0_I1399_bcon I0_pp7_9 XI0_I1399_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1399_MP45 (XI0_I1399_bp2 I0_cm35_2 XI0_I1399_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1399_MP43 (VDD XI0_I1399_s1 XI0_I1399_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1399_MP44 (XI0_I1399_bp2 I0_pp7_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1399_MP56 (VDD XI0_I1399_bcon I0_cm38_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1399_MP46 (XI0_I1399_bp3 XI0_I1399_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1399_MP48 (VDD I0_cm35_2 XI0_I1399_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1399_MP50_1 (XI0_I1399_bp4 XI0_I1399_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1399_MP26 (VDD XI0_I1399_asn XI0_I1399_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1399_MP18 (XI0_I1399_ap3 I0_pp4_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1399_MP21 (XI0_I1399_asn XI0_I1399_acon XI0_I1399_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1399_MP24 (XI0_I1399_ap5 I0_pp6_11 XI0_I1399_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1399_MP23 (XI0_I1399_ap4 I0_pp5_13 XI0_I1399_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1399_MP22 (VDD I0_pp4_15 XI0_I1399_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1399_MP22_1 (XI0_I1399_ap4 I0_pp4_15 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1399_MP23_1 (XI0_I1399_ap5 I0_pp5_13 XI0_I1399_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1399_MP24_1 (XI0_I1399_asn I0_pp6_11 XI0_I1399_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1399_MP17 (XI0_I1399_acon I0_pp6_11 XI0_I1399_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1399_MP14 (XI0_I1399_ap1 I0_pp5_13 XI0_I1399_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1399_MP13 (VDD I0_pp4_15 XI0_I1399_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1399_MP15 (XI0_I1399_ap2 I0_pp4_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1399_MP16 (VDD I0_pp5_13 XI0_I1399_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1399_MP28 (I0_cm38_2 XI0_I1399_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1399_MP19 (XI0_I1399_ap3 I0_pp5_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1399_MP20 (VDD I0_pp6_11 XI0_I1399_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1522_MP50 (VDD XI0_I1522_s1 XI0_I1522_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1522_MP47 (XI0_I1522_bp3 I0_fa49_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1522_MP49 (XI0_I1522_bsn XI0_I1522_bcon XI0_I1522_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1522_MP52 (XI0_I1522_bp5 I0_cm159_2 XI0_I1522_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1522_MP51 (XI0_I1522_bp4 I0_fa49_1 XI0_I1522_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1522_MP51_1 (XI0_I1522_bp5 I0_fa49_1 XI0_I1522_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1522_MP52_1 (XI0_I1522_bsn I0_cm159_2 XI0_I1522_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1522_MP54 (VDD XI0_I1522_bsn I0_cm161_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1522_MP41 (XI0_I1522_bp1 XI0_I1522_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1522_MP42 (XI0_I1522_bcon I0_fa49_1 XI0_I1522_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1522_MP45 (XI0_I1522_bp2 I0_cm159_2 XI0_I1522_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1522_MP43 (VDD XI0_I1522_s1 XI0_I1522_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1522_MP44 (XI0_I1522_bp2 I0_fa49_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1522_MP56 (VDD XI0_I1522_bcon I0_cm161_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1522_MP46 (XI0_I1522_bp3 XI0_I1522_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1522_MP48 (VDD I0_cm159_2 XI0_I1522_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1522_MP50_1 (XI0_I1522_bp4 XI0_I1522_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1522_MP26 (VDD XI0_I1522_asn XI0_I1522_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1522_MP18 (XI0_I1522_ap3 I0_cm46_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1522_MP21 (XI0_I1522_asn XI0_I1522_acon XI0_I1522_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1522_MP24 (XI0_I1522_ap5 I0_cm48_1 XI0_I1522_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1522_MP23 (XI0_I1522_ap4 I0_cm47_1 XI0_I1522_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1522_MP22 (VDD I0_cm46_1 XI0_I1522_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1522_MP22_1 (XI0_I1522_ap4 I0_cm46_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1522_MP23_1 (XI0_I1522_ap5 I0_cm47_1 XI0_I1522_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1522_MP24_1 (XI0_I1522_asn I0_cm48_1 XI0_I1522_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1522_MP17 (XI0_I1522_acon I0_cm48_1 XI0_I1522_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1522_MP14 (XI0_I1522_ap1 I0_cm47_1 XI0_I1522_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1522_MP13 (VDD I0_cm46_1 XI0_I1522_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1522_MP15 (XI0_I1522_ap2 I0_cm46_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1522_MP16 (VDD I0_cm47_1 XI0_I1522_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1522_MP28 (I0_cm161_2 XI0_I1522_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1522_MP19 (XI0_I1522_ap3 I0_cm47_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1522_MP20 (VDD I0_cm48_1 XI0_I1522_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1585_MP50 (VDD XI0_I1585_s1 XI0_I1585_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1585_MP47 (XI0_I1585_bp3 I0_cm168_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1585_MP49 (XI0_I1585_bsn XI0_I1585_bcon XI0_I1585_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1585_MP52 (XI0_I1585_bp5 I0_cm223_2 XI0_I1585_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1585_MP51 (XI0_I1585_bp4 I0_cm168_0 XI0_I1585_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1585_MP51_1 (XI0_I1585_bp5 I0_cm168_0 XI0_I1585_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1585_MP52_1 (XI0_I1585_bsn I0_cm223_2 XI0_I1585_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1585_MP54 (VDD XI0_I1585_bsn I0_cm224_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1585_MP41 (XI0_I1585_bp1 XI0_I1585_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1585_MP42 (XI0_I1585_bcon I0_cm168_0 XI0_I1585_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1585_MP45 (XI0_I1585_bp2 I0_cm223_2 XI0_I1585_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1585_MP43 (VDD XI0_I1585_s1 XI0_I1585_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1585_MP44 (XI0_I1585_bp2 I0_cm168_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1585_MP56 (VDD XI0_I1585_bcon I0_cm224_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1585_MP46 (XI0_I1585_bp3 XI0_I1585_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1585_MP48 (VDD I0_cm223_2 XI0_I1585_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1585_MP50_1 (XI0_I1585_bp4 XI0_I1585_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1585_MP26 (VDD XI0_I1585_asn XI0_I1585_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1585_MP18 (XI0_I1585_ap3 I0_cm165_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1585_MP21 (XI0_I1585_asn XI0_I1585_acon XI0_I1585_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1585_MP24 (XI0_I1585_ap5 I0_cm167_0 XI0_I1585_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1585_MP23 (XI0_I1585_ap4 I0_cm166_1 XI0_I1585_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1585_MP22 (VDD I0_cm165_1 XI0_I1585_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1585_MP22_1 (XI0_I1585_ap4 I0_cm165_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1585_MP23_1 (XI0_I1585_ap5 I0_cm166_1 XI0_I1585_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1585_MP24_1 (XI0_I1585_asn I0_cm167_0 XI0_I1585_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1585_MP17 (XI0_I1585_acon I0_cm167_0 XI0_I1585_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1585_MP14 (XI0_I1585_ap1 I0_cm166_1 XI0_I1585_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1585_MP13 (VDD I0_cm165_1 XI0_I1585_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1585_MP15 (XI0_I1585_ap2 I0_cm165_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1585_MP16 (VDD I0_cm166_1 XI0_I1585_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1585_MP28 (I0_cm224_2 XI0_I1585_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1585_MP19 (XI0_I1585_ap3 I0_cm166_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1585_MP20 (VDD I0_cm167_0 XI0_I1585_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1586_MP50 (VDD XI0_I1586_s1 XI0_I1586_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1586_MP47 (XI0_I1586_bp3 I0_cm170_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1586_MP49 (XI0_I1586_bsn XI0_I1586_bcon XI0_I1586_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1586_MP52 (XI0_I1586_bp5 I0_cm224_2 XI0_I1586_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1586_MP51 (XI0_I1586_bp4 I0_cm170_0 XI0_I1586_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1586_MP51_1 (XI0_I1586_bp5 I0_cm170_0 XI0_I1586_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1586_MP52_1 (XI0_I1586_bsn I0_cm224_2 XI0_I1586_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1586_MP54 (VDD XI0_I1586_bsn I0_cm225_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1586_MP41 (XI0_I1586_bp1 XI0_I1586_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1586_MP42 (XI0_I1586_bcon I0_cm170_0 XI0_I1586_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1586_MP45 (XI0_I1586_bp2 I0_cm224_2 XI0_I1586_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1586_MP43 (VDD XI0_I1586_s1 XI0_I1586_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1586_MP44 (XI0_I1586_bp2 I0_cm170_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1586_MP56 (VDD XI0_I1586_bcon I0_cm225_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1586_MP46 (XI0_I1586_bp3 XI0_I1586_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1586_MP48 (VDD I0_cm224_2 XI0_I1586_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1586_MP50_1 (XI0_I1586_bp4 XI0_I1586_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1586_MP26 (VDD XI0_I1586_asn XI0_I1586_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1586_MP18 (XI0_I1586_ap3 I0_cm167_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1586_MP21 (XI0_I1586_asn XI0_I1586_acon XI0_I1586_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1586_MP24 (XI0_I1586_ap5 I0_cm169_0 XI0_I1586_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1586_MP23 (XI0_I1586_ap4 I0_cm168_1 XI0_I1586_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1586_MP22 (VDD I0_cm167_1 XI0_I1586_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1586_MP22_1 (XI0_I1586_ap4 I0_cm167_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1586_MP23_1 (XI0_I1586_ap5 I0_cm168_1 XI0_I1586_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1586_MP24_1 (XI0_I1586_asn I0_cm169_0 XI0_I1586_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1586_MP17 (XI0_I1586_acon I0_cm169_0 XI0_I1586_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1586_MP14 (XI0_I1586_ap1 I0_cm168_1 XI0_I1586_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1586_MP13 (VDD I0_cm167_1 XI0_I1586_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1586_MP15 (XI0_I1586_ap2 I0_cm167_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1586_MP16 (VDD I0_cm168_1 XI0_I1586_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1586_MP28 (I0_cm225_2 XI0_I1586_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1586_MP19 (XI0_I1586_ap3 I0_cm168_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1586_MP20 (VDD I0_cm169_0 XI0_I1586_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1587_MP50 (VDD XI0_I1587_s1 XI0_I1587_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1587_MP47 (XI0_I1587_bp3 I0_cm172_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1587_MP49 (XI0_I1587_bsn XI0_I1587_bcon XI0_I1587_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1587_MP52 (XI0_I1587_bp5 I0_cm225_2 XI0_I1587_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1587_MP51 (XI0_I1587_bp4 I0_cm172_0 XI0_I1587_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1587_MP51_1 (XI0_I1587_bp5 I0_cm172_0 XI0_I1587_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1587_MP52_1 (XI0_I1587_bsn I0_cm225_2 XI0_I1587_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1587_MP54 (VDD XI0_I1587_bsn I0_cm226_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1587_MP41 (XI0_I1587_bp1 XI0_I1587_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1587_MP42 (XI0_I1587_bcon I0_cm172_0 XI0_I1587_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1587_MP45 (XI0_I1587_bp2 I0_cm225_2 XI0_I1587_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1587_MP43 (VDD XI0_I1587_s1 XI0_I1587_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1587_MP44 (XI0_I1587_bp2 I0_cm172_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1587_MP56 (VDD XI0_I1587_bcon I0_cm226_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1587_MP46 (XI0_I1587_bp3 XI0_I1587_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1587_MP48 (VDD I0_cm225_2 XI0_I1587_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1587_MP50_1 (XI0_I1587_bp4 XI0_I1587_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1587_MP26 (VDD XI0_I1587_asn XI0_I1587_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1587_MP18 (XI0_I1587_ap3 I0_cm169_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1587_MP21 (XI0_I1587_asn XI0_I1587_acon XI0_I1587_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1587_MP24 (XI0_I1587_ap5 I0_cm171_0 XI0_I1587_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1587_MP23 (XI0_I1587_ap4 I0_cm170_1 XI0_I1587_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1587_MP22 (VDD I0_cm169_1 XI0_I1587_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1587_MP22_1 (XI0_I1587_ap4 I0_cm169_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1587_MP23_1 (XI0_I1587_ap5 I0_cm170_1 XI0_I1587_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1587_MP24_1 (XI0_I1587_asn I0_cm171_0 XI0_I1587_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1587_MP17 (XI0_I1587_acon I0_cm171_0 XI0_I1587_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1587_MP14 (XI0_I1587_ap1 I0_cm170_1 XI0_I1587_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1587_MP13 (VDD I0_cm169_1 XI0_I1587_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1587_MP15 (XI0_I1587_ap2 I0_cm169_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1587_MP16 (VDD I0_cm170_1 XI0_I1587_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1587_MP28 (I0_cm226_2 XI0_I1587_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1587_MP19 (XI0_I1587_ap3 I0_cm170_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1587_MP20 (VDD I0_cm171_0 XI0_I1587_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1588_MP50 (VDD XI0_I1588_s1 XI0_I1588_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1588_MP47 (XI0_I1588_bp3 I0_cm174_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1588_MP49 (XI0_I1588_bsn XI0_I1588_bcon XI0_I1588_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1588_MP52 (XI0_I1588_bp5 I0_cm226_2 XI0_I1588_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1588_MP51 (XI0_I1588_bp4 I0_cm174_0 XI0_I1588_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1588_MP51_1 (XI0_I1588_bp5 I0_cm174_0 XI0_I1588_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1588_MP52_1 (XI0_I1588_bsn I0_cm226_2 XI0_I1588_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1588_MP54 (VDD XI0_I1588_bsn I0_cm227_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1588_MP41 (XI0_I1588_bp1 XI0_I1588_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1588_MP42 (XI0_I1588_bcon I0_cm174_0 XI0_I1588_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1588_MP45 (XI0_I1588_bp2 I0_cm226_2 XI0_I1588_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1588_MP43 (VDD XI0_I1588_s1 XI0_I1588_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1588_MP44 (XI0_I1588_bp2 I0_cm174_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1588_MP56 (VDD XI0_I1588_bcon I0_cm227_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1588_MP46 (XI0_I1588_bp3 XI0_I1588_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1588_MP48 (VDD I0_cm226_2 XI0_I1588_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1588_MP50_1 (XI0_I1588_bp4 XI0_I1588_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1588_MP26 (VDD XI0_I1588_asn XI0_I1588_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1588_MP18 (XI0_I1588_ap3 I0_cm171_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1588_MP21 (XI0_I1588_asn XI0_I1588_acon XI0_I1588_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1588_MP24 (XI0_I1588_ap5 I0_cm173_0 XI0_I1588_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1588_MP23 (XI0_I1588_ap4 I0_cm172_1 XI0_I1588_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1588_MP22 (VDD I0_cm171_1 XI0_I1588_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1588_MP22_1 (XI0_I1588_ap4 I0_cm171_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1588_MP23_1 (XI0_I1588_ap5 I0_cm172_1 XI0_I1588_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1588_MP24_1 (XI0_I1588_asn I0_cm173_0 XI0_I1588_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1588_MP17 (XI0_I1588_acon I0_cm173_0 XI0_I1588_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1588_MP14 (XI0_I1588_ap1 I0_cm172_1 XI0_I1588_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1588_MP13 (VDD I0_cm171_1 XI0_I1588_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1588_MP15 (XI0_I1588_ap2 I0_cm171_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1588_MP16 (VDD I0_cm172_1 XI0_I1588_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1588_MP28 (I0_cm227_2 XI0_I1588_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1588_MP19 (XI0_I1588_ap3 I0_cm172_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1588_MP20 (VDD I0_cm173_0 XI0_I1588_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1590_MP50 (VDD XI0_I1590_s1 XI0_I1590_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1590_MP47 (XI0_I1590_bp3 I0_cm178_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1590_MP49 (XI0_I1590_bsn XI0_I1590_bcon XI0_I1590_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1590_MP52 (XI0_I1590_bp5 I0_cm228_2 XI0_I1590_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1590_MP51 (XI0_I1590_bp4 I0_cm178_0 XI0_I1590_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1590_MP51_1 (XI0_I1590_bp5 I0_cm178_0 XI0_I1590_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1590_MP52_1 (XI0_I1590_bsn I0_cm228_2 XI0_I1590_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1590_MP54 (VDD XI0_I1590_bsn I0_cm229_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1590_MP41 (XI0_I1590_bp1 XI0_I1590_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1590_MP42 (XI0_I1590_bcon I0_cm178_0 XI0_I1590_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1590_MP45 (XI0_I1590_bp2 I0_cm228_2 XI0_I1590_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1590_MP43 (VDD XI0_I1590_s1 XI0_I1590_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1590_MP44 (XI0_I1590_bp2 I0_cm178_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1590_MP56 (VDD XI0_I1590_bcon I0_cm229_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1590_MP46 (XI0_I1590_bp3 XI0_I1590_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1590_MP48 (VDD I0_cm228_2 XI0_I1590_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1590_MP50_1 (XI0_I1590_bp4 XI0_I1590_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1590_MP26 (VDD XI0_I1590_asn XI0_I1590_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1590_MP18 (XI0_I1590_ap3 I0_cm175_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1590_MP21 (XI0_I1590_asn XI0_I1590_acon XI0_I1590_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1590_MP24 (XI0_I1590_ap5 I0_cm177_0 XI0_I1590_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1590_MP23 (XI0_I1590_ap4 I0_cm176_1 XI0_I1590_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1590_MP22 (VDD I0_cm175_1 XI0_I1590_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1590_MP22_1 (XI0_I1590_ap4 I0_cm175_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1590_MP23_1 (XI0_I1590_ap5 I0_cm176_1 XI0_I1590_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1590_MP24_1 (XI0_I1590_asn I0_cm177_0 XI0_I1590_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1590_MP17 (XI0_I1590_acon I0_cm177_0 XI0_I1590_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1590_MP14 (XI0_I1590_ap1 I0_cm176_1 XI0_I1590_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1590_MP13 (VDD I0_cm175_1 XI0_I1590_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1590_MP15 (XI0_I1590_ap2 I0_cm175_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1590_MP16 (VDD I0_cm176_1 XI0_I1590_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1590_MP28 (I0_cm229_2 XI0_I1590_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1590_MP19 (XI0_I1590_ap3 I0_cm176_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1590_MP20 (VDD I0_cm177_0 XI0_I1590_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1539_MP50 (VDD XI0_I1539_s1 XI0_I1539_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1539_MP47 (XI0_I1539_bp3 I0_cm84_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1539_MP49 (XI0_I1539_bsn XI0_I1539_bcon XI0_I1539_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1539_MP52 (XI0_I1539_bp5 I0_cm176_2 XI0_I1539_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1539_MP51 (XI0_I1539_bp4 I0_cm84_0 XI0_I1539_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1539_MP51_1 (XI0_I1539_bp5 I0_cm84_0 XI0_I1539_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1539_MP52_1 (XI0_I1539_bsn I0_cm176_2 XI0_I1539_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1539_MP54 (VDD XI0_I1539_bsn I0_cm178_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1539_MP41 (XI0_I1539_bp1 XI0_I1539_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1539_MP42 (XI0_I1539_bcon I0_cm84_0 XI0_I1539_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1539_MP45 (XI0_I1539_bp2 I0_cm176_2 XI0_I1539_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1539_MP43 (VDD XI0_I1539_s1 XI0_I1539_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1539_MP44 (XI0_I1539_bp2 I0_cm84_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1539_MP56 (VDD XI0_I1539_bcon I0_cm178_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1539_MP46 (XI0_I1539_bp3 XI0_I1539_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1539_MP48 (VDD I0_cm176_2 XI0_I1539_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1539_MP50_1 (XI0_I1539_bp4 XI0_I1539_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1539_MP26 (VDD XI0_I1539_asn XI0_I1539_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1539_MP18 (XI0_I1539_ap3 I0_cm81_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1539_MP21 (XI0_I1539_asn XI0_I1539_acon XI0_I1539_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1539_MP24 (XI0_I1539_ap5 I0_cm83_0 XI0_I1539_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1539_MP23 (XI0_I1539_ap4 I0_cm82_0 XI0_I1539_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1539_MP22 (VDD I0_cm81_0 XI0_I1539_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1539_MP22_1 (XI0_I1539_ap4 I0_cm81_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1539_MP23_1 (XI0_I1539_ap5 I0_cm82_0 XI0_I1539_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1539_MP24_1 (XI0_I1539_asn I0_cm83_0 XI0_I1539_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1539_MP17 (XI0_I1539_acon I0_cm83_0 XI0_I1539_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1539_MP14 (XI0_I1539_ap1 I0_cm82_0 XI0_I1539_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1539_MP13 (VDD I0_cm81_0 XI0_I1539_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1539_MP15 (XI0_I1539_ap2 I0_cm81_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1539_MP16 (VDD I0_cm82_0 XI0_I1539_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1539_MP28 (I0_cm178_2 XI0_I1539_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1539_MP19 (XI0_I1539_ap3 I0_cm82_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1539_MP20 (VDD I0_cm83_0 XI0_I1539_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1537_MP50 (VDD XI0_I1537_s1 XI0_I1537_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1537_MP47 (XI0_I1537_bp3 I0_cm80_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1537_MP49 (XI0_I1537_bsn XI0_I1537_bcon XI0_I1537_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1537_MP52 (XI0_I1537_bp5 I0_cm174_2 XI0_I1537_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1537_MP51 (XI0_I1537_bp4 I0_cm80_0 XI0_I1537_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1537_MP51_1 (XI0_I1537_bp5 I0_cm80_0 XI0_I1537_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1537_MP52_1 (XI0_I1537_bsn I0_cm174_2 XI0_I1537_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1537_MP54 (VDD XI0_I1537_bsn I0_cm176_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1537_MP41 (XI0_I1537_bp1 XI0_I1537_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1537_MP42 (XI0_I1537_bcon I0_cm80_0 XI0_I1537_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1537_MP45 (XI0_I1537_bp2 I0_cm174_2 XI0_I1537_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1537_MP43 (VDD XI0_I1537_s1 XI0_I1537_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1537_MP44 (XI0_I1537_bp2 I0_cm80_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1537_MP56 (VDD XI0_I1537_bcon I0_cm176_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1537_MP46 (XI0_I1537_bp3 XI0_I1537_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1537_MP48 (VDD I0_cm174_2 XI0_I1537_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1537_MP50_1 (XI0_I1537_bp4 XI0_I1537_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1537_MP26 (VDD XI0_I1537_asn XI0_I1537_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1537_MP18 (XI0_I1537_ap3 I0_cm77_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1537_MP21 (XI0_I1537_asn XI0_I1537_acon XI0_I1537_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1537_MP24 (XI0_I1537_ap5 I0_cm79_0 XI0_I1537_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1537_MP23 (XI0_I1537_ap4 I0_cm78_0 XI0_I1537_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1537_MP22 (VDD I0_cm77_0 XI0_I1537_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1537_MP22_1 (XI0_I1537_ap4 I0_cm77_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1537_MP23_1 (XI0_I1537_ap5 I0_cm78_0 XI0_I1537_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1537_MP24_1 (XI0_I1537_asn I0_cm79_0 XI0_I1537_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1537_MP17 (XI0_I1537_acon I0_cm79_0 XI0_I1537_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1537_MP14 (XI0_I1537_ap1 I0_cm78_0 XI0_I1537_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1537_MP13 (VDD I0_cm77_0 XI0_I1537_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1537_MP15 (XI0_I1537_ap2 I0_cm77_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1537_MP16 (VDD I0_cm78_0 XI0_I1537_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1537_MP28 (I0_cm176_2 XI0_I1537_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1537_MP19 (XI0_I1537_ap3 I0_cm78_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1537_MP20 (VDD I0_cm79_0 XI0_I1537_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1541_MP50 (VDD XI0_I1541_s1 XI0_I1541_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1541_MP47 (XI0_I1541_bp3 I0_fa88_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1541_MP49 (XI0_I1541_bsn XI0_I1541_bcon XI0_I1541_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1541_MP52 (XI0_I1541_bp5 I0_cm178_2 XI0_I1541_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1541_MP51 (XI0_I1541_bp4 I0_fa88_0 XI0_I1541_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1541_MP51_1 (XI0_I1541_bp5 I0_fa88_0 XI0_I1541_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1541_MP52_1 (XI0_I1541_bsn I0_cm178_2 XI0_I1541_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1541_MP54 (VDD XI0_I1541_bsn I0_cm180_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1541_MP41 (XI0_I1541_bp1 XI0_I1541_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1541_MP42 (XI0_I1541_bcon I0_fa88_0 XI0_I1541_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1541_MP45 (XI0_I1541_bp2 I0_cm178_2 XI0_I1541_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1541_MP43 (VDD XI0_I1541_s1 XI0_I1541_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1541_MP44 (XI0_I1541_bp2 I0_fa88_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1541_MP56 (VDD XI0_I1541_bcon I0_cm180_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1541_MP46 (XI0_I1541_bp3 XI0_I1541_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1541_MP48 (VDD I0_cm178_2 XI0_I1541_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1541_MP50_1 (XI0_I1541_bp4 XI0_I1541_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1541_MP26 (VDD XI0_I1541_asn XI0_I1541_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1541_MP18 (XI0_I1541_ap3 I0_cm85_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1541_MP21 (XI0_I1541_asn XI0_I1541_acon XI0_I1541_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1541_MP24 (XI0_I1541_ap5 I0_cm87_0 XI0_I1541_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1541_MP23 (XI0_I1541_ap4 I0_cm86_0 XI0_I1541_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1541_MP22 (VDD I0_cm85_0 XI0_I1541_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1541_MP22_1 (XI0_I1541_ap4 I0_cm85_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1541_MP23_1 (XI0_I1541_ap5 I0_cm86_0 XI0_I1541_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1541_MP24_1 (XI0_I1541_asn I0_cm87_0 XI0_I1541_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1541_MP17 (XI0_I1541_acon I0_cm87_0 XI0_I1541_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1541_MP14 (XI0_I1541_ap1 I0_cm86_0 XI0_I1541_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1541_MP13 (VDD I0_cm85_0 XI0_I1541_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1541_MP15 (XI0_I1541_ap2 I0_cm85_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1541_MP16 (VDD I0_cm86_0 XI0_I1541_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1541_MP28 (I0_cm180_2 XI0_I1541_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1541_MP19 (XI0_I1541_ap3 I0_cm86_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1541_MP20 (VDD I0_cm87_0 XI0_I1541_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1367_MP50 (VDD XI0_I1367_s1 XI0_I1367_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1367_MP47 (XI0_I1367_bp3 I0_pp3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1367_MP49 (XI0_I1367_bsn XI0_I1367_bcon XI0_I1367_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1367_MP52 (XI0_I1367_bp5 I0_cm5_2 XI0_I1367_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1367_MP51 (XI0_I1367_bp4 I0_pp3_2 XI0_I1367_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1367_MP51_1 (XI0_I1367_bp5 I0_pp3_2 XI0_I1367_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1367_MP52_1 (XI0_I1367_bsn I0_cm5_2 XI0_I1367_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1367_MP54 (VDD XI0_I1367_bsn I0_cm6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1367_MP41 (XI0_I1367_bp1 XI0_I1367_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1367_MP42 (XI0_I1367_bcon I0_pp3_2 XI0_I1367_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1367_MP45 (XI0_I1367_bp2 I0_cm5_2 XI0_I1367_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1367_MP43 (VDD XI0_I1367_s1 XI0_I1367_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1367_MP44 (XI0_I1367_bp2 I0_pp3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1367_MP56 (VDD XI0_I1367_bcon I0_cm6_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1367_MP46 (XI0_I1367_bp3 XI0_I1367_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1367_MP48 (VDD I0_cm5_2 XI0_I1367_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1367_MP50_1 (XI0_I1367_bp4 XI0_I1367_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1367_MP26 (VDD XI0_I1367_asn XI0_I1367_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1367_MP18 (XI0_I1367_ap3 I0_pp0_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1367_MP21 (XI0_I1367_asn XI0_I1367_acon XI0_I1367_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1367_MP24 (XI0_I1367_ap5 I0_pp2_4 XI0_I1367_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1367_MP23 (XI0_I1367_ap4 I0_pp1_6 XI0_I1367_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1367_MP22 (VDD I0_pp0_8 XI0_I1367_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1367_MP22_1 (XI0_I1367_ap4 I0_pp0_8 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1367_MP23_1 (XI0_I1367_ap5 I0_pp1_6 XI0_I1367_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1367_MP24_1 (XI0_I1367_asn I0_pp2_4 XI0_I1367_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1367_MP17 (XI0_I1367_acon I0_pp2_4 XI0_I1367_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1367_MP14 (XI0_I1367_ap1 I0_pp1_6 XI0_I1367_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1367_MP13 (VDD I0_pp0_8 XI0_I1367_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1367_MP15 (XI0_I1367_ap2 I0_pp0_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1367_MP16 (VDD I0_pp1_6 XI0_I1367_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1367_MP28 (I0_cm6_2 XI0_I1367_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1367_MP19 (XI0_I1367_ap3 I0_pp1_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1367_MP20 (VDD I0_pp2_4 XI0_I1367_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1369_MP50 (VDD XI0_I1369_s1 XI0_I1369_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1369_MP47 (XI0_I1369_bp3 I0_pp3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1369_MP49 (XI0_I1369_bsn XI0_I1369_bcon XI0_I1369_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1369_MP52 (XI0_I1369_bp5 I0_cm7_2 XI0_I1369_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1369_MP51 (XI0_I1369_bp4 I0_pp3_4 XI0_I1369_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1369_MP51_1 (XI0_I1369_bp5 I0_pp3_4 XI0_I1369_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1369_MP52_1 (XI0_I1369_bsn I0_cm7_2 XI0_I1369_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1369_MP54 (VDD XI0_I1369_bsn I0_cm8_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1369_MP41 (XI0_I1369_bp1 XI0_I1369_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1369_MP42 (XI0_I1369_bcon I0_pp3_4 XI0_I1369_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1369_MP45 (XI0_I1369_bp2 I0_cm7_2 XI0_I1369_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1369_MP43 (VDD XI0_I1369_s1 XI0_I1369_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1369_MP44 (XI0_I1369_bp2 I0_pp3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1369_MP56 (VDD XI0_I1369_bcon I0_cm8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1369_MP46 (XI0_I1369_bp3 XI0_I1369_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1369_MP48 (VDD I0_cm7_2 XI0_I1369_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1369_MP50_1 (XI0_I1369_bp4 XI0_I1369_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1369_MP26 (VDD XI0_I1369_asn XI0_I1369_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1369_MP18 (XI0_I1369_ap3 I0_pp0_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1369_MP21 (XI0_I1369_asn XI0_I1369_acon XI0_I1369_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1369_MP24 (XI0_I1369_ap5 I0_pp2_6 XI0_I1369_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1369_MP23 (XI0_I1369_ap4 I0_pp1_8 XI0_I1369_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1369_MP22 (VDD I0_pp0_10 XI0_I1369_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1369_MP22_1 (XI0_I1369_ap4 I0_pp0_10 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1369_MP23_1 (XI0_I1369_ap5 I0_pp1_8 XI0_I1369_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1369_MP24_1 (XI0_I1369_asn I0_pp2_6 XI0_I1369_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1369_MP17 (XI0_I1369_acon I0_pp2_6 XI0_I1369_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1369_MP14 (XI0_I1369_ap1 I0_pp1_8 XI0_I1369_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1369_MP13 (VDD I0_pp0_10 XI0_I1369_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1369_MP15 (XI0_I1369_ap2 I0_pp0_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1369_MP16 (VDD I0_pp1_8 XI0_I1369_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1369_MP28 (I0_cm8_2 XI0_I1369_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1369_MP19 (XI0_I1369_ap3 I0_pp1_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1369_MP20 (VDD I0_pp2_6 XI0_I1369_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1366_MP50 (VDD XI0_I1366_s1 XI0_I1366_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1366_MP47 (XI0_I1366_bp3 I0_pp3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1366_MP49 (XI0_I1366_bsn XI0_I1366_bcon XI0_I1366_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1366_MP52 (XI0_I1366_bp5 I0_cm4_2 XI0_I1366_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1366_MP51 (XI0_I1366_bp4 I0_pp3_1 XI0_I1366_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1366_MP51_1 (XI0_I1366_bp5 I0_pp3_1 XI0_I1366_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1366_MP52_1 (XI0_I1366_bsn I0_cm4_2 XI0_I1366_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1366_MP54 (VDD XI0_I1366_bsn I0_cm5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1366_MP41 (XI0_I1366_bp1 XI0_I1366_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1366_MP42 (XI0_I1366_bcon I0_pp3_1 XI0_I1366_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1366_MP45 (XI0_I1366_bp2 I0_cm4_2 XI0_I1366_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1366_MP43 (VDD XI0_I1366_s1 XI0_I1366_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1366_MP44 (XI0_I1366_bp2 I0_pp3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1366_MP56 (VDD XI0_I1366_bcon I0_cm5_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1366_MP46 (XI0_I1366_bp3 XI0_I1366_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1366_MP48 (VDD I0_cm4_2 XI0_I1366_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1366_MP50_1 (XI0_I1366_bp4 XI0_I1366_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1366_MP26 (VDD XI0_I1366_asn XI0_I1366_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1366_MP18 (XI0_I1366_ap3 I0_pp0_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1366_MP21 (XI0_I1366_asn XI0_I1366_acon XI0_I1366_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1366_MP24 (XI0_I1366_ap5 I0_pp2_3 XI0_I1366_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1366_MP23 (XI0_I1366_ap4 I0_pp1_5 XI0_I1366_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1366_MP22 (VDD I0_pp0_7 XI0_I1366_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1366_MP22_1 (XI0_I1366_ap4 I0_pp0_7 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1366_MP23_1 (XI0_I1366_ap5 I0_pp1_5 XI0_I1366_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1366_MP24_1 (XI0_I1366_asn I0_pp2_3 XI0_I1366_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1366_MP17 (XI0_I1366_acon I0_pp2_3 XI0_I1366_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1366_MP14 (XI0_I1366_ap1 I0_pp1_5 XI0_I1366_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1366_MP13 (VDD I0_pp0_7 XI0_I1366_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1366_MP15 (XI0_I1366_ap2 I0_pp0_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1366_MP16 (VDD I0_pp1_5 XI0_I1366_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1366_MP28 (I0_cm5_2 XI0_I1366_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1366_MP19 (XI0_I1366_ap3 I0_pp1_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1366_MP20 (VDD I0_pp2_3 XI0_I1366_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1512_MP50 (VDD XI0_I1512_s1 XI0_I1512_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1512_MP47 (XI0_I1512_bp3 I0_cm29_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1512_MP49 (XI0_I1512_bsn XI0_I1512_bcon XI0_I1512_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1512_MP52 (XI0_I1512_bp5 I0_cm149_2 XI0_I1512_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1512_MP51 (XI0_I1512_bp4 I0_cm29_0 XI0_I1512_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1512_MP51_1 (XI0_I1512_bp5 I0_cm29_0 XI0_I1512_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1512_MP52_1 (XI0_I1512_bsn I0_cm149_2 XI0_I1512_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1512_MP54 (VDD XI0_I1512_bsn I0_cm151_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1512_MP41 (XI0_I1512_bp1 XI0_I1512_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1512_MP42 (XI0_I1512_bcon I0_cm29_0 XI0_I1512_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1512_MP45 (XI0_I1512_bp2 I0_cm149_2 XI0_I1512_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1512_MP43 (VDD XI0_I1512_s1 XI0_I1512_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1512_MP44 (XI0_I1512_bp2 I0_cm29_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1512_MP56 (VDD XI0_I1512_bcon I0_cm151_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1512_MP46 (XI0_I1512_bp3 XI0_I1512_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1512_MP48 (VDD I0_cm149_2 XI0_I1512_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1512_MP50_1 (XI0_I1512_bp4 XI0_I1512_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1512_MP26 (VDD XI0_I1512_asn XI0_I1512_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1512_MP18 (XI0_I1512_ap3 I0_cm26_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1512_MP21 (XI0_I1512_asn XI0_I1512_acon XI0_I1512_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1512_MP24 (XI0_I1512_ap5 I0_cm28_0 XI0_I1512_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1512_MP23 (XI0_I1512_ap4 I0_cm27_1 XI0_I1512_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1512_MP22 (VDD I0_cm26_1 XI0_I1512_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1512_MP22_1 (XI0_I1512_ap4 I0_cm26_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1512_MP23_1 (XI0_I1512_ap5 I0_cm27_1 XI0_I1512_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1512_MP24_1 (XI0_I1512_asn I0_cm28_0 XI0_I1512_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1512_MP17 (XI0_I1512_acon I0_cm28_0 XI0_I1512_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1512_MP14 (XI0_I1512_ap1 I0_cm27_1 XI0_I1512_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1512_MP13 (VDD I0_cm26_1 XI0_I1512_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1512_MP15 (XI0_I1512_ap2 I0_cm26_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1512_MP16 (VDD I0_cm27_1 XI0_I1512_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1512_MP28 (I0_cm151_2 XI0_I1512_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1512_MP19 (XI0_I1512_ap3 I0_cm27_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1512_MP20 (VDD I0_cm28_0 XI0_I1512_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1515_MP50 (VDD XI0_I1515_s1 XI0_I1515_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1515_MP47 (XI0_I1515_bp3 I0_cm37_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1515_MP49 (XI0_I1515_bsn XI0_I1515_bcon XI0_I1515_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1515_MP52 (XI0_I1515_bp5 I0_cm153_2 XI0_I1515_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1515_MP51 (XI0_I1515_bp4 I0_cm37_0 XI0_I1515_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1515_MP51_1 (XI0_I1515_bp5 I0_cm37_0 XI0_I1515_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1515_MP52_1 (XI0_I1515_bsn I0_cm153_2 XI0_I1515_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1515_MP54 (VDD XI0_I1515_bsn I0_cm154_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1515_MP41 (XI0_I1515_bp1 XI0_I1515_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1515_MP42 (XI0_I1515_bcon I0_cm37_0 XI0_I1515_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1515_MP45 (XI0_I1515_bp2 I0_cm153_2 XI0_I1515_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1515_MP43 (VDD XI0_I1515_s1 XI0_I1515_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1515_MP44 (XI0_I1515_bp2 I0_cm37_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1515_MP56 (VDD XI0_I1515_bcon I0_cm154_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1515_MP46 (XI0_I1515_bp3 XI0_I1515_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1515_MP48 (VDD I0_cm153_2 XI0_I1515_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1515_MP50_1 (XI0_I1515_bp4 XI0_I1515_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1515_MP26 (VDD XI0_I1515_asn XI0_I1515_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1515_MP18 (XI0_I1515_ap3 I0_cm34_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1515_MP21 (XI0_I1515_asn XI0_I1515_acon XI0_I1515_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1515_MP24 (XI0_I1515_ap5 I0_cm36_1 XI0_I1515_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1515_MP23 (XI0_I1515_ap4 I0_cm35_1 XI0_I1515_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1515_MP22 (VDD I0_cm34_1 XI0_I1515_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1515_MP22_1 (XI0_I1515_ap4 I0_cm34_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1515_MP23_1 (XI0_I1515_ap5 I0_cm35_1 XI0_I1515_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1515_MP24_1 (XI0_I1515_asn I0_cm36_1 XI0_I1515_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1515_MP17 (XI0_I1515_acon I0_cm36_1 XI0_I1515_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1515_MP14 (XI0_I1515_ap1 I0_cm35_1 XI0_I1515_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1515_MP13 (VDD I0_cm34_1 XI0_I1515_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1515_MP15 (XI0_I1515_ap2 I0_cm34_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1515_MP16 (VDD I0_cm35_1 XI0_I1515_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1515_MP28 (I0_cm154_2 XI0_I1515_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1515_MP19 (XI0_I1515_ap3 I0_cm35_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1515_MP20 (VDD I0_cm36_1 XI0_I1515_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1516_MP50 (VDD XI0_I1516_s1 XI0_I1516_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1516_MP47 (XI0_I1516_bp3 I0_cm40_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1516_MP49 (XI0_I1516_bsn XI0_I1516_bcon XI0_I1516_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1516_MP52 (XI0_I1516_bp5 I0_cm154_2 XI0_I1516_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1516_MP51 (XI0_I1516_bp4 I0_cm40_0 XI0_I1516_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1516_MP51_1 (XI0_I1516_bp5 I0_cm40_0 XI0_I1516_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1516_MP52_1 (XI0_I1516_bsn I0_cm154_2 XI0_I1516_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1516_MP54 (VDD XI0_I1516_bsn I0_cm155_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1516_MP41 (XI0_I1516_bp1 XI0_I1516_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1516_MP42 (XI0_I1516_bcon I0_cm40_0 XI0_I1516_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1516_MP45 (XI0_I1516_bp2 I0_cm154_2 XI0_I1516_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1516_MP43 (VDD XI0_I1516_s1 XI0_I1516_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1516_MP44 (XI0_I1516_bp2 I0_cm40_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1516_MP56 (VDD XI0_I1516_bcon I0_cm155_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1516_MP46 (XI0_I1516_bp3 XI0_I1516_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1516_MP48 (VDD I0_cm154_2 XI0_I1516_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1516_MP50_1 (XI0_I1516_bp4 XI0_I1516_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1516_MP26 (VDD XI0_I1516_asn XI0_I1516_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1516_MP18 (XI0_I1516_ap3 I0_cm37_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1516_MP21 (XI0_I1516_asn XI0_I1516_acon XI0_I1516_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1516_MP24 (XI0_I1516_ap5 I0_cm39_1 XI0_I1516_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1516_MP23 (XI0_I1516_ap4 I0_cm38_1 XI0_I1516_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1516_MP22 (VDD I0_cm37_1 XI0_I1516_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1516_MP22_1 (XI0_I1516_ap4 I0_cm37_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1516_MP23_1 (XI0_I1516_ap5 I0_cm38_1 XI0_I1516_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1516_MP24_1 (XI0_I1516_asn I0_cm39_1 XI0_I1516_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1516_MP17 (XI0_I1516_acon I0_cm39_1 XI0_I1516_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1516_MP14 (XI0_I1516_ap1 I0_cm38_1 XI0_I1516_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1516_MP13 (VDD I0_cm37_1 XI0_I1516_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1516_MP15 (XI0_I1516_ap2 I0_cm37_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1516_MP16 (VDD I0_cm38_1 XI0_I1516_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1516_MP28 (I0_cm155_2 XI0_I1516_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1516_MP19 (XI0_I1516_ap3 I0_cm38_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1516_MP20 (VDD I0_cm39_1 XI0_I1516_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1583_MP50 (VDD XI0_I1583_s1 XI0_I1583_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1583_MP47 (XI0_I1583_bp3 I0_cm164_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1583_MP49 (XI0_I1583_bsn XI0_I1583_bcon XI0_I1583_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1583_MP52 (XI0_I1583_bp5 I0_cm221_2 XI0_I1583_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1583_MP51 (XI0_I1583_bp4 I0_cm164_0 XI0_I1583_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1583_MP51_1 (XI0_I1583_bp5 I0_cm164_0 XI0_I1583_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1583_MP52_1 (XI0_I1583_bsn I0_cm221_2 XI0_I1583_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1583_MP54 (VDD XI0_I1583_bsn I0_cm222_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1583_MP41 (XI0_I1583_bp1 XI0_I1583_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1583_MP42 (XI0_I1583_bcon I0_cm164_0 XI0_I1583_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1583_MP45 (XI0_I1583_bp2 I0_cm221_2 XI0_I1583_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1583_MP43 (VDD XI0_I1583_s1 XI0_I1583_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1583_MP44 (XI0_I1583_bp2 I0_cm164_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1583_MP56 (VDD XI0_I1583_bcon I0_cm222_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1583_MP46 (XI0_I1583_bp3 XI0_I1583_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1583_MP48 (VDD I0_cm221_2 XI0_I1583_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1583_MP50_1 (XI0_I1583_bp4 XI0_I1583_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1583_MP26 (VDD XI0_I1583_asn XI0_I1583_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1583_MP18 (XI0_I1583_ap3 I0_cm161_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1583_MP21 (XI0_I1583_asn XI0_I1583_acon XI0_I1583_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1583_MP24 (XI0_I1583_ap5 I0_cm163_0 XI0_I1583_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1583_MP23 (XI0_I1583_ap4 I0_cm162_1 XI0_I1583_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1583_MP22 (VDD I0_cm161_1 XI0_I1583_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1583_MP22_1 (XI0_I1583_ap4 I0_cm161_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1583_MP23_1 (XI0_I1583_ap5 I0_cm162_1 XI0_I1583_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1583_MP24_1 (XI0_I1583_asn I0_cm163_0 XI0_I1583_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1583_MP17 (XI0_I1583_acon I0_cm163_0 XI0_I1583_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1583_MP14 (XI0_I1583_ap1 I0_cm162_1 XI0_I1583_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1583_MP13 (VDD I0_cm161_1 XI0_I1583_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1583_MP15 (XI0_I1583_ap2 I0_cm161_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1583_MP16 (VDD I0_cm162_1 XI0_I1583_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1583_MP28 (I0_cm222_2 XI0_I1583_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1583_MP19 (XI0_I1583_ap3 I0_cm162_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1583_MP20 (VDD I0_cm163_0 XI0_I1583_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1531_MP50 (VDD XI0_I1531_s1 XI0_I1531_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1531_MP47 (XI0_I1531_bp3 I0_cm68_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1531_MP49 (XI0_I1531_bsn XI0_I1531_bcon XI0_I1531_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1531_MP52 (XI0_I1531_bp5 I0_cm168_2 XI0_I1531_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1531_MP51 (XI0_I1531_bp4 I0_cm68_0 XI0_I1531_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1531_MP51_1 (XI0_I1531_bp5 I0_cm68_0 XI0_I1531_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1531_MP52_1 (XI0_I1531_bsn I0_cm168_2 XI0_I1531_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1531_MP54 (VDD XI0_I1531_bsn I0_cm170_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1531_MP41 (XI0_I1531_bp1 XI0_I1531_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1531_MP42 (XI0_I1531_bcon I0_cm68_0 XI0_I1531_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1531_MP45 (XI0_I1531_bp2 I0_cm168_2 XI0_I1531_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1531_MP43 (VDD XI0_I1531_s1 XI0_I1531_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1531_MP44 (XI0_I1531_bp2 I0_cm68_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1531_MP56 (VDD XI0_I1531_bcon I0_cm170_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1531_MP46 (XI0_I1531_bp3 XI0_I1531_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1531_MP48 (VDD I0_cm168_2 XI0_I1531_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1531_MP50_1 (XI0_I1531_bp4 XI0_I1531_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1531_MP26 (VDD XI0_I1531_asn XI0_I1531_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1531_MP18 (XI0_I1531_ap3 I0_cm65_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1531_MP21 (XI0_I1531_asn XI0_I1531_acon XI0_I1531_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1531_MP24 (XI0_I1531_ap5 I0_cm67_0 XI0_I1531_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1531_MP23 (XI0_I1531_ap4 I0_cm66_0 XI0_I1531_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1531_MP22 (VDD I0_cm65_0 XI0_I1531_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1531_MP22_1 (XI0_I1531_ap4 I0_cm65_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1531_MP23_1 (XI0_I1531_ap5 I0_cm66_0 XI0_I1531_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1531_MP24_1 (XI0_I1531_asn I0_cm67_0 XI0_I1531_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1531_MP17 (XI0_I1531_acon I0_cm67_0 XI0_I1531_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1531_MP14 (XI0_I1531_ap1 I0_cm66_0 XI0_I1531_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1531_MP13 (VDD I0_cm65_0 XI0_I1531_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1531_MP15 (XI0_I1531_ap2 I0_cm65_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1531_MP16 (VDD I0_cm66_0 XI0_I1531_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1531_MP28 (I0_cm170_2 XI0_I1531_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1531_MP19 (XI0_I1531_ap3 I0_cm66_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1531_MP20 (VDD I0_cm67_0 XI0_I1531_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1523_MP50 (VDD XI0_I1523_s1 XI0_I1523_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1523_MP47 (XI0_I1523_bp3 I0_pp12_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1523_MP49 (XI0_I1523_bsn XI0_I1523_bcon XI0_I1523_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1523_MP52 (XI0_I1523_bp5 I0_pp13_1 XI0_I1523_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1523_MP51 (XI0_I1523_bp4 I0_pp12_3 XI0_I1523_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1523_MP51_1 (XI0_I1523_bp5 I0_pp12_3 XI0_I1523_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1523_MP52_1 (XI0_I1523_bsn I0_pp13_1 XI0_I1523_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1523_MP54 (VDD XI0_I1523_bsn I0_cm162_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1523_MP41 (XI0_I1523_bp1 XI0_I1523_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1523_MP42 (XI0_I1523_bcon I0_pp12_3 XI0_I1523_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1523_MP45 (XI0_I1523_bp2 I0_pp13_1 XI0_I1523_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1523_MP43 (VDD XI0_I1523_s1 XI0_I1523_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1523_MP44 (XI0_I1523_bp2 I0_pp12_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1523_MP56 (VDD XI0_I1523_bcon I0_cm162_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1523_MP46 (XI0_I1523_bp3 XI0_I1523_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1523_MP48 (VDD I0_pp13_1 XI0_I1523_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1523_MP50_1 (XI0_I1523_bp4 XI0_I1523_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1523_MP26 (VDD XI0_I1523_asn XI0_I1523_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1523_MP18 (XI0_I1523_ap3 I0_cm50_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1523_MP21 (XI0_I1523_asn XI0_I1523_acon XI0_I1523_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1523_MP24 (XI0_I1523_ap5 I0_cm52_0 XI0_I1523_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1523_MP23 (XI0_I1523_ap4 I0_cm51_0 XI0_I1523_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1523_MP22 (VDD I0_cm50_0 XI0_I1523_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1523_MP22_1 (XI0_I1523_ap4 I0_cm50_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1523_MP23_1 (XI0_I1523_ap5 I0_cm51_0 XI0_I1523_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1523_MP24_1 (XI0_I1523_asn I0_cm52_0 XI0_I1523_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1523_MP17 (XI0_I1523_acon I0_cm52_0 XI0_I1523_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1523_MP14 (XI0_I1523_ap1 I0_cm51_0 XI0_I1523_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1523_MP13 (VDD I0_cm50_0 XI0_I1523_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1523_MP15 (XI0_I1523_ap2 I0_cm50_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1523_MP16 (VDD I0_cm51_0 XI0_I1523_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1523_MP28 (I0_cm162_2 XI0_I1523_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1523_MP19 (XI0_I1523_ap3 I0_cm51_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1523_MP20 (VDD I0_cm52_0 XI0_I1523_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1533_MP50 (VDD XI0_I1533_s1 XI0_I1533_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1533_MP47 (XI0_I1533_bp3 I0_cm72_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1533_MP49 (XI0_I1533_bsn XI0_I1533_bcon XI0_I1533_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1533_MP52 (XI0_I1533_bp5 I0_cm170_2 XI0_I1533_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1533_MP51 (XI0_I1533_bp4 I0_cm72_0 XI0_I1533_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1533_MP51_1 (XI0_I1533_bp5 I0_cm72_0 XI0_I1533_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1533_MP52_1 (XI0_I1533_bsn I0_cm170_2 XI0_I1533_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1533_MP54 (VDD XI0_I1533_bsn I0_cm172_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1533_MP41 (XI0_I1533_bp1 XI0_I1533_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1533_MP42 (XI0_I1533_bcon I0_cm72_0 XI0_I1533_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1533_MP45 (XI0_I1533_bp2 I0_cm170_2 XI0_I1533_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1533_MP43 (VDD XI0_I1533_s1 XI0_I1533_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1533_MP44 (XI0_I1533_bp2 I0_cm72_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1533_MP56 (VDD XI0_I1533_bcon I0_cm172_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1533_MP46 (XI0_I1533_bp3 XI0_I1533_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1533_MP48 (VDD I0_cm170_2 XI0_I1533_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1533_MP50_1 (XI0_I1533_bp4 XI0_I1533_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1533_MP26 (VDD XI0_I1533_asn XI0_I1533_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1533_MP18 (XI0_I1533_ap3 I0_cm69_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1533_MP21 (XI0_I1533_asn XI0_I1533_acon XI0_I1533_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1533_MP24 (XI0_I1533_ap5 I0_cm71_0 XI0_I1533_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1533_MP23 (XI0_I1533_ap4 I0_cm70_0 XI0_I1533_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1533_MP22 (VDD I0_cm69_0 XI0_I1533_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1533_MP22_1 (XI0_I1533_ap4 I0_cm69_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1533_MP23_1 (XI0_I1533_ap5 I0_cm70_0 XI0_I1533_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1533_MP24_1 (XI0_I1533_asn I0_cm71_0 XI0_I1533_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1533_MP17 (XI0_I1533_acon I0_cm71_0 XI0_I1533_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1533_MP14 (XI0_I1533_ap1 I0_cm70_0 XI0_I1533_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1533_MP13 (VDD I0_cm69_0 XI0_I1533_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1533_MP15 (XI0_I1533_ap2 I0_cm69_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1533_MP16 (VDD I0_cm70_0 XI0_I1533_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1533_MP28 (I0_cm172_2 XI0_I1533_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1533_MP19 (XI0_I1533_ap3 I0_cm70_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1533_MP20 (VDD I0_cm71_0 XI0_I1533_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1589_MP50 (VDD XI0_I1589_s1 XI0_I1589_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1589_MP47 (XI0_I1589_bp3 I0_cm176_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1589_MP49 (XI0_I1589_bsn XI0_I1589_bcon XI0_I1589_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1589_MP52 (XI0_I1589_bp5 I0_cm227_2 XI0_I1589_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1589_MP51 (XI0_I1589_bp4 I0_cm176_0 XI0_I1589_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1589_MP51_1 (XI0_I1589_bp5 I0_cm176_0 XI0_I1589_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1589_MP52_1 (XI0_I1589_bsn I0_cm227_2 XI0_I1589_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1589_MP54 (VDD XI0_I1589_bsn I0_cm228_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1589_MP41 (XI0_I1589_bp1 XI0_I1589_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1589_MP42 (XI0_I1589_bcon I0_cm176_0 XI0_I1589_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1589_MP45 (XI0_I1589_bp2 I0_cm227_2 XI0_I1589_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1589_MP43 (VDD XI0_I1589_s1 XI0_I1589_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1589_MP44 (XI0_I1589_bp2 I0_cm176_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1589_MP56 (VDD XI0_I1589_bcon I0_cm228_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1589_MP46 (XI0_I1589_bp3 XI0_I1589_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1589_MP48 (VDD I0_cm227_2 XI0_I1589_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1589_MP50_1 (XI0_I1589_bp4 XI0_I1589_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1589_MP26 (VDD XI0_I1589_asn XI0_I1589_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1589_MP18 (XI0_I1589_ap3 I0_cm173_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1589_MP21 (XI0_I1589_asn XI0_I1589_acon XI0_I1589_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1589_MP24 (XI0_I1589_ap5 I0_cm175_0 XI0_I1589_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1589_MP23 (XI0_I1589_ap4 I0_cm174_1 XI0_I1589_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1589_MP22 (VDD I0_cm173_1 XI0_I1589_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1589_MP22_1 (XI0_I1589_ap4 I0_cm173_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1589_MP23_1 (XI0_I1589_ap5 I0_cm174_1 XI0_I1589_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1589_MP24_1 (XI0_I1589_asn I0_cm175_0 XI0_I1589_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1589_MP17 (XI0_I1589_acon I0_cm175_0 XI0_I1589_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1589_MP14 (XI0_I1589_ap1 I0_cm174_1 XI0_I1589_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1589_MP13 (VDD I0_cm173_1 XI0_I1589_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1589_MP15 (XI0_I1589_ap2 I0_cm173_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1589_MP16 (VDD I0_cm174_1 XI0_I1589_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1589_MP28 (I0_cm228_2 XI0_I1589_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1589_MP19 (XI0_I1589_ap3 I0_cm174_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1589_MP20 (VDD I0_cm175_0 XI0_I1589_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1535_MP50 (VDD XI0_I1535_s1 XI0_I1535_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1535_MP47 (XI0_I1535_bp3 I0_cm76_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1535_MP49 (XI0_I1535_bsn XI0_I1535_bcon XI0_I1535_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1535_MP52 (XI0_I1535_bp5 I0_cm172_2 XI0_I1535_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1535_MP51 (XI0_I1535_bp4 I0_cm76_0 XI0_I1535_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1535_MP51_1 (XI0_I1535_bp5 I0_cm76_0 XI0_I1535_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1535_MP52_1 (XI0_I1535_bsn I0_cm172_2 XI0_I1535_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1535_MP54 (VDD XI0_I1535_bsn I0_cm174_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1535_MP41 (XI0_I1535_bp1 XI0_I1535_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1535_MP42 (XI0_I1535_bcon I0_cm76_0 XI0_I1535_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1535_MP45 (XI0_I1535_bp2 I0_cm172_2 XI0_I1535_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1535_MP43 (VDD XI0_I1535_s1 XI0_I1535_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1535_MP44 (XI0_I1535_bp2 I0_cm76_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1535_MP56 (VDD XI0_I1535_bcon I0_cm174_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1535_MP46 (XI0_I1535_bp3 XI0_I1535_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1535_MP48 (VDD I0_cm172_2 XI0_I1535_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1535_MP50_1 (XI0_I1535_bp4 XI0_I1535_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1535_MP26 (VDD XI0_I1535_asn XI0_I1535_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1535_MP18 (XI0_I1535_ap3 I0_cm73_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1535_MP21 (XI0_I1535_asn XI0_I1535_acon XI0_I1535_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1535_MP24 (XI0_I1535_ap5 I0_cm75_0 XI0_I1535_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1535_MP23 (XI0_I1535_ap4 I0_cm74_0 XI0_I1535_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1535_MP22 (VDD I0_cm73_0 XI0_I1535_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1535_MP22_1 (XI0_I1535_ap4 I0_cm73_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1535_MP23_1 (XI0_I1535_ap5 I0_cm74_0 XI0_I1535_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1535_MP24_1 (XI0_I1535_asn I0_cm75_0 XI0_I1535_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1535_MP17 (XI0_I1535_acon I0_cm75_0 XI0_I1535_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1535_MP14 (XI0_I1535_ap1 I0_cm74_0 XI0_I1535_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1535_MP13 (VDD I0_cm73_0 XI0_I1535_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1535_MP15 (XI0_I1535_ap2 I0_cm73_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1535_MP16 (VDD I0_cm74_0 XI0_I1535_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1535_MP28 (I0_cm174_2 XI0_I1535_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1535_MP19 (XI0_I1535_ap3 I0_cm74_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1535_MP20 (VDD I0_cm75_0 XI0_I1535_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1540_MP50 (VDD XI0_I1540_s1 XI0_I1540_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1540_MP47 (XI0_I1540_bp3 I0_cm84_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1540_MP49 (XI0_I1540_bsn XI0_I1540_bcon XI0_I1540_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1540_MP52 (XI0_I1540_bp5 I0_cm177_2 XI0_I1540_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1540_MP51 (XI0_I1540_bp4 I0_cm84_1 XI0_I1540_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1540_MP51_1 (XI0_I1540_bp5 I0_cm84_1 XI0_I1540_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1540_MP52_1 (XI0_I1540_bsn I0_cm177_2 XI0_I1540_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1540_MP54 (VDD XI0_I1540_bsn I0_cm179_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1540_MP41 (XI0_I1540_bp1 XI0_I1540_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1540_MP42 (XI0_I1540_bcon I0_cm84_1 XI0_I1540_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1540_MP45 (XI0_I1540_bp2 I0_cm177_2 XI0_I1540_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1540_MP43 (VDD XI0_I1540_s1 XI0_I1540_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1540_MP44 (XI0_I1540_bp2 I0_cm84_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1540_MP56 (VDD XI0_I1540_bcon I0_cm179_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1540_MP46 (XI0_I1540_bp3 XI0_I1540_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1540_MP48 (VDD I0_cm177_2 XI0_I1540_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1540_MP50_1 (XI0_I1540_bp4 XI0_I1540_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1540_MP26 (VDD XI0_I1540_asn XI0_I1540_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1540_MP18 (XI0_I1540_ap3 I0_cm81_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1540_MP21 (XI0_I1540_asn XI0_I1540_acon XI0_I1540_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1540_MP24 (XI0_I1540_ap5 I0_cm83_1 XI0_I1540_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1540_MP23 (XI0_I1540_ap4 I0_cm82_1 XI0_I1540_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1540_MP22 (VDD I0_cm81_1 XI0_I1540_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1540_MP22_1 (XI0_I1540_ap4 I0_cm81_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1540_MP23_1 (XI0_I1540_ap5 I0_cm82_1 XI0_I1540_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1540_MP24_1 (XI0_I1540_asn I0_cm83_1 XI0_I1540_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1540_MP17 (XI0_I1540_acon I0_cm83_1 XI0_I1540_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1540_MP14 (XI0_I1540_ap1 I0_cm82_1 XI0_I1540_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1540_MP13 (VDD I0_cm81_1 XI0_I1540_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1540_MP15 (XI0_I1540_ap2 I0_cm81_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1540_MP16 (VDD I0_cm82_1 XI0_I1540_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1540_MP28 (I0_cm179_2 XI0_I1540_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1540_MP19 (XI0_I1540_ap3 I0_cm82_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1540_MP20 (VDD I0_cm83_1 XI0_I1540_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1451_MP50 (VDD XI0_I1451_s1 XI0_I1451_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1451_MP47 (XI0_I1451_bp3 I0_pp9_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1451_MP49 (XI0_I1451_bsn XI0_I1451_bcon XI0_I1451_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1451_MP52 (XI0_I1451_bp5 I0_cm86_2 XI0_I1451_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1451_MP51 (XI0_I1451_bp4 I0_pp9_19 XI0_I1451_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1451_MP51_1 (XI0_I1451_bp5 I0_pp9_19 XI0_I1451_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1451_MP52_1 (XI0_I1451_bsn I0_cm86_2 XI0_I1451_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1451_MP54 (VDD XI0_I1451_bsn I0_cm90_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1451_MP41 (XI0_I1451_bp1 XI0_I1451_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1451_MP42 (XI0_I1451_bcon I0_pp9_19 XI0_I1451_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1451_MP45 (XI0_I1451_bp2 I0_cm86_2 XI0_I1451_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1451_MP43 (VDD XI0_I1451_s1 XI0_I1451_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1451_MP44 (XI0_I1451_bp2 I0_pp9_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1451_MP56 (VDD XI0_I1451_bcon I0_cm90_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1451_MP46 (XI0_I1451_bp3 XI0_I1451_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1451_MP48 (VDD I0_cm86_2 XI0_I1451_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1451_MP50_1 (XI0_I1451_bp4 XI0_I1451_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1451_MP26 (VDD XI0_I1451_asn XI0_I1451_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1451_MP18 (XI0_I1451_ap3 I0_pp6_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1451_MP21 (XI0_I1451_asn XI0_I1451_acon XI0_I1451_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1451_MP24 (XI0_I1451_ap5 I0_pp8_21 XI0_I1451_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1451_MP23 (XI0_I1451_ap4 I0_pp7_23 XI0_I1451_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1451_MP22 (VDD I0_pp6_25 XI0_I1451_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1451_MP22_1 (XI0_I1451_ap4 I0_pp6_25 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1451_MP23_1 (XI0_I1451_ap5 I0_pp7_23 XI0_I1451_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1451_MP24_1 (XI0_I1451_asn I0_pp8_21 XI0_I1451_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1451_MP17 (XI0_I1451_acon I0_pp8_21 XI0_I1451_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1451_MP14 (XI0_I1451_ap1 I0_pp7_23 XI0_I1451_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1451_MP13 (VDD I0_pp6_25 XI0_I1451_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1451_MP15 (XI0_I1451_ap2 I0_pp6_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1451_MP16 (VDD I0_pp7_23 XI0_I1451_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1451_MP28 (I0_cm90_2 XI0_I1451_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1451_MP19 (XI0_I1451_ap3 I0_pp7_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1451_MP20 (VDD I0_pp8_21 XI0_I1451_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1591_MP50 (VDD XI0_I1591_s1 XI0_I1591_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1591_MP47 (XI0_I1591_bp3 I0_cm180_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1591_MP49 (XI0_I1591_bsn XI0_I1591_bcon XI0_I1591_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1591_MP52 (XI0_I1591_bp5 I0_cm229_2 XI0_I1591_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1591_MP51 (XI0_I1591_bp4 I0_cm180_0 XI0_I1591_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1591_MP51_1 (XI0_I1591_bp5 I0_cm180_0 XI0_I1591_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1591_MP52_1 (XI0_I1591_bsn I0_cm229_2 XI0_I1591_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1591_MP54 (VDD XI0_I1591_bsn I0_cm230_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1591_MP41 (XI0_I1591_bp1 XI0_I1591_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1591_MP42 (XI0_I1591_bcon I0_cm180_0 XI0_I1591_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1591_MP45 (XI0_I1591_bp2 I0_cm229_2 XI0_I1591_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1591_MP43 (VDD XI0_I1591_s1 XI0_I1591_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1591_MP44 (XI0_I1591_bp2 I0_cm180_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1591_MP56 (VDD XI0_I1591_bcon I0_cm230_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1591_MP46 (XI0_I1591_bp3 XI0_I1591_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1591_MP48 (VDD I0_cm229_2 XI0_I1591_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1591_MP50_1 (XI0_I1591_bp4 XI0_I1591_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1591_MP26 (VDD XI0_I1591_asn XI0_I1591_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1591_MP18 (XI0_I1591_ap3 I0_cm177_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1591_MP21 (XI0_I1591_asn XI0_I1591_acon XI0_I1591_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1591_MP24 (XI0_I1591_ap5 I0_cm179_0 XI0_I1591_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1591_MP23 (XI0_I1591_ap4 I0_cm178_1 XI0_I1591_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1591_MP22 (VDD I0_cm177_1 XI0_I1591_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1591_MP22_1 (XI0_I1591_ap4 I0_cm177_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1591_MP23_1 (XI0_I1591_ap5 I0_cm178_1 XI0_I1591_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1591_MP24_1 (XI0_I1591_asn I0_cm179_0 XI0_I1591_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1591_MP17 (XI0_I1591_acon I0_cm179_0 XI0_I1591_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1591_MP14 (XI0_I1591_ap1 I0_cm178_1 XI0_I1591_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1591_MP13 (VDD I0_cm177_1 XI0_I1591_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1591_MP15 (XI0_I1591_ap2 I0_cm177_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1591_MP16 (VDD I0_cm178_1 XI0_I1591_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1591_MP28 (I0_cm230_2 XI0_I1591_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1591_MP19 (XI0_I1591_ap3 I0_cm178_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1591_MP20 (VDD I0_cm179_0 XI0_I1591_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1468_MP50 (VDD XI0_I1468_s1 XI0_I1468_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1468_MP47 (XI0_I1468_bp3 I0_pp8_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1468_MP49 (XI0_I1468_bsn XI0_I1468_bcon XI0_I1468_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1468_MP52 (XI0_I1468_bp5 I0_cm104_2 XI0_I1468_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1468_MP51 (XI0_I1468_bp4 I0_pp8_27 XI0_I1468_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1468_MP51_1 (XI0_I1468_bp5 I0_pp8_27 XI0_I1468_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1468_MP52_1 (XI0_I1468_bsn I0_cm104_2 XI0_I1468_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1468_MP54 (VDD XI0_I1468_bsn I0_cm107_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1468_MP41 (XI0_I1468_bp1 XI0_I1468_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1468_MP42 (XI0_I1468_bcon I0_pp8_27 XI0_I1468_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1468_MP45 (XI0_I1468_bp2 I0_cm104_2 XI0_I1468_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1468_MP43 (VDD XI0_I1468_s1 XI0_I1468_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1468_MP44 (XI0_I1468_bp2 I0_pp8_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1468_MP56 (VDD XI0_I1468_bcon I0_cm107_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1468_MP46 (XI0_I1468_bp3 XI0_I1468_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1468_MP48 (VDD I0_cm104_2 XI0_I1468_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1468_MP50_1 (XI0_I1468_bp4 XI0_I1468_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1468_MP26 (VDD XI0_I1468_asn XI0_I1468_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1468_MP18 (XI0_I1468_ap3 I0_sn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1468_MP21 (XI0_I1468_asn XI0_I1468_acon XI0_I1468_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1468_MP24 (XI0_I1468_ap5 I0_pp7_29 XI0_I1468_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1468_MP23 (XI0_I1468_ap4 I0_pp6_31 XI0_I1468_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1468_MP22 (VDD I0_sn5 XI0_I1468_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1468_MP22_1 (XI0_I1468_ap4 I0_sn5 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1468_MP23_1 (XI0_I1468_ap5 I0_pp6_31 XI0_I1468_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1468_MP24_1 (XI0_I1468_asn I0_pp7_29 XI0_I1468_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1468_MP17 (XI0_I1468_acon I0_pp7_29 XI0_I1468_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1468_MP14 (XI0_I1468_ap1 I0_pp6_31 XI0_I1468_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1468_MP13 (VDD I0_sn5 XI0_I1468_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1468_MP15 (XI0_I1468_ap2 I0_sn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1468_MP16 (VDD I0_pp6_31 XI0_I1468_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1468_MP28 (I0_cm107_2 XI0_I1468_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1468_MP19 (XI0_I1468_ap3 I0_pp6_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1468_MP20 (VDD I0_pp7_29 XI0_I1468_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1365_MP50 (VDD XI0_I1365_s1 XI0_I1365_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1365_MP47 (XI0_I1365_bp3 I0_pp3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1365_MP49 (XI0_I1365_bsn XI0_I1365_bcon XI0_I1365_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1365_MP52 (XI0_I1365_bp5 I0_B_7_b3_5 XI0_I1365_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1365_MP51 (XI0_I1365_bp4 I0_pp3_0 XI0_I1365_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1365_MP51_1 (XI0_I1365_bp5 I0_pp3_0 XI0_I1365_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1365_MP52_1 (XI0_I1365_bsn I0_B_7_b3_5 XI0_I1365_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1365_MP54 (VDD XI0_I1365_bsn I0_cm4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1365_MP41 (XI0_I1365_bp1 XI0_I1365_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1365_MP42 (XI0_I1365_bcon I0_pp3_0 XI0_I1365_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1365_MP45 (XI0_I1365_bp2 I0_B_7_b3_5 XI0_I1365_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1365_MP43 (VDD XI0_I1365_s1 XI0_I1365_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1365_MP44 (XI0_I1365_bp2 I0_pp3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1365_MP56 (VDD XI0_I1365_bcon I0_cm4_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1365_MP46 (XI0_I1365_bp3 XI0_I1365_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1365_MP48 (VDD I0_B_7_b3_5 XI0_I1365_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1365_MP50_1 (XI0_I1365_bp4 XI0_I1365_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1365_MP26 (VDD XI0_I1365_asn XI0_I1365_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1365_MP18 (XI0_I1365_ap3 I0_pp0_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1365_MP21 (XI0_I1365_asn XI0_I1365_acon XI0_I1365_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1365_MP24 (XI0_I1365_ap5 I0_pp2_2 XI0_I1365_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1365_MP23 (XI0_I1365_ap4 I0_pp1_4 XI0_I1365_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1365_MP22 (VDD I0_pp0_6 XI0_I1365_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1365_MP22_1 (XI0_I1365_ap4 I0_pp0_6 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1365_MP23_1 (XI0_I1365_ap5 I0_pp1_4 XI0_I1365_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1365_MP24_1 (XI0_I1365_asn I0_pp2_2 XI0_I1365_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1365_MP17 (XI0_I1365_acon I0_pp2_2 XI0_I1365_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1365_MP14 (XI0_I1365_ap1 I0_pp1_4 XI0_I1365_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1365_MP13 (VDD I0_pp0_6 XI0_I1365_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1365_MP15 (XI0_I1365_ap2 I0_pp0_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1365_MP16 (VDD I0_pp1_4 XI0_I1365_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1365_MP28 (I0_cm4_2 XI0_I1365_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1365_MP19 (XI0_I1365_ap3 I0_pp1_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1365_MP20 (VDD I0_pp2_2 XI0_I1365_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1388_MP50 (VDD XI0_I1388_s1 XI0_I1388_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1388_MP47 (XI0_I1388_bp3 I0_pp7_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1388_MP49 (XI0_I1388_bsn XI0_I1388_bcon XI0_I1388_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1388_MP52 (XI0_I1388_bp5 I0_cm24_2 XI0_I1388_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1388_MP51 (XI0_I1388_bp4 I0_pp7_5 XI0_I1388_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1388_MP51_1 (XI0_I1388_bp5 I0_pp7_5 XI0_I1388_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1388_MP52_1 (XI0_I1388_bsn I0_cm24_2 XI0_I1388_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1388_MP54 (VDD XI0_I1388_bsn I0_cm27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1388_MP41 (XI0_I1388_bp1 XI0_I1388_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1388_MP42 (XI0_I1388_bcon I0_pp7_5 XI0_I1388_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1388_MP45 (XI0_I1388_bp2 I0_cm24_2 XI0_I1388_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1388_MP43 (VDD XI0_I1388_s1 XI0_I1388_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1388_MP44 (XI0_I1388_bp2 I0_pp7_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1388_MP56 (VDD XI0_I1388_bcon I0_cm27_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1388_MP46 (XI0_I1388_bp3 XI0_I1388_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1388_MP48 (VDD I0_cm24_2 XI0_I1388_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1388_MP50_1 (XI0_I1388_bp4 XI0_I1388_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1388_MP26 (VDD XI0_I1388_asn XI0_I1388_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1388_MP18 (XI0_I1388_ap3 I0_pp4_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1388_MP21 (XI0_I1388_asn XI0_I1388_acon XI0_I1388_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1388_MP24 (XI0_I1388_ap5 I0_pp6_7 XI0_I1388_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1388_MP23 (XI0_I1388_ap4 I0_pp5_9 XI0_I1388_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1388_MP22 (VDD I0_pp4_11 XI0_I1388_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1388_MP22_1 (XI0_I1388_ap4 I0_pp4_11 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1388_MP23_1 (XI0_I1388_ap5 I0_pp5_9 XI0_I1388_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1388_MP24_1 (XI0_I1388_asn I0_pp6_7 XI0_I1388_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1388_MP17 (XI0_I1388_acon I0_pp6_7 XI0_I1388_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1388_MP14 (XI0_I1388_ap1 I0_pp5_9 XI0_I1388_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1388_MP13 (VDD I0_pp4_11 XI0_I1388_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1388_MP15 (XI0_I1388_ap2 I0_pp4_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1388_MP16 (VDD I0_pp5_9 XI0_I1388_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1388_MP28 (I0_cm27_2 XI0_I1388_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1388_MP19 (XI0_I1388_ap3 I0_pp5_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1388_MP20 (VDD I0_pp6_7 XI0_I1388_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1390_MP50 (VDD XI0_I1390_s1 XI0_I1390_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1390_MP47 (XI0_I1390_bp3 I0_pp7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1390_MP49 (XI0_I1390_bsn XI0_I1390_bcon XI0_I1390_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1390_MP52 (XI0_I1390_bp5 I0_cm27_2 XI0_I1390_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1390_MP51 (XI0_I1390_bp4 I0_pp7_6 XI0_I1390_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1390_MP51_1 (XI0_I1390_bp5 I0_pp7_6 XI0_I1390_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1390_MP52_1 (XI0_I1390_bsn I0_cm27_2 XI0_I1390_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1390_MP54 (VDD XI0_I1390_bsn I0_cm29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1390_MP41 (XI0_I1390_bp1 XI0_I1390_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1390_MP42 (XI0_I1390_bcon I0_pp7_6 XI0_I1390_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1390_MP45 (XI0_I1390_bp2 I0_cm27_2 XI0_I1390_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1390_MP43 (VDD XI0_I1390_s1 XI0_I1390_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1390_MP44 (XI0_I1390_bp2 I0_pp7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1390_MP56 (VDD XI0_I1390_bcon I0_cm29_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1390_MP46 (XI0_I1390_bp3 XI0_I1390_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1390_MP48 (VDD I0_cm27_2 XI0_I1390_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1390_MP50_1 (XI0_I1390_bp4 XI0_I1390_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1390_MP26 (VDD XI0_I1390_asn XI0_I1390_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1390_MP18 (XI0_I1390_ap3 I0_pp4_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1390_MP21 (XI0_I1390_asn XI0_I1390_acon XI0_I1390_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1390_MP24 (XI0_I1390_ap5 I0_pp6_8 XI0_I1390_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1390_MP23 (XI0_I1390_ap4 I0_pp5_10 XI0_I1390_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1390_MP22 (VDD I0_pp4_12 XI0_I1390_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1390_MP22_1 (XI0_I1390_ap4 I0_pp4_12 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1390_MP23_1 (XI0_I1390_ap5 I0_pp5_10 XI0_I1390_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1390_MP24_1 (XI0_I1390_asn I0_pp6_8 XI0_I1390_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1390_MP17 (XI0_I1390_acon I0_pp6_8 XI0_I1390_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1390_MP14 (XI0_I1390_ap1 I0_pp5_10 XI0_I1390_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1390_MP13 (VDD I0_pp4_12 XI0_I1390_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1390_MP15 (XI0_I1390_ap2 I0_pp4_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1390_MP16 (VDD I0_pp5_10 XI0_I1390_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1390_MP28 (I0_cm29_2 XI0_I1390_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1390_MP19 (XI0_I1390_ap3 I0_pp5_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1390_MP20 (VDD I0_pp6_8 XI0_I1390_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1581_MP50 (VDD XI0_I1581_s1 XI0_I1581_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1581_MP47 (XI0_I1581_bp3 I0_fa160_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1581_MP49 (XI0_I1581_bsn XI0_I1581_bcon XI0_I1581_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1581_MP52 (XI0_I1581_bp5 I0_cm219_2 XI0_I1581_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1581_MP51 (XI0_I1581_bp4 I0_fa160_0 XI0_I1581_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1581_MP51_1 (XI0_I1581_bp5 I0_fa160_0 XI0_I1581_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1581_MP52_1 (XI0_I1581_bsn I0_cm219_2 XI0_I1581_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1581_MP54 (VDD XI0_I1581_bsn I0_cm220_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1581_MP41 (XI0_I1581_bp1 XI0_I1581_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1581_MP42 (XI0_I1581_bcon I0_fa160_0 XI0_I1581_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1581_MP45 (XI0_I1581_bp2 I0_cm219_2 XI0_I1581_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1581_MP43 (VDD XI0_I1581_s1 XI0_I1581_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1581_MP44 (XI0_I1581_bp2 I0_fa160_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1581_MP56 (VDD XI0_I1581_bcon I0_cm220_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1581_MP46 (XI0_I1581_bp3 XI0_I1581_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1581_MP48 (VDD I0_cm219_2 XI0_I1581_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1581_MP50_1 (XI0_I1581_bp4 XI0_I1581_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1581_MP26 (VDD XI0_I1581_asn XI0_I1581_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1581_MP18 (XI0_I1581_ap3 I0_cm157_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1581_MP21 (XI0_I1581_asn XI0_I1581_acon XI0_I1581_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1581_MP24 (XI0_I1581_ap5 I0_cm159_0 XI0_I1581_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1581_MP23 (XI0_I1581_ap4 I0_fa158_1 XI0_I1581_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1581_MP22 (VDD I0_cm157_1 XI0_I1581_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1581_MP22_1 (XI0_I1581_ap4 I0_cm157_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1581_MP23_1 (XI0_I1581_ap5 I0_fa158_1 XI0_I1581_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1581_MP24_1 (XI0_I1581_asn I0_cm159_0 XI0_I1581_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1581_MP17 (XI0_I1581_acon I0_cm159_0 XI0_I1581_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1581_MP14 (XI0_I1581_ap1 I0_fa158_1 XI0_I1581_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1581_MP13 (VDD I0_cm157_1 XI0_I1581_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1581_MP15 (XI0_I1581_ap2 I0_cm157_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1581_MP16 (VDD I0_fa158_1 XI0_I1581_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1581_MP28 (I0_cm220_2 XI0_I1581_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1581_MP19 (XI0_I1581_ap3 I0_fa158_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1581_MP20 (VDD I0_cm159_0 XI0_I1581_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1514_MP50 (VDD XI0_I1514_s1 XI0_I1514_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1514_MP47 (XI0_I1514_bp3 I0_cm34_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1514_MP49 (XI0_I1514_bsn XI0_I1514_bcon XI0_I1514_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1514_MP52 (XI0_I1514_bp5 I0_cm152_2 XI0_I1514_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1514_MP51 (XI0_I1514_bp4 I0_cm34_0 XI0_I1514_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1514_MP51_1 (XI0_I1514_bp5 I0_cm34_0 XI0_I1514_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1514_MP52_1 (XI0_I1514_bsn I0_cm152_2 XI0_I1514_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1514_MP54 (VDD XI0_I1514_bsn I0_cm153_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1514_MP41 (XI0_I1514_bp1 XI0_I1514_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1514_MP42 (XI0_I1514_bcon I0_cm34_0 XI0_I1514_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1514_MP45 (XI0_I1514_bp2 I0_cm152_2 XI0_I1514_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1514_MP43 (VDD XI0_I1514_s1 XI0_I1514_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1514_MP44 (XI0_I1514_bp2 I0_cm34_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1514_MP56 (VDD XI0_I1514_bcon I0_cm153_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1514_MP46 (XI0_I1514_bp3 XI0_I1514_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1514_MP48 (VDD I0_cm152_2 XI0_I1514_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1514_MP50_1 (XI0_I1514_bp4 XI0_I1514_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1514_MP26 (VDD XI0_I1514_asn XI0_I1514_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1514_MP18 (XI0_I1514_ap3 I0_cm31_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1514_MP21 (XI0_I1514_asn XI0_I1514_acon XI0_I1514_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1514_MP24 (XI0_I1514_ap5 I0_fa33_1 XI0_I1514_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1514_MP23 (XI0_I1514_ap4 I0_cm32_1 XI0_I1514_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1514_MP22 (VDD I0_cm31_1 XI0_I1514_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1514_MP22_1 (XI0_I1514_ap4 I0_cm31_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1514_MP23_1 (XI0_I1514_ap5 I0_cm32_1 XI0_I1514_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1514_MP24_1 (XI0_I1514_asn I0_fa33_1 XI0_I1514_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1514_MP17 (XI0_I1514_acon I0_fa33_1 XI0_I1514_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1514_MP14 (XI0_I1514_ap1 I0_cm32_1 XI0_I1514_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1514_MP13 (VDD I0_cm31_1 XI0_I1514_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1514_MP15 (XI0_I1514_ap2 I0_cm31_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1514_MP16 (VDD I0_cm32_1 XI0_I1514_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1514_MP28 (I0_cm153_2 XI0_I1514_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1514_MP19 (XI0_I1514_ap3 I0_cm32_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1514_MP20 (VDD I0_fa33_1 XI0_I1514_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1416_MP50 (VDD XI0_I1416_s1 XI0_I1416_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1416_MP47 (XI0_I1416_bp3 I0_pp11_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1416_MP49 (XI0_I1416_bsn XI0_I1416_bcon XI0_I1416_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1416_MP52 (XI0_I1416_bp5 I0_cm52_2 XI0_I1416_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1416_MP51 (XI0_I1416_bp4 I0_pp11_6 XI0_I1416_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1416_MP51_1 (XI0_I1416_bp5 I0_pp11_6 XI0_I1416_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1416_MP52_1 (XI0_I1416_bsn I0_cm52_2 XI0_I1416_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1416_MP54 (VDD XI0_I1416_bsn I0_cm55_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1416_MP41 (XI0_I1416_bp1 XI0_I1416_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1416_MP42 (XI0_I1416_bcon I0_pp11_6 XI0_I1416_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1416_MP45 (XI0_I1416_bp2 I0_cm52_2 XI0_I1416_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1416_MP43 (VDD XI0_I1416_s1 XI0_I1416_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1416_MP44 (XI0_I1416_bp2 I0_pp11_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1416_MP56 (VDD XI0_I1416_bcon I0_cm55_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1416_MP46 (XI0_I1416_bp3 XI0_I1416_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1416_MP48 (VDD I0_cm52_2 XI0_I1416_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1416_MP50_1 (XI0_I1416_bp4 XI0_I1416_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1416_MP26 (VDD XI0_I1416_asn XI0_I1416_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1416_MP18 (XI0_I1416_ap3 I0_pp8_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1416_MP21 (XI0_I1416_asn XI0_I1416_acon XI0_I1416_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1416_MP24 (XI0_I1416_ap5 I0_pp10_8 XI0_I1416_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1416_MP23 (XI0_I1416_ap4 I0_pp9_10 XI0_I1416_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1416_MP22 (VDD I0_pp8_12 XI0_I1416_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1416_MP22_1 (XI0_I1416_ap4 I0_pp8_12 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1416_MP23_1 (XI0_I1416_ap5 I0_pp9_10 XI0_I1416_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1416_MP24_1 (XI0_I1416_asn I0_pp10_8 XI0_I1416_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1416_MP17 (XI0_I1416_acon I0_pp10_8 XI0_I1416_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1416_MP14 (XI0_I1416_ap1 I0_pp9_10 XI0_I1416_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1416_MP13 (VDD I0_pp8_12 XI0_I1416_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1416_MP15 (XI0_I1416_ap2 I0_pp8_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1416_MP16 (VDD I0_pp9_10 XI0_I1416_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1416_MP28 (I0_cm55_2 XI0_I1416_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1416_MP19 (XI0_I1416_ap3 I0_pp9_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1416_MP20 (VDD I0_pp10_8 XI0_I1416_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1525_MP50 (VDD XI0_I1525_s1 XI0_I1525_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1525_MP47 (XI0_I1525_bp3 I0_B_29_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1525_MP49 (XI0_I1525_bsn XI0_I1525_bcon XI0_I1525_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1525_MP52 (XI0_I1525_bp5 I0_cm162_2 XI0_I1525_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1525_MP51 (XI0_I1525_bp4 I0_B_29_b3_5 XI0_I1525_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1525_MP51_1 (XI0_I1525_bp5 I0_B_29_b3_5 XI0_I1525_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1525_MP52_1 (XI0_I1525_bsn I0_cm162_2 XI0_I1525_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1525_MP54 (VDD XI0_I1525_bsn I0_cm164_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1525_MP41 (XI0_I1525_bp1 XI0_I1525_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1525_MP42 (XI0_I1525_bcon I0_B_29_b3_5 XI0_I1525_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1525_MP45 (XI0_I1525_bp2 I0_cm162_2 XI0_I1525_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1525_MP43 (VDD XI0_I1525_s1 XI0_I1525_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1525_MP44 (XI0_I1525_bp2 I0_B_29_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1525_MP56 (VDD XI0_I1525_bcon I0_cm164_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1525_MP46 (XI0_I1525_bp3 XI0_I1525_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1525_MP48 (VDD I0_cm162_2 XI0_I1525_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1525_MP50_1 (XI0_I1525_bp4 XI0_I1525_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1525_MP26 (VDD XI0_I1525_asn XI0_I1525_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1525_MP18 (XI0_I1525_ap3 I0_cm54_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1525_MP21 (XI0_I1525_asn XI0_I1525_acon XI0_I1525_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1525_MP24 (XI0_I1525_ap5 I0_fa56_0 XI0_I1525_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1525_MP23 (XI0_I1525_ap4 I0_cm55_0 XI0_I1525_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1525_MP22 (VDD I0_cm54_0 XI0_I1525_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1525_MP22_1 (XI0_I1525_ap4 I0_cm54_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1525_MP23_1 (XI0_I1525_ap5 I0_cm55_0 XI0_I1525_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1525_MP24_1 (XI0_I1525_asn I0_fa56_0 XI0_I1525_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1525_MP17 (XI0_I1525_acon I0_fa56_0 XI0_I1525_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1525_MP14 (XI0_I1525_ap1 I0_cm55_0 XI0_I1525_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1525_MP13 (VDD I0_cm54_0 XI0_I1525_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1525_MP15 (XI0_I1525_ap2 I0_cm54_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1525_MP16 (VDD I0_cm55_0 XI0_I1525_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1525_MP28 (I0_cm164_2 XI0_I1525_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1525_MP19 (XI0_I1525_ap3 I0_cm55_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1525_MP20 (VDD I0_fa56_0 XI0_I1525_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1527_MP50 (VDD XI0_I1527_s1 XI0_I1527_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1527_MP47 (XI0_I1527_bp3 I0_fa60_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1527_MP49 (XI0_I1527_bsn XI0_I1527_bcon XI0_I1527_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1527_MP52 (XI0_I1527_bp5 I0_cm164_2 XI0_I1527_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1527_MP51 (XI0_I1527_bp4 I0_fa60_0 XI0_I1527_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1527_MP51_1 (XI0_I1527_bp5 I0_fa60_0 XI0_I1527_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1527_MP52_1 (XI0_I1527_bsn I0_cm164_2 XI0_I1527_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1527_MP54 (VDD XI0_I1527_bsn I0_cm166_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1527_MP41 (XI0_I1527_bp1 XI0_I1527_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1527_MP42 (XI0_I1527_bcon I0_fa60_0 XI0_I1527_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1527_MP45 (XI0_I1527_bp2 I0_cm164_2 XI0_I1527_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1527_MP43 (VDD XI0_I1527_s1 XI0_I1527_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1527_MP44 (XI0_I1527_bp2 I0_fa60_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1527_MP56 (VDD XI0_I1527_bcon I0_cm166_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1527_MP46 (XI0_I1527_bp3 XI0_I1527_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1527_MP48 (VDD I0_cm164_2 XI0_I1527_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1527_MP50_1 (XI0_I1527_bp4 XI0_I1527_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1527_MP26 (VDD XI0_I1527_asn XI0_I1527_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1527_MP18 (XI0_I1527_ap3 I0_cm57_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1527_MP21 (XI0_I1527_asn XI0_I1527_acon XI0_I1527_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1527_MP24 (XI0_I1527_ap5 I0_cm59_0 XI0_I1527_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1527_MP23 (XI0_I1527_ap4 I0_cm58_0 XI0_I1527_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1527_MP22 (VDD I0_cm57_0 XI0_I1527_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1527_MP22_1 (XI0_I1527_ap4 I0_cm57_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1527_MP23_1 (XI0_I1527_ap5 I0_cm58_0 XI0_I1527_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1527_MP24_1 (XI0_I1527_asn I0_cm59_0 XI0_I1527_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1527_MP17 (XI0_I1527_acon I0_cm59_0 XI0_I1527_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1527_MP14 (XI0_I1527_ap1 I0_cm58_0 XI0_I1527_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1527_MP13 (VDD I0_cm57_0 XI0_I1527_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1527_MP15 (XI0_I1527_ap2 I0_cm57_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1527_MP16 (VDD I0_cm58_0 XI0_I1527_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1527_MP28 (I0_cm166_2 XI0_I1527_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1527_MP19 (XI0_I1527_ap3 I0_cm58_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1527_MP20 (VDD I0_cm59_0 XI0_I1527_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1428_MP50 (VDD XI0_I1428_s1 XI0_I1428_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1428_MP47 (XI0_I1428_bp3 I0_pp11_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1428_MP49 (XI0_I1428_bsn XI0_I1428_bcon XI0_I1428_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1428_MP52 (XI0_I1428_bp5 I0_cm63_2 XI0_I1428_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1428_MP51 (XI0_I1428_bp4 I0_pp11_9 XI0_I1428_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1428_MP51_1 (XI0_I1428_bp5 I0_pp11_9 XI0_I1428_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1428_MP52_1 (XI0_I1428_bsn I0_cm63_2 XI0_I1428_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1428_MP54 (VDD XI0_I1428_bsn I0_cm67_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1428_MP41 (XI0_I1428_bp1 XI0_I1428_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1428_MP42 (XI0_I1428_bcon I0_pp11_9 XI0_I1428_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1428_MP45 (XI0_I1428_bp2 I0_cm63_2 XI0_I1428_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1428_MP43 (VDD XI0_I1428_s1 XI0_I1428_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1428_MP44 (XI0_I1428_bp2 I0_pp11_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1428_MP56 (VDD XI0_I1428_bcon I0_cm67_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1428_MP46 (XI0_I1428_bp3 XI0_I1428_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1428_MP48 (VDD I0_cm63_2 XI0_I1428_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1428_MP50_1 (XI0_I1428_bp4 XI0_I1428_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1428_MP26 (VDD XI0_I1428_asn XI0_I1428_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1428_MP18 (XI0_I1428_ap3 I0_pp8_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1428_MP21 (XI0_I1428_asn XI0_I1428_acon XI0_I1428_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1428_MP24 (XI0_I1428_ap5 I0_pp10_11 XI0_I1428_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1428_MP23 (XI0_I1428_ap4 I0_pp9_13 XI0_I1428_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1428_MP22 (VDD I0_pp8_15 XI0_I1428_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1428_MP22_1 (XI0_I1428_ap4 I0_pp8_15 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1428_MP23_1 (XI0_I1428_ap5 I0_pp9_13 XI0_I1428_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1428_MP24_1 (XI0_I1428_asn I0_pp10_11 XI0_I1428_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1428_MP17 (XI0_I1428_acon I0_pp10_11 XI0_I1428_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1428_MP14 (XI0_I1428_ap1 I0_pp9_13 XI0_I1428_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1428_MP13 (VDD I0_pp8_15 XI0_I1428_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1428_MP15 (XI0_I1428_ap2 I0_pp8_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1428_MP16 (VDD I0_pp9_13 XI0_I1428_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1428_MP28 (I0_cm67_2 XI0_I1428_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1428_MP19 (XI0_I1428_ap3 I0_pp9_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1428_MP20 (VDD I0_pp10_11 XI0_I1428_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1436_MP50 (VDD XI0_I1436_s1 XI0_I1436_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1436_MP47 (XI0_I1436_bp3 I0_pp11_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1436_MP49 (XI0_I1436_bsn XI0_I1436_bcon XI0_I1436_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1436_MP52 (XI0_I1436_bp5 I0_cm71_2 XI0_I1436_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1436_MP51 (XI0_I1436_bp4 I0_pp11_11 XI0_I1436_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1436_MP51_1 (XI0_I1436_bp5 I0_pp11_11 XI0_I1436_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1436_MP52_1 (XI0_I1436_bsn I0_cm71_2 XI0_I1436_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1436_MP54 (VDD XI0_I1436_bsn I0_cm75_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1436_MP41 (XI0_I1436_bp1 XI0_I1436_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1436_MP42 (XI0_I1436_bcon I0_pp11_11 XI0_I1436_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1436_MP45 (XI0_I1436_bp2 I0_cm71_2 XI0_I1436_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1436_MP43 (VDD XI0_I1436_s1 XI0_I1436_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1436_MP44 (XI0_I1436_bp2 I0_pp11_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1436_MP56 (VDD XI0_I1436_bcon I0_cm75_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1436_MP46 (XI0_I1436_bp3 XI0_I1436_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1436_MP48 (VDD I0_cm71_2 XI0_I1436_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1436_MP50_1 (XI0_I1436_bp4 XI0_I1436_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1436_MP26 (VDD XI0_I1436_asn XI0_I1436_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1436_MP18 (XI0_I1436_ap3 I0_pp8_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1436_MP21 (XI0_I1436_asn XI0_I1436_acon XI0_I1436_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1436_MP24 (XI0_I1436_ap5 I0_pp10_13 XI0_I1436_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1436_MP23 (XI0_I1436_ap4 I0_pp9_15 XI0_I1436_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1436_MP22 (VDD I0_pp8_17 XI0_I1436_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1436_MP22_1 (XI0_I1436_ap4 I0_pp8_17 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1436_MP23_1 (XI0_I1436_ap5 I0_pp9_15 XI0_I1436_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1436_MP24_1 (XI0_I1436_asn I0_pp10_13 XI0_I1436_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1436_MP17 (XI0_I1436_acon I0_pp10_13 XI0_I1436_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1436_MP14 (XI0_I1436_ap1 I0_pp9_15 XI0_I1436_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1436_MP13 (VDD I0_pp8_17 XI0_I1436_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1436_MP15 (XI0_I1436_ap2 I0_pp8_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1436_MP16 (VDD I0_pp9_15 XI0_I1436_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1436_MP28 (I0_cm75_2 XI0_I1436_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1436_MP19 (XI0_I1436_ap3 I0_pp9_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1436_MP20 (VDD I0_pp10_13 XI0_I1436_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1538_MP50 (VDD XI0_I1538_s1 XI0_I1538_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1538_MP47 (XI0_I1538_bp3 I0_cm80_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1538_MP49 (XI0_I1538_bsn XI0_I1538_bcon XI0_I1538_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1538_MP52 (XI0_I1538_bp5 I0_cm175_2 XI0_I1538_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1538_MP51 (XI0_I1538_bp4 I0_cm80_1 XI0_I1538_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1538_MP51_1 (XI0_I1538_bp5 I0_cm80_1 XI0_I1538_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1538_MP52_1 (XI0_I1538_bsn I0_cm175_2 XI0_I1538_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1538_MP54 (VDD XI0_I1538_bsn I0_cm177_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1538_MP41 (XI0_I1538_bp1 XI0_I1538_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1538_MP42 (XI0_I1538_bcon I0_cm80_1 XI0_I1538_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1538_MP45 (XI0_I1538_bp2 I0_cm175_2 XI0_I1538_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1538_MP43 (VDD XI0_I1538_s1 XI0_I1538_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1538_MP44 (XI0_I1538_bp2 I0_cm80_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1538_MP56 (VDD XI0_I1538_bcon I0_cm177_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1538_MP46 (XI0_I1538_bp3 XI0_I1538_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1538_MP48 (VDD I0_cm175_2 XI0_I1538_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1538_MP50_1 (XI0_I1538_bp4 XI0_I1538_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1538_MP26 (VDD XI0_I1538_asn XI0_I1538_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1538_MP18 (XI0_I1538_ap3 I0_cm77_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1538_MP21 (XI0_I1538_asn XI0_I1538_acon XI0_I1538_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1538_MP24 (XI0_I1538_ap5 I0_cm79_1 XI0_I1538_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1538_MP23 (XI0_I1538_ap4 I0_cm78_1 XI0_I1538_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1538_MP22 (VDD I0_cm77_1 XI0_I1538_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1538_MP22_1 (XI0_I1538_ap4 I0_cm77_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1538_MP23_1 (XI0_I1538_ap5 I0_cm78_1 XI0_I1538_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1538_MP24_1 (XI0_I1538_asn I0_cm79_1 XI0_I1538_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1538_MP17 (XI0_I1538_acon I0_cm79_1 XI0_I1538_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1538_MP14 (XI0_I1538_ap1 I0_cm78_1 XI0_I1538_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1538_MP13 (VDD I0_cm77_1 XI0_I1538_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1538_MP15 (XI0_I1538_ap2 I0_cm77_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1538_MP16 (VDD I0_cm78_1 XI0_I1538_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1538_MP28 (I0_cm177_2 XI0_I1538_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1538_MP19 (XI0_I1538_ap3 I0_cm78_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1538_MP20 (VDD I0_cm79_1 XI0_I1538_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1542_MP50 (VDD XI0_I1542_s1 XI0_I1542_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1542_MP47 (XI0_I1542_bp3 I0_fa88_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1542_MP49 (XI0_I1542_bsn XI0_I1542_bcon XI0_I1542_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1542_MP52 (XI0_I1542_bp5 I0_cm179_2 XI0_I1542_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1542_MP51 (XI0_I1542_bp4 I0_fa88_1 XI0_I1542_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1542_MP51_1 (XI0_I1542_bp5 I0_fa88_1 XI0_I1542_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1542_MP52_1 (XI0_I1542_bsn I0_cm179_2 XI0_I1542_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1542_MP54 (VDD XI0_I1542_bsn I0_cm181_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1542_MP41 (XI0_I1542_bp1 XI0_I1542_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1542_MP42 (XI0_I1542_bcon I0_fa88_1 XI0_I1542_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1542_MP45 (XI0_I1542_bp2 I0_cm179_2 XI0_I1542_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1542_MP43 (VDD XI0_I1542_s1 XI0_I1542_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1542_MP44 (XI0_I1542_bp2 I0_fa88_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1542_MP56 (VDD XI0_I1542_bcon I0_cm181_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1542_MP46 (XI0_I1542_bp3 XI0_I1542_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1542_MP48 (VDD I0_cm179_2 XI0_I1542_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1542_MP50_1 (XI0_I1542_bp4 XI0_I1542_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1542_MP26 (VDD XI0_I1542_asn XI0_I1542_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1542_MP18 (XI0_I1542_ap3 I0_cm85_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1542_MP21 (XI0_I1542_asn XI0_I1542_acon XI0_I1542_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1542_MP24 (XI0_I1542_ap5 I0_cm87_1 XI0_I1542_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1542_MP23 (XI0_I1542_ap4 I0_cm86_1 XI0_I1542_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1542_MP22 (VDD I0_cm85_1 XI0_I1542_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1542_MP22_1 (XI0_I1542_ap4 I0_cm85_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1542_MP23_1 (XI0_I1542_ap5 I0_cm86_1 XI0_I1542_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1542_MP24_1 (XI0_I1542_asn I0_cm87_1 XI0_I1542_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1542_MP17 (XI0_I1542_acon I0_cm87_1 XI0_I1542_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1542_MP14 (XI0_I1542_ap1 I0_cm86_1 XI0_I1542_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1542_MP13 (VDD I0_cm85_1 XI0_I1542_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1542_MP15 (XI0_I1542_ap2 I0_cm85_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1542_MP16 (VDD I0_cm86_1 XI0_I1542_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1542_MP28 (I0_cm181_2 XI0_I1542_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1542_MP19 (XI0_I1542_ap3 I0_cm86_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1542_MP20 (VDD I0_cm87_1 XI0_I1542_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1454_MP50 (VDD XI0_I1454_s1 XI0_I1454_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1454_MP47 (XI0_I1454_bp3 I0_pp9_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1454_MP49 (XI0_I1454_bsn XI0_I1454_bcon XI0_I1454_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1454_MP52 (XI0_I1454_bp5 I0_cm90_2 XI0_I1454_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1454_MP51 (XI0_I1454_bp4 I0_pp9_20 XI0_I1454_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1454_MP51_1 (XI0_I1454_bp5 I0_pp9_20 XI0_I1454_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1454_MP52_1 (XI0_I1454_bsn I0_cm90_2 XI0_I1454_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1454_MP54 (VDD XI0_I1454_bsn I0_cm93_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1454_MP41 (XI0_I1454_bp1 XI0_I1454_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1454_MP42 (XI0_I1454_bcon I0_pp9_20 XI0_I1454_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1454_MP45 (XI0_I1454_bp2 I0_cm90_2 XI0_I1454_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1454_MP43 (VDD XI0_I1454_s1 XI0_I1454_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1454_MP44 (XI0_I1454_bp2 I0_pp9_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1454_MP56 (VDD XI0_I1454_bcon I0_cm93_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1454_MP46 (XI0_I1454_bp3 XI0_I1454_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1454_MP48 (VDD I0_cm90_2 XI0_I1454_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1454_MP50_1 (XI0_I1454_bp4 XI0_I1454_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1454_MP26 (VDD XI0_I1454_asn XI0_I1454_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1454_MP18 (XI0_I1454_ap3 I0_pp6_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1454_MP21 (XI0_I1454_asn XI0_I1454_acon XI0_I1454_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1454_MP24 (XI0_I1454_ap5 I0_pp8_22 XI0_I1454_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1454_MP23 (XI0_I1454_ap4 I0_pp7_24 XI0_I1454_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1454_MP22 (VDD I0_pp6_26 XI0_I1454_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1454_MP22_1 (XI0_I1454_ap4 I0_pp6_26 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1454_MP23_1 (XI0_I1454_ap5 I0_pp7_24 XI0_I1454_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1454_MP24_1 (XI0_I1454_asn I0_pp8_22 XI0_I1454_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1454_MP17 (XI0_I1454_acon I0_pp8_22 XI0_I1454_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1454_MP14 (XI0_I1454_ap1 I0_pp7_24 XI0_I1454_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1454_MP13 (VDD I0_pp6_26 XI0_I1454_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1454_MP15 (XI0_I1454_ap2 I0_pp6_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1454_MP16 (VDD I0_pp7_24 XI0_I1454_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1454_MP28 (I0_cm93_2 XI0_I1454_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1454_MP19 (XI0_I1454_ap3 I0_pp7_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1454_MP20 (VDD I0_pp8_22 XI0_I1454_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1592_MP50 (VDD XI0_I1592_s1 XI0_I1592_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1592_MP47 (XI0_I1592_bp3 I0_cm182_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1592_MP49 (XI0_I1592_bsn XI0_I1592_bcon XI0_I1592_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1592_MP52 (XI0_I1592_bp5 I0_cm230_2 XI0_I1592_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1592_MP51 (XI0_I1592_bp4 I0_cm182_0 XI0_I1592_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1592_MP51_1 (XI0_I1592_bp5 I0_cm182_0 XI0_I1592_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1592_MP52_1 (XI0_I1592_bsn I0_cm230_2 XI0_I1592_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1592_MP54 (VDD XI0_I1592_bsn I0_cm231_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1592_MP41 (XI0_I1592_bp1 XI0_I1592_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1592_MP42 (XI0_I1592_bcon I0_cm182_0 XI0_I1592_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1592_MP45 (XI0_I1592_bp2 I0_cm230_2 XI0_I1592_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1592_MP43 (VDD XI0_I1592_s1 XI0_I1592_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1592_MP44 (XI0_I1592_bp2 I0_cm182_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1592_MP56 (VDD XI0_I1592_bcon I0_cm231_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1592_MP46 (XI0_I1592_bp3 XI0_I1592_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1592_MP48 (VDD I0_cm230_2 XI0_I1592_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1592_MP50_1 (XI0_I1592_bp4 XI0_I1592_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1592_MP26 (VDD XI0_I1592_asn XI0_I1592_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1592_MP18 (XI0_I1592_ap3 I0_cm179_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1592_MP21 (XI0_I1592_asn XI0_I1592_acon XI0_I1592_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1592_MP24 (XI0_I1592_ap5 I0_cm181_0 XI0_I1592_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1592_MP23 (XI0_I1592_ap4 I0_cm180_1 XI0_I1592_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1592_MP22 (VDD I0_cm179_1 XI0_I1592_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1592_MP22_1 (XI0_I1592_ap4 I0_cm179_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1592_MP23_1 (XI0_I1592_ap5 I0_cm180_1 XI0_I1592_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1592_MP24_1 (XI0_I1592_asn I0_cm181_0 XI0_I1592_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1592_MP17 (XI0_I1592_acon I0_cm181_0 XI0_I1592_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1592_MP14 (XI0_I1592_ap1 I0_cm180_1 XI0_I1592_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1592_MP13 (VDD I0_cm179_1 XI0_I1592_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1592_MP15 (XI0_I1592_ap2 I0_cm179_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1592_MP16 (VDD I0_cm180_1 XI0_I1592_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1592_MP28 (I0_cm231_2 XI0_I1592_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1592_MP19 (XI0_I1592_ap3 I0_cm180_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1592_MP20 (VDD I0_cm181_0 XI0_I1592_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1544_MP50 (VDD XI0_I1544_s1 XI0_I1544_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1544_MP47 (XI0_I1544_bp3 I0_cm92_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1544_MP49 (XI0_I1544_bsn XI0_I1544_bcon XI0_I1544_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1544_MP52 (XI0_I1544_bp5 I0_cm181_2 XI0_I1544_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1544_MP51 (XI0_I1544_bp4 I0_cm92_0 XI0_I1544_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1544_MP51_1 (XI0_I1544_bp5 I0_cm92_0 XI0_I1544_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1544_MP52_1 (XI0_I1544_bsn I0_cm181_2 XI0_I1544_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1544_MP54 (VDD XI0_I1544_bsn I0_cm183_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1544_MP41 (XI0_I1544_bp1 XI0_I1544_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1544_MP42 (XI0_I1544_bcon I0_cm92_0 XI0_I1544_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1544_MP45 (XI0_I1544_bp2 I0_cm181_2 XI0_I1544_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1544_MP43 (VDD XI0_I1544_s1 XI0_I1544_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1544_MP44 (XI0_I1544_bp2 I0_cm92_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1544_MP56 (VDD XI0_I1544_bcon I0_cm183_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1544_MP46 (XI0_I1544_bp3 XI0_I1544_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1544_MP48 (VDD I0_cm181_2 XI0_I1544_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1544_MP50_1 (XI0_I1544_bp4 XI0_I1544_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1544_MP26 (VDD XI0_I1544_asn XI0_I1544_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1544_MP18 (XI0_I1544_ap3 I0_cm89_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1544_MP21 (XI0_I1544_asn XI0_I1544_acon XI0_I1544_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1544_MP24 (XI0_I1544_ap5 I0_cm91_1 XI0_I1544_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1544_MP23 (XI0_I1544_ap4 I0_cm90_1 XI0_I1544_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1544_MP22 (VDD I0_cm89_1 XI0_I1544_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1544_MP22_1 (XI0_I1544_ap4 I0_cm89_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1544_MP23_1 (XI0_I1544_ap5 I0_cm90_1 XI0_I1544_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1544_MP24_1 (XI0_I1544_asn I0_cm91_1 XI0_I1544_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1544_MP17 (XI0_I1544_acon I0_cm91_1 XI0_I1544_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1544_MP14 (XI0_I1544_ap1 I0_cm90_1 XI0_I1544_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1544_MP13 (VDD I0_cm89_1 XI0_I1544_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1544_MP15 (XI0_I1544_ap2 I0_cm89_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1544_MP16 (VDD I0_cm90_1 XI0_I1544_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1544_MP28 (I0_cm183_2 XI0_I1544_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1544_MP19 (XI0_I1544_ap3 I0_cm90_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1544_MP20 (VDD I0_cm91_1 XI0_I1544_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1385_MP50 (VDD XI0_I1385_s1 XI0_I1385_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1385_MP47 (XI0_I1385_bp3 I0_pp7_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1385_MP49 (XI0_I1385_bsn XI0_I1385_bcon XI0_I1385_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1385_MP52 (XI0_I1385_bp5 I0_cm22_2 XI0_I1385_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1385_MP51 (XI0_I1385_bp4 I0_pp7_4 XI0_I1385_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1385_MP51_1 (XI0_I1385_bp5 I0_pp7_4 XI0_I1385_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1385_MP52_1 (XI0_I1385_bsn I0_cm22_2 XI0_I1385_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1385_MP54 (VDD XI0_I1385_bsn I0_cm24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
