    I_MXI1_I1988_I91_XG_MP2 (VDD I1_I1988_gn25 I1_I1988_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I91_XG_MP0 (XI1_I1988_I91_XG_p1 I1_I1988_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I91_XG_MP1 (I1_I1988_G25_24 I1_I1988_gn24 XI1_I1988_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I202_XG_MP2 (VDD I1_I1988_G31_16n I1_c31_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I202_XG_MP0 (XI1_I1988_I202_XG_p1 I1_I1988_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I202_XG_MP1 (I1_c31_o I1_I1988_G15_0n XI1_I1988_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I155_XG_MP2 (VDD I1_I1988_G30_27n I1_I1988_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I155_XG_MP0 (XI1_I1988_I155_XG_p1 I1_I1988_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I155_XG_MP1 (I1_I1988_G30_23 I1_I1988_G26_23n XI1_I1988_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I201_XG_MP2 (VDD I1_I1988_G30_15n I1_c31_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I201_XG_MP0 (XI1_I1988_I201_XG_p1 I1_I1988_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I201_XG_MP1 (I1_c31_m I1_I1988_G14_0n XI1_I1988_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I89_XG_MP2 (VDD I1_I2066_gn23 I1_I2066_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I89_XG_MP0 (XI1_I2066_I89_XG_p1 I1_I2066_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I89_XG_MP1 (I1_I2066_G23_22 I1_I2066_gn22 XI1_I2066_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I88_XG_MP2 (VDD I1_I2066_gn22 I1_I2066_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I88_XG_MP0 (XI1_I2066_I88_XG_p1 I1_I2066_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I88_XG_MP1 (I1_I2066_G22_21 I1_I2066_gn21 XI1_I2066_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I153_XG_MP2 (VDD I1_I2066_G28_25n I1_I2066_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I153_XG_MP0 (XI1_I2066_I153_XG_p1 I1_I2066_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I153_XG_MP1 (I1_I2066_G28_21 I1_I2066_G24_21n XI1_I2066_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I151_XG_MP2 (VDD I1_I2066_G26_23n I1_I2066_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I151_XG_MP0 (XI1_I2066_I151_XG_p1 I1_I2066_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I151_XG_MP1 (I1_I2066_G26_19 I1_I2066_G22_19n XI1_I2066_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I147_XG_MP2 (VDD I1_I2066_G22_19n I1_I2066_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I147_XG_MP0 (XI1_I2066_I147_XG_p1 I1_I2066_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I147_XG_MP1 (I1_I2066_G22_15 I1_I2066_G18_15n XI1_I2066_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I192_XG_MP2 (VDD I1_I2066_G22_7n I1_I2066_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I192_XG_MP0 (XI1_I2066_I192_XG_p1 I1_I2066_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I192_XG_MP1 (I1_I2066_G22_0 I1_I2066_G6_0n XI1_I2066_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I148_XG_MP2 (VDD I1_I2066_G23_20n I1_I2066_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I148_XG_MP0 (XI1_I2066_I148_XG_p1 I1_I2066_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I148_XG_MP1 (I1_I2066_G23_16 I1_I2066_G19_16n XI1_I2066_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I152_XG_MP2 (VDD I1_I2066_G27_24n I1_I2066_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I152_XG_MP0 (XI1_I2066_I152_XG_p1 I1_I2066_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I152_XG_MP1 (I1_I2066_G27_20 I1_I2066_G23_20n XI1_I2066_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I198_XG_MP2 (VDD I1_I2066_G27_12n I1_I2066_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I198_XG_MP0 (XI1_I2066_I198_XG_p1 I1_I2066_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I198_XG_MP1 (I1_I2066_G27_0 I1_I2066_G11_0n XI1_I2066_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I194_XG_MP2 (VDD I1_I2066_G23_8n I1_I2066_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I194_XG_MP0 (XI1_I2066_I194_XG_p1 I1_I2066_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I194_XG_MP1 (I1_I2066_G23_0 I1_I2066_G7_0n XI1_I2066_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I311_XG_MP2 (VDD I0_I1660_G58_55n I0_I1660_G58_51 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I311_XG_MP0 (XI0_I1660_I311_XG_p1 I0_I1660_P58_55n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I311_XG_MP1 (I0_I1660_G58_51 I0_I1660_G54_51n XI0_I1660_I311_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I307_XG_MP2 (VDD I0_I1660_G54_51n I0_I1660_G54_47 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I307_XG_MP0 (XI0_I1660_I307_XG_p1 I0_I1660_P54_51n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I307_XG_MP1 (I0_I1660_G54_47 I0_I1660_G50_47n XI0_I1660_I307_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I313_XG_MP2 (VDD I0_I1660_G60_57n I0_I1660_G60_53 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I313_XG_MP0 (XI0_I1660_I313_XG_p1 I0_I1660_P60_57n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I313_XG_MP1 (I0_I1660_G60_53 I0_I1660_G56_53n XI0_I1660_I313_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I187_XG_MP2 (VDD I0_I1660_gn57 I0_I1660_G57_56 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I187_XG_MP0 (XI0_I1660_I187_XG_p1 I0_I1660_pn57 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I187_XG_MP1 (I0_I1660_G57_56 I0_I1660_gn56 XI0_I1660_I187_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I181_XG_MP2 (VDD I0_I1660_gn51 I0_I1660_G51_50 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I181_XG_MP0 (XI0_I1660_I181_XG_p1 I0_I1660_pn51 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I181_XG_MP1 (I0_I1660_G51_50 I0_I1660_gn50 XI0_I1660_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I97_XG_MP2 (VDD I1_I1850_gn31 I1_I1850_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I97_XG_MP0 (XI1_I1850_I97_XG_p1 I1_I1850_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I97_XG_MP1 (I1_I1850_G31_30 I1_I1850_gn30 XI1_I1850_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I92_XG_MP2 (VDD I1_I1850_gn26 I1_I1850_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I92_XG_MP0 (XI1_I1850_I92_XG_p1 I1_I1850_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I92_XG_MP1 (I1_I1850_G26_25 I1_I1850_gn25 XI1_I1850_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I153_XG_MP2 (VDD I1_I1850_G28_25n I1_I1850_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I153_XG_MP0 (XI1_I1850_I153_XG_p1 I1_I1850_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I153_XG_MP1 (I1_I1850_G28_21 I1_I1850_G24_21n XI1_I1850_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I151_XG_MP2 (VDD I1_I1850_G26_23n I1_I1850_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I151_XG_MP0 (XI1_I1850_I151_XG_p1 I1_I1850_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I151_XG_MP1 (I1_I1850_G26_19 I1_I1850_G22_19n XI1_I1850_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I199_XG_MP2 (VDD I1_I1850_G28_13n I1_I1850_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I199_XG_MP0 (XI1_I1850_I199_XG_p1 I1_I1850_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I199_XG_MP1 (I1_I1850_G28_0 I1_I1850_G12_0n XI1_I1850_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I91_XG_MP2 (VDD I1_I1896_gn25 I1_I1896_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I91_XG_MP0 (XI1_I1896_I91_XG_p1 I1_I1896_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I91_XG_MP1 (I1_I1896_G25_24 I1_I1896_gn24 XI1_I1896_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I90_XG_MP2 (VDD I1_I1896_gn24 I1_I1896_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I90_XG_MP0 (XI1_I1896_I90_XG_p1 I1_I1896_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I90_XG_MP1 (I1_I1896_G24_23 I1_I1896_gn23 XI1_I1896_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I154_XG_MP2 (VDD I1_I1896_G29_26n I1_I1896_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I154_XG_MP0 (XI1_I1896_I154_XG_p1 I1_I1896_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I154_XG_MP1 (I1_I1896_G29_22 I1_I1896_G25_22n XI1_I1896_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I200_XG_MP2 (VDD I1_I1896_G29_14n I1_I1896_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I200_XG_MP0 (XI1_I1896_I200_XG_p1 I1_I1896_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I200_XG_MP1 (I1_I1896_G29_0 I1_I1896_G13_0n XI1_I1896_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I202_XG_MP2 (VDD I1_I1896_G31_16n I1_c29_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I202_XG_MP0 (XI1_I1896_I202_XG_p1 I1_I1896_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I202_XG_MP1 (I1_c29_o I1_I1896_G15_0n XI1_I1896_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I153_XG_MP2 (VDD I1_I1896_G28_25n I1_I1896_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I153_XG_MP0 (XI1_I1896_I153_XG_p1 I1_I1896_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I153_XG_MP1 (I1_I1896_G28_21 I1_I1896_G24_21n XI1_I1896_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I199_XG_MP2 (VDD I1_I1896_G28_13n I1_I1896_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I199_XG_MP0 (XI1_I1896_I199_XG_p1 I1_I1896_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I199_XG_MP1 (I1_I1896_G28_0 I1_I1896_G12_0n XI1_I1896_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I92_XG_MP2 (VDD I1_I1942_gn26 I1_I1942_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I92_XG_MP0 (XI1_I1942_I92_XG_p1 I1_I1942_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I92_XG_MP1 (I1_I1942_G26_25 I1_I1942_gn25 XI1_I1942_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I156_XG_MP2 (VDD I1_I1942_G31_28n I1_I1942_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I156_XG_MP0 (XI1_I1942_I156_XG_p1 I1_I1942_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I156_XG_MP1 (I1_I1942_G31_24 I1_I1942_G27_24n XI1_I1942_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I92_XG_MP2 (VDD I1_I1988_gn26 I1_I1988_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I92_XG_MP0 (XI1_I1988_I92_XG_p1 I1_I1988_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I92_XG_MP1 (I1_I1988_G26_25 I1_I1988_gn25 XI1_I1988_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I93_XG_MP2 (VDD I1_I1988_gn27 I1_I1988_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I93_XG_MP0 (XI1_I1988_I93_XG_p1 I1_I1988_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I93_XG_MP1 (I1_I1988_G27_26 I1_I1988_gn26 XI1_I1988_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I156_XG_MP2 (VDD I1_I1988_G31_28n I1_I1988_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I156_XG_MP0 (XI1_I1988_I156_XG_p1 I1_I1988_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I156_XG_MP1 (I1_I1988_G31_24 I1_I1988_G27_24n XI1_I1988_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I91_XG_MP2 (VDD I1_I2066_gn25 I1_I2066_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I91_XG_MP0 (XI1_I2066_I91_XG_p1 I1_I2066_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I91_XG_MP1 (I1_I2066_G25_24 I1_I2066_gn24 XI1_I2066_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I90_XG_MP2 (VDD I1_I2066_gn24 I1_I2066_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I90_XG_MP0 (XI1_I2066_I90_XG_p1 I1_I2066_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I90_XG_MP1 (I1_I2066_G24_23 I1_I2066_gn23 XI1_I2066_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I154_XG_MP2 (VDD I1_I2066_G29_26n I1_I2066_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I154_XG_MP0 (XI1_I2066_I154_XG_p1 I1_I2066_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I154_XG_MP1 (I1_I2066_G29_22 I1_I2066_G25_22n XI1_I2066_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I202_XG_MP2 (VDD I1_I2066_G31_16n I1_rco VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I202_XG_MP0 (XI1_I2066_I202_XG_p1 I1_I2066_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I202_XG_MP1 (I1_rco I1_I2066_G15_0n XI1_I2066_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I425_XG_MP2 (VDD I0_I1660_G62_47n I0_I1660_G62_31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I425_XG_MP0 (XI0_I1660_I425_XG_p1 I0_I1660_P62_47n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I425_XG_MP1 (I0_I1660_G62_31 I0_I1660_G46_31n XI0_I1660_I425_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I315_XG_MP2 (VDD I0_I1660_G62_59n I0_I1660_G62_55 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I315_XG_MP0 (XI0_I1660_I315_XG_p1 I0_I1660_P62_59n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I315_XG_MP1 (I0_I1660_G62_55 I0_I1660_G58_55n XI0_I1660_I315_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I188_XG_MP2 (VDD I0_I1660_gn58 I0_I1660_G58_57 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I188_XG_MP0 (XI0_I1660_I188_XG_p1 I0_I1660_pn58 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I188_XG_MP1 (I0_I1660_G58_57 I0_I1660_gn57 XI0_I1660_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I189_XG_MP2 (VDD I0_I1660_gn59 I0_I1660_G59_58 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I189_XG_MP0 (XI0_I1660_I189_XG_p1 I0_I1660_pn59 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I189_XG_MP1 (I0_I1660_G59_58 I0_I1660_gn58 XI0_I1660_I189_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I184_XG_MP2 (VDD I0_I1660_gn54 I0_I1660_G54_53 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I184_XG_MP0 (XI0_I1660_I184_XG_p1 I0_I1660_pn54 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I184_XG_MP1 (I0_I1660_G54_53 I0_I1660_gn53 XI0_I1660_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I186_XG_MP2 (VDD I0_I1660_gn56 I0_I1660_G56_55 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I186_XG_MP0 (XI0_I1660_I186_XG_p1 I0_I1660_pn56 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I186_XG_MP1 (I0_I1660_G56_55 I0_I1660_gn55 XI0_I1660_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I185_XG_MP2 (VDD I0_I1660_gn55 I0_I1660_G55_54 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I185_XG_MP0 (XI0_I1660_I185_XG_p1 I0_I1660_pn55 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I185_XG_MP1 (I0_I1660_G55_54 I0_I1660_gn54 XI0_I1660_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I182_XG_MP2 (VDD I0_I1660_gn52 I0_I1660_G52_51 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I182_XG_MP0 (XI0_I1660_I182_XG_p1 I0_I1660_pn52 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I182_XG_MP1 (I0_I1660_G52_51 I0_I1660_gn51 XI0_I1660_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I96_XG_MP2 (VDD I1_I1850_gn30 I1_I1850_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I96_XG_MP0 (XI1_I1850_I96_XG_p1 I1_I1850_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I96_XG_MP1 (I1_I1850_G30_29 I1_I1850_gn29 XI1_I1850_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I93_XG_MP2 (VDD I1_I1850_gn27 I1_I1850_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I93_XG_MP0 (XI1_I1850_I93_XG_p1 I1_I1850_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I93_XG_MP1 (I1_I1850_G27_26 I1_I1850_gn26 XI1_I1850_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I155_XG_MP2 (VDD I1_I1850_G30_27n I1_I1850_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I155_XG_MP0 (XI1_I1850_I155_XG_p1 I1_I1850_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I155_XG_MP1 (I1_I1850_G30_23 I1_I1850_G26_23n XI1_I1850_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I201_XG_MP2 (VDD I1_I1850_G30_15n I1_c28_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I201_XG_MP0 (XI1_I1850_I201_XG_p1 I1_I1850_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I201_XG_MP1 (I1_c28_m I1_I1850_G14_0n XI1_I1850_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I92_XG_MP2 (VDD I1_I1896_gn26 I1_I1896_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I92_XG_MP0 (XI1_I1896_I92_XG_p1 I1_I1896_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I92_XG_MP1 (I1_I1896_G26_25 I1_I1896_gn25 XI1_I1896_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I93_XG_MP2 (VDD I1_I1896_gn27 I1_I1896_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I93_XG_MP0 (XI1_I1896_I93_XG_p1 I1_I1896_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I93_XG_MP1 (I1_I1896_G27_26 I1_I1896_gn26 XI1_I1896_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I156_XG_MP2 (VDD I1_I1896_G31_28n I1_I1896_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I156_XG_MP0 (XI1_I1896_I156_XG_p1 I1_I1896_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I156_XG_MP1 (I1_I1896_G31_24 I1_I1896_G27_24n XI1_I1896_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I155_XG_MP2 (VDD I1_I1896_G30_27n I1_I1896_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I155_XG_MP0 (XI1_I1896_I155_XG_p1 I1_I1896_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I155_XG_MP1 (I1_I1896_G30_23 I1_I1896_G26_23n XI1_I1896_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I201_XG_MP2 (VDD I1_I1896_G30_15n I1_c29_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I201_XG_MP0 (XI1_I1896_I201_XG_p1 I1_I1896_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I201_XG_MP1 (I1_c29_m I1_I1896_G14_0n XI1_I1896_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I93_XG_MP2 (VDD I1_I1942_gn27 I1_I1942_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I93_XG_MP0 (XI1_I1942_I93_XG_p1 I1_I1942_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I93_XG_MP1 (I1_I1942_G27_26 I1_I1942_gn26 XI1_I1942_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I94_XG_MP2 (VDD I1_I1942_gn28 I1_I1942_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I94_XG_MP0 (XI1_I1942_I94_XG_p1 I1_I1942_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I94_XG_MP1 (I1_I1942_G28_27 I1_I1942_gn27 XI1_I1942_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I95_XG_MP2 (VDD I1_I1988_gn29 I1_I1988_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I95_XG_MP0 (XI1_I1988_I95_XG_p1 I1_I1988_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I95_XG_MP1 (I1_I1988_G29_28 I1_I1988_gn28 XI1_I1988_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I94_XG_MP2 (VDD I1_I1988_gn28 I1_I1988_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I94_XG_MP0 (XI1_I1988_I94_XG_p1 I1_I1988_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I94_XG_MP1 (I1_I1988_G28_27 I1_I1988_gn27 XI1_I1988_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I92_XG_MP2 (VDD I1_I2066_gn26 I1_I2066_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I92_XG_MP0 (XI1_I2066_I92_XG_p1 I1_I2066_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I92_XG_MP1 (I1_I2066_G26_25 I1_I2066_gn25 XI1_I2066_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I93_XG_MP2 (VDD I1_I2066_gn27 I1_I2066_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I93_XG_MP0 (XI1_I2066_I93_XG_p1 I1_I2066_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I93_XG_MP1 (I1_I2066_G27_26 I1_I2066_gn26 XI1_I2066_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I155_XG_MP2 (VDD I1_I2066_G30_27n I1_I2066_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I155_XG_MP0 (XI1_I2066_I155_XG_p1 I1_I2066_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I155_XG_MP1 (I1_I2066_G30_23 I1_I2066_G26_23n XI1_I2066_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I201_XG_MP2 (VDD I1_I2066_G30_15n I1_rcm VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I201_XG_MP0 (XI1_I2066_I201_XG_p1 I1_I2066_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I201_XG_MP1 (I1_rcm I1_I2066_G14_0n XI1_I2066_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I156_XG_MP2 (VDD I1_I2066_G31_28n I1_I2066_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I156_XG_MP0 (XI1_I2066_I156_XG_p1 I1_I2066_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I156_XG_MP1 (I1_I2066_G31_24 I1_I2066_G27_24n XI1_I2066_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I200_XG_MP2 (VDD I1_I2066_G29_14n I1_I2066_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I200_XG_MP0 (XI1_I2066_I200_XG_p1 I1_I2066_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I200_XG_MP1 (I1_I2066_G29_0 I1_I2066_G13_0n XI1_I2066_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I190_XG_MP2 (VDD I0_I1660_gn60 I0_I1660_G60_59 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I190_XG_MP0 (XI0_I1660_I190_XG_p1 I0_I1660_pn60 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I190_XG_MP1 (I0_I1660_G60_59 I0_I1660_gn59 XI0_I1660_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I183_XG_MP2 (VDD I0_I1660_gn53 I0_I1660_G53_52 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I183_XG_MP0 (XI0_I1660_I183_XG_p1 I0_I1660_pn53 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I183_XG_MP1 (I0_I1660_G53_52 I0_I1660_gn52 XI0_I1660_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I95_XG_MP2 (VDD I1_I1850_gn29 I1_I1850_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I95_XG_MP0 (XI1_I1850_I95_XG_p1 I1_I1850_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I95_XG_MP1 (I1_I1850_G29_28 I1_I1850_gn28 XI1_I1850_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I94_XG_MP2 (VDD I1_I1850_gn28 I1_I1850_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I94_XG_MP0 (XI1_I1850_I94_XG_p1 I1_I1850_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I94_XG_MP1 (I1_I1850_G28_27 I1_I1850_gn27 XI1_I1850_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I94_XG_MP2 (VDD I1_I1896_gn28 I1_I1896_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I94_XG_MP0 (XI1_I1896_I94_XG_p1 I1_I1896_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I94_XG_MP1 (I1_I1896_G28_27 I1_I1896_gn27 XI1_I1896_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I95_XG_MP2 (VDD I1_I1896_gn29 I1_I1896_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I95_XG_MP0 (XI1_I1896_I95_XG_p1 I1_I1896_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I95_XG_MP1 (I1_I1896_G29_28 I1_I1896_gn28 XI1_I1896_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I97_XG_MP2 (VDD I1_I1896_gn31 I1_I1896_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I97_XG_MP0 (XI1_I1896_I97_XG_p1 I1_I1896_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I97_XG_MP1 (I1_I1896_G31_30 I1_I1896_gn30 XI1_I1896_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I96_XG_MP2 (VDD I1_I1896_gn30 I1_I1896_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I96_XG_MP0 (XI1_I1896_I96_XG_p1 I1_I1896_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I96_XG_MP1 (I1_I1896_G30_29 I1_I1896_gn29 XI1_I1896_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I95_XG_MP2 (VDD I1_I1942_gn29 I1_I1942_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I95_XG_MP0 (XI1_I1942_I95_XG_p1 I1_I1942_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I95_XG_MP1 (I1_I1942_G29_28 I1_I1942_gn28 XI1_I1942_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I97_XG_MP2 (VDD I1_I1942_gn31 I1_I1942_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I97_XG_MP0 (XI1_I1942_I97_XG_p1 I1_I1942_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I97_XG_MP1 (I1_I1942_G31_30 I1_I1942_gn30 XI1_I1942_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I96_XG_MP2 (VDD I1_I1942_gn30 I1_I1942_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I96_XG_MP0 (XI1_I1942_I96_XG_p1 I1_I1942_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I96_XG_MP1 (I1_I1942_G30_29 I1_I1942_gn29 XI1_I1942_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I97_XG_MP2 (VDD I1_I2066_gn31 I1_I2066_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I97_XG_MP0 (XI1_I2066_I97_XG_p1 I1_I2066_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I97_XG_MP1 (I1_I2066_G31_30 I1_I2066_gn30 XI1_I2066_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I96_XG_MP2 (VDD I1_I2066_gn30 I1_I2066_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I96_XG_MP0 (XI1_I2066_I96_XG_p1 I1_I2066_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I96_XG_MP1 (I1_I2066_G30_29 I1_I2066_gn29 XI1_I2066_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I95_XG_MP2 (VDD I1_I2066_gn29 I1_I2066_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I95_XG_MP0 (XI1_I2066_I95_XG_p1 I1_I2066_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I95_XG_MP1 (I1_I2066_G29_28 I1_I2066_gn28 XI1_I2066_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I94_XG_MP2 (VDD I1_I2066_gn28 I1_I2066_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I94_XG_MP0 (XI1_I2066_I94_XG_p1 I1_I2066_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I94_XG_MP1 (I1_I2066_G28_27 I1_I2066_gn27 XI1_I2066_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I192_XG_MP2 (VDD I0_I1660_gn62 I0_I1660_G62_61 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I192_XG_MP0 (XI0_I1660_I192_XG_p1 I0_I1660_pn62 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I192_XG_MP1 (I0_I1660_G62_61 I0_I1660_gn61 XI0_I1660_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I193_XG_MP2 (VDD I0_I1660_gn63 I0_I1660_G63_62 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I193_XG_MP0 (XI0_I1660_I193_XG_p1 I0_I1660_pn63 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I193_XG_MP1 (I0_I1660_G63_62 I0_I1660_gn62 XI0_I1660_I193_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I191_XG_MP2 (VDD I0_I1660_gn61 I0_I1660_G61_60 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I191_XG_MP0 (XI0_I1660_I191_XG_p1 I0_I1660_pn61 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I191_XG_MP1 (I0_I1660_G61_60 I0_I1660_gn60 XI0_I1660_I191_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I530_MP12 (VDD I0_B_1_b3_4 XI0_I530_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I530_MP18 (XI0_I530_xp1 XI0_I530_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I530_MP20 (I0_pp0_27 I0_B_1_b3_4 XI0_I530_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I530_MP19 (XI0_I530_xp1 XI0_I530_xan I0_pp0_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I530_MP17 (VDD XI0_I530_xn XI0_I530_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I530_MP6 (XI0_I530_p1 I0_A_27_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I530_MP8 (XI0_I530_xn I0_A_26_b3_0 XI0_I530_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I530_MP7 (XI0_I530_p1 I0_two0_b3_4 XI0_I530_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I530_MP5 (VDD I0_one0_b3_4 XI0_I530_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I530_MP10 (XI0_I530_xan XI0_I530_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I531_MP12 (VDD I0_B_1_b3_4 XI0_I531_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I531_MP18 (XI0_I531_xp1 XI0_I531_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I531_MP20 (I0_pp0_28 I0_B_1_b3_4 XI0_I531_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I531_MP19 (XI0_I531_xp1 XI0_I531_xan I0_pp0_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I531_MP17 (VDD XI0_I531_xn XI0_I531_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I531_MP6 (XI0_I531_p1 I0_A_28_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I531_MP8 (XI0_I531_xn I0_A_27_b3_0 XI0_I531_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I531_MP7 (XI0_I531_p1 I0_two0_b3_5 XI0_I531_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I531_MP5 (VDD I0_one0_b3_5 XI0_I531_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I531_MP10 (XI0_I531_xan XI0_I531_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I532_MP12 (VDD I0_B_1_b3_5 XI0_I532_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I532_MP18 (XI0_I532_xp1 XI0_I532_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I532_MP20 (I0_pp0_29 I0_B_1_b3_5 XI0_I532_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I532_MP19 (XI0_I532_xp1 XI0_I532_xan I0_pp0_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I532_MP17 (VDD XI0_I532_xn XI0_I532_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I532_MP6 (XI0_I532_p1 I0_A_29_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I532_MP8 (XI0_I532_xn I0_A_28_b3_0 XI0_I532_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I532_MP7 (XI0_I532_p1 I0_two0_b3_5 XI0_I532_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I532_MP5 (VDD I0_one0_b3_5 XI0_I532_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I532_MP10 (XI0_I532_xan XI0_I532_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I534_MP12 (VDD I0_B_1_b3_5 XI0_I534_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I534_MP18 (XI0_I534_xp1 XI0_I534_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I534_MP20 (I0_pp0_31 I0_B_1_b3_5 XI0_I534_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I534_MP19 (XI0_I534_xp1 XI0_I534_xan I0_pp0_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I534_MP17 (VDD XI0_I534_xn XI0_I534_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I534_MP6 (XI0_I534_p1 I0_A_31_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I534_MP8 (XI0_I534_xn I0_A_30_b3_0 XI0_I534_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I534_MP7 (XI0_I534_p1 I0_two0_b3_5 XI0_I534_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I534_MP5 (VDD I0_one0_b3_5 XI0_I534_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I534_MP10 (XI0_I534_xan XI0_I534_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I588_MP12 (VDD I0_B_3_b3_5 XI0_I588_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I588_MP18 (XI0_I588_xp1 XI0_I588_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I588_MP20 (I0_pp1_30 I0_B_3_b3_5 XI0_I588_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I588_MP19 (XI0_I588_xp1 XI0_I588_xan I0_pp1_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I588_MP17 (VDD XI0_I588_xn XI0_I588_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I588_MP6 (XI0_I588_p1 I0_A_30_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I588_MP8 (XI0_I588_xn I0_A_29_b3_0 XI0_I588_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I588_MP7 (XI0_I588_p1 I0_two1_b3_5 XI0_I588_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I588_MP5 (VDD I0_one1_b3_5 XI0_I588_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I588_MP10 (XI0_I588_xan XI0_I588_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I590_MP12 (VDD I0_B_3_b3_5 XI0_I590_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I590_MP18 (XI0_I590_xp1 XI0_I590_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I590_MP20 (I0_pp1_32 I0_B_3_b3_5 XI0_I590_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I590_MP19 (XI0_I590_xp1 XI0_I590_xan I0_pp1_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I590_MP17 (VDD XI0_I590_xn XI0_I590_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I590_MP6 (XI0_I590_p1 I0_A_31_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I590_MP8 (XI0_I590_xn I0_A_31_b3_0 XI0_I590_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I590_MP7 (XI0_I590_p1 I0_two1_b3_5 XI0_I590_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I590_MP5 (VDD I0_one1_b3_5 XI0_I590_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I590_MP10 (XI0_I590_xan XI0_I590_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I589_MP12 (VDD I0_B_3_b3_5 XI0_I589_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I589_MP18 (XI0_I589_xp1 XI0_I589_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I589_MP20 (I0_pp1_31 I0_B_3_b3_5 XI0_I589_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I589_MP19 (XI0_I589_xp1 XI0_I589_xan I0_pp1_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I589_MP17 (VDD XI0_I589_xn XI0_I589_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I589_MP6 (XI0_I589_p1 I0_A_31_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I589_MP8 (XI0_I589_xn I0_A_30_b3_0 XI0_I589_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I589_MP7 (XI0_I589_p1 I0_two1_b3_5 XI0_I589_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I589_MP5 (VDD I0_one1_b3_5 XI0_I589_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I589_MP10 (XI0_I589_xan XI0_I589_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I643_MP12 (VDD I0_B_5_b3_5 XI0_I643_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I643_MP18 (XI0_I643_xp1 XI0_I643_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I643_MP20 (I0_pp2_30 I0_B_5_b3_5 XI0_I643_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I643_MP19 (XI0_I643_xp1 XI0_I643_xan I0_pp2_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I643_MP17 (VDD XI0_I643_xn XI0_I643_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I643_MP6 (XI0_I643_p1 I0_A_30_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I643_MP8 (XI0_I643_xn I0_A_29_b3_0 XI0_I643_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I643_MP7 (XI0_I643_p1 I0_two2_b3_5 XI0_I643_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I643_MP5 (VDD I0_one2_b3_5 XI0_I643_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I643_MP10 (XI0_I643_xan XI0_I643_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I642_MP12 (VDD I0_B_5_b3_5 XI0_I642_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I642_MP18 (XI0_I642_xp1 XI0_I642_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I642_MP20 (I0_pp2_29 I0_B_5_b3_5 XI0_I642_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I642_MP19 (XI0_I642_xp1 XI0_I642_xan I0_pp2_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I642_MP17 (VDD XI0_I642_xn XI0_I642_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I642_MP6 (XI0_I642_p1 I0_A_29_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I642_MP8 (XI0_I642_xn I0_A_28_b3_0 XI0_I642_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I642_MP7 (XI0_I642_p1 I0_two2_b3_5 XI0_I642_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I642_MP5 (VDD I0_one2_b3_5 XI0_I642_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I642_MP10 (XI0_I642_xan XI0_I642_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I644_MP12 (VDD I0_B_5_b3_5 XI0_I644_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I644_MP18 (XI0_I644_xp1 XI0_I644_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I644_MP20 (I0_pp2_31 I0_B_5_b3_5 XI0_I644_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I644_MP19 (XI0_I644_xp1 XI0_I644_xan I0_pp2_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I644_MP17 (VDD XI0_I644_xn XI0_I644_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I644_MP6 (XI0_I644_p1 I0_A_31_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I644_MP8 (XI0_I644_xn I0_A_30_b3_0 XI0_I644_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I644_MP7 (XI0_I644_p1 I0_two2_b3_5 XI0_I644_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I644_MP5 (VDD I0_one2_b3_5 XI0_I644_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I644_MP10 (XI0_I644_xan XI0_I644_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I645_MP12 (VDD I0_B_5_b3_5 XI0_I645_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I645_MP18 (XI0_I645_xp1 XI0_I645_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I645_MP20 (I0_pp2_32 I0_B_5_b3_5 XI0_I645_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I645_MP19 (XI0_I645_xp1 XI0_I645_xan I0_pp2_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I645_MP17 (VDD XI0_I645_xn XI0_I645_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I645_MP6 (XI0_I645_p1 I0_A_31_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I645_MP8 (XI0_I645_xn I0_A_31_b3_1 XI0_I645_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I645_MP7 (XI0_I645_p1 I0_two2_b3_5 XI0_I645_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I645_MP5 (VDD I0_one2_b3_5 XI0_I645_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I645_MP10 (XI0_I645_xan XI0_I645_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I521_MP12 (VDD I0_B_1_b3_3 XI0_I521_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I521_MP18 (XI0_I521_xp1 XI0_I521_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I521_MP20 (I0_pp0_18 I0_B_1_b3_3 XI0_I521_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I521_MP19 (XI0_I521_xp1 XI0_I521_xan I0_pp0_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I521_MP17 (VDD XI0_I521_xn XI0_I521_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I521_MP6 (XI0_I521_p1 I0_A_18_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I521_MP8 (XI0_I521_xn I0_A_17_b3_0 XI0_I521_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I521_MP7 (XI0_I521_p1 I0_two0_b3_3 XI0_I521_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I521_MP5 (VDD I0_one0_b3_3 XI0_I521_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I521_MP10 (XI0_I521_xan XI0_I521_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I523_MP12 (VDD I0_B_1_b3_3 XI0_I523_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I523_MP18 (XI0_I523_xp1 XI0_I523_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I523_MP20 (I0_pp0_20 I0_B_1_b3_3 XI0_I523_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I523_MP19 (XI0_I523_xp1 XI0_I523_xan I0_pp0_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I523_MP17 (VDD XI0_I523_xn XI0_I523_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I523_MP6 (XI0_I523_p1 I0_A_20_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I523_MP8 (XI0_I523_xn I0_A_19_b3_0 XI0_I523_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I523_MP7 (XI0_I523_p1 I0_two0_b3_3 XI0_I523_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I523_MP5 (VDD I0_one0_b3_3 XI0_I523_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I523_MP10 (XI0_I523_xan XI0_I523_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I524_MP12 (VDD I0_B_1_b3_3 XI0_I524_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I524_MP18 (XI0_I524_xp1 XI0_I524_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I524_MP20 (I0_pp0_21 I0_B_1_b3_3 XI0_I524_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I524_MP19 (XI0_I524_xp1 XI0_I524_xan I0_pp0_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I524_MP17 (VDD XI0_I524_xn XI0_I524_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I524_MP6 (XI0_I524_p1 I0_A_21_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I524_MP8 (XI0_I524_xn I0_A_20_b3_0 XI0_I524_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I524_MP7 (XI0_I524_p1 I0_two0_b3_3 XI0_I524_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I524_MP5 (VDD I0_one0_b3_3 XI0_I524_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I524_MP10 (XI0_I524_xan XI0_I524_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I577_MP12 (VDD I0_B_3_b3_3 XI0_I577_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I577_MP18 (XI0_I577_xp1 XI0_I577_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I577_MP20 (I0_pp1_19 I0_B_3_b3_3 XI0_I577_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I577_MP19 (XI0_I577_xp1 XI0_I577_xan I0_pp1_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I577_MP17 (VDD XI0_I577_xn XI0_I577_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I577_MP6 (XI0_I577_p1 I0_A_19_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I577_MP8 (XI0_I577_xn I0_A_18_b3_0 XI0_I577_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I577_MP7 (XI0_I577_p1 I0_two1_b3_3 XI0_I577_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I577_MP5 (VDD I0_one1_b3_3 XI0_I577_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I577_MP10 (XI0_I577_xan XI0_I577_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I525_MP12 (VDD I0_B_1_b3_3 XI0_I525_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I525_MP18 (XI0_I525_xp1 XI0_I525_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I525_MP20 (I0_pp0_22 I0_B_1_b3_3 XI0_I525_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I525_MP19 (XI0_I525_xp1 XI0_I525_xan I0_pp0_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I525_MP17 (VDD XI0_I525_xn XI0_I525_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I525_MP6 (XI0_I525_p1 I0_A_22_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I525_MP8 (XI0_I525_xn I0_A_21_b3_0 XI0_I525_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I525_MP7 (XI0_I525_p1 I0_two0_b3_4 XI0_I525_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I525_MP5 (VDD I0_one0_b3_4 XI0_I525_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I525_MP10 (XI0_I525_xan XI0_I525_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I526_MP12 (VDD I0_B_1_b3_4 XI0_I526_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I526_MP18 (XI0_I526_xp1 XI0_I526_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I526_MP20 (I0_pp0_23 I0_B_1_b3_4 XI0_I526_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I526_MP19 (XI0_I526_xp1 XI0_I526_xan I0_pp0_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I526_MP17 (VDD XI0_I526_xn XI0_I526_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I526_MP6 (XI0_I526_p1 I0_A_23_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I526_MP8 (XI0_I526_xn I0_A_22_b3_0 XI0_I526_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I526_MP7 (XI0_I526_p1 I0_two0_b3_4 XI0_I526_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I526_MP5 (VDD I0_one0_b3_4 XI0_I526_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I526_MP10 (XI0_I526_xan XI0_I526_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I580_MP12 (VDD I0_B_3_b3_3 XI0_I580_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I580_MP18 (XI0_I580_xp1 XI0_I580_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I580_MP20 (I0_pp1_22 I0_B_3_b3_3 XI0_I580_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I580_MP19 (XI0_I580_xp1 XI0_I580_xan I0_pp1_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I580_MP17 (VDD XI0_I580_xn XI0_I580_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I580_MP6 (XI0_I580_p1 I0_A_22_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I580_MP8 (XI0_I580_xn I0_A_21_b3_0 XI0_I580_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I580_MP7 (XI0_I580_p1 I0_two1_b3_4 XI0_I580_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I580_MP5 (VDD I0_one1_b3_4 XI0_I580_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I580_MP10 (XI0_I580_xan XI0_I580_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I527_MP12 (VDD I0_B_1_b3_4 XI0_I527_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I527_MP18 (XI0_I527_xp1 XI0_I527_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I527_MP20 (I0_pp0_24 I0_B_1_b3_4 XI0_I527_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I527_MP19 (XI0_I527_xp1 XI0_I527_xan I0_pp0_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I527_MP17 (VDD XI0_I527_xn XI0_I527_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I527_MP6 (XI0_I527_p1 I0_A_24_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I527_MP8 (XI0_I527_xn I0_A_23_b3_0 XI0_I527_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I527_MP7 (XI0_I527_p1 I0_two0_b3_4 XI0_I527_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I527_MP5 (VDD I0_one0_b3_4 XI0_I527_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I527_MP10 (XI0_I527_xan XI0_I527_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I528_MP12 (VDD I0_B_1_b3_4 XI0_I528_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I528_MP18 (XI0_I528_xp1 XI0_I528_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I528_MP20 (I0_pp0_25 I0_B_1_b3_4 XI0_I528_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I528_MP19 (XI0_I528_xp1 XI0_I528_xan I0_pp0_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I528_MP17 (VDD XI0_I528_xn XI0_I528_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I528_MP6 (XI0_I528_p1 I0_A_25_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I528_MP8 (XI0_I528_xn I0_A_24_b3_0 XI0_I528_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I528_MP7 (XI0_I528_p1 I0_two0_b3_4 XI0_I528_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I528_MP5 (VDD I0_one0_b3_4 XI0_I528_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I528_MP10 (XI0_I528_xan XI0_I528_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I529_MP12 (VDD I0_B_1_b3_4 XI0_I529_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I529_MP18 (XI0_I529_xp1 XI0_I529_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I529_MP20 (I0_pp0_26 I0_B_1_b3_4 XI0_I529_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I529_MP19 (XI0_I529_xp1 XI0_I529_xan I0_pp0_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I529_MP17 (VDD XI0_I529_xn XI0_I529_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I529_MP6 (XI0_I529_p1 I0_A_26_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I529_MP8 (XI0_I529_xn I0_A_25_b3_0 XI0_I529_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I529_MP7 (XI0_I529_p1 I0_two0_b3_4 XI0_I529_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I529_MP5 (VDD I0_one0_b3_4 XI0_I529_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I529_MP10 (XI0_I529_xan XI0_I529_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I585_MP12 (VDD I0_B_3_b3_4 XI0_I585_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I585_MP18 (XI0_I585_xp1 XI0_I585_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I585_MP20 (I0_pp1_27 I0_B_3_b3_4 XI0_I585_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I585_MP19 (XI0_I585_xp1 XI0_I585_xan I0_pp1_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I585_MP17 (VDD XI0_I585_xn XI0_I585_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I585_MP6 (XI0_I585_p1 I0_A_27_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I585_MP8 (XI0_I585_xn I0_A_26_b3_0 XI0_I585_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I585_MP7 (XI0_I585_p1 I0_two1_b3_4 XI0_I585_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I585_MP5 (VDD I0_one1_b3_4 XI0_I585_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I585_MP10 (XI0_I585_xan XI0_I585_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I586_MP12 (VDD I0_B_3_b3_4 XI0_I586_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I586_MP18 (XI0_I586_xp1 XI0_I586_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I586_MP20 (I0_pp1_28 I0_B_3_b3_4 XI0_I586_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I586_MP19 (XI0_I586_xp1 XI0_I586_xan I0_pp1_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I586_MP17 (VDD XI0_I586_xn XI0_I586_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I586_MP6 (XI0_I586_p1 I0_A_28_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I586_MP8 (XI0_I586_xn I0_A_27_b3_0 XI0_I586_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I586_MP7 (XI0_I586_p1 I0_two1_b3_5 XI0_I586_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I586_MP5 (VDD I0_one1_b3_5 XI0_I586_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I586_MP10 (XI0_I586_xan XI0_I586_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I583_MP12 (VDD I0_B_3_b3_4 XI0_I583_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I583_MP18 (XI0_I583_xp1 XI0_I583_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I583_MP20 (I0_pp1_25 I0_B_3_b3_4 XI0_I583_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I583_MP19 (XI0_I583_xp1 XI0_I583_xan I0_pp1_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I583_MP17 (VDD XI0_I583_xn XI0_I583_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I583_MP6 (XI0_I583_p1 I0_A_25_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I583_MP8 (XI0_I583_xn I0_A_24_b3_0 XI0_I583_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I583_MP7 (XI0_I583_p1 I0_two1_b3_4 XI0_I583_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I583_MP5 (VDD I0_one1_b3_4 XI0_I583_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I583_MP10 (XI0_I583_xan XI0_I583_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I533_MP12 (VDD I0_B_1_b3_5 XI0_I533_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I533_MP18 (XI0_I533_xp1 XI0_I533_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I533_MP20 (I0_pp0_30 I0_B_1_b3_5 XI0_I533_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I533_MP19 (XI0_I533_xp1 XI0_I533_xan I0_pp0_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I533_MP17 (VDD XI0_I533_xn XI0_I533_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I533_MP6 (XI0_I533_p1 I0_A_30_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I533_MP8 (XI0_I533_xn I0_A_29_b3_0 XI0_I533_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I533_MP7 (XI0_I533_p1 I0_two0_b3_5 XI0_I533_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I533_MP5 (VDD I0_one0_b3_5 XI0_I533_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I533_MP10 (XI0_I533_xan XI0_I533_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I640_MP12 (VDD I0_B_5_b3_4 XI0_I640_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I640_MP18 (XI0_I640_xp1 XI0_I640_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I640_MP20 (I0_pp2_27 I0_B_5_b3_4 XI0_I640_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I640_MP19 (XI0_I640_xp1 XI0_I640_xan I0_pp2_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I640_MP17 (VDD XI0_I640_xn XI0_I640_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I640_MP6 (XI0_I640_p1 I0_A_27_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I640_MP8 (XI0_I640_xn I0_A_26_b3_0 XI0_I640_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I640_MP7 (XI0_I640_p1 I0_two2_b3_4 XI0_I640_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I640_MP5 (VDD I0_one2_b3_4 XI0_I640_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I640_MP10 (XI0_I640_xan XI0_I640_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I535_MP12 (VDD I0_B_1_b3_5 XI0_I535_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I535_MP18 (XI0_I535_xp1 XI0_I535_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I535_MP20 (I0_pp0_32 I0_B_1_b3_5 XI0_I535_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I535_MP19 (XI0_I535_xp1 XI0_I535_xan I0_pp0_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I535_MP17 (VDD XI0_I535_xn XI0_I535_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I535_MP6 (XI0_I535_p1 I0_A_31_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I535_MP8 (XI0_I535_xn I0_A_31_b3_0 XI0_I535_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I535_MP7 (XI0_I535_p1 I0_two0_b3_5 XI0_I535_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I535_MP5 (VDD I0_one0_b3_5 XI0_I535_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I535_MP10 (XI0_I535_xan XI0_I535_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I587_MP12 (VDD I0_B_3_b3_5 XI0_I587_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I587_MP18 (XI0_I587_xp1 XI0_I587_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I587_MP20 (I0_pp1_29 I0_B_3_b3_5 XI0_I587_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I587_MP19 (XI0_I587_xp1 XI0_I587_xan I0_pp1_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I587_MP17 (VDD XI0_I587_xn XI0_I587_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I587_MP6 (XI0_I587_p1 I0_A_29_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I587_MP8 (XI0_I587_xn I0_A_28_b3_0 XI0_I587_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I587_MP7 (XI0_I587_p1 I0_two1_b3_5 XI0_I587_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I587_MP5 (VDD I0_one1_b3_5 XI0_I587_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I587_MP10 (XI0_I587_xan XI0_I587_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I641_MP12 (VDD I0_B_5_b3_4 XI0_I641_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I641_MP18 (XI0_I641_xp1 XI0_I641_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I641_MP20 (I0_pp2_28 I0_B_5_b3_4 XI0_I641_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I641_MP19 (XI0_I641_xp1 XI0_I641_xan I0_pp2_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I641_MP17 (VDD XI0_I641_xn XI0_I641_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I641_MP6 (XI0_I641_p1 I0_A_28_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I641_MP8 (XI0_I641_xn I0_A_27_b3_0 XI0_I641_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I641_MP7 (XI0_I641_p1 I0_two2_b3_5 XI0_I641_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I641_MP5 (VDD I0_one2_b3_5 XI0_I641_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I641_MP10 (XI0_I641_xan XI0_I641_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I520_MP12 (VDD I0_B_1_b3_3 XI0_I520_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I520_MP18 (XI0_I520_xp1 XI0_I520_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I520_MP20 (I0_pp0_17 I0_B_1_b3_3 XI0_I520_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I520_MP19 (XI0_I520_xp1 XI0_I520_xan I0_pp0_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I520_MP17 (VDD XI0_I520_xn XI0_I520_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I520_MP6 (XI0_I520_p1 I0_A_17_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I520_MP8 (XI0_I520_xn I0_A_16_b3_0 XI0_I520_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I520_MP7 (XI0_I520_p1 I0_two0_b3_3 XI0_I520_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I520_MP5 (VDD I0_one0_b3_3 XI0_I520_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I520_MP10 (XI0_I520_xan XI0_I520_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I522_MP12 (VDD I0_B_1_b3_3 XI0_I522_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I522_MP18 (XI0_I522_xp1 XI0_I522_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I522_MP20 (I0_pp0_19 I0_B_1_b3_3 XI0_I522_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I522_MP19 (XI0_I522_xp1 XI0_I522_xan I0_pp0_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I522_MP17 (VDD XI0_I522_xn XI0_I522_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I522_MP6 (XI0_I522_p1 I0_A_19_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I522_MP8 (XI0_I522_xn I0_A_18_b3_0 XI0_I522_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I522_MP7 (XI0_I522_p1 I0_two0_b3_3 XI0_I522_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I522_MP5 (VDD I0_one0_b3_3 XI0_I522_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I522_MP10 (XI0_I522_xan XI0_I522_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I576_MP12 (VDD I0_B_3_b3_3 XI0_I576_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I576_MP18 (XI0_I576_xp1 XI0_I576_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I576_MP20 (I0_pp1_18 I0_B_3_b3_3 XI0_I576_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I576_MP19 (XI0_I576_xp1 XI0_I576_xan I0_pp1_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I576_MP17 (VDD XI0_I576_xn XI0_I576_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I576_MP6 (XI0_I576_p1 I0_A_18_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I576_MP8 (XI0_I576_xn I0_A_17_b3_0 XI0_I576_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I576_MP7 (XI0_I576_p1 I0_two1_b3_3 XI0_I576_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I576_MP5 (VDD I0_one1_b3_3 XI0_I576_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I576_MP10 (XI0_I576_xan XI0_I576_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I575_MP12 (VDD I0_B_3_b3_3 XI0_I575_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I575_MP18 (XI0_I575_xp1 XI0_I575_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I575_MP20 (I0_pp1_17 I0_B_3_b3_3 XI0_I575_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I575_MP19 (XI0_I575_xp1 XI0_I575_xan I0_pp1_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I575_MP17 (VDD XI0_I575_xn XI0_I575_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I575_MP6 (XI0_I575_p1 I0_A_17_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I575_MP8 (XI0_I575_xn I0_A_16_b3_0 XI0_I575_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I575_MP7 (XI0_I575_p1 I0_two1_b3_3 XI0_I575_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I575_MP5 (VDD I0_one1_b3_3 XI0_I575_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I575_MP10 (XI0_I575_xan XI0_I575_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I579_MP12 (VDD I0_B_3_b3_3 XI0_I579_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I579_MP18 (XI0_I579_xp1 XI0_I579_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I579_MP20 (I0_pp1_21 I0_B_3_b3_3 XI0_I579_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I579_MP19 (XI0_I579_xp1 XI0_I579_xan I0_pp1_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I579_MP17 (VDD XI0_I579_xn XI0_I579_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I579_MP6 (XI0_I579_p1 I0_A_21_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I579_MP8 (XI0_I579_xn I0_A_20_b3_0 XI0_I579_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I579_MP7 (XI0_I579_p1 I0_two1_b3_3 XI0_I579_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I579_MP5 (VDD I0_one1_b3_3 XI0_I579_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I579_MP10 (XI0_I579_xan XI0_I579_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I578_MP12 (VDD I0_B_3_b3_3 XI0_I578_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I578_MP18 (XI0_I578_xp1 XI0_I578_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I578_MP20 (I0_pp1_20 I0_B_3_b3_3 XI0_I578_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I578_MP19 (XI0_I578_xp1 XI0_I578_xan I0_pp1_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I578_MP17 (VDD XI0_I578_xn XI0_I578_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I578_MP6 (XI0_I578_p1 I0_A_20_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I578_MP8 (XI0_I578_xn I0_A_19_b3_0 XI0_I578_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I578_MP7 (XI0_I578_p1 I0_two1_b3_3 XI0_I578_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I578_MP5 (VDD I0_one1_b3_3 XI0_I578_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I578_MP10 (XI0_I578_xan XI0_I578_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I581_MP12 (VDD I0_B_3_b3_4 XI0_I581_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I581_MP18 (XI0_I581_xp1 XI0_I581_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I581_MP20 (I0_pp1_23 I0_B_3_b3_4 XI0_I581_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I581_MP19 (XI0_I581_xp1 XI0_I581_xan I0_pp1_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I581_MP17 (VDD XI0_I581_xn XI0_I581_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I581_MP6 (XI0_I581_p1 I0_A_23_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I581_MP8 (XI0_I581_xn I0_A_22_b3_0 XI0_I581_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I581_MP7 (XI0_I581_p1 I0_two1_b3_4 XI0_I581_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I581_MP5 (VDD I0_one1_b3_4 XI0_I581_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I581_MP10 (XI0_I581_xan XI0_I581_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I634_MP12 (VDD I0_B_5_b3_3 XI0_I634_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I634_MP18 (XI0_I634_xp1 XI0_I634_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I634_MP20 (I0_pp2_21 I0_B_5_b3_3 XI0_I634_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I634_MP19 (XI0_I634_xp1 XI0_I634_xan I0_pp2_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I634_MP17 (VDD XI0_I634_xn XI0_I634_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I634_MP6 (XI0_I634_p1 I0_A_21_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I634_MP8 (XI0_I634_xn I0_A_20_b3_0 XI0_I634_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I634_MP7 (XI0_I634_p1 I0_two2_b3_3 XI0_I634_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I634_MP5 (VDD I0_one2_b3_3 XI0_I634_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I634_MP10 (XI0_I634_xan XI0_I634_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I582_MP12 (VDD I0_B_3_b3_4 XI0_I582_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I582_MP18 (XI0_I582_xp1 XI0_I582_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I582_MP20 (I0_pp1_24 I0_B_3_b3_4 XI0_I582_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I582_MP19 (XI0_I582_xp1 XI0_I582_xan I0_pp1_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I582_MP17 (VDD XI0_I582_xn XI0_I582_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I582_MP6 (XI0_I582_p1 I0_A_24_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I582_MP8 (XI0_I582_xn I0_A_23_b3_0 XI0_I582_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I582_MP7 (XI0_I582_p1 I0_two1_b3_4 XI0_I582_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I582_MP5 (VDD I0_one1_b3_4 XI0_I582_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I582_MP10 (XI0_I582_xan XI0_I582_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I638_MP12 (VDD I0_B_5_b3_4 XI0_I638_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I638_MP18 (XI0_I638_xp1 XI0_I638_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I638_MP20 (I0_pp2_25 I0_B_5_b3_4 XI0_I638_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I638_MP19 (XI0_I638_xp1 XI0_I638_xan I0_pp2_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I638_MP17 (VDD XI0_I638_xn XI0_I638_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I638_MP6 (XI0_I638_p1 I0_A_25_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I638_MP8 (XI0_I638_xn I0_A_24_b3_0 XI0_I638_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I638_MP7 (XI0_I638_p1 I0_two2_b3_4 XI0_I638_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I638_MP5 (VDD I0_one2_b3_4 XI0_I638_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I638_MP10 (XI0_I638_xan XI0_I638_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I636_MP12 (VDD I0_B_5_b3_4 XI0_I636_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I636_MP18 (XI0_I636_xp1 XI0_I636_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I636_MP20 (I0_pp2_23 I0_B_5_b3_4 XI0_I636_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I636_MP19 (XI0_I636_xp1 XI0_I636_xan I0_pp2_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I636_MP17 (VDD XI0_I636_xn XI0_I636_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I636_MP6 (XI0_I636_p1 I0_A_23_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I636_MP8 (XI0_I636_xn I0_A_22_b3_0 XI0_I636_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I636_MP7 (XI0_I636_p1 I0_two2_b3_4 XI0_I636_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I636_MP5 (VDD I0_one2_b3_4 XI0_I636_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I636_MP10 (XI0_I636_xan XI0_I636_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I584_MP12 (VDD I0_B_3_b3_4 XI0_I584_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I584_MP18 (XI0_I584_xp1 XI0_I584_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I584_MP20 (I0_pp1_26 I0_B_3_b3_4 XI0_I584_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I584_MP19 (XI0_I584_xp1 XI0_I584_xan I0_pp1_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I584_MP17 (VDD XI0_I584_xn XI0_I584_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I584_MP6 (XI0_I584_p1 I0_A_26_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I584_MP8 (XI0_I584_xn I0_A_25_b3_0 XI0_I584_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I584_MP7 (XI0_I584_p1 I0_two1_b3_4 XI0_I584_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I584_MP5 (VDD I0_one1_b3_4 XI0_I584_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I584_MP10 (XI0_I584_xan XI0_I584_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I639_MP12 (VDD I0_B_5_b3_4 XI0_I639_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I639_MP18 (XI0_I639_xp1 XI0_I639_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I639_MP20 (I0_pp2_26 I0_B_5_b3_4 XI0_I639_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I639_MP19 (XI0_I639_xp1 XI0_I639_xan I0_pp2_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I639_MP17 (VDD XI0_I639_xn XI0_I639_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I639_MP6 (XI0_I639_p1 I0_A_26_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I639_MP8 (XI0_I639_xn I0_A_25_b3_0 XI0_I639_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I639_MP7 (XI0_I639_p1 I0_two2_b3_4 XI0_I639_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I639_MP5 (VDD I0_one2_b3_4 XI0_I639_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I639_MP10 (XI0_I639_xan XI0_I639_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I637_MP12 (VDD I0_B_5_b3_4 XI0_I637_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I637_MP18 (XI0_I637_xp1 XI0_I637_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I637_MP20 (I0_pp2_24 I0_B_5_b3_4 XI0_I637_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I637_MP19 (XI0_I637_xp1 XI0_I637_xan I0_pp2_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I637_MP17 (VDD XI0_I637_xn XI0_I637_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I637_MP6 (XI0_I637_p1 I0_A_24_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I637_MP8 (XI0_I637_xn I0_A_23_b3_0 XI0_I637_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I637_MP7 (XI0_I637_p1 I0_two2_b3_4 XI0_I637_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I637_MP5 (VDD I0_one2_b3_4 XI0_I637_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I637_MP10 (XI0_I637_xan XI0_I637_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I696_MP12 (VDD I0_B_7_b3_4 XI0_I696_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I696_MP18 (XI0_I696_xp1 XI0_I696_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I696_MP20 (I0_pp3_28 I0_B_7_b3_4 XI0_I696_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I696_MP19 (XI0_I696_xp1 XI0_I696_xan I0_pp3_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I696_MP17 (VDD XI0_I696_xn XI0_I696_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I696_MP6 (XI0_I696_p1 I0_A_28_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I696_MP8 (XI0_I696_xn I0_A_27_b3_1 XI0_I696_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I696_MP7 (XI0_I696_p1 I0_two3_b3_5 XI0_I696_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I696_MP5 (VDD I0_one3_b3_5 XI0_I696_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I696_MP10 (XI0_I696_xan XI0_I696_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I697_MP12 (VDD I0_B_7_b3_5 XI0_I697_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I697_MP18 (XI0_I697_xp1 XI0_I697_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I697_MP20 (I0_pp3_29 I0_B_7_b3_5 XI0_I697_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I697_MP19 (XI0_I697_xp1 XI0_I697_xan I0_pp3_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I697_MP17 (VDD XI0_I697_xn XI0_I697_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I697_MP6 (XI0_I697_p1 I0_A_29_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I697_MP8 (XI0_I697_xn I0_A_28_b3_1 XI0_I697_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I697_MP7 (XI0_I697_p1 I0_two3_b3_5 XI0_I697_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I697_MP5 (VDD I0_one3_b3_5 XI0_I697_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I697_MP10 (XI0_I697_xan XI0_I697_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I700_MP12 (VDD I0_B_7_b3_5 XI0_I700_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I700_MP18 (XI0_I700_xp1 XI0_I700_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I700_MP20 (I0_pp3_32 I0_B_7_b3_5 XI0_I700_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I700_MP19 (XI0_I700_xp1 XI0_I700_xan I0_pp3_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I700_MP17 (VDD XI0_I700_xn XI0_I700_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I700_MP6 (XI0_I700_p1 I0_A_31_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I700_MP8 (XI0_I700_xn I0_A_31_b3_1 XI0_I700_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I700_MP7 (XI0_I700_p1 I0_two3_b3_5 XI0_I700_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I700_MP5 (VDD I0_one3_b3_5 XI0_I700_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I700_MP10 (XI0_I700_xan XI0_I700_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I699_MP12 (VDD I0_B_7_b3_5 XI0_I699_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I699_MP18 (XI0_I699_xp1 XI0_I699_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I699_MP20 (I0_pp3_31 I0_B_7_b3_5 XI0_I699_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I699_MP19 (XI0_I699_xp1 XI0_I699_xan I0_pp3_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I699_MP17 (VDD XI0_I699_xn XI0_I699_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I699_MP6 (XI0_I699_p1 I0_A_31_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I699_MP8 (XI0_I699_xn I0_A_30_b3_1 XI0_I699_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I699_MP7 (XI0_I699_p1 I0_two3_b3_5 XI0_I699_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I699_MP5 (VDD I0_one3_b3_5 XI0_I699_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I699_MP10 (XI0_I699_xan XI0_I699_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I698_MP12 (VDD I0_B_7_b3_5 XI0_I698_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I698_MP18 (XI0_I698_xp1 XI0_I698_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I698_MP20 (I0_pp3_30 I0_B_7_b3_5 XI0_I698_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I698_MP19 (XI0_I698_xp1 XI0_I698_xan I0_pp3_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I698_MP17 (VDD XI0_I698_xn XI0_I698_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I698_MP6 (XI0_I698_p1 I0_A_30_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I698_MP8 (XI0_I698_xn I0_A_29_b3_1 XI0_I698_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I698_MP7 (XI0_I698_p1 I0_two3_b3_5 XI0_I698_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I698_MP5 (VDD I0_one3_b3_5 XI0_I698_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I698_MP10 (XI0_I698_xan XI0_I698_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I574_MP12 (VDD I0_B_3_b3_2 XI0_I574_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I574_MP18 (XI0_I574_xp1 XI0_I574_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I574_MP20 (I0_pp1_16 I0_B_3_b3_2 XI0_I574_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I574_MP19 (XI0_I574_xp1 XI0_I574_xan I0_pp1_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I574_MP17 (VDD XI0_I574_xn XI0_I574_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I574_MP6 (XI0_I574_p1 I0_A_16_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I574_MP8 (XI0_I574_xn I0_A_15_b3_0 XI0_I574_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I574_MP7 (XI0_I574_p1 I0_two1_b3_2 XI0_I574_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I574_MP5 (VDD I0_one1_b3_2 XI0_I574_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I574_MP10 (XI0_I574_xan XI0_I574_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I629_MP12 (VDD I0_B_5_b3_2 XI0_I629_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I629_MP18 (XI0_I629_xp1 XI0_I629_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I629_MP20 (I0_pp2_16 I0_B_5_b3_2 XI0_I629_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I629_MP19 (XI0_I629_xp1 XI0_I629_xan I0_pp2_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I629_MP17 (VDD XI0_I629_xn XI0_I629_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I629_MP6 (XI0_I629_p1 I0_A_16_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I629_MP8 (XI0_I629_xn I0_A_15_b3_0 XI0_I629_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I629_MP7 (XI0_I629_p1 I0_two2_b3_2 XI0_I629_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I629_MP5 (VDD I0_one2_b3_2 XI0_I629_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I629_MP10 (XI0_I629_xan XI0_I629_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I632_MP12 (VDD I0_B_5_b3_3 XI0_I632_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I632_MP18 (XI0_I632_xp1 XI0_I632_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I632_MP20 (I0_pp2_19 I0_B_5_b3_3 XI0_I632_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I632_MP19 (XI0_I632_xp1 XI0_I632_xan I0_pp2_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I632_MP17 (VDD XI0_I632_xn XI0_I632_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I632_MP6 (XI0_I632_p1 I0_A_19_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I632_MP8 (XI0_I632_xn I0_A_18_b3_0 XI0_I632_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I632_MP7 (XI0_I632_p1 I0_two2_b3_3 XI0_I632_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I632_MP5 (VDD I0_one2_b3_3 XI0_I632_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I632_MP10 (XI0_I632_xan XI0_I632_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I631_MP12 (VDD I0_B_5_b3_3 XI0_I631_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I631_MP18 (XI0_I631_xp1 XI0_I631_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I631_MP20 (I0_pp2_18 I0_B_5_b3_3 XI0_I631_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I631_MP19 (XI0_I631_xp1 XI0_I631_xan I0_pp2_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I631_MP17 (VDD XI0_I631_xn XI0_I631_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I631_MP6 (XI0_I631_p1 I0_A_18_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I631_MP8 (XI0_I631_xn I0_A_17_b3_0 XI0_I631_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I631_MP7 (XI0_I631_p1 I0_two2_b3_3 XI0_I631_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I631_MP5 (VDD I0_one2_b3_3 XI0_I631_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I631_MP10 (XI0_I631_xan XI0_I631_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I630_MP12 (VDD I0_B_5_b3_3 XI0_I630_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I630_MP18 (XI0_I630_xp1 XI0_I630_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I630_MP20 (I0_pp2_17 I0_B_5_b3_3 XI0_I630_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I630_MP19 (XI0_I630_xp1 XI0_I630_xan I0_pp2_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I630_MP17 (VDD XI0_I630_xn XI0_I630_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I630_MP6 (XI0_I630_p1 I0_A_17_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I630_MP8 (XI0_I630_xn I0_A_16_b3_0 XI0_I630_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I630_MP7 (XI0_I630_p1 I0_two2_b3_3 XI0_I630_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I630_MP5 (VDD I0_one2_b3_3 XI0_I630_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I630_MP10 (XI0_I630_xan XI0_I630_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I633_MP12 (VDD I0_B_5_b3_3 XI0_I633_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I633_MP18 (XI0_I633_xp1 XI0_I633_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I633_MP20 (I0_pp2_20 I0_B_5_b3_3 XI0_I633_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I633_MP19 (XI0_I633_xp1 XI0_I633_xan I0_pp2_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I633_MP17 (VDD XI0_I633_xn XI0_I633_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I633_MP6 (XI0_I633_p1 I0_A_20_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I633_MP8 (XI0_I633_xn I0_A_19_b3_0 XI0_I633_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I633_MP7 (XI0_I633_p1 I0_two2_b3_3 XI0_I633_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I633_MP5 (VDD I0_one2_b3_3 XI0_I633_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I633_MP10 (XI0_I633_xan XI0_I633_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I635_MP12 (VDD I0_B_5_b3_3 XI0_I635_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I635_MP18 (XI0_I635_xp1 XI0_I635_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I635_MP20 (I0_pp2_22 I0_B_5_b3_3 XI0_I635_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I635_MP19 (XI0_I635_xp1 XI0_I635_xan I0_pp2_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I635_MP17 (VDD XI0_I635_xn XI0_I635_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I635_MP6 (XI0_I635_p1 I0_A_22_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I635_MP8 (XI0_I635_xn I0_A_21_b3_0 XI0_I635_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I635_MP7 (XI0_I635_p1 I0_two2_b3_4 XI0_I635_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I635_MP5 (VDD I0_one2_b3_4 XI0_I635_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I635_MP10 (XI0_I635_xan XI0_I635_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I690_MP12 (VDD I0_B_7_b3_3 XI0_I690_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I690_MP18 (XI0_I690_xp1 XI0_I690_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I690_MP20 (I0_pp3_22 I0_B_7_b3_3 XI0_I690_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I690_MP19 (XI0_I690_xp1 XI0_I690_xan I0_pp3_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I690_MP17 (VDD XI0_I690_xn XI0_I690_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I690_MP6 (XI0_I690_p1 I0_A_22_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I690_MP8 (XI0_I690_xn I0_A_21_b3_1 XI0_I690_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I690_MP7 (XI0_I690_p1 I0_two3_b3_4 XI0_I690_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I690_MP5 (VDD I0_one3_b3_4 XI0_I690_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I690_MP10 (XI0_I690_xan XI0_I690_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I745_MP12 (VDD I0_B_9_b3_3 XI0_I745_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I745_MP18 (XI0_I745_xp1 XI0_I745_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I745_MP20 (I0_pp4_22 I0_B_9_b3_3 XI0_I745_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I745_MP19 (XI0_I745_xp1 XI0_I745_xan I0_pp4_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I745_MP17 (VDD XI0_I745_xn XI0_I745_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I745_MP6 (XI0_I745_p1 I0_A_22_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I745_MP8 (XI0_I745_xn I0_A_21_b3_1 XI0_I745_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I745_MP7 (XI0_I745_p1 I0_two4_b3_4 XI0_I745_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I745_MP5 (VDD I0_one4_b3_4 XI0_I745_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I745_MP10 (XI0_I745_xan XI0_I745_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I692_MP12 (VDD I0_B_7_b3_4 XI0_I692_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I692_MP18 (XI0_I692_xp1 XI0_I692_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I692_MP20 (I0_pp3_24 I0_B_7_b3_4 XI0_I692_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I692_MP19 (XI0_I692_xp1 XI0_I692_xan I0_pp3_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I692_MP17 (VDD XI0_I692_xn XI0_I692_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I692_MP6 (XI0_I692_p1 I0_A_24_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I692_MP8 (XI0_I692_xn I0_A_23_b3_1 XI0_I692_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I692_MP7 (XI0_I692_p1 I0_two3_b3_4 XI0_I692_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I692_MP5 (VDD I0_one3_b3_4 XI0_I692_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I692_MP10 (XI0_I692_xan XI0_I692_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I693_MP12 (VDD I0_B_7_b3_4 XI0_I693_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I693_MP18 (XI0_I693_xp1 XI0_I693_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I693_MP20 (I0_pp3_25 I0_B_7_b3_4 XI0_I693_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I693_MP19 (XI0_I693_xp1 XI0_I693_xan I0_pp3_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I693_MP17 (VDD XI0_I693_xn XI0_I693_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I693_MP6 (XI0_I693_p1 I0_A_25_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I693_MP8 (XI0_I693_xn I0_A_24_b3_1 XI0_I693_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I693_MP7 (XI0_I693_p1 I0_two3_b3_4 XI0_I693_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I693_MP5 (VDD I0_one3_b3_4 XI0_I693_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I693_MP10 (XI0_I693_xan XI0_I693_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I694_MP12 (VDD I0_B_7_b3_4 XI0_I694_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I694_MP18 (XI0_I694_xp1 XI0_I694_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I694_MP20 (I0_pp3_26 I0_B_7_b3_4 XI0_I694_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I694_MP19 (XI0_I694_xp1 XI0_I694_xan I0_pp3_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I694_MP17 (VDD XI0_I694_xn XI0_I694_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I694_MP6 (XI0_I694_p1 I0_A_26_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I694_MP8 (XI0_I694_xn I0_A_25_b3_1 XI0_I694_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I694_MP7 (XI0_I694_p1 I0_two3_b3_4 XI0_I694_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I694_MP5 (VDD I0_one3_b3_4 XI0_I694_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I694_MP10 (XI0_I694_xan XI0_I694_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I695_MP12 (VDD I0_B_7_b3_4 XI0_I695_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I695_MP18 (XI0_I695_xp1 XI0_I695_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I695_MP20 (I0_pp3_27 I0_B_7_b3_4 XI0_I695_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I695_MP19 (XI0_I695_xp1 XI0_I695_xan I0_pp3_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I695_MP17 (VDD XI0_I695_xn XI0_I695_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I695_MP6 (XI0_I695_p1 I0_A_27_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I695_MP8 (XI0_I695_xn I0_A_26_b3_1 XI0_I695_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I695_MP7 (XI0_I695_p1 I0_two3_b3_4 XI0_I695_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I695_MP5 (VDD I0_one3_b3_4 XI0_I695_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I695_MP10 (XI0_I695_xan XI0_I695_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I516_MP12 (VDD I0_B_1_b3_2 XI0_I516_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I516_MP18 (XI0_I516_xp1 XI0_I516_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I516_MP20 (I0_pp0_13 I0_B_1_b3_2 XI0_I516_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I516_MP19 (XI0_I516_xp1 XI0_I516_xan I0_pp0_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I516_MP17 (VDD XI0_I516_xn XI0_I516_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I516_MP6 (XI0_I516_p1 I0_A_13_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I516_MP8 (XI0_I516_xn I0_A_12_b3_0 XI0_I516_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I516_MP7 (XI0_I516_p1 I0_two0_b3_2 XI0_I516_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I516_MP5 (VDD I0_one0_b3_2 XI0_I516_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I516_MP10 (XI0_I516_xan XI0_I516_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I624_MP12 (VDD I0_B_5_b3_2 XI0_I624_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I624_MP18 (XI0_I624_xp1 XI0_I624_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I624_MP20 (I0_pp2_11 I0_B_5_b3_2 XI0_I624_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I624_MP19 (XI0_I624_xp1 XI0_I624_xan I0_pp2_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I624_MP17 (VDD XI0_I624_xn XI0_I624_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I624_MP6 (XI0_I624_p1 I0_A_11_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I624_MP8 (XI0_I624_xn I0_A_10_b3_0 XI0_I624_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I624_MP7 (XI0_I624_p1 I0_two2_b3_2 XI0_I624_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I624_MP5 (VDD I0_one2_b3_2 XI0_I624_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I624_MP10 (XI0_I624_xan XI0_I624_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I573_MP12 (VDD I0_B_3_b3_2 XI0_I573_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I573_MP18 (XI0_I573_xp1 XI0_I573_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I573_MP20 (I0_pp1_15 I0_B_3_b3_2 XI0_I573_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I573_MP19 (XI0_I573_xp1 XI0_I573_xan I0_pp1_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I573_MP17 (VDD XI0_I573_xn XI0_I573_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I573_MP6 (XI0_I573_p1 I0_A_15_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I573_MP8 (XI0_I573_xn I0_A_14_b3_0 XI0_I573_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I573_MP7 (XI0_I573_p1 I0_two1_b3_2 XI0_I573_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I573_MP5 (VDD I0_one1_b3_2 XI0_I573_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I573_MP10 (XI0_I573_xan XI0_I573_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I572_MP12 (VDD I0_B_3_b3_2 XI0_I572_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I572_MP18 (XI0_I572_xp1 XI0_I572_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I572_MP20 (I0_pp1_14 I0_B_3_b3_2 XI0_I572_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I572_MP19 (XI0_I572_xp1 XI0_I572_xan I0_pp1_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I572_MP17 (VDD XI0_I572_xn XI0_I572_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I572_MP6 (XI0_I572_p1 I0_A_14_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I572_MP8 (XI0_I572_xn I0_A_13_b3_0 XI0_I572_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I572_MP7 (XI0_I572_p1 I0_two1_b3_2 XI0_I572_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I572_MP5 (VDD I0_one1_b3_2 XI0_I572_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I572_MP10 (XI0_I572_xan XI0_I572_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I627_MP12 (VDD I0_B_5_b3_2 XI0_I627_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I627_MP18 (XI0_I627_xp1 XI0_I627_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I627_MP20 (I0_pp2_14 I0_B_5_b3_2 XI0_I627_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I627_MP19 (XI0_I627_xp1 XI0_I627_xan I0_pp2_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I627_MP17 (VDD XI0_I627_xn XI0_I627_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I627_MP6 (XI0_I627_p1 I0_A_14_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I627_MP8 (XI0_I627_xn I0_A_13_b3_0 XI0_I627_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I627_MP7 (XI0_I627_p1 I0_two2_b3_2 XI0_I627_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I627_MP5 (VDD I0_one2_b3_2 XI0_I627_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I627_MP10 (XI0_I627_xan XI0_I627_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I626_MP12 (VDD I0_B_5_b3_2 XI0_I626_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I626_MP18 (XI0_I626_xp1 XI0_I626_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I626_MP20 (I0_pp2_13 I0_B_5_b3_2 XI0_I626_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I626_MP19 (XI0_I626_xp1 XI0_I626_xan I0_pp2_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I626_MP17 (VDD XI0_I626_xn XI0_I626_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I626_MP6 (XI0_I626_p1 I0_A_13_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I626_MP8 (XI0_I626_xn I0_A_12_b3_0 XI0_I626_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I626_MP7 (XI0_I626_p1 I0_two2_b3_2 XI0_I626_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I626_MP5 (VDD I0_one2_b3_2 XI0_I626_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I626_MP10 (XI0_I626_xan XI0_I626_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I628_MP12 (VDD I0_B_5_b3_2 XI0_I628_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I628_MP18 (XI0_I628_xp1 XI0_I628_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I628_MP20 (I0_pp2_15 I0_B_5_b3_2 XI0_I628_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I628_MP19 (XI0_I628_xp1 XI0_I628_xan I0_pp2_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I628_MP17 (VDD XI0_I628_xn XI0_I628_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I628_MP6 (XI0_I628_p1 I0_A_15_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I628_MP8 (XI0_I628_xn I0_A_14_b3_0 XI0_I628_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I628_MP7 (XI0_I628_p1 I0_two2_b3_2 XI0_I628_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I628_MP5 (VDD I0_one2_b3_2 XI0_I628_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I628_MP10 (XI0_I628_xan XI0_I628_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I688_MP12 (VDD I0_B_7_b3_3 XI0_I688_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I688_MP18 (XI0_I688_xp1 XI0_I688_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I688_MP20 (I0_pp3_20 I0_B_7_b3_3 XI0_I688_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I688_MP19 (XI0_I688_xp1 XI0_I688_xan I0_pp3_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I688_MP17 (VDD XI0_I688_xn XI0_I688_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I688_MP6 (XI0_I688_p1 I0_A_20_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I688_MP8 (XI0_I688_xn I0_A_19_b3_1 XI0_I688_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I688_MP7 (XI0_I688_p1 I0_two3_b3_3 XI0_I688_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I688_MP5 (VDD I0_one3_b3_3 XI0_I688_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I688_MP10 (XI0_I688_xan XI0_I688_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I689_MP12 (VDD I0_B_7_b3_3 XI0_I689_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I689_MP18 (XI0_I689_xp1 XI0_I689_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I689_MP20 (I0_pp3_21 I0_B_7_b3_3 XI0_I689_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I689_MP19 (XI0_I689_xp1 XI0_I689_xan I0_pp3_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I689_MP17 (VDD XI0_I689_xn XI0_I689_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I689_MP6 (XI0_I689_p1 I0_A_21_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I689_MP8 (XI0_I689_xn I0_A_20_b3_1 XI0_I689_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I689_MP7 (XI0_I689_p1 I0_two3_b3_3 XI0_I689_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I689_MP5 (VDD I0_one3_b3_3 XI0_I689_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I689_MP10 (XI0_I689_xan XI0_I689_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I746_MP12 (VDD I0_B_9_b3_4 XI0_I746_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I746_MP18 (XI0_I746_xp1 XI0_I746_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I746_MP20 (I0_pp4_23 I0_B_9_b3_4 XI0_I746_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I746_MP19 (XI0_I746_xp1 XI0_I746_xan I0_pp4_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I746_MP17 (VDD XI0_I746_xn XI0_I746_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I746_MP6 (XI0_I746_p1 I0_A_23_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I746_MP8 (XI0_I746_xn I0_A_22_b3_1 XI0_I746_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I746_MP7 (XI0_I746_p1 I0_two4_b3_4 XI0_I746_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I746_MP5 (VDD I0_one4_b3_4 XI0_I746_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I746_MP10 (XI0_I746_xan XI0_I746_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I691_MP12 (VDD I0_B_7_b3_4 XI0_I691_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I691_MP18 (XI0_I691_xp1 XI0_I691_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I691_MP20 (I0_pp3_23 I0_B_7_b3_4 XI0_I691_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I691_MP19 (XI0_I691_xp1 XI0_I691_xan I0_pp3_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I691_MP17 (VDD XI0_I691_xn XI0_I691_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I691_MP6 (XI0_I691_p1 I0_A_23_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I691_MP8 (XI0_I691_xn I0_A_22_b3_1 XI0_I691_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I691_MP7 (XI0_I691_p1 I0_two3_b3_4 XI0_I691_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I691_MP5 (VDD I0_one3_b3_4 XI0_I691_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I691_MP10 (XI0_I691_xan XI0_I691_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I799_MP12 (VDD I0_B_11_b3_3 XI0_I799_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I799_MP18 (XI0_I799_xp1 XI0_I799_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I799_MP20 (I0_pp5_21 I0_B_11_b3_3 XI0_I799_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I799_MP19 (XI0_I799_xp1 XI0_I799_xan I0_pp5_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I799_MP17 (VDD XI0_I799_xn XI0_I799_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I799_MP6 (XI0_I799_p1 I0_A_21_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I799_MP8 (XI0_I799_xn I0_A_20_b3_2 XI0_I799_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I799_MP7 (XI0_I799_p1 I0_two5_b3_3 XI0_I799_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I799_MP5 (VDD I0_one5_b3_3 XI0_I799_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I799_MP10 (XI0_I799_xan XI0_I799_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I747_MP12 (VDD I0_B_9_b3_4 XI0_I747_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I747_MP18 (XI0_I747_xp1 XI0_I747_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I747_MP20 (I0_pp4_24 I0_B_9_b3_4 XI0_I747_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I747_MP19 (XI0_I747_xp1 XI0_I747_xan I0_pp4_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I747_MP17 (VDD XI0_I747_xn XI0_I747_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I747_MP6 (XI0_I747_p1 I0_A_24_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I747_MP8 (XI0_I747_xn I0_A_23_b3_1 XI0_I747_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I747_MP7 (XI0_I747_p1 I0_two4_b3_4 XI0_I747_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I747_MP5 (VDD I0_one4_b3_4 XI0_I747_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I747_MP10 (XI0_I747_xan XI0_I747_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I748_MP12 (VDD I0_B_9_b3_4 XI0_I748_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I748_MP18 (XI0_I748_xp1 XI0_I748_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I748_MP20 (I0_pp4_25 I0_B_9_b3_4 XI0_I748_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I748_MP19 (XI0_I748_xp1 XI0_I748_xan I0_pp4_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I748_MP17 (VDD XI0_I748_xn XI0_I748_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I748_MP6 (XI0_I748_p1 I0_A_25_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I748_MP8 (XI0_I748_xn I0_A_24_b3_1 XI0_I748_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I748_MP7 (XI0_I748_p1 I0_two4_b3_4 XI0_I748_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I748_MP5 (VDD I0_one4_b3_4 XI0_I748_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I748_MP10 (XI0_I748_xan XI0_I748_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I750_MP12 (VDD I0_B_9_b3_4 XI0_I750_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I750_MP18 (XI0_I750_xp1 XI0_I750_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I750_MP20 (I0_pp4_27 I0_B_9_b3_4 XI0_I750_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I750_MP19 (XI0_I750_xp1 XI0_I750_xan I0_pp4_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I750_MP17 (VDD XI0_I750_xn XI0_I750_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I750_MP6 (XI0_I750_p1 I0_A_27_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I750_MP8 (XI0_I750_xn I0_A_26_b3_1 XI0_I750_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I750_MP7 (XI0_I750_p1 I0_two4_b3_4 XI0_I750_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I750_MP5 (VDD I0_one4_b3_4 XI0_I750_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I750_MP10 (XI0_I750_xan XI0_I750_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I751_MP12 (VDD I0_B_9_b3_4 XI0_I751_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I751_MP18 (XI0_I751_xp1 XI0_I751_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I751_MP20 (I0_pp4_28 I0_B_9_b3_4 XI0_I751_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I751_MP19 (XI0_I751_xp1 XI0_I751_xan I0_pp4_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I751_MP17 (VDD XI0_I751_xn XI0_I751_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I751_MP6 (XI0_I751_p1 I0_A_28_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I751_MP8 (XI0_I751_xn I0_A_27_b3_1 XI0_I751_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I751_MP7 (XI0_I751_p1 I0_two4_b3_5 XI0_I751_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I751_MP5 (VDD I0_one4_b3_5 XI0_I751_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I751_MP10 (XI0_I751_xan XI0_I751_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I752_MP12 (VDD I0_B_9_b3_5 XI0_I752_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I752_MP18 (XI0_I752_xp1 XI0_I752_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I752_MP20 (I0_pp4_29 I0_B_9_b3_5 XI0_I752_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I752_MP19 (XI0_I752_xp1 XI0_I752_xan I0_pp4_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I752_MP17 (VDD XI0_I752_xn XI0_I752_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I752_MP6 (XI0_I752_p1 I0_A_29_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I752_MP8 (XI0_I752_xn I0_A_28_b3_1 XI0_I752_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I752_MP7 (XI0_I752_p1 I0_two4_b3_5 XI0_I752_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I752_MP5 (VDD I0_one4_b3_5 XI0_I752_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I752_MP10 (XI0_I752_xan XI0_I752_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I753_MP12 (VDD I0_B_9_b3_5 XI0_I753_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I753_MP18 (XI0_I753_xp1 XI0_I753_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I753_MP20 (I0_pp4_30 I0_B_9_b3_5 XI0_I753_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I753_MP19 (XI0_I753_xp1 XI0_I753_xan I0_pp4_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I753_MP17 (VDD XI0_I753_xn XI0_I753_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I753_MP6 (XI0_I753_p1 I0_A_30_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I753_MP8 (XI0_I753_xn I0_A_29_b3_1 XI0_I753_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I753_MP7 (XI0_I753_p1 I0_two4_b3_5 XI0_I753_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I753_MP5 (VDD I0_one4_b3_5 XI0_I753_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I753_MP10 (XI0_I753_xan XI0_I753_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I754_MP12 (VDD I0_B_9_b3_5 XI0_I754_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I754_MP18 (XI0_I754_xp1 XI0_I754_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I754_MP20 (I0_pp4_31 I0_B_9_b3_5 XI0_I754_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I754_MP19 (XI0_I754_xp1 XI0_I754_xan I0_pp4_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I754_MP17 (VDD XI0_I754_xn XI0_I754_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I754_MP6 (XI0_I754_p1 I0_A_31_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I754_MP8 (XI0_I754_xn I0_A_30_b3_1 XI0_I754_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I754_MP7 (XI0_I754_p1 I0_two4_b3_5 XI0_I754_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I754_MP5 (VDD I0_one4_b3_5 XI0_I754_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I754_MP10 (XI0_I754_xan XI0_I754_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I755_MP12 (VDD I0_B_9_b3_5 XI0_I755_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I755_MP18 (XI0_I755_xp1 XI0_I755_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I755_MP20 (I0_pp4_32 I0_B_9_b3_5 XI0_I755_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I755_MP19 (XI0_I755_xp1 XI0_I755_xan I0_pp4_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I755_MP17 (VDD XI0_I755_xn XI0_I755_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I755_MP6 (XI0_I755_p1 I0_A_31_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I755_MP8 (XI0_I755_xn I0_A_31_b3_2 XI0_I755_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I755_MP7 (XI0_I755_p1 I0_two4_b3_5 XI0_I755_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I755_MP5 (VDD I0_one4_b3_5 XI0_I755_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I755_MP10 (XI0_I755_xan XI0_I755_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I569_MP12 (VDD I0_B_3_b3_2 XI0_I569_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I569_MP18 (XI0_I569_xp1 XI0_I569_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I569_MP20 (I0_pp1_11 I0_B_3_b3_2 XI0_I569_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I569_MP19 (XI0_I569_xp1 XI0_I569_xan I0_pp1_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I569_MP17 (VDD XI0_I569_xn XI0_I569_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I569_MP6 (XI0_I569_p1 I0_A_11_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I569_MP8 (XI0_I569_xn I0_A_10_b3_0 XI0_I569_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I569_MP7 (XI0_I569_p1 I0_two1_b3_2 XI0_I569_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I569_MP5 (VDD I0_one1_b3_2 XI0_I569_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I569_MP10 (XI0_I569_xan XI0_I569_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I515_MP12 (VDD I0_B_1_b3_2 XI0_I515_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I515_MP18 (XI0_I515_xp1 XI0_I515_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I515_MP20 (I0_pp0_12 I0_B_1_b3_2 XI0_I515_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I515_MP19 (XI0_I515_xp1 XI0_I515_xan I0_pp0_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I515_MP17 (VDD XI0_I515_xn XI0_I515_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I515_MP6 (XI0_I515_p1 I0_A_12_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I515_MP8 (XI0_I515_xn I0_A_11_b3_0 XI0_I515_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I515_MP7 (XI0_I515_p1 I0_two0_b3_2 XI0_I515_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I515_MP5 (VDD I0_one0_b3_2 XI0_I515_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I515_MP10 (XI0_I515_xan XI0_I515_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I514_MP12 (VDD I0_B_1_b3_2 XI0_I514_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I514_MP18 (XI0_I514_xp1 XI0_I514_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I514_MP20 (I0_pp0_11 I0_B_1_b3_2 XI0_I514_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I514_MP19 (XI0_I514_xp1 XI0_I514_xan I0_pp0_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I514_MP17 (VDD XI0_I514_xn XI0_I514_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I514_MP6 (XI0_I514_p1 I0_A_11_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I514_MP8 (XI0_I514_xn I0_A_10_b3_0 XI0_I514_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I514_MP7 (XI0_I514_p1 I0_two0_b3_2 XI0_I514_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I514_MP5 (VDD I0_one0_b3_2 XI0_I514_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I514_MP10 (XI0_I514_xan XI0_I514_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I517_MP12 (VDD I0_B_1_b3_2 XI0_I517_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I517_MP18 (XI0_I517_xp1 XI0_I517_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I517_MP20 (I0_pp0_14 I0_B_1_b3_2 XI0_I517_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I517_MP19 (XI0_I517_xp1 XI0_I517_xan I0_pp0_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I517_MP17 (VDD XI0_I517_xn XI0_I517_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I517_MP6 (XI0_I517_p1 I0_A_14_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I517_MP8 (XI0_I517_xn I0_A_13_b3_0 XI0_I517_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I517_MP7 (XI0_I517_p1 I0_two0_b3_2 XI0_I517_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I517_MP5 (VDD I0_one0_b3_2 XI0_I517_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I517_MP10 (XI0_I517_xan XI0_I517_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I571_MP12 (VDD I0_B_3_b3_2 XI0_I571_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I571_MP18 (XI0_I571_xp1 XI0_I571_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I571_MP20 (I0_pp1_13 I0_B_3_b3_2 XI0_I571_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I571_MP19 (XI0_I571_xp1 XI0_I571_xan I0_pp1_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I571_MP17 (VDD XI0_I571_xn XI0_I571_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I571_MP6 (XI0_I571_p1 I0_A_13_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I571_MP8 (XI0_I571_xn I0_A_12_b3_0 XI0_I571_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I571_MP7 (XI0_I571_p1 I0_two1_b3_2 XI0_I571_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I571_MP5 (VDD I0_one1_b3_2 XI0_I571_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I571_MP10 (XI0_I571_xan XI0_I571_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I518_MP12 (VDD I0_B_1_b3_2 XI0_I518_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I518_MP18 (XI0_I518_xp1 XI0_I518_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I518_MP20 (I0_pp0_15 I0_B_1_b3_2 XI0_I518_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I518_MP19 (XI0_I518_xp1 XI0_I518_xan I0_pp0_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I518_MP17 (VDD XI0_I518_xn XI0_I518_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I518_MP6 (XI0_I518_p1 I0_A_15_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I518_MP8 (XI0_I518_xn I0_A_14_b3_0 XI0_I518_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I518_MP7 (XI0_I518_p1 I0_two0_b3_2 XI0_I518_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I518_MP5 (VDD I0_one0_b3_2 XI0_I518_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I518_MP10 (XI0_I518_xan XI0_I518_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I570_MP12 (VDD I0_B_3_b3_2 XI0_I570_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I570_MP18 (XI0_I570_xp1 XI0_I570_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I570_MP20 (I0_pp1_12 I0_B_3_b3_2 XI0_I570_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I570_MP19 (XI0_I570_xp1 XI0_I570_xan I0_pp1_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I570_MP17 (VDD XI0_I570_xn XI0_I570_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I570_MP6 (XI0_I570_p1 I0_A_12_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I570_MP8 (XI0_I570_xn I0_A_11_b3_0 XI0_I570_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I570_MP7 (XI0_I570_p1 I0_two1_b3_2 XI0_I570_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I570_MP5 (VDD I0_one1_b3_2 XI0_I570_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I570_MP10 (XI0_I570_xan XI0_I570_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I625_MP12 (VDD I0_B_5_b3_2 XI0_I625_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I625_MP18 (XI0_I625_xp1 XI0_I625_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I625_MP20 (I0_pp2_12 I0_B_5_b3_2 XI0_I625_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I625_MP19 (XI0_I625_xp1 XI0_I625_xan I0_pp2_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I625_MP17 (VDD XI0_I625_xn XI0_I625_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I625_MP6 (XI0_I625_p1 I0_A_12_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I625_MP8 (XI0_I625_xn I0_A_11_b3_0 XI0_I625_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I625_MP7 (XI0_I625_p1 I0_two2_b3_2 XI0_I625_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I625_MP5 (VDD I0_one2_b3_2 XI0_I625_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I625_MP10 (XI0_I625_xan XI0_I625_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I679_MP12 (VDD I0_B_7_b3_2 XI0_I679_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I679_MP18 (XI0_I679_xp1 XI0_I679_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I679_MP20 (I0_pp3_11 I0_B_7_b3_2 XI0_I679_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I679_MP19 (XI0_I679_xp1 XI0_I679_xan I0_pp3_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I679_MP17 (VDD XI0_I679_xn XI0_I679_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I679_MP6 (XI0_I679_p1 I0_A_11_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I679_MP8 (XI0_I679_xn I0_A_10_b3_1 XI0_I679_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I679_MP7 (XI0_I679_p1 I0_two3_b3_2 XI0_I679_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I679_MP5 (VDD I0_one3_b3_2 XI0_I679_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I679_MP10 (XI0_I679_xan XI0_I679_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I680_MP12 (VDD I0_B_7_b3_2 XI0_I680_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I680_MP18 (XI0_I680_xp1 XI0_I680_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I680_MP20 (I0_pp3_12 I0_B_7_b3_2 XI0_I680_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I680_MP19 (XI0_I680_xp1 XI0_I680_xan I0_pp3_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I680_MP17 (VDD XI0_I680_xn XI0_I680_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I680_MP6 (XI0_I680_p1 I0_A_12_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I680_MP8 (XI0_I680_xn I0_A_11_b3_1 XI0_I680_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I680_MP7 (XI0_I680_p1 I0_two3_b3_2 XI0_I680_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I680_MP5 (VDD I0_one3_b3_2 XI0_I680_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I680_MP10 (XI0_I680_xan XI0_I680_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I682_MP12 (VDD I0_B_7_b3_2 XI0_I682_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I682_MP18 (XI0_I682_xp1 XI0_I682_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I682_MP20 (I0_pp3_14 I0_B_7_b3_2 XI0_I682_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I682_MP19 (XI0_I682_xp1 XI0_I682_xan I0_pp3_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I682_MP17 (VDD XI0_I682_xn XI0_I682_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I682_MP6 (XI0_I682_p1 I0_A_14_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I682_MP8 (XI0_I682_xn I0_A_13_b3_1 XI0_I682_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I682_MP7 (XI0_I682_p1 I0_two3_b3_2 XI0_I682_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I682_MP5 (VDD I0_one3_b3_2 XI0_I682_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I682_MP10 (XI0_I682_xan XI0_I682_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I681_MP12 (VDD I0_B_7_b3_2 XI0_I681_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I681_MP18 (XI0_I681_xp1 XI0_I681_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I681_MP20 (I0_pp3_13 I0_B_7_b3_2 XI0_I681_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I681_MP19 (XI0_I681_xp1 XI0_I681_xan I0_pp3_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I681_MP17 (VDD XI0_I681_xn XI0_I681_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I681_MP6 (XI0_I681_p1 I0_A_13_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I681_MP8 (XI0_I681_xn I0_A_12_b3_1 XI0_I681_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I681_MP7 (XI0_I681_p1 I0_two3_b3_2 XI0_I681_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I681_MP5 (VDD I0_one3_b3_2 XI0_I681_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I681_MP10 (XI0_I681_xan XI0_I681_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I683_MP12 (VDD I0_B_7_b3_2 XI0_I683_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I683_MP18 (XI0_I683_xp1 XI0_I683_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I683_MP20 (I0_pp3_15 I0_B_7_b3_2 XI0_I683_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I683_MP19 (XI0_I683_xp1 XI0_I683_xan I0_pp3_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I683_MP17 (VDD XI0_I683_xn XI0_I683_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I683_MP6 (XI0_I683_p1 I0_A_15_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I683_MP8 (XI0_I683_xn I0_A_14_b3_1 XI0_I683_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I683_MP7 (XI0_I683_p1 I0_two3_b3_2 XI0_I683_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I683_MP5 (VDD I0_one3_b3_2 XI0_I683_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I683_MP10 (XI0_I683_xan XI0_I683_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I684_MP12 (VDD I0_B_7_b3_2 XI0_I684_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I684_MP18 (XI0_I684_xp1 XI0_I684_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I684_MP20 (I0_pp3_16 I0_B_7_b3_2 XI0_I684_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I684_MP19 (XI0_I684_xp1 XI0_I684_xan I0_pp3_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I684_MP17 (VDD XI0_I684_xn XI0_I684_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I684_MP6 (XI0_I684_p1 I0_A_16_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I684_MP8 (XI0_I684_xn I0_A_15_b3_1 XI0_I684_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I684_MP7 (XI0_I684_p1 I0_two3_b3_2 XI0_I684_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I684_MP5 (VDD I0_one3_b3_2 XI0_I684_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I684_MP10 (XI0_I684_xan XI0_I684_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I687_MP12 (VDD I0_B_7_b3_3 XI0_I687_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I687_MP18 (XI0_I687_xp1 XI0_I687_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I687_MP20 (I0_pp3_19 I0_B_7_b3_3 XI0_I687_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I687_MP19 (XI0_I687_xp1 XI0_I687_xan I0_pp3_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I687_MP17 (VDD XI0_I687_xn XI0_I687_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I687_MP6 (XI0_I687_p1 I0_A_19_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I687_MP8 (XI0_I687_xn I0_A_18_b3_1 XI0_I687_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I687_MP7 (XI0_I687_p1 I0_two3_b3_3 XI0_I687_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I687_MP5 (VDD I0_one3_b3_3 XI0_I687_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I687_MP10 (XI0_I687_xan XI0_I687_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I685_MP12 (VDD I0_B_7_b3_3 XI0_I685_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I685_MP18 (XI0_I685_xp1 XI0_I685_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I685_MP20 (I0_pp3_17 I0_B_7_b3_3 XI0_I685_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I685_MP19 (XI0_I685_xp1 XI0_I685_xan I0_pp3_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I685_MP17 (VDD XI0_I685_xn XI0_I685_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I685_MP6 (XI0_I685_p1 I0_A_17_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I685_MP8 (XI0_I685_xn I0_A_16_b3_1 XI0_I685_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I685_MP7 (XI0_I685_p1 I0_two3_b3_3 XI0_I685_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I685_MP5 (VDD I0_one3_b3_3 XI0_I685_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I685_MP10 (XI0_I685_xan XI0_I685_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I686_MP12 (VDD I0_B_7_b3_3 XI0_I686_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I686_MP18 (XI0_I686_xp1 XI0_I686_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I686_MP20 (I0_pp3_18 I0_B_7_b3_3 XI0_I686_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I686_MP19 (XI0_I686_xp1 XI0_I686_xan I0_pp3_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I686_MP17 (VDD XI0_I686_xn XI0_I686_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I686_MP6 (XI0_I686_p1 I0_A_18_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I686_MP8 (XI0_I686_xn I0_A_17_b3_1 XI0_I686_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I686_MP7 (XI0_I686_p1 I0_two3_b3_3 XI0_I686_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I686_MP5 (VDD I0_one3_b3_3 XI0_I686_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I686_MP10 (XI0_I686_xan XI0_I686_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I744_MP12 (VDD I0_B_9_b3_3 XI0_I744_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I744_MP18 (XI0_I744_xp1 XI0_I744_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I744_MP20 (I0_pp4_21 I0_B_9_b3_3 XI0_I744_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I744_MP19 (XI0_I744_xp1 XI0_I744_xan I0_pp4_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I744_MP17 (VDD XI0_I744_xn XI0_I744_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I744_MP6 (XI0_I744_p1 I0_A_21_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I744_MP8 (XI0_I744_xn I0_A_20_b3_1 XI0_I744_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I744_MP7 (XI0_I744_p1 I0_two4_b3_3 XI0_I744_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I744_MP5 (VDD I0_one4_b3_3 XI0_I744_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I744_MP10 (XI0_I744_xan XI0_I744_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I795_MP12 (VDD I0_B_11_b3_3 XI0_I795_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I795_MP18 (XI0_I795_xp1 XI0_I795_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I795_MP20 (I0_pp5_17 I0_B_11_b3_3 XI0_I795_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I795_MP19 (XI0_I795_xp1 XI0_I795_xan I0_pp5_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I795_MP17 (VDD XI0_I795_xn XI0_I795_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I795_MP6 (XI0_I795_p1 I0_A_17_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I795_MP8 (XI0_I795_xn I0_A_16_b3_2 XI0_I795_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I795_MP7 (XI0_I795_p1 I0_two5_b3_3 XI0_I795_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I795_MP5 (VDD I0_one5_b3_3 XI0_I795_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I795_MP10 (XI0_I795_xan XI0_I795_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I798_MP12 (VDD I0_B_11_b3_3 XI0_I798_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I798_MP18 (XI0_I798_xp1 XI0_I798_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I798_MP20 (I0_pp5_20 I0_B_11_b3_3 XI0_I798_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I798_MP19 (XI0_I798_xp1 XI0_I798_xan I0_pp5_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I798_MP17 (VDD XI0_I798_xn XI0_I798_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I798_MP6 (XI0_I798_p1 I0_A_20_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I798_MP8 (XI0_I798_xn I0_A_19_b3_2 XI0_I798_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I798_MP7 (XI0_I798_p1 I0_two5_b3_3 XI0_I798_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I798_MP5 (VDD I0_one5_b3_3 XI0_I798_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I798_MP10 (XI0_I798_xan XI0_I798_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I851_MP12 (VDD I0_B_13_b3_3 XI0_I851_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I851_MP18 (XI0_I851_xp1 XI0_I851_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I851_MP20 (I0_pp6_18 I0_B_13_b3_3 XI0_I851_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I851_MP19 (XI0_I851_xp1 XI0_I851_xan I0_pp6_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I851_MP17 (VDD XI0_I851_xn XI0_I851_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I851_MP6 (XI0_I851_p1 I0_A_18_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I851_MP8 (XI0_I851_xn I0_A_17_b3_2 XI0_I851_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I851_MP7 (XI0_I851_p1 I0_two6_b3_3 XI0_I851_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I851_MP5 (VDD I0_one6_b3_3 XI0_I851_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I851_MP10 (XI0_I851_xan XI0_I851_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I800_MP12 (VDD I0_B_11_b3_3 XI0_I800_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I800_MP18 (XI0_I800_xp1 XI0_I800_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I800_MP20 (I0_pp5_22 I0_B_11_b3_3 XI0_I800_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I800_MP19 (XI0_I800_xp1 XI0_I800_xan I0_pp5_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I800_MP17 (VDD XI0_I800_xn XI0_I800_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I800_MP6 (XI0_I800_p1 I0_A_22_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I800_MP8 (XI0_I800_xn I0_A_21_b3_2 XI0_I800_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I800_MP7 (XI0_I800_p1 I0_two5_b3_4 XI0_I800_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I800_MP5 (VDD I0_one5_b3_4 XI0_I800_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I800_MP10 (XI0_I800_xan XI0_I800_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I853_MP12 (VDD I0_B_13_b3_3 XI0_I853_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I853_MP18 (XI0_I853_xp1 XI0_I853_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I853_MP20 (I0_pp6_20 I0_B_13_b3_3 XI0_I853_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I853_MP19 (XI0_I853_xp1 XI0_I853_xan I0_pp6_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I853_MP17 (VDD XI0_I853_xn XI0_I853_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I853_MP6 (XI0_I853_p1 I0_A_20_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I853_MP8 (XI0_I853_xn I0_A_19_b3_2 XI0_I853_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I853_MP7 (XI0_I853_p1 I0_two6_b3_3 XI0_I853_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I853_MP5 (VDD I0_one6_b3_3 XI0_I853_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I853_MP10 (XI0_I853_xan XI0_I853_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I905_MP12 (VDD I0_B_15_b3_3 XI0_I905_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I905_MP18 (XI0_I905_xp1 XI0_I905_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I905_MP20 (I0_pp7_17 I0_B_15_b3_3 XI0_I905_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I905_MP19 (XI0_I905_xp1 XI0_I905_xan I0_pp7_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I905_MP17 (VDD XI0_I905_xn XI0_I905_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I905_MP6 (XI0_I905_p1 I0_A_17_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I905_MP8 (XI0_I905_xn I0_A_16_b3_2 XI0_I905_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I905_MP7 (XI0_I905_p1 I0_two7_b3_3 XI0_I905_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I905_MP5 (VDD I0_one7_b3_3 XI0_I905_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I905_MP10 (XI0_I905_xan XI0_I905_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I801_MP12 (VDD I0_B_11_b3_4 XI0_I801_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I801_MP18 (XI0_I801_xp1 XI0_I801_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I801_MP20 (I0_pp5_23 I0_B_11_b3_4 XI0_I801_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I801_MP19 (XI0_I801_xp1 XI0_I801_xan I0_pp5_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I801_MP17 (VDD XI0_I801_xn XI0_I801_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I801_MP6 (XI0_I801_p1 I0_A_23_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I801_MP8 (XI0_I801_xn I0_A_22_b3_2 XI0_I801_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I801_MP7 (XI0_I801_p1 I0_two5_b3_4 XI0_I801_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I801_MP5 (VDD I0_one5_b3_4 XI0_I801_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I801_MP10 (XI0_I801_xan XI0_I801_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I749_MP12 (VDD I0_B_9_b3_4 XI0_I749_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I749_MP18 (XI0_I749_xp1 XI0_I749_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I749_MP20 (I0_pp4_26 I0_B_9_b3_4 XI0_I749_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I749_MP19 (XI0_I749_xp1 XI0_I749_xan I0_pp4_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I749_MP17 (VDD XI0_I749_xn XI0_I749_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I749_MP6 (XI0_I749_p1 I0_A_26_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I749_MP8 (XI0_I749_xn I0_A_25_b3_1 XI0_I749_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I749_MP7 (XI0_I749_p1 I0_two4_b3_4 XI0_I749_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I749_MP5 (VDD I0_one4_b3_4 XI0_I749_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I749_MP10 (XI0_I749_xan XI0_I749_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I804_MP12 (VDD I0_B_11_b3_4 XI0_I804_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I804_MP18 (XI0_I804_xp1 XI0_I804_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I804_MP20 (I0_pp5_26 I0_B_11_b3_4 XI0_I804_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I804_MP19 (XI0_I804_xp1 XI0_I804_xan I0_pp5_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I804_MP17 (VDD XI0_I804_xn XI0_I804_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I804_MP6 (XI0_I804_p1 I0_A_26_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I804_MP8 (XI0_I804_xn I0_A_25_b3_2 XI0_I804_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I804_MP7 (XI0_I804_p1 I0_two5_b3_4 XI0_I804_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I804_MP5 (VDD I0_one5_b3_4 XI0_I804_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I804_MP10 (XI0_I804_xan XI0_I804_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I802_MP12 (VDD I0_B_11_b3_4 XI0_I802_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I802_MP18 (XI0_I802_xp1 XI0_I802_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I802_MP20 (I0_pp5_24 I0_B_11_b3_4 XI0_I802_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I802_MP19 (XI0_I802_xp1 XI0_I802_xan I0_pp5_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I802_MP17 (VDD XI0_I802_xn XI0_I802_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I802_MP6 (XI0_I802_p1 I0_A_24_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I802_MP8 (XI0_I802_xn I0_A_23_b3_2 XI0_I802_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I802_MP7 (XI0_I802_p1 I0_two5_b3_4 XI0_I802_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I802_MP5 (VDD I0_one5_b3_4 XI0_I802_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I802_MP10 (XI0_I802_xan XI0_I802_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I805_MP12 (VDD I0_B_11_b3_4 XI0_I805_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I805_MP18 (XI0_I805_xp1 XI0_I805_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I805_MP20 (I0_pp5_27 I0_B_11_b3_4 XI0_I805_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I805_MP19 (XI0_I805_xp1 XI0_I805_xan I0_pp5_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I805_MP17 (VDD XI0_I805_xn XI0_I805_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I805_MP6 (XI0_I805_p1 I0_A_27_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I805_MP8 (XI0_I805_xn I0_A_26_b3_2 XI0_I805_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I805_MP7 (XI0_I805_p1 I0_two5_b3_4 XI0_I805_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I805_MP5 (VDD I0_one5_b3_4 XI0_I805_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I805_MP10 (XI0_I805_xan XI0_I805_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I803_MP12 (VDD I0_B_11_b3_4 XI0_I803_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I803_MP18 (XI0_I803_xp1 XI0_I803_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I803_MP20 (I0_pp5_25 I0_B_11_b3_4 XI0_I803_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I803_MP19 (XI0_I803_xp1 XI0_I803_xan I0_pp5_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I803_MP17 (VDD XI0_I803_xn XI0_I803_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I803_MP6 (XI0_I803_p1 I0_A_25_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I803_MP8 (XI0_I803_xn I0_A_24_b3_2 XI0_I803_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I803_MP7 (XI0_I803_p1 I0_two5_b3_4 XI0_I803_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I803_MP5 (VDD I0_one5_b3_4 XI0_I803_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I803_MP10 (XI0_I803_xan XI0_I803_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I806_MP12 (VDD I0_B_11_b3_4 XI0_I806_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I806_MP18 (XI0_I806_xp1 XI0_I806_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I806_MP20 (I0_pp5_28 I0_B_11_b3_4 XI0_I806_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I806_MP19 (XI0_I806_xp1 XI0_I806_xan I0_pp5_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I806_MP17 (VDD XI0_I806_xn XI0_I806_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I806_MP6 (XI0_I806_p1 I0_A_28_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I806_MP8 (XI0_I806_xn I0_A_27_b3_2 XI0_I806_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I806_MP7 (XI0_I806_p1 I0_two5_b3_5 XI0_I806_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I806_MP5 (VDD I0_one5_b3_5 XI0_I806_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I806_MP10 (XI0_I806_xan XI0_I806_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I807_MP12 (VDD I0_B_11_b3_5 XI0_I807_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I807_MP18 (XI0_I807_xp1 XI0_I807_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I807_MP20 (I0_pp5_29 I0_B_11_b3_5 XI0_I807_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I807_MP19 (XI0_I807_xp1 XI0_I807_xan I0_pp5_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I807_MP17 (VDD XI0_I807_xn XI0_I807_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I807_MP6 (XI0_I807_p1 I0_A_29_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I807_MP8 (XI0_I807_xn I0_A_28_b3_2 XI0_I807_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I807_MP7 (XI0_I807_p1 I0_two5_b3_5 XI0_I807_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I807_MP5 (VDD I0_one5_b3_5 XI0_I807_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I807_MP10 (XI0_I807_xan XI0_I807_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I810_MP12 (VDD I0_B_11_b3_5 XI0_I810_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I810_MP18 (XI0_I810_xp1 XI0_I810_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I810_MP20 (I0_pp5_32 I0_B_11_b3_5 XI0_I810_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I810_MP19 (XI0_I810_xp1 XI0_I810_xan I0_pp5_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I810_MP17 (VDD XI0_I810_xn XI0_I810_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I810_MP6 (XI0_I810_p1 I0_A_31_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I810_MP8 (XI0_I810_xn I0_A_31_b3_2 XI0_I810_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I810_MP7 (XI0_I810_p1 I0_two5_b3_5 XI0_I810_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I810_MP5 (VDD I0_one5_b3_5 XI0_I810_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I810_MP10 (XI0_I810_xan XI0_I810_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I623_MP12 (VDD I0_B_5_b3_1 XI0_I623_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I623_MP18 (XI0_I623_xp1 XI0_I623_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I623_MP20 (I0_pp2_10 I0_B_5_b3_1 XI0_I623_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I623_MP19 (XI0_I623_xp1 XI0_I623_xan I0_pp2_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I623_MP17 (VDD XI0_I623_xn XI0_I623_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I623_MP6 (XI0_I623_p1 I0_A_10_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I623_MP8 (XI0_I623_xn I0_A_9_b3_0 XI0_I623_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I623_MP7 (XI0_I623_p1 I0_two2_b3_1 XI0_I623_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I623_MP5 (VDD I0_one2_b3_1 XI0_I623_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I623_MP10 (XI0_I623_xan XI0_I623_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I519_MP12 (VDD I0_B_1_b3_2 XI0_I519_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I519_MP18 (XI0_I519_xp1 XI0_I519_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I519_MP20 (I0_pp0_16 I0_B_1_b3_2 XI0_I519_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I519_MP19 (XI0_I519_xp1 XI0_I519_xan I0_pp0_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I519_MP17 (VDD XI0_I519_xn XI0_I519_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I519_MP6 (XI0_I519_p1 I0_A_16_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I519_MP8 (XI0_I519_xn I0_A_15_b3_0 XI0_I519_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I519_MP7 (XI0_I519_p1 I0_two0_b3_2 XI0_I519_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I519_MP5 (VDD I0_one0_b3_2 XI0_I519_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I519_MP10 (XI0_I519_xan XI0_I519_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I794_MP12 (VDD I0_B_11_b3_2 XI0_I794_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I794_MP18 (XI0_I794_xp1 XI0_I794_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I794_MP20 (I0_pp5_16 I0_B_11_b3_2 XI0_I794_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I794_MP19 (XI0_I794_xp1 XI0_I794_xan I0_pp5_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I794_MP17 (VDD XI0_I794_xn XI0_I794_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I794_MP6 (XI0_I794_p1 I0_A_16_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I794_MP8 (XI0_I794_xn I0_A_15_b3_2 XI0_I794_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I794_MP7 (XI0_I794_p1 I0_two5_b3_2 XI0_I794_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I794_MP5 (VDD I0_one5_b3_2 XI0_I794_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I794_MP10 (XI0_I794_xan XI0_I794_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I900_MP12 (VDD I0_B_15_b3_2 XI0_I900_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I900_MP18 (XI0_I900_xp1 XI0_I900_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I900_MP20 (I0_pp7_12 I0_B_15_b3_2 XI0_I900_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I900_MP19 (XI0_I900_xp1 XI0_I900_xan I0_pp7_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I900_MP17 (VDD XI0_I900_xn XI0_I900_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I900_MP6 (XI0_I900_p1 I0_A_12_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I900_MP8 (XI0_I900_xn I0_A_11_b3_2 XI0_I900_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I900_MP7 (XI0_I900_p1 I0_two7_b3_2 XI0_I900_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I900_MP5 (VDD I0_one7_b3_2 XI0_I900_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I900_MP10 (XI0_I900_xan XI0_I900_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I902_MP12 (VDD I0_B_15_b3_2 XI0_I902_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I902_MP18 (XI0_I902_xp1 XI0_I902_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I902_MP20 (I0_pp7_14 I0_B_15_b3_2 XI0_I902_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I902_MP19 (XI0_I902_xp1 XI0_I902_xan I0_pp7_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I902_MP17 (VDD XI0_I902_xn XI0_I902_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I902_MP6 (XI0_I902_p1 I0_A_14_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I902_MP8 (XI0_I902_xn I0_A_13_b3_2 XI0_I902_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I902_MP7 (XI0_I902_p1 I0_two7_b3_2 XI0_I902_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I902_MP5 (VDD I0_one7_b3_2 XI0_I902_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I902_MP10 (XI0_I902_xan XI0_I902_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I904_MP12 (VDD I0_B_15_b3_2 XI0_I904_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I904_MP18 (XI0_I904_xp1 XI0_I904_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I904_MP20 (I0_pp7_16 I0_B_15_b3_2 XI0_I904_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I904_MP19 (XI0_I904_xp1 XI0_I904_xan I0_pp7_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I904_MP17 (VDD XI0_I904_xn XI0_I904_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I904_MP6 (XI0_I904_p1 I0_A_16_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I904_MP8 (XI0_I904_xn I0_A_15_b3_2 XI0_I904_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I904_MP7 (XI0_I904_p1 I0_two7_b3_2 XI0_I904_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I904_MP5 (VDD I0_one7_b3_2 XI0_I904_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I904_MP10 (XI0_I904_xan XI0_I904_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I903_MP12 (VDD I0_B_15_b3_2 XI0_I903_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I903_MP18 (XI0_I903_xp1 XI0_I903_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I903_MP20 (I0_pp7_15 I0_B_15_b3_2 XI0_I903_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I903_MP19 (XI0_I903_xp1 XI0_I903_xan I0_pp7_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I903_MP17 (VDD XI0_I903_xn XI0_I903_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I903_MP6 (XI0_I903_p1 I0_A_15_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I903_MP8 (XI0_I903_xn I0_A_14_b3_2 XI0_I903_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I903_MP7 (XI0_I903_p1 I0_two7_b3_2 XI0_I903_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I903_MP5 (VDD I0_one7_b3_2 XI0_I903_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I903_MP10 (XI0_I903_xan XI0_I903_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I740_MP12 (VDD I0_B_9_b3_3 XI0_I740_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I740_MP18 (XI0_I740_xp1 XI0_I740_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I740_MP20 (I0_pp4_17 I0_B_9_b3_3 XI0_I740_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I740_MP19 (XI0_I740_xp1 XI0_I740_xan I0_pp4_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I740_MP17 (VDD XI0_I740_xn XI0_I740_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I740_MP6 (XI0_I740_p1 I0_A_17_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I740_MP8 (XI0_I740_xn I0_A_16_b3_1 XI0_I740_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I740_MP7 (XI0_I740_p1 I0_two4_b3_3 XI0_I740_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I740_MP5 (VDD I0_one4_b3_3 XI0_I740_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I740_MP10 (XI0_I740_xan XI0_I740_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I742_MP12 (VDD I0_B_9_b3_3 XI0_I742_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I742_MP18 (XI0_I742_xp1 XI0_I742_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I742_MP20 (I0_pp4_19 I0_B_9_b3_3 XI0_I742_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I742_MP19 (XI0_I742_xp1 XI0_I742_xan I0_pp4_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I742_MP17 (VDD XI0_I742_xn XI0_I742_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I742_MP6 (XI0_I742_p1 I0_A_19_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I742_MP8 (XI0_I742_xn I0_A_18_b3_1 XI0_I742_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I742_MP7 (XI0_I742_p1 I0_two4_b3_3 XI0_I742_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I742_MP5 (VDD I0_one4_b3_3 XI0_I742_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I742_MP10 (XI0_I742_xan XI0_I742_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I741_MP12 (VDD I0_B_9_b3_3 XI0_I741_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I741_MP18 (XI0_I741_xp1 XI0_I741_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I741_MP20 (I0_pp4_18 I0_B_9_b3_3 XI0_I741_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I741_MP19 (XI0_I741_xp1 XI0_I741_xan I0_pp4_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I741_MP17 (VDD XI0_I741_xn XI0_I741_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I741_MP6 (XI0_I741_p1 I0_A_18_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I741_MP8 (XI0_I741_xn I0_A_17_b3_1 XI0_I741_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I741_MP7 (XI0_I741_p1 I0_two4_b3_3 XI0_I741_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I741_MP5 (VDD I0_one4_b3_3 XI0_I741_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I741_MP10 (XI0_I741_xan XI0_I741_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I743_MP12 (VDD I0_B_9_b3_3 XI0_I743_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I743_MP18 (XI0_I743_xp1 XI0_I743_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I743_MP20 (I0_pp4_20 I0_B_9_b3_3 XI0_I743_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I743_MP19 (XI0_I743_xp1 XI0_I743_xan I0_pp4_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I743_MP17 (VDD XI0_I743_xn XI0_I743_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I743_MP6 (XI0_I743_p1 I0_A_20_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I743_MP8 (XI0_I743_xn I0_A_19_b3_1 XI0_I743_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I743_MP7 (XI0_I743_p1 I0_two4_b3_3 XI0_I743_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I743_MP5 (VDD I0_one4_b3_3 XI0_I743_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I743_MP10 (XI0_I743_xan XI0_I743_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I797_MP12 (VDD I0_B_11_b3_3 XI0_I797_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I797_MP18 (XI0_I797_xp1 XI0_I797_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I797_MP20 (I0_pp5_19 I0_B_11_b3_3 XI0_I797_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I797_MP19 (XI0_I797_xp1 XI0_I797_xan I0_pp5_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I797_MP17 (VDD XI0_I797_xn XI0_I797_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I797_MP6 (XI0_I797_p1 I0_A_19_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I797_MP8 (XI0_I797_xn I0_A_18_b3_2 XI0_I797_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I797_MP7 (XI0_I797_p1 I0_two5_b3_3 XI0_I797_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I797_MP5 (VDD I0_one5_b3_3 XI0_I797_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I797_MP10 (XI0_I797_xan XI0_I797_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I796_MP12 (VDD I0_B_11_b3_3 XI0_I796_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I796_MP18 (XI0_I796_xp1 XI0_I796_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I796_MP20 (I0_pp5_18 I0_B_11_b3_3 XI0_I796_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I796_MP19 (XI0_I796_xp1 XI0_I796_xan I0_pp5_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I796_MP17 (VDD XI0_I796_xn XI0_I796_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I796_MP6 (XI0_I796_p1 I0_A_18_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I796_MP8 (XI0_I796_xn I0_A_17_b3_2 XI0_I796_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I796_MP7 (XI0_I796_p1 I0_two5_b3_3 XI0_I796_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I796_MP5 (VDD I0_one5_b3_3 XI0_I796_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I796_MP10 (XI0_I796_xan XI0_I796_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I850_MP12 (VDD I0_B_13_b3_3 XI0_I850_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I850_MP18 (XI0_I850_xp1 XI0_I850_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I850_MP20 (I0_pp6_17 I0_B_13_b3_3 XI0_I850_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I850_MP19 (XI0_I850_xp1 XI0_I850_xan I0_pp6_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I850_MP17 (VDD XI0_I850_xn XI0_I850_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I850_MP6 (XI0_I850_p1 I0_A_17_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I850_MP8 (XI0_I850_xn I0_A_16_b3_2 XI0_I850_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I850_MP7 (XI0_I850_p1 I0_two6_b3_3 XI0_I850_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I850_MP5 (VDD I0_one6_b3_3 XI0_I850_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I850_MP10 (XI0_I850_xan XI0_I850_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I852_MP12 (VDD I0_B_13_b3_3 XI0_I852_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I852_MP18 (XI0_I852_xp1 XI0_I852_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I852_MP20 (I0_pp6_19 I0_B_13_b3_3 XI0_I852_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I852_MP19 (XI0_I852_xp1 XI0_I852_xan I0_pp6_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I852_MP17 (VDD XI0_I852_xn XI0_I852_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I852_MP6 (XI0_I852_p1 I0_A_19_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I852_MP8 (XI0_I852_xn I0_A_18_b3_2 XI0_I852_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I852_MP7 (XI0_I852_p1 I0_two6_b3_3 XI0_I852_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I852_MP5 (VDD I0_one6_b3_3 XI0_I852_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I852_MP10 (XI0_I852_xan XI0_I852_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I906_MP12 (VDD I0_B_15_b3_3 XI0_I906_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I906_MP18 (XI0_I906_xp1 XI0_I906_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I906_MP20 (I0_pp7_18 I0_B_15_b3_3 XI0_I906_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I906_MP19 (XI0_I906_xp1 XI0_I906_xan I0_pp7_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I906_MP17 (VDD XI0_I906_xn XI0_I906_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I906_MP6 (XI0_I906_p1 I0_A_18_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I906_MP8 (XI0_I906_xn I0_A_17_b3_2 XI0_I906_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I906_MP7 (XI0_I906_p1 I0_two7_b3_3 XI0_I906_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I906_MP5 (VDD I0_one7_b3_3 XI0_I906_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I906_MP10 (XI0_I906_xan XI0_I906_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I908_MP12 (VDD I0_B_15_b3_3 XI0_I908_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I908_MP18 (XI0_I908_xp1 XI0_I908_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I908_MP20 (I0_pp7_20 I0_B_15_b3_3 XI0_I908_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I908_MP19 (XI0_I908_xp1 XI0_I908_xan I0_pp7_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I908_MP17 (VDD XI0_I908_xn XI0_I908_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I908_MP6 (XI0_I908_p1 I0_A_20_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I908_MP8 (XI0_I908_xn I0_A_19_b3_2 XI0_I908_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I908_MP7 (XI0_I908_p1 I0_two7_b3_3 XI0_I908_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I908_MP5 (VDD I0_one7_b3_3 XI0_I908_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I908_MP10 (XI0_I908_xan XI0_I908_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I909_MP12 (VDD I0_B_15_b3_3 XI0_I909_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I909_MP18 (XI0_I909_xp1 XI0_I909_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I909_MP20 (I0_pp7_21 I0_B_15_b3_3 XI0_I909_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I909_MP19 (XI0_I909_xp1 XI0_I909_xan I0_pp7_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I909_MP17 (VDD XI0_I909_xn XI0_I909_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I909_MP6 (XI0_I909_p1 I0_A_21_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I909_MP8 (XI0_I909_xn I0_A_20_b3_2 XI0_I909_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I909_MP7 (XI0_I909_p1 I0_two7_b3_3 XI0_I909_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I909_MP5 (VDD I0_one7_b3_3 XI0_I909_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I909_MP10 (XI0_I909_xan XI0_I909_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I855_MP12 (VDD I0_B_13_b3_3 XI0_I855_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I855_MP18 (XI0_I855_xp1 XI0_I855_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I855_MP20 (I0_pp6_22 I0_B_13_b3_3 XI0_I855_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I855_MP19 (XI0_I855_xp1 XI0_I855_xan I0_pp6_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I855_MP17 (VDD XI0_I855_xn XI0_I855_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I855_MP6 (XI0_I855_p1 I0_A_22_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I855_MP8 (XI0_I855_xn I0_A_21_b3_2 XI0_I855_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I855_MP7 (XI0_I855_p1 I0_two6_b3_4 XI0_I855_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I855_MP5 (VDD I0_one6_b3_4 XI0_I855_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I855_MP10 (XI0_I855_xan XI0_I855_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I907_MP12 (VDD I0_B_15_b3_3 XI0_I907_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I907_MP18 (XI0_I907_xp1 XI0_I907_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I907_MP20 (I0_pp7_19 I0_B_15_b3_3 XI0_I907_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I907_MP19 (XI0_I907_xp1 XI0_I907_xan I0_pp7_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I907_MP17 (VDD XI0_I907_xn XI0_I907_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I907_MP6 (XI0_I907_p1 I0_A_19_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I907_MP8 (XI0_I907_xn I0_A_18_b3_2 XI0_I907_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I907_MP7 (XI0_I907_p1 I0_two7_b3_3 XI0_I907_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I907_MP5 (VDD I0_one7_b3_3 XI0_I907_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I907_MP10 (XI0_I907_xan XI0_I907_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I857_MP12 (VDD I0_B_13_b3_4 XI0_I857_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I857_MP18 (XI0_I857_xp1 XI0_I857_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I857_MP20 (I0_pp6_24 I0_B_13_b3_4 XI0_I857_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I857_MP19 (XI0_I857_xp1 XI0_I857_xan I0_pp6_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I857_MP17 (VDD XI0_I857_xn XI0_I857_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I857_MP6 (XI0_I857_p1 I0_A_24_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I857_MP8 (XI0_I857_xn I0_A_23_b3_2 XI0_I857_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I857_MP7 (XI0_I857_p1 I0_two6_b3_4 XI0_I857_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I857_MP5 (VDD I0_one6_b3_4 XI0_I857_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I857_MP10 (XI0_I857_xan XI0_I857_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I858_MP12 (VDD I0_B_13_b3_4 XI0_I858_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I858_MP18 (XI0_I858_xp1 XI0_I858_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I858_MP20 (I0_pp6_25 I0_B_13_b3_4 XI0_I858_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I858_MP19 (XI0_I858_xp1 XI0_I858_xan I0_pp6_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I858_MP17 (VDD XI0_I858_xn XI0_I858_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I858_MP6 (XI0_I858_p1 I0_A_25_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I858_MP8 (XI0_I858_xn I0_A_24_b3_2 XI0_I858_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I858_MP7 (XI0_I858_p1 I0_two6_b3_4 XI0_I858_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I858_MP5 (VDD I0_one6_b3_4 XI0_I858_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I858_MP10 (XI0_I858_xan XI0_I858_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I860_MP12 (VDD I0_B_13_b3_4 XI0_I860_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I860_MP18 (XI0_I860_xp1 XI0_I860_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I860_MP20 (I0_pp6_27 I0_B_13_b3_4 XI0_I860_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I860_MP19 (XI0_I860_xp1 XI0_I860_xan I0_pp6_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I860_MP17 (VDD XI0_I860_xn XI0_I860_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I860_MP6 (XI0_I860_p1 I0_A_27_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I860_MP8 (XI0_I860_xn I0_A_26_b3_2 XI0_I860_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I860_MP7 (XI0_I860_p1 I0_two6_b3_4 XI0_I860_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I860_MP5 (VDD I0_one6_b3_4 XI0_I860_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I860_MP10 (XI0_I860_xan XI0_I860_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I808_MP12 (VDD I0_B_11_b3_5 XI0_I808_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I808_MP18 (XI0_I808_xp1 XI0_I808_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I808_MP20 (I0_pp5_30 I0_B_11_b3_5 XI0_I808_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I808_MP19 (XI0_I808_xp1 XI0_I808_xan I0_pp5_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I808_MP17 (VDD XI0_I808_xn XI0_I808_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I808_MP6 (XI0_I808_p1 I0_A_30_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I808_MP8 (XI0_I808_xn I0_A_29_b3_2 XI0_I808_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I808_MP7 (XI0_I808_p1 I0_two5_b3_5 XI0_I808_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I808_MP5 (VDD I0_one5_b3_5 XI0_I808_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I808_MP10 (XI0_I808_xan XI0_I808_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I809_MP12 (VDD I0_B_11_b3_5 XI0_I809_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I809_MP18 (XI0_I809_xp1 XI0_I809_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I809_MP20 (I0_pp5_31 I0_B_11_b3_5 XI0_I809_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I809_MP19 (XI0_I809_xp1 XI0_I809_xan I0_pp5_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I809_MP17 (VDD XI0_I809_xn XI0_I809_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I809_MP6 (XI0_I809_p1 I0_A_31_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I809_MP8 (XI0_I809_xn I0_A_30_b3_2 XI0_I809_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I809_MP7 (XI0_I809_p1 I0_two5_b3_5 XI0_I809_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I809_MP5 (VDD I0_one5_b3_5 XI0_I809_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I809_MP10 (XI0_I809_xan XI0_I809_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I513_MP12 (VDD I0_B_1_b3_1 XI0_I513_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I513_MP18 (XI0_I513_xp1 XI0_I513_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I513_MP20 (I0_pp0_10 I0_B_1_b3_1 XI0_I513_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I513_MP19 (XI0_I513_xp1 XI0_I513_xan I0_pp0_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I513_MP17 (VDD XI0_I513_xn XI0_I513_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I513_MP6 (XI0_I513_p1 I0_A_10_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I513_MP8 (XI0_I513_xn I0_A_9_b3_0 XI0_I513_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I513_MP7 (XI0_I513_p1 I0_two0_b3_1 XI0_I513_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I513_MP5 (VDD I0_one0_b3_1 XI0_I513_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I513_MP10 (XI0_I513_xan XI0_I513_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I568_MP12 (VDD I0_B_3_b3_1 XI0_I568_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I568_MP18 (XI0_I568_xp1 XI0_I568_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I568_MP20 (I0_pp1_10 I0_B_3_b3_1 XI0_I568_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I568_MP19 (XI0_I568_xp1 XI0_I568_xan I0_pp1_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I568_MP17 (VDD XI0_I568_xn XI0_I568_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I568_MP6 (XI0_I568_p1 I0_A_10_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I568_MP8 (XI0_I568_xn I0_A_9_b3_0 XI0_I568_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I568_MP7 (XI0_I568_p1 I0_two1_b3_1 XI0_I568_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I568_MP5 (VDD I0_one1_b3_1 XI0_I568_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I568_MP10 (XI0_I568_xan XI0_I568_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I678_MP12 (VDD I0_B_7_b3_1 XI0_I678_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I678_MP18 (XI0_I678_xp1 XI0_I678_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I678_MP20 (I0_pp3_10 I0_B_7_b3_1 XI0_I678_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I678_MP19 (XI0_I678_xp1 XI0_I678_xan I0_pp3_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I678_MP17 (VDD XI0_I678_xn XI0_I678_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I678_MP6 (XI0_I678_p1 I0_A_10_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I678_MP8 (XI0_I678_xn I0_A_9_b3_1 XI0_I678_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I678_MP7 (XI0_I678_p1 I0_two3_b3_1 XI0_I678_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I678_MP5 (VDD I0_one3_b3_1 XI0_I678_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I678_MP10 (XI0_I678_xan XI0_I678_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I734_MP12 (VDD I0_B_9_b3_2 XI0_I734_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I734_MP18 (XI0_I734_xp1 XI0_I734_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I734_MP20 (I0_pp4_11 I0_B_9_b3_2 XI0_I734_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I734_MP19 (XI0_I734_xp1 XI0_I734_xan I0_pp4_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I734_MP17 (VDD XI0_I734_xn XI0_I734_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I734_MP6 (XI0_I734_p1 I0_A_11_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I734_MP8 (XI0_I734_xn I0_A_10_b3_1 XI0_I734_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I734_MP7 (XI0_I734_p1 I0_two4_b3_2 XI0_I734_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I734_MP5 (VDD I0_one4_b3_2 XI0_I734_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I734_MP10 (XI0_I734_xan XI0_I734_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I789_MP12 (VDD I0_B_11_b3_2 XI0_I789_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I789_MP18 (XI0_I789_xp1 XI0_I789_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I789_MP20 (I0_pp5_11 I0_B_11_b3_2 XI0_I789_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I789_MP19 (XI0_I789_xp1 XI0_I789_xan I0_pp5_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I789_MP17 (VDD XI0_I789_xn XI0_I789_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I789_MP6 (XI0_I789_p1 I0_A_11_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I789_MP8 (XI0_I789_xn I0_A_10_b3_2 XI0_I789_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I789_MP7 (XI0_I789_p1 I0_two5_b3_2 XI0_I789_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I789_MP5 (VDD I0_one5_b3_2 XI0_I789_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I789_MP10 (XI0_I789_xan XI0_I789_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I790_MP12 (VDD I0_B_11_b3_2 XI0_I790_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I790_MP18 (XI0_I790_xp1 XI0_I790_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I790_MP20 (I0_pp5_12 I0_B_11_b3_2 XI0_I790_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I790_MP19 (XI0_I790_xp1 XI0_I790_xan I0_pp5_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I790_MP17 (VDD XI0_I790_xn XI0_I790_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I790_MP6 (XI0_I790_p1 I0_A_12_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I790_MP8 (XI0_I790_xn I0_A_11_b3_2 XI0_I790_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I790_MP7 (XI0_I790_p1 I0_two5_b3_2 XI0_I790_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I790_MP5 (VDD I0_one5_b3_2 XI0_I790_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I790_MP10 (XI0_I790_xan XI0_I790_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I791_MP12 (VDD I0_B_11_b3_2 XI0_I791_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I791_MP18 (XI0_I791_xp1 XI0_I791_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I791_MP20 (I0_pp5_13 I0_B_11_b3_2 XI0_I791_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I791_MP19 (XI0_I791_xp1 XI0_I791_xan I0_pp5_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I791_MP17 (VDD XI0_I791_xn XI0_I791_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I791_MP6 (XI0_I791_p1 I0_A_13_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I791_MP8 (XI0_I791_xn I0_A_12_b3_2 XI0_I791_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I791_MP7 (XI0_I791_p1 I0_two5_b3_2 XI0_I791_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I791_MP5 (VDD I0_one5_b3_2 XI0_I791_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I791_MP10 (XI0_I791_xan XI0_I791_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I792_MP12 (VDD I0_B_11_b3_2 XI0_I792_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I792_MP18 (XI0_I792_xp1 XI0_I792_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I792_MP20 (I0_pp5_14 I0_B_11_b3_2 XI0_I792_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I792_MP19 (XI0_I792_xp1 XI0_I792_xan I0_pp5_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I792_MP17 (VDD XI0_I792_xn XI0_I792_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I792_MP6 (XI0_I792_p1 I0_A_14_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I792_MP8 (XI0_I792_xn I0_A_13_b3_2 XI0_I792_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I792_MP7 (XI0_I792_p1 I0_two5_b3_2 XI0_I792_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I792_MP5 (VDD I0_one5_b3_2 XI0_I792_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I792_MP10 (XI0_I792_xan XI0_I792_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I793_MP12 (VDD I0_B_11_b3_2 XI0_I793_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I793_MP18 (XI0_I793_xp1 XI0_I793_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I793_MP20 (I0_pp5_15 I0_B_11_b3_2 XI0_I793_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I793_MP19 (XI0_I793_xp1 XI0_I793_xan I0_pp5_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I793_MP17 (VDD XI0_I793_xn XI0_I793_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I793_MP6 (XI0_I793_p1 I0_A_15_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I793_MP8 (XI0_I793_xn I0_A_14_b3_2 XI0_I793_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I793_MP7 (XI0_I793_p1 I0_two5_b3_2 XI0_I793_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I793_MP5 (VDD I0_one5_b3_2 XI0_I793_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I793_MP10 (XI0_I793_xan XI0_I793_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I846_MP12 (VDD I0_B_13_b3_2 XI0_I846_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I846_MP18 (XI0_I846_xp1 XI0_I846_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I846_MP20 (I0_pp6_13 I0_B_13_b3_2 XI0_I846_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I846_MP19 (XI0_I846_xp1 XI0_I846_xan I0_pp6_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I846_MP17 (VDD XI0_I846_xn XI0_I846_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I846_MP6 (XI0_I846_p1 I0_A_13_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I846_MP8 (XI0_I846_xn I0_A_12_b3_2 XI0_I846_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I846_MP7 (XI0_I846_p1 I0_two6_b3_2 XI0_I846_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I846_MP5 (VDD I0_one6_b3_2 XI0_I846_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I846_MP10 (XI0_I846_xan XI0_I846_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I845_MP12 (VDD I0_B_13_b3_2 XI0_I845_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I845_MP18 (XI0_I845_xp1 XI0_I845_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I845_MP20 (I0_pp6_12 I0_B_13_b3_2 XI0_I845_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I845_MP19 (XI0_I845_xp1 XI0_I845_xan I0_pp6_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I845_MP17 (VDD XI0_I845_xn XI0_I845_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I845_MP6 (XI0_I845_p1 I0_A_12_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I845_MP8 (XI0_I845_xn I0_A_11_b3_2 XI0_I845_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I845_MP7 (XI0_I845_p1 I0_two6_b3_2 XI0_I845_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I845_MP5 (VDD I0_one6_b3_2 XI0_I845_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I845_MP10 (XI0_I845_xan XI0_I845_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I844_MP12 (VDD I0_B_13_b3_2 XI0_I844_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I844_MP18 (XI0_I844_xp1 XI0_I844_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I844_MP20 (I0_pp6_11 I0_B_13_b3_2 XI0_I844_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I844_MP19 (XI0_I844_xp1 XI0_I844_xan I0_pp6_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I844_MP17 (VDD XI0_I844_xn XI0_I844_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I844_MP6 (XI0_I844_p1 I0_A_11_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I844_MP8 (XI0_I844_xn I0_A_10_b3_2 XI0_I844_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I844_MP7 (XI0_I844_p1 I0_two6_b3_2 XI0_I844_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I844_MP5 (VDD I0_one6_b3_2 XI0_I844_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I844_MP10 (XI0_I844_xan XI0_I844_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I847_MP12 (VDD I0_B_13_b3_2 XI0_I847_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I847_MP18 (XI0_I847_xp1 XI0_I847_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I847_MP20 (I0_pp6_14 I0_B_13_b3_2 XI0_I847_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I847_MP19 (XI0_I847_xp1 XI0_I847_xan I0_pp6_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I847_MP17 (VDD XI0_I847_xn XI0_I847_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I847_MP6 (XI0_I847_p1 I0_A_14_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I847_MP8 (XI0_I847_xn I0_A_13_b3_2 XI0_I847_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I847_MP7 (XI0_I847_p1 I0_two6_b3_2 XI0_I847_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I847_MP5 (VDD I0_one6_b3_2 XI0_I847_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I847_MP10 (XI0_I847_xan XI0_I847_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I901_MP12 (VDD I0_B_15_b3_2 XI0_I901_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I901_MP18 (XI0_I901_xp1 XI0_I901_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I901_MP20 (I0_pp7_13 I0_B_15_b3_2 XI0_I901_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I901_MP19 (XI0_I901_xp1 XI0_I901_xan I0_pp7_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I901_MP17 (VDD XI0_I901_xn XI0_I901_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I901_MP6 (XI0_I901_p1 I0_A_13_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I901_MP8 (XI0_I901_xn I0_A_12_b3_2 XI0_I901_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I901_MP7 (XI0_I901_p1 I0_two7_b3_2 XI0_I901_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I901_MP5 (VDD I0_one7_b3_2 XI0_I901_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I901_MP10 (XI0_I901_xan XI0_I901_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I848_MP12 (VDD I0_B_13_b3_2 XI0_I848_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I848_MP18 (XI0_I848_xp1 XI0_I848_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I848_MP20 (I0_pp6_15 I0_B_13_b3_2 XI0_I848_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I848_MP19 (XI0_I848_xp1 XI0_I848_xan I0_pp6_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I848_MP17 (VDD XI0_I848_xn XI0_I848_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I848_MP6 (XI0_I848_p1 I0_A_15_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I848_MP8 (XI0_I848_xn I0_A_14_b3_2 XI0_I848_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I848_MP7 (XI0_I848_p1 I0_two6_b3_2 XI0_I848_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I848_MP5 (VDD I0_one6_b3_2 XI0_I848_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I848_MP10 (XI0_I848_xan XI0_I848_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I854_MP12 (VDD I0_B_13_b3_3 XI0_I854_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I854_MP18 (XI0_I854_xp1 XI0_I854_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I854_MP20 (I0_pp6_21 I0_B_13_b3_3 XI0_I854_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I854_MP19 (XI0_I854_xp1 XI0_I854_xan I0_pp6_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I854_MP17 (VDD XI0_I854_xn XI0_I854_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I854_MP6 (XI0_I854_p1 I0_A_21_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I854_MP8 (XI0_I854_xn I0_A_20_b3_2 XI0_I854_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I854_MP7 (XI0_I854_p1 I0_two6_b3_3 XI0_I854_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I854_MP5 (VDD I0_one6_b3_3 XI0_I854_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I854_MP10 (XI0_I854_xan XI0_I854_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I856_MP12 (VDD I0_B_13_b3_4 XI0_I856_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I856_MP18 (XI0_I856_xp1 XI0_I856_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I856_MP20 (I0_pp6_23 I0_B_13_b3_4 XI0_I856_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I856_MP19 (XI0_I856_xp1 XI0_I856_xan I0_pp6_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I856_MP17 (VDD XI0_I856_xn XI0_I856_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I856_MP6 (XI0_I856_p1 I0_A_23_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I856_MP8 (XI0_I856_xn I0_A_22_b3_2 XI0_I856_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I856_MP7 (XI0_I856_p1 I0_two6_b3_4 XI0_I856_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I856_MP5 (VDD I0_one6_b3_4 XI0_I856_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I856_MP10 (XI0_I856_xan XI0_I856_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I859_MP12 (VDD I0_B_13_b3_4 XI0_I859_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I859_MP18 (XI0_I859_xp1 XI0_I859_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I859_MP20 (I0_pp6_26 I0_B_13_b3_4 XI0_I859_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I859_MP19 (XI0_I859_xp1 XI0_I859_xan I0_pp6_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I859_MP17 (VDD XI0_I859_xn XI0_I859_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I859_MP6 (XI0_I859_p1 I0_A_26_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I859_MP8 (XI0_I859_xn I0_A_25_b3_2 XI0_I859_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I859_MP7 (XI0_I859_p1 I0_two6_b3_4 XI0_I859_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I859_MP5 (VDD I0_one6_b3_4 XI0_I859_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I859_MP10 (XI0_I859_xan XI0_I859_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I861_MP12 (VDD I0_B_13_b3_4 XI0_I861_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I861_MP18 (XI0_I861_xp1 XI0_I861_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I861_MP20 (I0_pp6_28 I0_B_13_b3_4 XI0_I861_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I861_MP19 (XI0_I861_xp1 XI0_I861_xan I0_pp6_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I861_MP17 (VDD XI0_I861_xn XI0_I861_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I861_MP6 (XI0_I861_p1 I0_A_28_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I861_MP8 (XI0_I861_xn I0_A_27_b3_2 XI0_I861_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I861_MP7 (XI0_I861_p1 I0_two6_b3_5 XI0_I861_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I861_MP5 (VDD I0_one6_b3_5 XI0_I861_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I861_MP10 (XI0_I861_xan XI0_I861_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I862_MP12 (VDD I0_B_13_b3_5 XI0_I862_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I862_MP18 (XI0_I862_xp1 XI0_I862_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I862_MP20 (I0_pp6_29 I0_B_13_b3_5 XI0_I862_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I862_MP19 (XI0_I862_xp1 XI0_I862_xan I0_pp6_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I862_MP17 (VDD XI0_I862_xn XI0_I862_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I862_MP6 (XI0_I862_p1 I0_A_29_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I862_MP8 (XI0_I862_xn I0_A_28_b3_2 XI0_I862_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I862_MP7 (XI0_I862_p1 I0_two6_b3_5 XI0_I862_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I862_MP5 (VDD I0_one6_b3_5 XI0_I862_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I862_MP10 (XI0_I862_xan XI0_I862_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I510_MP12 (VDD I0_B_1_b3_1 XI0_I510_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I510_MP18 (XI0_I510_xp1 XI0_I510_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I510_MP20 (I0_pp0_7 I0_B_1_b3_1 XI0_I510_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I510_MP19 (XI0_I510_xp1 XI0_I510_xan I0_pp0_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I510_MP17 (VDD XI0_I510_xn XI0_I510_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I510_MP6 (XI0_I510_p1 I0_A_7_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I510_MP8 (XI0_I510_xn I0_A_6_b3_0 XI0_I510_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I510_MP7 (XI0_I510_p1 I0_two0_b3_1 XI0_I510_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I510_MP5 (VDD I0_one0_b3_1 XI0_I510_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I510_MP10 (XI0_I510_xan XI0_I510_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I565_MP12 (VDD I0_B_3_b3_1 XI0_I565_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I565_MP18 (XI0_I565_xp1 XI0_I565_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I565_MP20 (I0_pp1_7 I0_B_3_b3_1 XI0_I565_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I565_MP19 (XI0_I565_xp1 XI0_I565_xan I0_pp1_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I565_MP17 (VDD XI0_I565_xn XI0_I565_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I565_MP6 (XI0_I565_p1 I0_A_7_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I565_MP8 (XI0_I565_xn I0_A_6_b3_0 XI0_I565_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I565_MP7 (XI0_I565_p1 I0_two1_b3_1 XI0_I565_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I565_MP5 (VDD I0_one1_b3_1 XI0_I565_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I565_MP10 (XI0_I565_xan XI0_I565_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I512_MP12 (VDD I0_B_1_b3_1 XI0_I512_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I512_MP18 (XI0_I512_xp1 XI0_I512_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I512_MP20 (I0_pp0_9 I0_B_1_b3_1 XI0_I512_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I512_MP19 (XI0_I512_xp1 XI0_I512_xan I0_pp0_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I512_MP17 (VDD XI0_I512_xn XI0_I512_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I512_MP6 (XI0_I512_p1 I0_A_9_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I512_MP8 (XI0_I512_xn I0_A_8_b3_0 XI0_I512_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I512_MP7 (XI0_I512_p1 I0_two0_b3_1 XI0_I512_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I512_MP5 (VDD I0_one0_b3_1 XI0_I512_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I512_MP10 (XI0_I512_xan XI0_I512_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I567_MP12 (VDD I0_B_3_b3_1 XI0_I567_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I567_MP18 (XI0_I567_xp1 XI0_I567_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I567_MP20 (I0_pp1_9 I0_B_3_b3_1 XI0_I567_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I567_MP19 (XI0_I567_xp1 XI0_I567_xan I0_pp1_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I567_MP17 (VDD XI0_I567_xn XI0_I567_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I567_MP6 (XI0_I567_p1 I0_A_9_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I567_MP8 (XI0_I567_xn I0_A_8_b3_0 XI0_I567_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I567_MP7 (XI0_I567_p1 I0_two1_b3_1 XI0_I567_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I567_MP5 (VDD I0_one1_b3_1 XI0_I567_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I567_MP10 (XI0_I567_xan XI0_I567_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I622_MP12 (VDD I0_B_5_b3_1 XI0_I622_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I622_MP18 (XI0_I622_xp1 XI0_I622_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I622_MP20 (I0_pp2_9 I0_B_5_b3_1 XI0_I622_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I622_MP19 (XI0_I622_xp1 XI0_I622_xan I0_pp2_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I622_MP17 (VDD XI0_I622_xn XI0_I622_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I622_MP6 (XI0_I622_p1 I0_A_9_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I622_MP8 (XI0_I622_xn I0_A_8_b3_0 XI0_I622_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I622_MP7 (XI0_I622_p1 I0_two2_b3_1 XI0_I622_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I622_MP5 (VDD I0_one2_b3_1 XI0_I622_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I622_MP10 (XI0_I622_xan XI0_I622_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I675_MP12 (VDD I0_B_7_b3_1 XI0_I675_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I675_MP18 (XI0_I675_xp1 XI0_I675_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I675_MP20 (I0_pp3_7 I0_B_7_b3_1 XI0_I675_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I675_MP19 (XI0_I675_xp1 XI0_I675_xan I0_pp3_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I675_MP17 (VDD XI0_I675_xn XI0_I675_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I675_MP6 (XI0_I675_p1 I0_A_7_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I675_MP8 (XI0_I675_xn I0_A_6_b3_1 XI0_I675_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I675_MP7 (XI0_I675_p1 I0_two3_b3_1 XI0_I675_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I675_MP5 (VDD I0_one3_b3_1 XI0_I675_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I675_MP10 (XI0_I675_xan XI0_I675_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I676_MP12 (VDD I0_B_7_b3_1 XI0_I676_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I676_MP18 (XI0_I676_xp1 XI0_I676_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I676_MP20 (I0_pp3_8 I0_B_7_b3_1 XI0_I676_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I676_MP19 (XI0_I676_xp1 XI0_I676_xan I0_pp3_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I676_MP17 (VDD XI0_I676_xn XI0_I676_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I676_MP6 (XI0_I676_p1 I0_A_8_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I676_MP8 (XI0_I676_xn I0_A_7_b3_1 XI0_I676_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I676_MP7 (XI0_I676_p1 I0_two3_b3_1 XI0_I676_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I676_MP5 (VDD I0_one3_b3_1 XI0_I676_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I676_MP10 (XI0_I676_xan XI0_I676_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I677_MP12 (VDD I0_B_7_b3_1 XI0_I677_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I677_MP18 (XI0_I677_xp1 XI0_I677_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I677_MP20 (I0_pp3_9 I0_B_7_b3_1 XI0_I677_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I677_MP19 (XI0_I677_xp1 XI0_I677_xan I0_pp3_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I677_MP17 (VDD XI0_I677_xn XI0_I677_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I677_MP6 (XI0_I677_p1 I0_A_9_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I677_MP8 (XI0_I677_xn I0_A_8_b3_1 XI0_I677_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I677_MP7 (XI0_I677_p1 I0_two3_b3_1 XI0_I677_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I677_MP5 (VDD I0_one3_b3_1 XI0_I677_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I677_MP10 (XI0_I677_xan XI0_I677_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I843_MP12 (VDD I0_B_13_b3_1 XI0_I843_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I843_MP18 (XI0_I843_xp1 XI0_I843_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I843_MP20 (I0_pp6_10 I0_B_13_b3_1 XI0_I843_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I843_MP19 (XI0_I843_xp1 XI0_I843_xan I0_pp6_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I843_MP17 (VDD XI0_I843_xn XI0_I843_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I843_MP6 (XI0_I843_p1 I0_A_10_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I843_MP8 (XI0_I843_xn I0_A_9_b3_2 XI0_I843_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I843_MP7 (XI0_I843_p1 I0_two6_b3_1 XI0_I843_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I843_MP5 (VDD I0_one6_b3_1 XI0_I843_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I843_MP10 (XI0_I843_xan XI0_I843_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I736_MP12 (VDD I0_B_9_b3_2 XI0_I736_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I736_MP18 (XI0_I736_xp1 XI0_I736_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I736_MP20 (I0_pp4_13 I0_B_9_b3_2 XI0_I736_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I736_MP19 (XI0_I736_xp1 XI0_I736_xan I0_pp4_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I736_MP17 (VDD XI0_I736_xn XI0_I736_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I736_MP6 (XI0_I736_p1 I0_A_13_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I736_MP8 (XI0_I736_xn I0_A_12_b3_1 XI0_I736_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I736_MP7 (XI0_I736_p1 I0_two4_b3_2 XI0_I736_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I736_MP5 (VDD I0_one4_b3_2 XI0_I736_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I736_MP10 (XI0_I736_xan XI0_I736_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I735_MP12 (VDD I0_B_9_b3_2 XI0_I735_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I735_MP18 (XI0_I735_xp1 XI0_I735_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I735_MP20 (I0_pp4_12 I0_B_9_b3_2 XI0_I735_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I735_MP19 (XI0_I735_xp1 XI0_I735_xan I0_pp4_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I735_MP17 (VDD XI0_I735_xn XI0_I735_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I735_MP6 (XI0_I735_p1 I0_A_12_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I735_MP8 (XI0_I735_xn I0_A_11_b3_1 XI0_I735_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I735_MP7 (XI0_I735_p1 I0_two4_b3_2 XI0_I735_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I735_MP5 (VDD I0_one4_b3_2 XI0_I735_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I735_MP10 (XI0_I735_xan XI0_I735_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I737_MP12 (VDD I0_B_9_b3_2 XI0_I737_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I737_MP18 (XI0_I737_xp1 XI0_I737_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I737_MP20 (I0_pp4_14 I0_B_9_b3_2 XI0_I737_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I737_MP19 (XI0_I737_xp1 XI0_I737_xan I0_pp4_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I737_MP17 (VDD XI0_I737_xn XI0_I737_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I737_MP6 (XI0_I737_p1 I0_A_14_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I737_MP8 (XI0_I737_xn I0_A_13_b3_1 XI0_I737_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I737_MP7 (XI0_I737_p1 I0_two4_b3_2 XI0_I737_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I737_MP5 (VDD I0_one4_b3_2 XI0_I737_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I737_MP10 (XI0_I737_xan XI0_I737_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I738_MP12 (VDD I0_B_9_b3_2 XI0_I738_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I738_MP18 (XI0_I738_xp1 XI0_I738_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I738_MP20 (I0_pp4_15 I0_B_9_b3_2 XI0_I738_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I738_MP19 (XI0_I738_xp1 XI0_I738_xan I0_pp4_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I738_MP17 (VDD XI0_I738_xn XI0_I738_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I738_MP6 (XI0_I738_p1 I0_A_15_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I738_MP8 (XI0_I738_xn I0_A_14_b3_1 XI0_I738_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I738_MP7 (XI0_I738_p1 I0_two4_b3_2 XI0_I738_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I738_MP5 (VDD I0_one4_b3_2 XI0_I738_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I738_MP10 (XI0_I738_xan XI0_I738_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I739_MP12 (VDD I0_B_9_b3_2 XI0_I739_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I739_MP18 (XI0_I739_xp1 XI0_I739_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I739_MP20 (I0_pp4_16 I0_B_9_b3_2 XI0_I739_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I739_MP19 (XI0_I739_xp1 XI0_I739_xan I0_pp4_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I739_MP17 (VDD XI0_I739_xn XI0_I739_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I739_MP6 (XI0_I739_p1 I0_A_16_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I739_MP8 (XI0_I739_xn I0_A_15_b3_1 XI0_I739_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I739_MP7 (XI0_I739_p1 I0_two4_b3_2 XI0_I739_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I739_MP5 (VDD I0_one4_b3_2 XI0_I739_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I739_MP10 (XI0_I739_xan XI0_I739_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I899_MP12 (VDD I0_B_15_b3_2 XI0_I899_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I899_MP18 (XI0_I899_xp1 XI0_I899_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I899_MP20 (I0_pp7_11 I0_B_15_b3_2 XI0_I899_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I899_MP19 (XI0_I899_xp1 XI0_I899_xan I0_pp7_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I899_MP17 (VDD XI0_I899_xn XI0_I899_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I899_MP6 (XI0_I899_p1 I0_A_11_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I899_MP8 (XI0_I899_xn I0_A_10_b3_2 XI0_I899_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I899_MP7 (XI0_I899_p1 I0_two7_b3_2 XI0_I899_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I899_MP5 (VDD I0_one7_b3_2 XI0_I899_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I899_MP10 (XI0_I899_xan XI0_I899_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I849_MP12 (VDD I0_B_13_b3_2 XI0_I849_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I849_MP18 (XI0_I849_xp1 XI0_I849_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I849_MP20 (I0_pp6_16 I0_B_13_b3_2 XI0_I849_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I849_MP19 (XI0_I849_xp1 XI0_I849_xan I0_pp6_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I849_MP17 (VDD XI0_I849_xn XI0_I849_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I849_MP6 (XI0_I849_p1 I0_A_16_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I849_MP8 (XI0_I849_xn I0_A_15_b3_2 XI0_I849_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I849_MP7 (XI0_I849_p1 I0_two6_b3_2 XI0_I849_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I849_MP5 (VDD I0_one6_b3_2 XI0_I849_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I849_MP10 (XI0_I849_xan XI0_I849_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I910_MP12 (VDD I0_B_15_b3_3 XI0_I910_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I910_MP18 (XI0_I910_xp1 XI0_I910_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I910_MP20 (I0_pp7_22 I0_B_15_b3_3 XI0_I910_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I910_MP19 (XI0_I910_xp1 XI0_I910_xan I0_pp7_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I910_MP17 (VDD XI0_I910_xn XI0_I910_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I910_MP6 (XI0_I910_p1 I0_A_22_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I910_MP8 (XI0_I910_xn I0_A_21_b3_2 XI0_I910_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I910_MP7 (XI0_I910_p1 I0_two7_b3_4 XI0_I910_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I910_MP5 (VDD I0_one7_b3_4 XI0_I910_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I910_MP10 (XI0_I910_xan XI0_I910_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I911_MP12 (VDD I0_B_15_b3_4 XI0_I911_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I911_MP18 (XI0_I911_xp1 XI0_I911_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I911_MP20 (I0_pp7_23 I0_B_15_b3_4 XI0_I911_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I911_MP19 (XI0_I911_xp1 XI0_I911_xan I0_pp7_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I911_MP17 (VDD XI0_I911_xn XI0_I911_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I911_MP6 (XI0_I911_p1 I0_A_23_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I911_MP8 (XI0_I911_xn I0_A_22_b3_2 XI0_I911_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I911_MP7 (XI0_I911_p1 I0_two7_b3_4 XI0_I911_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I911_MP5 (VDD I0_one7_b3_4 XI0_I911_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I911_MP10 (XI0_I911_xan XI0_I911_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I913_MP12 (VDD I0_B_15_b3_4 XI0_I913_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I913_MP18 (XI0_I913_xp1 XI0_I913_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I913_MP20 (I0_pp7_25 I0_B_15_b3_4 XI0_I913_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I913_MP19 (XI0_I913_xp1 XI0_I913_xan I0_pp7_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I913_MP17 (VDD XI0_I913_xn XI0_I913_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I913_MP6 (XI0_I913_p1 I0_A_25_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I913_MP8 (XI0_I913_xn I0_A_24_b3_2 XI0_I913_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I913_MP7 (XI0_I913_p1 I0_two7_b3_4 XI0_I913_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I913_MP5 (VDD I0_one7_b3_4 XI0_I913_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I913_MP10 (XI0_I913_xan XI0_I913_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I912_MP12 (VDD I0_B_15_b3_4 XI0_I912_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I912_MP18 (XI0_I912_xp1 XI0_I912_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I912_MP20 (I0_pp7_24 I0_B_15_b3_4 XI0_I912_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I912_MP19 (XI0_I912_xp1 XI0_I912_xan I0_pp7_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I912_MP17 (VDD XI0_I912_xn XI0_I912_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I912_MP6 (XI0_I912_p1 I0_A_24_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I912_MP8 (XI0_I912_xn I0_A_23_b3_2 XI0_I912_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I912_MP7 (XI0_I912_p1 I0_two7_b3_4 XI0_I912_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I912_MP5 (VDD I0_one7_b3_4 XI0_I912_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I912_MP10 (XI0_I912_xan XI0_I912_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I915_MP12 (VDD I0_B_15_b3_4 XI0_I915_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I915_MP18 (XI0_I915_xp1 XI0_I915_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I915_MP20 (I0_pp7_27 I0_B_15_b3_4 XI0_I915_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I915_MP19 (XI0_I915_xp1 XI0_I915_xan I0_pp7_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I915_MP17 (VDD XI0_I915_xn XI0_I915_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I915_MP6 (XI0_I915_p1 I0_A_27_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I915_MP8 (XI0_I915_xn I0_A_26_b3_2 XI0_I915_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I915_MP7 (XI0_I915_p1 I0_two7_b3_4 XI0_I915_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I915_MP5 (VDD I0_one7_b3_4 XI0_I915_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I915_MP10 (XI0_I915_xan XI0_I915_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I863_MP12 (VDD I0_B_13_b3_5 XI0_I863_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I863_MP18 (XI0_I863_xp1 XI0_I863_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I863_MP20 (I0_pp6_30 I0_B_13_b3_5 XI0_I863_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I863_MP19 (XI0_I863_xp1 XI0_I863_xan I0_pp6_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I863_MP17 (VDD XI0_I863_xn XI0_I863_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I863_MP6 (XI0_I863_p1 I0_A_30_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I863_MP8 (XI0_I863_xn I0_A_29_b3_2 XI0_I863_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I863_MP7 (XI0_I863_p1 I0_two6_b3_5 XI0_I863_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I863_MP5 (VDD I0_one6_b3_5 XI0_I863_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I863_MP10 (XI0_I863_xan XI0_I863_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I865_MP12 (VDD I0_B_13_b3_5 XI0_I865_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I865_MP18 (XI0_I865_xp1 XI0_I865_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I865_MP20 (I0_pp6_32 I0_B_13_b3_5 XI0_I865_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I865_MP19 (XI0_I865_xp1 XI0_I865_xan I0_pp6_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I865_MP17 (VDD XI0_I865_xn XI0_I865_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I865_MP6 (XI0_I865_p1 I0_A_31_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I865_MP8 (XI0_I865_xn I0_A_31_b3_3 XI0_I865_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I865_MP7 (XI0_I865_p1 I0_two6_b3_5 XI0_I865_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I865_MP5 (VDD I0_one6_b3_5 XI0_I865_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I865_MP10 (XI0_I865_xan XI0_I865_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I511_MP12 (VDD I0_B_1_b3_1 XI0_I511_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I511_MP18 (XI0_I511_xp1 XI0_I511_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I511_MP20 (I0_pp0_8 I0_B_1_b3_1 XI0_I511_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I511_MP19 (XI0_I511_xp1 XI0_I511_xan I0_pp0_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I511_MP17 (VDD XI0_I511_xn XI0_I511_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I511_MP6 (XI0_I511_p1 I0_A_8_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I511_MP8 (XI0_I511_xn I0_A_7_b3_0 XI0_I511_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I511_MP7 (XI0_I511_p1 I0_two0_b3_1 XI0_I511_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I511_MP5 (VDD I0_one0_b3_1 XI0_I511_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I511_MP10 (XI0_I511_xan XI0_I511_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I509_MP12 (VDD I0_B_1_b3_1 XI0_I509_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I509_MP18 (XI0_I509_xp1 XI0_I509_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I509_MP20 (I0_pp0_6 I0_B_1_b3_1 XI0_I509_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I509_MP19 (XI0_I509_xp1 XI0_I509_xan I0_pp0_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I509_MP17 (VDD XI0_I509_xn XI0_I509_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I509_MP6 (XI0_I509_p1 I0_A_6_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I509_MP8 (XI0_I509_xn I0_A_5_b3_0 XI0_I509_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I509_MP7 (XI0_I509_p1 I0_two0_b3_1 XI0_I509_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I509_MP5 (VDD I0_one0_b3_1 XI0_I509_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I509_MP10 (XI0_I509_xan XI0_I509_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I564_MP12 (VDD I0_B_3_b3_1 XI0_I564_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I564_MP18 (XI0_I564_xp1 XI0_I564_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I564_MP20 (I0_pp1_6 I0_B_3_b3_1 XI0_I564_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I564_MP19 (XI0_I564_xp1 XI0_I564_xan I0_pp1_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I564_MP17 (VDD XI0_I564_xn XI0_I564_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I564_MP6 (XI0_I564_p1 I0_A_6_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I564_MP8 (XI0_I564_xn I0_A_5_b3_0 XI0_I564_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I564_MP7 (XI0_I564_p1 I0_two1_b3_1 XI0_I564_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I564_MP5 (VDD I0_one1_b3_1 XI0_I564_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I564_MP10 (XI0_I564_xan XI0_I564_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I618_MP12 (VDD I0_B_5_b3_1 XI0_I618_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I618_MP18 (XI0_I618_xp1 XI0_I618_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I618_MP20 (I0_pp2_5 I0_B_5_b3_1 XI0_I618_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I618_MP19 (XI0_I618_xp1 XI0_I618_xan I0_pp2_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I618_MP17 (VDD XI0_I618_xn XI0_I618_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I618_MP6 (XI0_I618_p1 I0_A_5_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I618_MP8 (XI0_I618_xn I0_A_4_b3_0 XI0_I618_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I618_MP7 (XI0_I618_p1 I0_two2_b3_0 XI0_I618_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I618_MP5 (VDD I0_one2_b3_0 XI0_I618_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I618_MP10 (XI0_I618_xan XI0_I618_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I619_MP12 (VDD I0_B_5_b3_1 XI0_I619_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I619_MP18 (XI0_I619_xp1 XI0_I619_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I619_MP20 (I0_pp2_6 I0_B_5_b3_1 XI0_I619_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I619_MP19 (XI0_I619_xp1 XI0_I619_xan I0_pp2_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I619_MP17 (VDD XI0_I619_xn XI0_I619_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I619_MP6 (XI0_I619_p1 I0_A_6_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I619_MP8 (XI0_I619_xn I0_A_5_b3_0 XI0_I619_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I619_MP7 (XI0_I619_p1 I0_two2_b3_1 XI0_I619_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I619_MP5 (VDD I0_one2_b3_1 XI0_I619_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I619_MP10 (XI0_I619_xan XI0_I619_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I566_MP12 (VDD I0_B_3_b3_1 XI0_I566_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I566_MP18 (XI0_I566_xp1 XI0_I566_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I566_MP20 (I0_pp1_8 I0_B_3_b3_1 XI0_I566_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I566_MP19 (XI0_I566_xp1 XI0_I566_xan I0_pp1_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I566_MP17 (VDD XI0_I566_xn XI0_I566_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I566_MP6 (XI0_I566_p1 I0_A_8_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I566_MP8 (XI0_I566_xn I0_A_7_b3_0 XI0_I566_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I566_MP7 (XI0_I566_p1 I0_two1_b3_1 XI0_I566_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I566_MP5 (VDD I0_one1_b3_1 XI0_I566_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I566_MP10 (XI0_I566_xan XI0_I566_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I621_MP12 (VDD I0_B_5_b3_1 XI0_I621_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I621_MP18 (XI0_I621_xp1 XI0_I621_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I621_MP20 (I0_pp2_8 I0_B_5_b3_1 XI0_I621_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I621_MP19 (XI0_I621_xp1 XI0_I621_xan I0_pp2_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I621_MP17 (VDD XI0_I621_xn XI0_I621_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I621_MP6 (XI0_I621_p1 I0_A_8_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I621_MP8 (XI0_I621_xn I0_A_7_b3_0 XI0_I621_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I621_MP7 (XI0_I621_p1 I0_two2_b3_1 XI0_I621_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I621_MP5 (VDD I0_one2_b3_1 XI0_I621_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I621_MP10 (XI0_I621_xan XI0_I621_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I620_MP12 (VDD I0_B_5_b3_1 XI0_I620_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I620_MP18 (XI0_I620_xp1 XI0_I620_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I620_MP20 (I0_pp2_7 I0_B_5_b3_1 XI0_I620_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I620_MP19 (XI0_I620_xp1 XI0_I620_xan I0_pp2_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I620_MP17 (VDD XI0_I620_xn XI0_I620_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I620_MP6 (XI0_I620_p1 I0_A_7_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I620_MP8 (XI0_I620_xn I0_A_6_b3_0 XI0_I620_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I620_MP7 (XI0_I620_p1 I0_two2_b3_1 XI0_I620_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I620_MP5 (VDD I0_one2_b3_1 XI0_I620_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I620_MP10 (XI0_I620_xan XI0_I620_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I674_MP12 (VDD I0_B_7_b3_1 XI0_I674_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I674_MP18 (XI0_I674_xp1 XI0_I674_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I674_MP20 (I0_pp3_6 I0_B_7_b3_1 XI0_I674_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I674_MP19 (XI0_I674_xp1 XI0_I674_xan I0_pp3_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I674_MP17 (VDD XI0_I674_xn XI0_I674_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I674_MP6 (XI0_I674_p1 I0_A_6_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I674_MP8 (XI0_I674_xn I0_A_5_b3_1 XI0_I674_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I674_MP7 (XI0_I674_p1 I0_two3_b3_1 XI0_I674_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I674_MP5 (VDD I0_one3_b3_1 XI0_I674_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I674_MP10 (XI0_I674_xan XI0_I674_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I673_MP12 (VDD I0_B_7_b3_1 XI0_I673_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I673_MP18 (XI0_I673_xp1 XI0_I673_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I673_MP20 (I0_pp3_5 I0_B_7_b3_1 XI0_I673_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I673_MP19 (XI0_I673_xp1 XI0_I673_xan I0_pp3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I673_MP17 (VDD XI0_I673_xn XI0_I673_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I673_MP6 (XI0_I673_p1 I0_A_5_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I673_MP8 (XI0_I673_xn I0_A_4_b3_1 XI0_I673_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I673_MP7 (XI0_I673_p1 I0_two3_b3_0 XI0_I673_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I673_MP5 (VDD I0_one3_b3_0 XI0_I673_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I673_MP10 (XI0_I673_xan XI0_I673_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I733_MP12 (VDD I0_B_9_b3_1 XI0_I733_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I733_MP18 (XI0_I733_xp1 XI0_I733_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I733_MP20 (I0_pp4_10 I0_B_9_b3_1 XI0_I733_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I733_MP19 (XI0_I733_xp1 XI0_I733_xan I0_pp4_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I733_MP17 (VDD XI0_I733_xn XI0_I733_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I733_MP6 (XI0_I733_p1 I0_A_10_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I733_MP8 (XI0_I733_xn I0_A_9_b3_1 XI0_I733_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I733_MP7 (XI0_I733_p1 I0_two4_b3_1 XI0_I733_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I733_MP5 (VDD I0_one4_b3_1 XI0_I733_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I733_MP10 (XI0_I733_xan XI0_I733_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I788_MP12 (VDD I0_B_11_b3_1 XI0_I788_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I788_MP18 (XI0_I788_xp1 XI0_I788_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I788_MP20 (I0_pp5_10 I0_B_11_b3_1 XI0_I788_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I788_MP19 (XI0_I788_xp1 XI0_I788_xan I0_pp5_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I788_MP17 (VDD XI0_I788_xn XI0_I788_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I788_MP6 (XI0_I788_p1 I0_A_10_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I788_MP8 (XI0_I788_xn I0_A_9_b3_2 XI0_I788_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I788_MP7 (XI0_I788_p1 I0_two5_b3_1 XI0_I788_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I788_MP5 (VDD I0_one5_b3_1 XI0_I788_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I788_MP10 (XI0_I788_xan XI0_I788_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I842_MP12 (VDD I0_B_13_b3_1 XI0_I842_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I842_MP18 (XI0_I842_xp1 XI0_I842_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I842_MP20 (I0_pp6_9 I0_B_13_b3_1 XI0_I842_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I842_MP19 (XI0_I842_xp1 XI0_I842_xan I0_pp6_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I842_MP17 (VDD XI0_I842_xn XI0_I842_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I842_MP6 (XI0_I842_p1 I0_A_9_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I842_MP8 (XI0_I842_xn I0_A_8_b3_2 XI0_I842_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I842_MP7 (XI0_I842_p1 I0_two6_b3_1 XI0_I842_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I842_MP5 (VDD I0_one6_b3_1 XI0_I842_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I842_MP10 (XI0_I842_xan XI0_I842_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I896_MP12 (VDD I0_B_15_b3_1 XI0_I896_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I896_MP18 (XI0_I896_xp1 XI0_I896_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I896_MP20 (I0_pp7_8 I0_B_15_b3_1 XI0_I896_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I896_MP19 (XI0_I896_xp1 XI0_I896_xan I0_pp7_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I896_MP17 (VDD XI0_I896_xn XI0_I896_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I896_MP6 (XI0_I896_p1 I0_A_8_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I896_MP8 (XI0_I896_xn I0_A_7_b3_2 XI0_I896_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I896_MP7 (XI0_I896_p1 I0_two7_b3_1 XI0_I896_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I896_MP5 (VDD I0_one7_b3_1 XI0_I896_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I896_MP10 (XI0_I896_xan XI0_I896_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I898_MP12 (VDD I0_B_15_b3_1 XI0_I898_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I898_MP18 (XI0_I898_xp1 XI0_I898_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I898_MP20 (I0_pp7_10 I0_B_15_b3_1 XI0_I898_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I898_MP19 (XI0_I898_xp1 XI0_I898_xan I0_pp7_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I898_MP17 (VDD XI0_I898_xn XI0_I898_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I898_MP6 (XI0_I898_p1 I0_A_10_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I898_MP8 (XI0_I898_xn I0_A_9_b3_2 XI0_I898_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I898_MP7 (XI0_I898_p1 I0_two7_b3_1 XI0_I898_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I898_MP5 (VDD I0_one7_b3_1 XI0_I898_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I898_MP10 (XI0_I898_xan XI0_I898_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I914_MP12 (VDD I0_B_15_b3_4 XI0_I914_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I914_MP18 (XI0_I914_xp1 XI0_I914_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I914_MP20 (I0_pp7_26 I0_B_15_b3_4 XI0_I914_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I914_MP19 (XI0_I914_xp1 XI0_I914_xan I0_pp7_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I914_MP17 (VDD XI0_I914_xn XI0_I914_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I914_MP6 (XI0_I914_p1 I0_A_26_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I914_MP8 (XI0_I914_xn I0_A_25_b3_2 XI0_I914_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I914_MP7 (XI0_I914_p1 I0_two7_b3_4 XI0_I914_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I914_MP5 (VDD I0_one7_b3_4 XI0_I914_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I914_MP10 (XI0_I914_xan XI0_I914_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I916_MP12 (VDD I0_B_15_b3_4 XI0_I916_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I916_MP18 (XI0_I916_xp1 XI0_I916_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I916_MP20 (I0_pp7_28 I0_B_15_b3_4 XI0_I916_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I916_MP19 (XI0_I916_xp1 XI0_I916_xan I0_pp7_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I916_MP17 (VDD XI0_I916_xn XI0_I916_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I916_MP6 (XI0_I916_p1 I0_A_28_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I916_MP8 (XI0_I916_xn I0_A_27_b3_2 XI0_I916_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I916_MP7 (XI0_I916_p1 I0_two7_b3_5 XI0_I916_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I916_MP5 (VDD I0_one7_b3_5 XI0_I916_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I916_MP10 (XI0_I916_xan XI0_I916_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I917_MP12 (VDD I0_B_15_b3_5 XI0_I917_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I917_MP18 (XI0_I917_xp1 XI0_I917_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I917_MP20 (I0_pp7_29 I0_B_15_b3_5 XI0_I917_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I917_MP19 (XI0_I917_xp1 XI0_I917_xan I0_pp7_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I917_MP17 (VDD XI0_I917_xn XI0_I917_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I917_MP6 (XI0_I917_p1 I0_A_29_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I917_MP8 (XI0_I917_xn I0_A_28_b3_2 XI0_I917_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I917_MP7 (XI0_I917_p1 I0_two7_b3_5 XI0_I917_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I917_MP5 (VDD I0_one7_b3_5 XI0_I917_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I917_MP10 (XI0_I917_xan XI0_I917_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I919_MP12 (VDD I0_B_15_b3_5 XI0_I919_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I919_MP18 (XI0_I919_xp1 XI0_I919_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I919_MP20 (I0_pp7_31 I0_B_15_b3_5 XI0_I919_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I919_MP19 (XI0_I919_xp1 XI0_I919_xan I0_pp7_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I919_MP17 (VDD XI0_I919_xn XI0_I919_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I919_MP6 (XI0_I919_p1 I0_A_31_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I919_MP8 (XI0_I919_xn I0_A_30_b3_2 XI0_I919_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I919_MP7 (XI0_I919_p1 I0_two7_b3_5 XI0_I919_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I919_MP5 (VDD I0_one7_b3_5 XI0_I919_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I919_MP10 (XI0_I919_xan XI0_I919_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I864_MP12 (VDD I0_B_13_b3_5 XI0_I864_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I864_MP18 (XI0_I864_xp1 XI0_I864_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I864_MP20 (I0_pp6_31 I0_B_13_b3_5 XI0_I864_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I864_MP19 (XI0_I864_xp1 XI0_I864_xan I0_pp6_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I864_MP17 (VDD XI0_I864_xn XI0_I864_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I864_MP6 (XI0_I864_p1 I0_A_31_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I864_MP8 (XI0_I864_xn I0_A_30_b3_2 XI0_I864_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I864_MP7 (XI0_I864_p1 I0_two6_b3_5 XI0_I864_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I864_MP5 (VDD I0_one6_b3_5 XI0_I864_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I864_MP10 (XI0_I864_xan XI0_I864_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I508_MP12 (VDD I0_B_1_b3_1 XI0_I508_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I508_MP18 (XI0_I508_xp1 XI0_I508_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I508_MP20 (I0_pp0_5 I0_B_1_b3_1 XI0_I508_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I508_MP19 (XI0_I508_xp1 XI0_I508_xan I0_pp0_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I508_MP17 (VDD XI0_I508_xn XI0_I508_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I508_MP6 (XI0_I508_p1 I0_A_5_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I508_MP8 (XI0_I508_xn I0_A_4_b3_0 XI0_I508_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I508_MP7 (XI0_I508_p1 I0_two0_b3_0 XI0_I508_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I508_MP5 (VDD I0_one0_b3_0 XI0_I508_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I508_MP10 (XI0_I508_xan XI0_I508_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I563_MP12 (VDD I0_B_3_b3_1 XI0_I563_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I563_MP18 (XI0_I563_xp1 XI0_I563_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I563_MP20 (I0_pp1_5 I0_B_3_b3_1 XI0_I563_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I563_MP19 (XI0_I563_xp1 XI0_I563_xan I0_pp1_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I563_MP17 (VDD XI0_I563_xn XI0_I563_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I563_MP6 (XI0_I563_p1 I0_A_5_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I563_MP8 (XI0_I563_xn I0_A_4_b3_0 XI0_I563_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I563_MP7 (XI0_I563_p1 I0_two1_b3_0 XI0_I563_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I563_MP5 (VDD I0_one1_b3_0 XI0_I563_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I563_MP10 (XI0_I563_xan XI0_I563_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I671_MP12 (VDD I0_B_7_b3_0 XI0_I671_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I671_MP18 (XI0_I671_xp1 XI0_I671_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I671_MP20 (I0_pp3_3 I0_B_7_b3_0 XI0_I671_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I671_MP19 (XI0_I671_xp1 XI0_I671_xan I0_pp3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I671_MP17 (VDD XI0_I671_xn XI0_I671_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I671_MP6 (XI0_I671_p1 I0_A_3_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I671_MP8 (XI0_I671_xn I0_A_2_b3_1 XI0_I671_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I671_MP7 (XI0_I671_p1 I0_two3_b3_0 XI0_I671_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I671_MP5 (VDD I0_one3_b3_0 XI0_I671_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I671_MP10 (XI0_I671_xan XI0_I671_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I672_MP12 (VDD I0_B_7_b3_0 XI0_I672_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I672_MP18 (XI0_I672_xp1 XI0_I672_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I672_MP20 (I0_pp3_4 I0_B_7_b3_0 XI0_I672_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I672_MP19 (XI0_I672_xp1 XI0_I672_xan I0_pp3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I672_MP17 (VDD XI0_I672_xn XI0_I672_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I672_MP6 (XI0_I672_p1 I0_A_4_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I672_MP8 (XI0_I672_xn I0_A_3_b3_1 XI0_I672_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I672_MP7 (XI0_I672_p1 I0_two3_b3_0 XI0_I672_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I672_MP5 (VDD I0_one3_b3_0 XI0_I672_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I672_MP10 (XI0_I672_xan XI0_I672_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I729_MP12 (VDD I0_B_9_b3_1 XI0_I729_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I729_MP18 (XI0_I729_xp1 XI0_I729_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I729_MP20 (I0_pp4_6 I0_B_9_b3_1 XI0_I729_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I729_MP19 (XI0_I729_xp1 XI0_I729_xan I0_pp4_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I729_MP17 (VDD XI0_I729_xn XI0_I729_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I729_MP6 (XI0_I729_p1 I0_A_6_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I729_MP8 (XI0_I729_xn I0_A_5_b3_1 XI0_I729_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I729_MP7 (XI0_I729_p1 I0_two4_b3_1 XI0_I729_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I729_MP5 (VDD I0_one4_b3_1 XI0_I729_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I729_MP10 (XI0_I729_xan XI0_I729_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I731_MP12 (VDD I0_B_9_b3_1 XI0_I731_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I731_MP18 (XI0_I731_xp1 XI0_I731_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I731_MP20 (I0_pp4_8 I0_B_9_b3_1 XI0_I731_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I731_MP19 (XI0_I731_xp1 XI0_I731_xan I0_pp4_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I731_MP17 (VDD XI0_I731_xn XI0_I731_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I731_MP6 (XI0_I731_p1 I0_A_8_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I731_MP8 (XI0_I731_xn I0_A_7_b3_1 XI0_I731_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I731_MP7 (XI0_I731_p1 I0_two4_b3_1 XI0_I731_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I731_MP5 (VDD I0_one4_b3_1 XI0_I731_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I731_MP10 (XI0_I731_xan XI0_I731_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I732_MP12 (VDD I0_B_9_b3_1 XI0_I732_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I732_MP18 (XI0_I732_xp1 XI0_I732_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I732_MP20 (I0_pp4_9 I0_B_9_b3_1 XI0_I732_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I732_MP19 (XI0_I732_xp1 XI0_I732_xan I0_pp4_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I732_MP17 (VDD XI0_I732_xn XI0_I732_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I732_MP6 (XI0_I732_p1 I0_A_9_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I732_MP8 (XI0_I732_xn I0_A_8_b3_1 XI0_I732_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I732_MP7 (XI0_I732_p1 I0_two4_b3_1 XI0_I732_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I732_MP5 (VDD I0_one4_b3_1 XI0_I732_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I732_MP10 (XI0_I732_xan XI0_I732_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I786_MP12 (VDD I0_B_11_b3_1 XI0_I786_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I786_MP18 (XI0_I786_xp1 XI0_I786_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I786_MP20 (I0_pp5_8 I0_B_11_b3_1 XI0_I786_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I786_MP19 (XI0_I786_xp1 XI0_I786_xan I0_pp5_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I786_MP17 (VDD XI0_I786_xn XI0_I786_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I786_MP6 (XI0_I786_p1 I0_A_8_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I786_MP8 (XI0_I786_xn I0_A_7_b3_2 XI0_I786_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I786_MP7 (XI0_I786_p1 I0_two5_b3_1 XI0_I786_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I786_MP5 (VDD I0_one5_b3_1 XI0_I786_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I786_MP10 (XI0_I786_xan XI0_I786_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I787_MP12 (VDD I0_B_11_b3_1 XI0_I787_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I787_MP18 (XI0_I787_xp1 XI0_I787_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I787_MP20 (I0_pp5_9 I0_B_11_b3_1 XI0_I787_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I787_MP19 (XI0_I787_xp1 XI0_I787_xan I0_pp5_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I787_MP17 (VDD XI0_I787_xn XI0_I787_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I787_MP6 (XI0_I787_p1 I0_A_9_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I787_MP8 (XI0_I787_xn I0_A_8_b3_2 XI0_I787_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I787_MP7 (XI0_I787_p1 I0_two5_b3_1 XI0_I787_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I787_MP5 (VDD I0_one5_b3_1 XI0_I787_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I787_MP10 (XI0_I787_xan XI0_I787_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I897_MP12 (VDD I0_B_15_b3_1 XI0_I897_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I897_MP18 (XI0_I897_xp1 XI0_I897_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I897_MP20 (I0_pp7_9 I0_B_15_b3_1 XI0_I897_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I897_MP19 (XI0_I897_xp1 XI0_I897_xan I0_pp7_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I897_MP17 (VDD XI0_I897_xn XI0_I897_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I897_MP6 (XI0_I897_p1 I0_A_9_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I897_MP8 (XI0_I897_xn I0_A_8_b3_2 XI0_I897_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I897_MP7 (XI0_I897_p1 I0_two7_b3_1 XI0_I897_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I897_MP5 (VDD I0_one7_b3_1 XI0_I897_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I897_MP10 (XI0_I897_xan XI0_I897_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I841_MP12 (VDD I0_B_13_b3_1 XI0_I841_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I841_MP18 (XI0_I841_xp1 XI0_I841_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I841_MP20 (I0_pp6_8 I0_B_13_b3_1 XI0_I841_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I841_MP19 (XI0_I841_xp1 XI0_I841_xan I0_pp6_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I841_MP17 (VDD XI0_I841_xn XI0_I841_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I841_MP6 (XI0_I841_p1 I0_A_8_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I841_MP8 (XI0_I841_xn I0_A_7_b3_2 XI0_I841_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I841_MP7 (XI0_I841_p1 I0_two6_b3_1 XI0_I841_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I841_MP5 (VDD I0_one6_b3_1 XI0_I841_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I841_MP10 (XI0_I841_xan XI0_I841_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I918_MP12 (VDD I0_B_15_b3_5 XI0_I918_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I918_MP18 (XI0_I918_xp1 XI0_I918_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I918_MP20 (I0_pp7_30 I0_B_15_b3_5 XI0_I918_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I918_MP19 (XI0_I918_xp1 XI0_I918_xan I0_pp7_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I918_MP17 (VDD XI0_I918_xn XI0_I918_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I918_MP6 (XI0_I918_p1 I0_A_30_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I918_MP8 (XI0_I918_xn I0_A_29_b3_2 XI0_I918_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I918_MP7 (XI0_I918_p1 I0_two7_b3_5 XI0_I918_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I918_MP5 (VDD I0_one7_b3_5 XI0_I918_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I918_MP10 (XI0_I918_xan XI0_I918_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I920_MP12 (VDD I0_B_15_b3_5 XI0_I920_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I920_MP18 (XI0_I920_xp1 XI0_I920_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I920_MP20 (I0_pp7_32 I0_B_15_b3_5 XI0_I920_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I920_MP19 (XI0_I920_xp1 XI0_I920_xan I0_pp7_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I920_MP17 (VDD XI0_I920_xn XI0_I920_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I920_MP6 (XI0_I920_p1 I0_A_31_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I920_MP8 (XI0_I920_xn I0_A_31_b3_3 XI0_I920_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I920_MP7 (XI0_I920_p1 I0_two7_b3_5 XI0_I920_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I920_MP5 (VDD I0_one7_b3_5 XI0_I920_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I920_MP10 (XI0_I920_xan XI0_I920_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I670_MP12 (VDD I0_B_7_b3_0 XI0_I670_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I670_MP18 (XI0_I670_xp1 XI0_I670_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I670_MP20 (I0_pp3_2 I0_B_7_b3_0 XI0_I670_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I670_MP19 (XI0_I670_xp1 XI0_I670_xan I0_pp3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I670_MP17 (VDD XI0_I670_xn XI0_I670_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I670_MP6 (XI0_I670_p1 I0_A_2_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I670_MP8 (XI0_I670_xn I0_A_1_b3_1 XI0_I670_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I670_MP7 (XI0_I670_p1 I0_two3_b3_0 XI0_I670_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I670_MP5 (VDD I0_one3_b3_0 XI0_I670_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I670_MP10 (XI0_I670_xan XI0_I670_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I727_MP12 (VDD I0_B_9_b3_0 XI0_I727_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I727_MP18 (XI0_I727_xp1 XI0_I727_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I727_MP20 (I0_pp4_4 I0_B_9_b3_0 XI0_I727_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I727_MP19 (XI0_I727_xp1 XI0_I727_xan I0_pp4_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I727_MP17 (VDD XI0_I727_xn XI0_I727_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I727_MP6 (XI0_I727_p1 I0_A_4_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I727_MP8 (XI0_I727_xn I0_A_3_b3_1 XI0_I727_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I727_MP7 (XI0_I727_p1 I0_two4_b3_0 XI0_I727_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I727_MP5 (VDD I0_one4_b3_0 XI0_I727_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I727_MP10 (XI0_I727_xan XI0_I727_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I725_MP12 (VDD I0_B_9_b3_0 XI0_I725_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I725_MP18 (XI0_I725_xp1 XI0_I725_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I725_MP20 (I0_pp4_2 I0_B_9_b3_0 XI0_I725_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I725_MP19 (XI0_I725_xp1 XI0_I725_xan I0_pp4_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I725_MP17 (VDD XI0_I725_xn XI0_I725_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I725_MP6 (XI0_I725_p1 I0_A_2_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I725_MP8 (XI0_I725_xn I0_A_1_b3_1 XI0_I725_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I725_MP7 (XI0_I725_p1 I0_two4_b3_0 XI0_I725_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I725_MP5 (VDD I0_one4_b3_0 XI0_I725_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I725_MP10 (XI0_I725_xan XI0_I725_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I728_MP12 (VDD I0_B_9_b3_1 XI0_I728_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I728_MP18 (XI0_I728_xp1 XI0_I728_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I728_MP20 (I0_pp4_5 I0_B_9_b3_1 XI0_I728_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I728_MP19 (XI0_I728_xp1 XI0_I728_xan I0_pp4_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I728_MP17 (VDD XI0_I728_xn XI0_I728_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I728_MP6 (XI0_I728_p1 I0_A_5_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I728_MP8 (XI0_I728_xn I0_A_4_b3_1 XI0_I728_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I728_MP7 (XI0_I728_p1 I0_two4_b3_0 XI0_I728_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I728_MP5 (VDD I0_one4_b3_0 XI0_I728_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I728_MP10 (XI0_I728_xan XI0_I728_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I730_MP12 (VDD I0_B_9_b3_1 XI0_I730_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I730_MP18 (XI0_I730_xp1 XI0_I730_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I730_MP20 (I0_pp4_7 I0_B_9_b3_1 XI0_I730_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I730_MP19 (XI0_I730_xp1 XI0_I730_xan I0_pp4_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I730_MP17 (VDD XI0_I730_xn XI0_I730_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I730_MP6 (XI0_I730_p1 I0_A_7_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I730_MP8 (XI0_I730_xn I0_A_6_b3_1 XI0_I730_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I730_MP7 (XI0_I730_p1 I0_two4_b3_1 XI0_I730_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I730_MP5 (VDD I0_one4_b3_1 XI0_I730_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I730_MP10 (XI0_I730_xan XI0_I730_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I784_MP12 (VDD I0_B_11_b3_1 XI0_I784_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I784_MP18 (XI0_I784_xp1 XI0_I784_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I784_MP20 (I0_pp5_6 I0_B_11_b3_1 XI0_I784_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I784_MP19 (XI0_I784_xp1 XI0_I784_xan I0_pp5_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I784_MP17 (VDD XI0_I784_xn XI0_I784_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I784_MP6 (XI0_I784_p1 I0_A_6_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I784_MP8 (XI0_I784_xn I0_A_5_b3_2 XI0_I784_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I784_MP7 (XI0_I784_p1 I0_two5_b3_1 XI0_I784_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I784_MP5 (VDD I0_one5_b3_1 XI0_I784_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I784_MP10 (XI0_I784_xan XI0_I784_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I839_MP12 (VDD I0_B_13_b3_1 XI0_I839_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I839_MP18 (XI0_I839_xp1 XI0_I839_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I839_MP20 (I0_pp6_6 I0_B_13_b3_1 XI0_I839_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I839_MP19 (XI0_I839_xp1 XI0_I839_xan I0_pp6_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I839_MP17 (VDD XI0_I839_xn XI0_I839_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I839_MP6 (XI0_I839_p1 I0_A_6_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I839_MP8 (XI0_I839_xn I0_A_5_b3_2 XI0_I839_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I839_MP7 (XI0_I839_p1 I0_two6_b3_1 XI0_I839_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I839_MP5 (VDD I0_one6_b3_1 XI0_I839_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I839_MP10 (XI0_I839_xan XI0_I839_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I785_MP12 (VDD I0_B_11_b3_1 XI0_I785_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I785_MP18 (XI0_I785_xp1 XI0_I785_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I785_MP20 (I0_pp5_7 I0_B_11_b3_1 XI0_I785_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I785_MP19 (XI0_I785_xp1 XI0_I785_xan I0_pp5_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I785_MP17 (VDD XI0_I785_xn XI0_I785_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I785_MP6 (XI0_I785_p1 I0_A_7_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I785_MP8 (XI0_I785_xn I0_A_6_b3_2 XI0_I785_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I785_MP7 (XI0_I785_p1 I0_two5_b3_1 XI0_I785_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I785_MP5 (VDD I0_one5_b3_1 XI0_I785_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I785_MP10 (XI0_I785_xan XI0_I785_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I838_MP12 (VDD I0_B_13_b3_1 XI0_I838_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I838_MP18 (XI0_I838_xp1 XI0_I838_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I838_MP20 (I0_pp6_5 I0_B_13_b3_1 XI0_I838_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I838_MP19 (XI0_I838_xp1 XI0_I838_xan I0_pp6_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I838_MP17 (VDD XI0_I838_xn XI0_I838_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I838_MP6 (XI0_I838_p1 I0_A_5_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I838_MP8 (XI0_I838_xn I0_A_4_b3_2 XI0_I838_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I838_MP7 (XI0_I838_p1 I0_two6_b3_0 XI0_I838_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I838_MP5 (VDD I0_one6_b3_0 XI0_I838_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I838_MP10 (XI0_I838_xan XI0_I838_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I840_MP12 (VDD I0_B_13_b3_1 XI0_I840_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I840_MP18 (XI0_I840_xp1 XI0_I840_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I840_MP20 (I0_pp6_7 I0_B_13_b3_1 XI0_I840_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I840_MP19 (XI0_I840_xp1 XI0_I840_xan I0_pp6_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I840_MP17 (VDD XI0_I840_xn XI0_I840_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I840_MP6 (XI0_I840_p1 I0_A_7_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I840_MP8 (XI0_I840_xn I0_A_6_b3_2 XI0_I840_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I840_MP7 (XI0_I840_p1 I0_two6_b3_1 XI0_I840_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I840_MP5 (VDD I0_one6_b3_1 XI0_I840_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I840_MP10 (XI0_I840_xan XI0_I840_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I895_MP12 (VDD I0_B_15_b3_1 XI0_I895_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I895_MP18 (XI0_I895_xp1 XI0_I895_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I895_MP20 (I0_pp7_7 I0_B_15_b3_1 XI0_I895_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I895_MP19 (XI0_I895_xp1 XI0_I895_xan I0_pp7_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I895_MP17 (VDD XI0_I895_xn XI0_I895_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I895_MP6 (XI0_I895_p1 I0_A_7_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I895_MP8 (XI0_I895_xn I0_A_6_b3_2 XI0_I895_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I895_MP7 (XI0_I895_p1 I0_two7_b3_1 XI0_I895_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I895_MP5 (VDD I0_one7_b3_1 XI0_I895_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I895_MP10 (XI0_I895_xan XI0_I895_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I894_MP12 (VDD I0_B_15_b3_1 XI0_I894_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I894_MP18 (XI0_I894_xp1 XI0_I894_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I894_MP20 (I0_pp7_6 I0_B_15_b3_1 XI0_I894_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I894_MP19 (XI0_I894_xp1 XI0_I894_xan I0_pp7_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I894_MP17 (VDD XI0_I894_xn XI0_I894_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I894_MP6 (XI0_I894_p1 I0_A_6_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I894_MP8 (XI0_I894_xn I0_A_5_b3_2 XI0_I894_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I894_MP7 (XI0_I894_p1 I0_two7_b3_1 XI0_I894_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I894_MP5 (VDD I0_one7_b3_1 XI0_I894_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I894_MP10 (XI0_I894_xan XI0_I894_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I617_MP12 (VDD I0_B_5_b3_0 XI0_I617_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I617_MP18 (XI0_I617_xp1 XI0_I617_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I617_MP20 (I0_pp2_4 I0_B_5_b3_0 XI0_I617_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I617_MP19 (XI0_I617_xp1 XI0_I617_xan I0_pp2_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I617_MP17 (VDD XI0_I617_xn XI0_I617_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I617_MP6 (XI0_I617_p1 I0_A_4_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I617_MP8 (XI0_I617_xn I0_A_3_b3_0 XI0_I617_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I617_MP7 (XI0_I617_p1 I0_two2_b3_0 XI0_I617_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I617_MP5 (VDD I0_one2_b3_0 XI0_I617_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I617_MP10 (XI0_I617_xan XI0_I617_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I668_MP12 (VDD I0_B_7_b3_0 XI0_I668_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I668_MP18 (XI0_I668_xp1 XI0_I668_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I668_MP20 (I0_pp3_0 I0_B_7_b3_0 XI0_I668_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I668_MP19 (XI0_I668_xp1 XI0_I668_xan I0_pp3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I668_MP17 (VDD XI0_I668_xn XI0_I668_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I668_MP6 (XI0_I668_p1 I0_A_0_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I668_MP8 (XI0_I668_xn VSS XI0_I668_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I668_MP7 (XI0_I668_p1 I0_two3_b3_0 XI0_I668_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I668_MP5 (VDD I0_one3_b3_0 XI0_I668_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I668_MP10 (XI0_I668_xan XI0_I668_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I562_MP12 (VDD I0_B_3_b3_0 XI0_I562_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I562_MP18 (XI0_I562_xp1 XI0_I562_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I562_MP20 (I0_pp1_4 I0_B_3_b3_0 XI0_I562_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I562_MP19 (XI0_I562_xp1 XI0_I562_xan I0_pp1_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I562_MP17 (VDD XI0_I562_xn XI0_I562_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I562_MP6 (XI0_I562_p1 I0_A_4_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I562_MP8 (XI0_I562_xn I0_A_3_b3_0 XI0_I562_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I562_MP7 (XI0_I562_p1 I0_two1_b3_0 XI0_I562_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I562_MP5 (VDD I0_one1_b3_0 XI0_I562_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I562_MP10 (XI0_I562_xan XI0_I562_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I669_MP12 (VDD I0_B_7_b3_0 XI0_I669_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I669_MP18 (XI0_I669_xp1 XI0_I669_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I669_MP20 (I0_pp3_1 I0_B_7_b3_0 XI0_I669_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I669_MP19 (XI0_I669_xp1 XI0_I669_xan I0_pp3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I669_MP17 (VDD XI0_I669_xn XI0_I669_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I669_MP6 (XI0_I669_p1 I0_A_1_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I669_MP8 (XI0_I669_xn I0_A_0_b3_1 XI0_I669_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I669_MP7 (XI0_I669_p1 I0_two3_b3_0 XI0_I669_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I669_MP5 (VDD I0_one3_b3_0 XI0_I669_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I669_MP10 (XI0_I669_xan XI0_I669_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I780_MP12 (VDD I0_B_11_b3_0 XI0_I780_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I780_MP18 (XI0_I780_xp1 XI0_I780_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I780_MP20 (I0_pp5_2 I0_B_11_b3_0 XI0_I780_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I780_MP19 (XI0_I780_xp1 XI0_I780_xan I0_pp5_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I780_MP17 (VDD XI0_I780_xn XI0_I780_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I780_MP6 (XI0_I780_p1 I0_A_2_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I780_MP8 (XI0_I780_xn I0_A_1_b3_2 XI0_I780_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I780_MP7 (XI0_I780_p1 I0_two5_b3_0 XI0_I780_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I780_MP5 (VDD I0_one5_b3_0 XI0_I780_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I780_MP10 (XI0_I780_xan XI0_I780_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I778_MP12 (VDD I0_B_11_b3_0 XI0_I778_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I778_MP18 (XI0_I778_xp1 XI0_I778_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I778_MP20 (I0_pp5_0 I0_B_11_b3_0 XI0_I778_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I778_MP19 (XI0_I778_xp1 XI0_I778_xan I0_pp5_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I778_MP17 (VDD XI0_I778_xn XI0_I778_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I778_MP6 (XI0_I778_p1 I0_A_0_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I778_MP8 (XI0_I778_xn VSS XI0_I778_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I778_MP7 (XI0_I778_p1 I0_two5_b3_0 XI0_I778_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I778_MP5 (VDD I0_one5_b3_0 XI0_I778_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I778_MP10 (XI0_I778_xan XI0_I778_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I888_MP12 (VDD I0_B_15_b3_0 XI0_I888_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I888_MP18 (XI0_I888_xp1 XI0_I888_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I888_MP20 (I0_pp7_0 I0_B_15_b3_0 XI0_I888_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I888_MP19 (XI0_I888_xp1 XI0_I888_xan I0_pp7_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I888_MP17 (VDD XI0_I888_xn XI0_I888_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I888_MP6 (XI0_I888_p1 I0_A_0_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I888_MP8 (XI0_I888_xn VSS XI0_I888_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I888_MP7 (XI0_I888_p1 I0_two7_b3_0 XI0_I888_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I888_MP5 (VDD I0_one7_b3_0 XI0_I888_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I888_MP10 (XI0_I888_xan XI0_I888_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I782_MP12 (VDD I0_B_11_b3_0 XI0_I782_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I782_MP18 (XI0_I782_xp1 XI0_I782_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I782_MP20 (I0_pp5_4 I0_B_11_b3_0 XI0_I782_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I782_MP19 (XI0_I782_xp1 XI0_I782_xan I0_pp5_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I782_MP17 (VDD XI0_I782_xn XI0_I782_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I782_MP6 (XI0_I782_p1 I0_A_4_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I782_MP8 (XI0_I782_xn I0_A_3_b3_2 XI0_I782_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I782_MP7 (XI0_I782_p1 I0_two5_b3_0 XI0_I782_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I782_MP5 (VDD I0_one5_b3_0 XI0_I782_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I782_MP10 (XI0_I782_xan XI0_I782_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I837_MP12 (VDD I0_B_13_b3_0 XI0_I837_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I837_MP18 (XI0_I837_xp1 XI0_I837_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I837_MP20 (I0_pp6_4 I0_B_13_b3_0 XI0_I837_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I837_MP19 (XI0_I837_xp1 XI0_I837_xan I0_pp6_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I837_MP17 (VDD XI0_I837_xn XI0_I837_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I837_MP6 (XI0_I837_p1 I0_A_4_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I837_MP8 (XI0_I837_xn I0_A_3_b3_2 XI0_I837_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I837_MP7 (XI0_I837_p1 I0_two6_b3_0 XI0_I837_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I837_MP5 (VDD I0_one6_b3_0 XI0_I837_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I837_MP10 (XI0_I837_xan XI0_I837_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I890_MP12 (VDD I0_B_15_b3_0 XI0_I890_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I890_MP18 (XI0_I890_xp1 XI0_I890_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I890_MP20 (I0_pp7_2 I0_B_15_b3_0 XI0_I890_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I890_MP19 (XI0_I890_xp1 XI0_I890_xan I0_pp7_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I890_MP17 (VDD XI0_I890_xn XI0_I890_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I890_MP6 (XI0_I890_p1 I0_A_2_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I890_MP8 (XI0_I890_xn I0_A_1_b3_2 XI0_I890_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I890_MP7 (XI0_I890_p1 I0_two7_b3_0 XI0_I890_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I890_MP5 (VDD I0_one7_b3_0 XI0_I890_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I890_MP10 (XI0_I890_xan XI0_I890_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I783_MP12 (VDD I0_B_11_b3_1 XI0_I783_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I783_MP18 (XI0_I783_xp1 XI0_I783_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I783_MP20 (I0_pp5_5 I0_B_11_b3_1 XI0_I783_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I783_MP19 (XI0_I783_xp1 XI0_I783_xan I0_pp5_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I783_MP17 (VDD XI0_I783_xn XI0_I783_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I783_MP6 (XI0_I783_p1 I0_A_5_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I783_MP8 (XI0_I783_xn I0_A_4_b3_2 XI0_I783_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I783_MP7 (XI0_I783_p1 I0_two5_b3_0 XI0_I783_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I783_MP5 (VDD I0_one5_b3_0 XI0_I783_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I783_MP10 (XI0_I783_xan XI0_I783_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I893_MP12 (VDD I0_B_15_b3_1 XI0_I893_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I893_MP18 (XI0_I893_xp1 XI0_I893_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I893_MP20 (I0_pp7_5 I0_B_15_b3_1 XI0_I893_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I893_MP19 (XI0_I893_xp1 XI0_I893_xan I0_pp7_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I893_MP17 (VDD XI0_I893_xn XI0_I893_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I893_MP6 (XI0_I893_p1 I0_A_5_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I893_MP8 (XI0_I893_xn I0_A_4_b3_2 XI0_I893_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I893_MP7 (XI0_I893_p1 I0_two7_b3_0 XI0_I893_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I893_MP5 (VDD I0_one7_b3_0 XI0_I893_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I893_MP10 (XI0_I893_xan XI0_I893_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I507_MP12 (VDD I0_B_1_b3_0 XI0_I507_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I507_MP18 (XI0_I507_xp1 XI0_I507_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I507_MP20 (I0_pp0_4 I0_B_1_b3_0 XI0_I507_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I507_MP19 (XI0_I507_xp1 XI0_I507_xan I0_pp0_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I507_MP17 (VDD XI0_I507_xn XI0_I507_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I507_MP6 (XI0_I507_p1 I0_A_4_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I507_MP8 (XI0_I507_xn I0_A_3_b3_0 XI0_I507_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I507_MP7 (XI0_I507_p1 I0_two0_b3_0 XI0_I507_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I507_MP5 (VDD I0_one0_b3_0 XI0_I507_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I507_MP10 (XI0_I507_xan XI0_I507_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I615_MP12 (VDD I0_B_5_b3_0 XI0_I615_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I615_MP18 (XI0_I615_xp1 XI0_I615_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I615_MP20 (I0_pp2_2 I0_B_5_b3_0 XI0_I615_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I615_MP19 (XI0_I615_xp1 XI0_I615_xan I0_pp2_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I615_MP17 (VDD XI0_I615_xn XI0_I615_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I615_MP6 (XI0_I615_p1 I0_A_2_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I615_MP8 (XI0_I615_xn I0_A_1_b3_0 XI0_I615_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I615_MP7 (XI0_I615_p1 I0_two2_b3_0 XI0_I615_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I615_MP5 (VDD I0_one2_b3_0 XI0_I615_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I615_MP10 (XI0_I615_xan XI0_I615_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I613_MP12 (VDD I0_B_5_b3_0 XI0_I613_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I613_MP18 (XI0_I613_xp1 XI0_I613_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I613_MP20 (I0_pp2_0 I0_B_5_b3_0 XI0_I613_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I613_MP19 (XI0_I613_xp1 XI0_I613_xan I0_pp2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I613_MP17 (VDD XI0_I613_xn XI0_I613_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I613_MP6 (XI0_I613_p1 I0_A_0_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I613_MP8 (XI0_I613_xn VSS XI0_I613_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I613_MP7 (XI0_I613_p1 I0_two2_b3_0 XI0_I613_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I613_MP5 (VDD I0_one2_b3_0 XI0_I613_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I613_MP10 (XI0_I613_xan XI0_I613_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I614_MP12 (VDD I0_B_5_b3_0 XI0_I614_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I614_MP18 (XI0_I614_xp1 XI0_I614_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I614_MP20 (I0_pp2_1 I0_B_5_b3_0 XI0_I614_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I614_MP19 (XI0_I614_xp1 XI0_I614_xan I0_pp2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I614_MP17 (VDD XI0_I614_xn XI0_I614_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I614_MP6 (XI0_I614_p1 I0_A_1_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I614_MP8 (XI0_I614_xn I0_A_0_b3_0 XI0_I614_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I614_MP7 (XI0_I614_p1 I0_two2_b3_0 XI0_I614_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I614_MP5 (VDD I0_one2_b3_0 XI0_I614_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I614_MP10 (XI0_I614_xan XI0_I614_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I616_MP12 (VDD I0_B_5_b3_0 XI0_I616_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I616_MP18 (XI0_I616_xp1 XI0_I616_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I616_MP20 (I0_pp2_3 I0_B_5_b3_0 XI0_I616_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I616_MP19 (XI0_I616_xp1 XI0_I616_xan I0_pp2_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I616_MP17 (VDD XI0_I616_xn XI0_I616_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I616_MP6 (XI0_I616_p1 I0_A_3_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I616_MP8 (XI0_I616_xn I0_A_2_b3_0 XI0_I616_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I616_MP7 (XI0_I616_p1 I0_two2_b3_0 XI0_I616_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I616_MP5 (VDD I0_one2_b3_0 XI0_I616_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I616_MP10 (XI0_I616_xan XI0_I616_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I723_MP12 (VDD I0_B_9_b3_0 XI0_I723_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I723_MP18 (XI0_I723_xp1 XI0_I723_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I723_MP20 (I0_pp4_0 I0_B_9_b3_0 XI0_I723_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I723_MP19 (XI0_I723_xp1 XI0_I723_xan I0_pp4_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I723_MP17 (VDD XI0_I723_xn XI0_I723_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I723_MP6 (XI0_I723_p1 I0_A_0_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I723_MP8 (XI0_I723_xn VSS XI0_I723_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I723_MP7 (XI0_I723_p1 I0_two4_b3_0 XI0_I723_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I723_MP5 (VDD I0_one4_b3_0 XI0_I723_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I723_MP10 (XI0_I723_xan XI0_I723_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I724_MP12 (VDD I0_B_9_b3_0 XI0_I724_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I724_MP18 (XI0_I724_xp1 XI0_I724_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I724_MP20 (I0_pp4_1 I0_B_9_b3_0 XI0_I724_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I724_MP19 (XI0_I724_xp1 XI0_I724_xan I0_pp4_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I724_MP17 (VDD XI0_I724_xn XI0_I724_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I724_MP6 (XI0_I724_p1 I0_A_1_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I724_MP8 (XI0_I724_xn I0_A_0_b3_1 XI0_I724_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I724_MP7 (XI0_I724_p1 I0_two4_b3_0 XI0_I724_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I724_MP5 (VDD I0_one4_b3_0 XI0_I724_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I724_MP10 (XI0_I724_xan XI0_I724_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I726_MP12 (VDD I0_B_9_b3_0 XI0_I726_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I726_MP18 (XI0_I726_xp1 XI0_I726_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I726_MP20 (I0_pp4_3 I0_B_9_b3_0 XI0_I726_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I726_MP19 (XI0_I726_xp1 XI0_I726_xan I0_pp4_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I726_MP17 (VDD XI0_I726_xn XI0_I726_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I726_MP6 (XI0_I726_p1 I0_A_3_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I726_MP8 (XI0_I726_xn I0_A_2_b3_1 XI0_I726_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I726_MP7 (XI0_I726_p1 I0_two4_b3_0 XI0_I726_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I726_MP5 (VDD I0_one4_b3_0 XI0_I726_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I726_MP10 (XI0_I726_xan XI0_I726_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I779_MP12 (VDD I0_B_11_b3_0 XI0_I779_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I779_MP18 (XI0_I779_xp1 XI0_I779_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I779_MP20 (I0_pp5_1 I0_B_11_b3_0 XI0_I779_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I779_MP19 (XI0_I779_xp1 XI0_I779_xan I0_pp5_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I779_MP17 (VDD XI0_I779_xn XI0_I779_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I779_MP6 (XI0_I779_p1 I0_A_1_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I779_MP8 (XI0_I779_xn I0_A_0_b3_2 XI0_I779_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I779_MP7 (XI0_I779_p1 I0_two5_b3_0 XI0_I779_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I779_MP5 (VDD I0_one5_b3_0 XI0_I779_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I779_MP10 (XI0_I779_xan XI0_I779_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I781_MP12 (VDD I0_B_11_b3_0 XI0_I781_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I781_MP18 (XI0_I781_xp1 XI0_I781_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I781_MP20 (I0_pp5_3 I0_B_11_b3_0 XI0_I781_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I781_MP19 (XI0_I781_xp1 XI0_I781_xan I0_pp5_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I781_MP17 (VDD XI0_I781_xn XI0_I781_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I781_MP6 (XI0_I781_p1 I0_A_3_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I781_MP8 (XI0_I781_xn I0_A_2_b3_2 XI0_I781_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I781_MP7 (XI0_I781_p1 I0_two5_b3_0 XI0_I781_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I781_MP5 (VDD I0_one5_b3_0 XI0_I781_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I781_MP10 (XI0_I781_xan XI0_I781_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I889_MP12 (VDD I0_B_15_b3_0 XI0_I889_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I889_MP18 (XI0_I889_xp1 XI0_I889_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I889_MP20 (I0_pp7_1 I0_B_15_b3_0 XI0_I889_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I889_MP19 (XI0_I889_xp1 XI0_I889_xan I0_pp7_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I889_MP17 (VDD XI0_I889_xn XI0_I889_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I889_MP6 (XI0_I889_p1 I0_A_1_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I889_MP8 (XI0_I889_xn I0_A_0_b3_2 XI0_I889_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I889_MP7 (XI0_I889_p1 I0_two7_b3_0 XI0_I889_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I889_MP5 (VDD I0_one7_b3_0 XI0_I889_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I889_MP10 (XI0_I889_xan XI0_I889_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I833_MP12 (VDD I0_B_13_b3_0 XI0_I833_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I833_MP18 (XI0_I833_xp1 XI0_I833_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I833_MP20 (I0_pp6_0 I0_B_13_b3_0 XI0_I833_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I833_MP19 (XI0_I833_xp1 XI0_I833_xan I0_pp6_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I833_MP17 (VDD XI0_I833_xn XI0_I833_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I833_MP6 (XI0_I833_p1 I0_A_0_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I833_MP8 (XI0_I833_xn VSS XI0_I833_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I833_MP7 (XI0_I833_p1 I0_two6_b3_0 XI0_I833_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I833_MP5 (VDD I0_one6_b3_0 XI0_I833_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I833_MP10 (XI0_I833_xan XI0_I833_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I835_MP12 (VDD I0_B_13_b3_0 XI0_I835_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I835_MP18 (XI0_I835_xp1 XI0_I835_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I835_MP20 (I0_pp6_2 I0_B_13_b3_0 XI0_I835_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I835_MP19 (XI0_I835_xp1 XI0_I835_xan I0_pp6_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I835_MP17 (VDD XI0_I835_xn XI0_I835_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I835_MP6 (XI0_I835_p1 I0_A_2_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I835_MP8 (XI0_I835_xn I0_A_1_b3_2 XI0_I835_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I835_MP7 (XI0_I835_p1 I0_two6_b3_0 XI0_I835_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I835_MP5 (VDD I0_one6_b3_0 XI0_I835_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I835_MP10 (XI0_I835_xan XI0_I835_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I891_MP12 (VDD I0_B_15_b3_0 XI0_I891_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I891_MP18 (XI0_I891_xp1 XI0_I891_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I891_MP20 (I0_pp7_3 I0_B_15_b3_0 XI0_I891_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I891_MP19 (XI0_I891_xp1 XI0_I891_xan I0_pp7_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I891_MP17 (VDD XI0_I891_xn XI0_I891_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I891_MP6 (XI0_I891_p1 I0_A_3_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I891_MP8 (XI0_I891_xn I0_A_2_b3_2 XI0_I891_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I891_MP7 (XI0_I891_p1 I0_two7_b3_0 XI0_I891_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I891_MP5 (VDD I0_one7_b3_0 XI0_I891_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I891_MP10 (XI0_I891_xan XI0_I891_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I836_MP12 (VDD I0_B_13_b3_0 XI0_I836_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I836_MP18 (XI0_I836_xp1 XI0_I836_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I836_MP20 (I0_pp6_3 I0_B_13_b3_0 XI0_I836_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I836_MP19 (XI0_I836_xp1 XI0_I836_xan I0_pp6_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I836_MP17 (VDD XI0_I836_xn XI0_I836_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I836_MP6 (XI0_I836_p1 I0_A_3_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I836_MP8 (XI0_I836_xn I0_A_2_b3_2 XI0_I836_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I836_MP7 (XI0_I836_p1 I0_two6_b3_0 XI0_I836_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I836_MP5 (VDD I0_one6_b3_0 XI0_I836_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I836_MP10 (XI0_I836_xan XI0_I836_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I892_MP12 (VDD I0_B_15_b3_0 XI0_I892_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I892_MP18 (XI0_I892_xp1 XI0_I892_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I892_MP20 (I0_pp7_4 I0_B_15_b3_0 XI0_I892_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I892_MP19 (XI0_I892_xp1 XI0_I892_xan I0_pp7_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I892_MP17 (VDD XI0_I892_xn XI0_I892_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I892_MP6 (XI0_I892_p1 I0_A_4_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I892_MP8 (XI0_I892_xn I0_A_3_b3_2 XI0_I892_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I892_MP7 (XI0_I892_p1 I0_two7_b3_0 XI0_I892_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I892_MP5 (VDD I0_one7_b3_0 XI0_I892_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I892_MP10 (XI0_I892_xan XI0_I892_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I955_MP12 (VDD I0_B_17_b3_2 XI0_I955_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I955_MP18 (XI0_I955_xp1 XI0_I955_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I955_MP20 (I0_pp8_12 I0_B_17_b3_2 XI0_I955_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I955_MP19 (XI0_I955_xp1 XI0_I955_xan I0_pp8_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I955_MP17 (VDD XI0_I955_xn XI0_I955_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I955_MP6 (XI0_I955_p1 I0_A_12_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I955_MP8 (XI0_I955_xn I0_A_11_b3_3 XI0_I955_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I955_MP7 (XI0_I955_p1 I0_two8_b3_2 XI0_I955_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I955_MP5 (VDD I0_one8_b3_2 XI0_I955_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I955_MP10 (XI0_I955_xan XI0_I955_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I957_MP12 (VDD I0_B_17_b3_2 XI0_I957_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I957_MP18 (XI0_I957_xp1 XI0_I957_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I957_MP20 (I0_pp8_14 I0_B_17_b3_2 XI0_I957_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I957_MP19 (XI0_I957_xp1 XI0_I957_xan I0_pp8_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I957_MP17 (VDD XI0_I957_xn XI0_I957_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I957_MP6 (XI0_I957_p1 I0_A_14_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I957_MP8 (XI0_I957_xn I0_A_13_b3_3 XI0_I957_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I957_MP7 (XI0_I957_p1 I0_two8_b3_2 XI0_I957_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I957_MP5 (VDD I0_one8_b3_2 XI0_I957_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I957_MP10 (XI0_I957_xan XI0_I957_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I958_MP12 (VDD I0_B_17_b3_2 XI0_I958_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I958_MP18 (XI0_I958_xp1 XI0_I958_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I958_MP20 (I0_pp8_15 I0_B_17_b3_2 XI0_I958_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I958_MP19 (XI0_I958_xp1 XI0_I958_xan I0_pp8_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I958_MP17 (VDD XI0_I958_xn XI0_I958_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I958_MP6 (XI0_I958_p1 I0_A_15_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I958_MP8 (XI0_I958_xn I0_A_14_b3_3 XI0_I958_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I958_MP7 (XI0_I958_p1 I0_two8_b3_2 XI0_I958_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I958_MP5 (VDD I0_one8_b3_2 XI0_I958_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I958_MP10 (XI0_I958_xan XI0_I958_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1013_MP12 (VDD I0_B_19_b3_2 XI0_I1013_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1013_MP18 (XI0_I1013_xp1 XI0_I1013_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1013_MP20 (I0_pp9_15 I0_B_19_b3_2 XI0_I1013_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1013_MP19 (XI0_I1013_xp1 XI0_I1013_xan I0_pp9_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1013_MP17 (VDD XI0_I1013_xn XI0_I1013_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1013_MP6 (XI0_I1013_p1 I0_A_15_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1013_MP8 (XI0_I1013_xn I0_A_14_b3_3 XI0_I1013_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1013_MP7 (XI0_I1013_p1 I0_two9_b3_2 XI0_I1013_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1013_MP5 (VDD I0_one9_b3_2 XI0_I1013_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1013_MP10 (XI0_I1013_xan XI0_I1013_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I961_MP12 (VDD I0_B_17_b3_3 XI0_I961_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I961_MP18 (XI0_I961_xp1 XI0_I961_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I961_MP20 (I0_pp8_18 I0_B_17_b3_3 XI0_I961_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I961_MP19 (XI0_I961_xp1 XI0_I961_xan I0_pp8_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I961_MP17 (VDD XI0_I961_xn XI0_I961_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I961_MP6 (XI0_I961_p1 I0_A_18_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I961_MP8 (XI0_I961_xn I0_A_17_b3_3 XI0_I961_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I961_MP7 (XI0_I961_p1 I0_two8_b3_3 XI0_I961_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I961_MP5 (VDD I0_one8_b3_3 XI0_I961_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I961_MP10 (XI0_I961_xan XI0_I961_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I504_MP12 (VDD I0_B_1_b3_0 XI0_I504_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I504_MP18 (XI0_I504_xp1 XI0_I504_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I504_MP20 (I0_pp0_1 I0_B_1_b3_0 XI0_I504_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I504_MP19 (XI0_I504_xp1 XI0_I504_xan I0_pp0_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I504_MP17 (VDD XI0_I504_xn XI0_I504_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I504_MP6 (XI0_I504_p1 I0_A_1_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I504_MP8 (XI0_I504_xn I0_A_0_b3_0 XI0_I504_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I504_MP7 (XI0_I504_p1 I0_two0_b3_0 XI0_I504_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I504_MP5 (VDD I0_one0_b3_0 XI0_I504_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I504_MP10 (XI0_I504_xan XI0_I504_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I503_MP12 (VDD I0_B_1_b3_0 XI0_I503_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I503_MP18 (XI0_I503_xp1 XI0_I503_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I503_MP20 (I0_pp0_0 I0_B_1_b3_0 XI0_I503_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I503_MP19 (XI0_I503_xp1 XI0_I503_xan I0_pp0_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I503_MP17 (VDD XI0_I503_xn XI0_I503_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I503_MP6 (XI0_I503_p1 I0_A_0_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I503_MP8 (XI0_I503_xn VSS XI0_I503_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I503_MP7 (XI0_I503_p1 I0_two0_b3_0 XI0_I503_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I503_MP5 (VDD I0_one0_b3_0 XI0_I503_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I503_MP10 (XI0_I503_xan XI0_I503_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I506_MP12 (VDD I0_B_1_b3_0 XI0_I506_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I506_MP18 (XI0_I506_xp1 XI0_I506_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I506_MP20 (I0_pp0_3 I0_B_1_b3_0 XI0_I506_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I506_MP19 (XI0_I506_xp1 XI0_I506_xan I0_pp0_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I506_MP17 (VDD XI0_I506_xn XI0_I506_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I506_MP6 (XI0_I506_p1 I0_A_3_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I506_MP8 (XI0_I506_xn I0_A_2_b3_0 XI0_I506_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I506_MP7 (XI0_I506_p1 I0_two0_b3_0 XI0_I506_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I506_MP5 (VDD I0_one0_b3_0 XI0_I506_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I506_MP10 (XI0_I506_xan XI0_I506_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I561_MP12 (VDD I0_B_3_b3_0 XI0_I561_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I561_MP18 (XI0_I561_xp1 XI0_I561_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I561_MP20 (I0_pp1_3 I0_B_3_b3_0 XI0_I561_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I561_MP19 (XI0_I561_xp1 XI0_I561_xan I0_pp1_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I561_MP17 (VDD XI0_I561_xn XI0_I561_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I561_MP6 (XI0_I561_p1 I0_A_3_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I561_MP8 (XI0_I561_xn I0_A_2_b3_0 XI0_I561_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I561_MP7 (XI0_I561_p1 I0_two1_b3_0 XI0_I561_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I561_MP5 (VDD I0_one1_b3_0 XI0_I561_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I561_MP10 (XI0_I561_xan XI0_I561_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I560_MP12 (VDD I0_B_3_b3_0 XI0_I560_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
