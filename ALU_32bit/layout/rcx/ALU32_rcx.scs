    I_MXI1_I838_I22_MP1 (I1_I838_gn22 I1_b6_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I22_MP0 (VDD I1_p5_21 I1_I838_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I21_MP1 (I1_I838_gn21 I1_b6_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I21_MP0 (VDD I1_p5_20 I1_I838_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I17_MP1 (I1_I838_gn17 I1_b6_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I17_MP0 (VDD I1_p5_16 I1_I838_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I176_XP_MP1 (I1_I838_P25_10n I1_I838_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I176_XP_MP0 (VDD I1_I838_P25_18 I1_I838_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I15_MP1 (I1_I838_gn15 I1_b6_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I15_MP0 (VDD I1_p5_14 I1_I838_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I109_XP_MP1 (I1_I838_P13_10n I1_I838_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I109_XP_MP0 (VDD I1_I838_P13_12 I1_I838_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I107_XP_MP1 (I1_I838_P11_8n I1_I838_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I107_XP_MP0 (VDD I1_I838_P11_10 I1_I838_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I105_XP_MP1 (I1_I838_P9_6n I1_I838_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I105_XP_MP0 (VDD I1_I838_P9_8 I1_I838_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I103_XP_MP1 (I1_I838_P7_4n I1_I838_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I103_XP_MP0 (VDD I1_I838_P7_6 I1_I838_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I101_XP_MP1 (I1_I838_P5_2n I1_I838_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I101_XP_MP0 (VDD I1_I838_P5_4 I1_I838_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I172_XP_MP1 (I1_I792_P21_6n I1_I792_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I172_XP_MP0 (VDD I1_I792_P21_14 I1_I792_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I170_XP_MP1 (I1_I792_P19_4n I1_I792_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I170_XP_MP0 (VDD I1_I792_P19_12 I1_I792_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I115_XP_MP1 (I1_I792_P19_16n I1_I792_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I115_XP_MP0 (VDD I1_I792_P19_18 I1_I792_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I117_XP_MP1 (I1_I792_P21_18n I1_I792_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I117_XP_MP0 (VDD I1_I792_P21_20 I1_I792_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I173_XP_MP1 (I1_I792_P22_7n I1_I792_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I173_XP_MP0 (VDD I1_I792_P22_15 I1_I792_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I177_XP_MP1 (I1_I792_P26_11n I1_I792_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I177_XP_MP0 (VDD I1_I792_P26_19 I1_I792_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I118_XP_MP1 (I1_I792_P22_19n I1_I792_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I118_XP_MP0 (VDD I1_I792_P22_21 I1_I792_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I21_MP1 (I1_I792_gn21 I1_b5_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I21_MP0 (VDD I1_p4_20 I1_I792_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I22_MP1 (I1_I792_gn22 I1_b5_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I22_MP0 (VDD I1_p4_21 I1_I792_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I126_XP_MP1 (I1_I746_P30_27n I1_I746_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I126_XP_MP0 (VDD I1_I746_P30_29 I1_I746_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I26_MP1 (I1_I746_gn26 I1_b4_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I26_MP0 (VDD I1_p3_25 I1_I746_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I27_MP1 (I1_I1344_gn27 I1_b17_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I27_MP0 (VDD I1_p16_26 I1_I1344_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I25_MP1 (I1_I1344_gn25 I1_b17_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I25_MP0 (VDD I1_p16_24 I1_I1344_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I126_XP_MP1 (I1_I1344_P30_27n I1_I1344_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I126_XP_MP0 (VDD I1_I1344_P30_29 I1_I1344_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I24_MP1 (I1_I1344_gn24 I1_b17_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I24_MP0 (VDD I1_p16_23 I1_I1344_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I23_MP1 (I1_I1344_gn23 I1_b17_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I23_MP0 (VDD I1_p16_22 I1_I1344_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I117_XP_MP1 (I1_I1344_P21_18n I1_I1344_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I117_XP_MP0 (VDD I1_I1344_P21_20 I1_I1344_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I115_XP_MP1 (I1_I1344_P19_16n I1_I1344_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I115_XP_MP0 (VDD I1_I1344_P19_18 I1_I1344_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I113_XP_MP1 (I1_I1344_P17_14n I1_I1344_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I113_XP_MP0 (VDD I1_I1344_P17_16 I1_I1344_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I111_XP_MP1 (I1_I1344_P15_12n I1_I1344_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I111_XP_MP0 (VDD I1_I1344_P15_14 I1_I1344_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I174_XP_MP1 (I1_I1298_P23_8n I1_I1298_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I174_XP_MP0 (VDD I1_I1298_P23_16 I1_I1298_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I119_XP_MP1 (I1_I1298_P23_20n I1_I1298_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I119_XP_MP0 (VDD I1_I1298_P23_22 I1_I1298_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I179_XP_MP1 (I1_I1298_P28_13n I1_I1298_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I179_XP_MP0 (VDD I1_I1298_P28_21 I1_I1298_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I120_XP_MP1 (I1_I1298_P24_21n I1_I1298_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I120_XP_MP0 (VDD I1_I1298_P24_23 I1_I1298_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I23_MP1 (I1_I1298_gn23 I1_b16_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I23_MP0 (VDD I1_p15_22 I1_I1298_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I177_XP_MP1 (I1_I1252_P26_11n I1_I1252_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I177_XP_MP0 (VDD I1_I1252_P26_19 I1_I1252_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I120_XP_MP1 (I1_I1252_P24_21n I1_I1252_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I120_XP_MP0 (VDD I1_I1252_P24_23 I1_I1252_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I174_XP_MP1 (I1_I1252_P23_8n I1_I1252_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I174_XP_MP0 (VDD I1_I1252_P23_16 I1_I1252_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I180_XP_MP1 (I1_I1252_P29_14n I1_I1252_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I180_XP_MP0 (VDD I1_I1252_P29_22 I1_I1252_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I121_XP_MP1 (I1_I1252_P25_22n I1_I1252_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I121_XP_MP0 (VDD I1_I1252_P25_24 I1_I1252_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I22_MP1 (I1_I1252_gn22 I1_b15_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I22_MP0 (VDD I1_p14_21 I1_I1252_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I23_MP1 (I1_I1206_gn23 I1_b14_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I23_MP0 (VDD I1_p13_22 I1_I1206_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I22_MP1 (I1_I1206_gn22 I1_b14_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I22_MP0 (VDD I1_p13_21 I1_I1206_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I122_XP_MP1 (I1_I1206_P26_23n I1_I1206_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I122_XP_MP0 (VDD I1_I1206_P26_25 I1_I1206_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I126_XP_MP1 (I1_I838_P30_27n I1_I838_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I126_XP_MP0 (VDD I1_I838_P30_29 I1_I838_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I124_XP_MP1 (I1_I838_P28_25n I1_I838_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I124_XP_MP0 (VDD I1_I838_P28_27 I1_I838_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I122_XP_MP1 (I1_I838_P26_23n I1_I838_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I122_XP_MP0 (VDD I1_I838_P26_25 I1_I838_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I120_XP_MP1 (I1_I838_P24_21n I1_I838_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I120_XP_MP0 (VDD I1_I838_P24_23 I1_I838_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I20_MP1 (I1_I838_gn20 I1_b6_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I20_MP0 (VDD I1_p5_19 I1_I838_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I18_MP1 (I1_I838_gn18 I1_b6_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I18_MP0 (VDD I1_p5_17 I1_I838_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I16_MP1 (I1_I838_gn16 I1_b6_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I16_MP0 (VDD I1_p5_15 I1_I838_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I13_MP1 (I1_I838_gn13 I1_b6_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I13_MP0 (VDD I1_p5_12 I1_I838_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I113_XP_MP1 (I1_I792_P17_14n I1_I792_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I113_XP_MP0 (VDD I1_I792_P17_16 I1_I792_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I111_XP_MP1 (I1_I792_P15_12n I1_I792_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I111_XP_MP0 (VDD I1_I792_P15_14 I1_I792_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I171_XP_MP1 (I1_I792_P20_5n I1_I792_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I171_XP_MP0 (VDD I1_I792_P20_13 I1_I792_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I116_XP_MP1 (I1_I792_P20_17n I1_I792_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I116_XP_MP0 (VDD I1_I792_P20_19 I1_I792_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I19_MP1 (I1_I792_gn19 I1_b5_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I19_MP0 (VDD I1_p4_18 I1_I792_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I20_MP1 (I1_I792_gn20 I1_b5_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I20_MP0 (VDD I1_p4_19 I1_I792_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I181_XP_MP1 (I1_I746_P30_15n I1_I746_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I181_XP_MP0 (VDD I1_I746_P30_23 I1_I746_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I124_XP_MP1 (I1_I746_P28_25n I1_I746_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I124_XP_MP0 (VDD I1_I746_P28_27 I1_I746_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I27_MP1 (I1_I746_gn27 I1_b4_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I27_MP0 (VDD I1_p3_26 I1_I746_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I26_MP1 (I1_I1344_gn26 I1_b17_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I26_MP0 (VDD I1_p16_25 I1_I1344_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I124_XP_MP1 (I1_I1344_P28_25n I1_I1344_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I124_XP_MP0 (VDD I1_I1344_P28_27 I1_I1344_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I22_MP1 (I1_I1344_gn22 I1_b17_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I22_MP0 (VDD I1_p16_21 I1_I1344_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I21_MP1 (I1_I1344_gn21 I1_b17_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I21_MP0 (VDD I1_p16_20 I1_I1344_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I176_XP_MP1 (I1_I1344_P25_10n I1_I1344_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I176_XP_MP0 (VDD I1_I1344_P25_18 I1_I1344_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I172_XP_MP1 (I1_I1344_P21_6n I1_I1344_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I172_XP_MP0 (VDD I1_I1344_P21_14 I1_I1344_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I109_XP_MP1 (I1_I1344_P13_10n I1_I1344_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I109_XP_MP0 (VDD I1_I1344_P13_12 I1_I1344_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I107_XP_MP1 (I1_I1344_P11_8n I1_I1344_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I107_XP_MP0 (VDD I1_I1344_P11_10 I1_I1344_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I176_XP_MP1 (I1_I1298_P25_10n I1_I1298_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I176_XP_MP0 (VDD I1_I1298_P25_18 I1_I1298_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I117_XP_MP1 (I1_I1298_P21_18n I1_I1298_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I117_XP_MP0 (VDD I1_I1298_P21_20 I1_I1298_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I177_XP_MP1 (I1_I1298_P26_11n I1_I1298_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I177_XP_MP0 (VDD I1_I1298_P26_19 I1_I1298_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I118_XP_MP1 (I1_I1298_P22_19n I1_I1298_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I118_XP_MP0 (VDD I1_I1298_P22_21 I1_I1298_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I22_MP1 (I1_I1298_gn22 I1_b16_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I22_MP0 (VDD I1_p15_21 I1_I1298_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I20_MP1 (I1_I1298_gn20 I1_b16_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I20_MP0 (VDD I1_p15_19 I1_I1298_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I21_MP1 (I1_I1298_gn21 I1_b16_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I21_MP0 (VDD I1_p15_20 I1_I1298_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I173_XP_MP1 (I1_I1252_P22_7n I1_I1252_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I173_XP_MP0 (VDD I1_I1252_P22_15 I1_I1252_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I118_XP_MP1 (I1_I1252_P22_19n I1_I1252_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I118_XP_MP0 (VDD I1_I1252_P22_21 I1_I1252_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I178_XP_MP1 (I1_I1252_P27_12n I1_I1252_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I178_XP_MP0 (VDD I1_I1252_P27_20 I1_I1252_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I119_XP_MP1 (I1_I1252_P23_20n I1_I1252_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I119_XP_MP0 (VDD I1_I1252_P23_22 I1_I1252_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I21_MP1 (I1_I1252_gn21 I1_b15_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I21_MP0 (VDD I1_p14_20 I1_I1252_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I21_MP1 (I1_I1206_gn21 I1_b14_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I21_MP0 (VDD I1_p13_20 I1_I1206_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I119_XP_MP1 (I1_I1206_P23_20n I1_I1206_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I119_XP_MP0 (VDD I1_I1206_P23_22 I1_I1206_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I121_XP_MP1 (I1_I1206_P25_22n I1_I1206_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I121_XP_MP0 (VDD I1_I1206_P25_24 I1_I1206_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I180_XP_MP1 (I1_I1206_P29_14n I1_I1206_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I180_XP_MP0 (VDD I1_I1206_P29_22 I1_I1206_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I118_XP_MP1 (I1_I1206_P22_19n I1_I1206_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I118_XP_MP0 (VDD I1_I1206_P22_21 I1_I1206_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I181_XP_MP1 (I1_I1206_P30_15n I1_I1206_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I181_XP_MP0 (VDD I1_I1206_P30_23 I1_I1206_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I120_XP_MP1 (I1_I1206_P24_21n I1_I1206_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I120_XP_MP0 (VDD I1_I1206_P24_23 I1_I1206_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I179_XP_MP1 (I1_I838_P28_13n I1_I838_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I179_XP_MP0 (VDD I1_I838_P28_21 I1_I838_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I118_XP_MP1 (I1_I838_P22_19n I1_I838_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I118_XP_MP0 (VDD I1_I838_P22_21 I1_I838_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I19_MP1 (I1_I838_gn19 I1_b6_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I19_MP0 (VDD I1_p5_18 I1_I838_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I116_XP_MP1 (I1_I838_P20_17n I1_I838_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I116_XP_MP0 (VDD I1_I838_P20_19 I1_I838_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I114_XP_MP1 (I1_I838_P18_15n I1_I838_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I114_XP_MP0 (VDD I1_I838_P18_17 I1_I838_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I112_XP_MP1 (I1_I838_P16_13n I1_I838_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I112_XP_MP0 (VDD I1_I838_P16_15 I1_I838_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I110_XP_MP1 (I1_I838_P14_11n I1_I838_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I110_XP_MP0 (VDD I1_I838_P14_13 I1_I838_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I14_MP1 (I1_I838_gn14 I1_b6_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I14_MP0 (VDD I1_p5_13 I1_I838_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I12_MP1 (I1_I838_gn12 I1_b6_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I12_MP0 (VDD I1_p5_11 I1_I838_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I11_MP1 (I1_I838_gn11 I1_b6_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I11_MP0 (VDD I1_p5_10 I1_I838_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I9_MP1 (I1_I838_gn9 I1_b6_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I9_MP0 (VDD I1_p5_8 I1_I838_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I107_XP_MP1 (I1_I792_P11_8n I1_I792_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I107_XP_MP0 (VDD I1_I792_P11_10 I1_I792_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I109_XP_MP1 (I1_I792_P13_10n I1_I792_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I109_XP_MP0 (VDD I1_I792_P13_12 I1_I792_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I169_XP_MP1 (I1_I792_P18_3n I1_I792_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I169_XP_MP0 (VDD I1_I792_P18_11 I1_I792_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I175_XP_MP1 (I1_I792_P24_9n I1_I792_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I175_XP_MP0 (VDD I1_I792_P24_17 I1_I792_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I114_XP_MP1 (I1_I792_P18_15n I1_I792_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I114_XP_MP0 (VDD I1_I792_P18_17 I1_I792_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I16_MP1 (I1_I792_gn16 I1_b5_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I16_MP0 (VDD I1_p4_15 I1_I792_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I18_MP1 (I1_I792_gn18 I1_b5_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I18_MP0 (VDD I1_p4_17 I1_I792_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I179_XP_MP1 (I1_I746_P28_13n I1_I746_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I179_XP_MP0 (VDD I1_I746_P28_21 I1_I746_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I173_XP_MP1 (I1_I746_P22_7n I1_I746_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I173_XP_MP0 (VDD I1_I746_P22_15 I1_I746_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I122_XP_MP1 (I1_I746_P26_23n I1_I746_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I122_XP_MP0 (VDD I1_I746_P26_25 I1_I746_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I28_MP1 (I1_I746_gn28 I1_b4_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I28_MP0 (VDD I1_p3_27 I1_I746_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I122_XP_MP1 (I1_I1344_P26_23n I1_I1344_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I122_XP_MP0 (VDD I1_I1344_P26_25 I1_I1344_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I20_MP1 (I1_I1344_gn20 I1_b17_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I20_MP0 (VDD I1_p16_19 I1_I1344_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I18_MP1 (I1_I1344_gn18 I1_b17_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I18_MP0 (VDD I1_p16_17 I1_I1344_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I17_MP1 (I1_I1344_gn17 I1_b17_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I17_MP0 (VDD I1_p16_16 I1_I1344_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I168_XP_MP1 (I1_I1344_P17_2n I1_I1344_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I168_XP_MP0 (VDD I1_I1344_P17_10 I1_I1344_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I172_XP_MP1 (I1_I1298_P21_6n I1_I1298_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I172_XP_MP0 (VDD I1_I1298_P21_14 I1_I1298_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I115_XP_MP1 (I1_I1298_P19_16n I1_I1298_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I115_XP_MP0 (VDD I1_I1298_P19_18 I1_I1298_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I173_XP_MP1 (I1_I1298_P22_7n I1_I1298_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I173_XP_MP0 (VDD I1_I1298_P22_15 I1_I1298_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I116_XP_MP1 (I1_I1298_P20_17n I1_I1298_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I116_XP_MP0 (VDD I1_I1298_P20_19 I1_I1298_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I19_MP1 (I1_I1298_gn19 I1_b16_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I19_MP0 (VDD I1_p15_18 I1_I1298_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I18_MP1 (I1_I1298_gn18 I1_b16_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I18_MP0 (VDD I1_p15_17 I1_I1298_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I116_XP_MP1 (I1_I1252_P20_17n I1_I1252_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I116_XP_MP0 (VDD I1_I1252_P20_19 I1_I1252_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I172_XP_MP1 (I1_I1252_P21_6n I1_I1252_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I172_XP_MP0 (VDD I1_I1252_P21_14 I1_I1252_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I117_XP_MP1 (I1_I1252_P21_18n I1_I1252_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I117_XP_MP0 (VDD I1_I1252_P21_20 I1_I1252_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I20_MP1 (I1_I1252_gn20 I1_b15_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I20_MP0 (VDD I1_p14_19 I1_I1252_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I20_MP1 (I1_I1206_gn20 I1_b14_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I20_MP0 (VDD I1_p13_19 I1_I1206_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I19_MP1 (I1_I1206_gn19 I1_b14_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I19_MP0 (VDD I1_p13_18 I1_I1206_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I117_XP_MP1 (I1_I1206_P21_18n I1_I1206_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I117_XP_MP0 (VDD I1_I1206_P21_20 I1_I1206_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I178_XP_MP1 (I1_I1206_P27_12n I1_I1206_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I178_XP_MP0 (VDD I1_I1206_P27_20 I1_I1206_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I179_XP_MP1 (I1_I1206_P28_13n I1_I1206_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I179_XP_MP0 (VDD I1_I1206_P28_21 I1_I1206_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I25_MP1 (I1_I884_gn25 I1_b7_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I25_MP0 (VDD I1_p6_24 I1_I884_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I181_XP_MP1 (I1_I838_P30_15n I1_I838_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I181_XP_MP0 (VDD I1_I838_P30_23 I1_I838_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I177_XP_MP1 (I1_I838_P26_11n I1_I838_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I177_XP_MP0 (VDD I1_I838_P26_19 I1_I838_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I173_XP_MP1 (I1_I838_P22_7n I1_I838_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I173_XP_MP0 (VDD I1_I838_P22_15 I1_I838_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I175_XP_MP1 (I1_I838_P24_9n I1_I838_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I175_XP_MP0 (VDD I1_I838_P24_17 I1_I838_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I169_XP_MP1 (I1_I838_P18_3n I1_I838_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I169_XP_MP0 (VDD I1_I838_P18_11 I1_I838_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I108_XP_MP1 (I1_I838_P12_9n I1_I838_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I108_XP_MP0 (VDD I1_I838_P12_11 I1_I838_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I106_XP_MP1 (I1_I838_P10_7n I1_I838_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I106_XP_MP0 (VDD I1_I838_P10_9 I1_I838_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I10_MP1 (I1_I838_gn10 I1_b6_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I10_MP0 (VDD I1_p5_9 I1_I838_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I168_XP_MP1 (I1_I792_P17_2n I1_I792_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I168_XP_MP0 (VDD I1_I792_P17_10 I1_I792_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I110_XP_MP1 (I1_I792_P14_11n I1_I792_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I110_XP_MP0 (VDD I1_I792_P14_13 I1_I792_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I112_XP_MP1 (I1_I792_P16_13n I1_I792_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I112_XP_MP0 (VDD I1_I792_P16_15 I1_I792_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I169_XP_MP1 (I1_I746_P18_3n I1_I746_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I169_XP_MP0 (VDD I1_I746_P18_11 I1_I746_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I171_XP_MP1 (I1_I746_P20_5n I1_I746_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I171_XP_MP0 (VDD I1_I746_P20_13 I1_I746_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I177_XP_MP1 (I1_I746_P26_11n I1_I746_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I177_XP_MP0 (VDD I1_I746_P26_19 I1_I746_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I118_XP_MP1 (I1_I746_P22_19n I1_I746_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I118_XP_MP0 (VDD I1_I746_P22_21 I1_I746_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I120_XP_MP1 (I1_I746_P24_21n I1_I746_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I120_XP_MP0 (VDD I1_I746_P24_23 I1_I746_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I25_MP1 (I1_I746_gn25 I1_b4_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I25_MP0 (VDD I1_p3_24 I1_I746_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I29_MP1 (I1_I746_gn29 I1_b4_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I29_MP0 (VDD I1_p3_28 I1_I746_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I120_XP_MP1 (I1_I1344_P24_21n I1_I1344_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I120_XP_MP0 (VDD I1_I1344_P24_23 I1_I1344_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I118_XP_MP1 (I1_I1344_P22_19n I1_I1344_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I118_XP_MP0 (VDD I1_I1344_P22_21 I1_I1344_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I16_MP1 (I1_I1344_gn16 I1_b17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I16_MP0 (VDD I1_p16_15 I1_I1344_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I15_MP1 (I1_I1344_gn15 I1_b17_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I15_MP0 (VDD I1_p16_14 I1_I1344_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I170_XP_MP1 (I1_I1298_P19_4n I1_I1298_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I170_XP_MP0 (VDD I1_I1298_P19_12 I1_I1298_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I113_XP_MP1 (I1_I1298_P17_14n I1_I1298_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I113_XP_MP0 (VDD I1_I1298_P17_16 I1_I1298_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I171_XP_MP1 (I1_I1298_P20_5n I1_I1298_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I171_XP_MP0 (VDD I1_I1298_P20_13 I1_I1298_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I114_XP_MP1 (I1_I1298_P18_15n I1_I1298_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I114_XP_MP0 (VDD I1_I1298_P18_17 I1_I1298_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I17_MP1 (I1_I1298_gn17 I1_b16_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I17_MP0 (VDD I1_p15_16 I1_I1298_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I171_XP_MP1 (I1_I1252_P20_5n I1_I1252_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I171_XP_MP0 (VDD I1_I1252_P20_13 I1_I1252_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I175_XP_MP1 (I1_I1252_P24_9n I1_I1252_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I175_XP_MP0 (VDD I1_I1252_P24_17 I1_I1252_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I176_XP_MP1 (I1_I1252_P25_10n I1_I1252_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I176_XP_MP0 (VDD I1_I1252_P25_18 I1_I1252_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I113_XP_MP1 (I1_I1252_P17_14n I1_I1252_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I113_XP_MP0 (VDD I1_I1252_P17_16 I1_I1252_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I115_XP_MP1 (I1_I1252_P19_16n I1_I1252_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I115_XP_MP0 (VDD I1_I1252_P19_18 I1_I1252_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I17_MP1 (I1_I1252_gn17 I1_b15_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I17_MP0 (VDD I1_p14_16 I1_I1252_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I19_MP1 (I1_I1252_gn19 I1_b15_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I19_MP0 (VDD I1_p14_18 I1_I1252_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I18_MP1 (I1_I1252_gn18 I1_b15_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I18_MP0 (VDD I1_p14_17 I1_I1252_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I18_MP1 (I1_I1206_gn18 I1_b14_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I18_MP0 (VDD I1_p13_17 I1_I1206_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I115_XP_MP1 (I1_I1206_P19_16n I1_I1206_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I115_XP_MP0 (VDD I1_I1206_P19_18 I1_I1206_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I182_XP_MP1 (I1_I1206_P31_16n I1_I1206_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I182_XP_MP0 (VDD I1_I1206_P31_24 I1_I1206_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I174_XP_MP1 (I1_I1206_P23_8n I1_I1206_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I174_XP_MP0 (VDD I1_I1206_P23_16 I1_I1206_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I172_XP_MP1 (I1_I1206_P21_6n I1_I1206_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I172_XP_MP0 (VDD I1_I1206_P21_14 I1_I1206_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I116_XP_MP1 (I1_I1206_P20_17n I1_I1206_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I116_XP_MP0 (VDD I1_I1206_P20_19 I1_I1206_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I173_XP_MP1 (I1_I1206_P22_7n I1_I1206_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I173_XP_MP0 (VDD I1_I1206_P22_15 I1_I1206_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I177_XP_MP1 (I1_I1206_P26_11n I1_I1206_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I177_XP_MP0 (VDD I1_I1206_P26_19 I1_I1206_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I27_MP1 (I1_I884_gn27 I1_b7_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I27_MP0 (VDD I1_p6_26 I1_I884_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I23_MP1 (I1_I884_gn23 I1_b7_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I23_MP0 (VDD I1_p6_22 I1_I884_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I171_XP_MP1 (I1_I838_P20_5n I1_I838_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I171_XP_MP0 (VDD I1_I838_P20_13 I1_I838_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I167_XP_MP1 (I1_I838_P16_1n I1_I838_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I167_XP_MP0 (VDD I1_I838_P16_9 I1_I838_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I6_MP1 (I1_I838_gn6 I1_b6_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I6_MP0 (VDD I1_p5_5 I1_I838_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I8_MP1 (I1_I838_gn8 I1_b6_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I8_MP0 (VDD I1_p5_7 I1_I838_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I7_MP1 (I1_I838_gn7 I1_b6_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I7_MP0 (VDD I1_p5_6 I1_I838_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I103_XP_MP1 (I1_I792_P7_4n I1_I792_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I103_XP_MP0 (VDD I1_I792_P7_6 I1_I792_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I105_XP_MP1 (I1_I792_P9_6n I1_I792_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I105_XP_MP0 (VDD I1_I792_P9_8 I1_I792_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I167_XP_MP1 (I1_I792_P16_1n I1_I792_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I167_XP_MP0 (VDD I1_I792_P16_9 I1_I792_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I106_XP_MP1 (I1_I792_P10_7n I1_I792_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I106_XP_MP0 (VDD I1_I792_P10_9 I1_I792_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I108_XP_MP1 (I1_I792_P12_9n I1_I792_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I108_XP_MP0 (VDD I1_I792_P12_11 I1_I792_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I12_MP1 (I1_I792_gn12 I1_b5_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I12_MP0 (VDD I1_p4_11 I1_I792_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I14_MP1 (I1_I792_gn14 I1_b5_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I14_MP0 (VDD I1_p4_13 I1_I792_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I15_MP1 (I1_I792_gn15 I1_b5_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I15_MP0 (VDD I1_p4_14 I1_I792_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I167_XP_MP1 (I1_I746_P16_1n I1_I746_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I167_XP_MP0 (VDD I1_I746_P16_9 I1_I746_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I17_MP1 (I1_I792_gn17 I1_b5_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I17_MP0 (VDD I1_p4_16 I1_I792_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I175_XP_MP1 (I1_I746_P24_9n I1_I746_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I175_XP_MP0 (VDD I1_I746_P24_17 I1_I746_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I110_XP_MP1 (I1_I746_P14_11n I1_I746_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I110_XP_MP0 (VDD I1_I746_P14_13 I1_I746_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I112_XP_MP1 (I1_I746_P16_13n I1_I746_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I112_XP_MP0 (VDD I1_I746_P16_15 I1_I746_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I114_XP_MP1 (I1_I746_P18_15n I1_I746_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I114_XP_MP0 (VDD I1_I746_P18_17 I1_I746_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I116_XP_MP1 (I1_I746_P20_17n I1_I746_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I116_XP_MP0 (VDD I1_I746_P20_19 I1_I746_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I180_XP_MP1 (I1_I746_P29_14n I1_I746_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I180_XP_MP0 (VDD I1_I746_P29_22 I1_I746_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I24_MP1 (I1_I746_gn24 I1_b4_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I24_MP0 (VDD I1_p3_23 I1_I746_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I125_XP_MP1 (I1_I746_P29_26n I1_I746_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I125_XP_MP0 (VDD I1_I746_P29_28 I1_I746_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I127_XP_MP1 (I1_I746_P31_28n I1_I746_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I127_XP_MP0 (VDD I1_I746_P31_30 I1_I746_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I30_MP1 (I1_I746_gn30 I1_b4_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I30_MP0 (VDD I1_p3_29 I1_I746_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I29_MP1 (I1_I1390_gn29 I1_b18_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I29_MP0 (VDD I1_p17_28 I1_I1390_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I181_XP_MP1 (I1_I1344_P30_15n I1_I1344_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I181_XP_MP0 (VDD I1_I1344_P30_23 I1_I1344_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I179_XP_MP1 (I1_I1344_P28_13n I1_I1344_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I179_XP_MP0 (VDD I1_I1344_P28_21 I1_I1344_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I116_XP_MP1 (I1_I1344_P20_17n I1_I1344_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I116_XP_MP0 (VDD I1_I1344_P20_19 I1_I1344_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I19_MP1 (I1_I1344_gn19 I1_b17_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I19_MP0 (VDD I1_p16_18 I1_I1344_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I114_XP_MP1 (I1_I1344_P18_15n I1_I1344_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I114_XP_MP0 (VDD I1_I1344_P18_17 I1_I1344_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I112_XP_MP1 (I1_I1344_P16_13n I1_I1344_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I112_XP_MP0 (VDD I1_I1344_P16_15 I1_I1344_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I14_MP1 (I1_I1344_gn14 I1_b17_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I14_MP0 (VDD I1_p16_13 I1_I1344_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I13_MP1 (I1_I1344_gn13 I1_b17_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I13_MP0 (VDD I1_p16_12 I1_I1344_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I105_XP_MP1 (I1_I1344_P9_6n I1_I1344_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I105_XP_MP0 (VDD I1_I1344_P9_8 I1_I1344_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I111_XP_MP1 (I1_I1298_P15_12n I1_I1298_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I111_XP_MP0 (VDD I1_I1298_P15_14 I1_I1298_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I112_XP_MP1 (I1_I1298_P16_13n I1_I1298_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I112_XP_MP0 (VDD I1_I1298_P16_15 I1_I1298_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I13_MP1 (I1_I1298_gn13 I1_b16_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I13_MP0 (VDD I1_p15_12 I1_I1298_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I14_MP1 (I1_I1298_gn14 I1_b16_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I14_MP0 (VDD I1_p15_13 I1_I1298_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I16_MP1 (I1_I1298_gn16 I1_b16_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I16_MP0 (VDD I1_p15_15 I1_I1298_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I15_MP1 (I1_I1298_gn15 I1_b16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I15_MP0 (VDD I1_p15_14 I1_I1298_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I112_XP_MP1 (I1_I1252_P16_13n I1_I1252_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I112_XP_MP0 (VDD I1_I1252_P16_15 I1_I1252_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I114_XP_MP1 (I1_I1252_P18_15n I1_I1252_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I114_XP_MP0 (VDD I1_I1252_P18_17 I1_I1252_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I170_XP_MP1 (I1_I1252_P19_4n I1_I1252_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I170_XP_MP0 (VDD I1_I1252_P19_12 I1_I1252_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I111_XP_MP1 (I1_I1252_P15_12n I1_I1252_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I111_XP_MP0 (VDD I1_I1252_P15_14 I1_I1252_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I16_MP1 (I1_I1252_gn16 I1_b15_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I16_MP0 (VDD I1_p14_15 I1_I1252_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I15_MP1 (I1_I1252_gn15 I1_b15_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I15_MP0 (VDD I1_p14_14 I1_I1252_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I170_XP_MP1 (I1_I1206_P19_4n I1_I1206_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I170_XP_MP0 (VDD I1_I1206_P19_12 I1_I1206_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I176_XP_MP1 (I1_I1206_P25_10n I1_I1206_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I176_XP_MP0 (VDD I1_I1206_P25_18 I1_I1206_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I114_XP_MP1 (I1_I1206_P18_15n I1_I1206_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I114_XP_MP0 (VDD I1_I1206_P18_17 I1_I1206_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I169_XP_MP1 (I1_I1206_P18_3n I1_I1206_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I169_XP_MP0 (VDD I1_I1206_P18_11 I1_I1206_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I175_XP_MP1 (I1_I1206_P24_9n I1_I1206_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I175_XP_MP0 (VDD I1_I1206_P24_17 I1_I1206_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I29_MP1 (I1_I884_gn29 I1_b7_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I29_MP0 (VDD I1_p6_28 I1_I884_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I28_MP1 (I1_I884_gn28 I1_b7_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I28_MP0 (VDD I1_p6_27 I1_I884_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I26_MP1 (I1_I884_gn26 I1_b7_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I26_MP0 (VDD I1_p6_25 I1_I884_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I24_MP1 (I1_I884_gn24 I1_b7_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I24_MP0 (VDD I1_p6_23 I1_I884_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I21_MP1 (I1_I884_gn21 I1_b7_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I21_MP0 (VDD I1_p6_20 I1_I884_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I19_MP1 (I1_I884_gn19 I1_b7_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I19_MP0 (VDD I1_p6_18 I1_I884_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I17_MP1 (I1_I884_gn17 I1_b7_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I17_MP0 (VDD I1_p6_16 I1_I884_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I15_MP1 (I1_I884_gn15 I1_b7_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I15_MP0 (VDD I1_p6_14 I1_I884_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I5_MP1 (I1_I838_gn5 I1_b6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I5_MP0 (VDD I1_p5_4 I1_I838_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I101_XP_MP1 (I1_I792_P5_2n I1_I792_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I101_XP_MP0 (VDD I1_I792_P5_4 I1_I792_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I100_XP_MP1 (I1_I792_P4_1n I1_I792_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I100_XP_MP0 (VDD I1_I792_P4_3 I1_I792_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I102_XP_MP1 (I1_I792_P6_3n I1_I792_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I102_XP_MP0 (VDD I1_I792_P6_5 I1_I792_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I104_XP_MP1 (I1_I792_P8_5n I1_I792_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I104_XP_MP0 (VDD I1_I792_P8_7 I1_I792_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I10_MP1 (I1_I792_gn10 I1_b5_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I10_MP0 (VDD I1_p4_9 I1_I792_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I11_MP1 (I1_I792_gn11 I1_b5_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I11_MP0 (VDD I1_p4_10 I1_I792_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I106_XP_MP1 (I1_I746_P10_7n I1_I746_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I106_XP_MP0 (VDD I1_I746_P10_9 I1_I746_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I108_XP_MP1 (I1_I746_P12_9n I1_I746_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I108_XP_MP0 (VDD I1_I746_P12_11 I1_I746_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I172_XP_MP1 (I1_I746_P21_6n I1_I746_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I172_XP_MP0 (VDD I1_I746_P21_14 I1_I746_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I121_XP_MP1 (I1_I746_P25_22n I1_I746_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I121_XP_MP0 (VDD I1_I746_P25_24 I1_I746_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I123_XP_MP1 (I1_I746_P27_24n I1_I746_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I123_XP_MP0 (VDD I1_I746_P27_26 I1_I746_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I177_XP_MP1 (I1_I1344_P26_11n I1_I1344_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I177_XP_MP0 (VDD I1_I1344_P26_19 I1_I1344_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I173_XP_MP1 (I1_I1344_P22_7n I1_I1344_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I173_XP_MP0 (VDD I1_I1344_P22_15 I1_I1344_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I171_XP_MP1 (I1_I1344_P20_5n I1_I1344_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I171_XP_MP0 (VDD I1_I1344_P20_13 I1_I1344_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I110_XP_MP1 (I1_I1344_P14_11n I1_I1344_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I110_XP_MP0 (VDD I1_I1344_P14_13 I1_I1344_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I12_MP1 (I1_I1344_gn12 I1_b17_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I12_MP0 (VDD I1_p16_11 I1_I1344_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I11_MP1 (I1_I1344_gn11 I1_b17_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I11_MP0 (VDD I1_p16_10 I1_I1344_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I103_XP_MP1 (I1_I1344_P7_4n I1_I1344_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I103_XP_MP0 (VDD I1_I1344_P7_6 I1_I1344_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I168_XP_MP1 (I1_I1298_P17_2n I1_I1298_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I168_XP_MP0 (VDD I1_I1298_P17_10 I1_I1298_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I109_XP_MP1 (I1_I1298_P13_10n I1_I1298_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I109_XP_MP0 (VDD I1_I1298_P13_12 I1_I1298_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I107_XP_MP1 (I1_I1298_P11_8n I1_I1298_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I107_XP_MP0 (VDD I1_I1298_P11_10 I1_I1298_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I169_XP_MP1 (I1_I1298_P18_3n I1_I1298_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I169_XP_MP0 (VDD I1_I1298_P18_11 I1_I1298_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I110_XP_MP1 (I1_I1298_P14_11n I1_I1298_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I110_XP_MP0 (VDD I1_I1298_P14_13 I1_I1298_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I12_MP1 (I1_I1298_gn12 I1_b16_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I12_MP0 (VDD I1_p15_11 I1_I1298_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I169_XP_MP1 (I1_I1252_P18_3n I1_I1252_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I169_XP_MP0 (VDD I1_I1252_P18_11 I1_I1252_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I110_XP_MP1 (I1_I1252_P14_11n I1_I1252_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I110_XP_MP0 (VDD I1_I1252_P14_13 I1_I1252_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I13_MP1 (I1_I1252_gn13 I1_b15_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I13_MP0 (VDD I1_p14_12 I1_I1252_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I14_MP1 (I1_I1252_gn14 I1_b15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I14_MP0 (VDD I1_p14_13 I1_I1252_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I17_MP1 (I1_I1206_gn17 I1_b14_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I17_MP0 (VDD I1_p13_16 I1_I1206_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I113_XP_MP1 (I1_I1206_P17_14n I1_I1206_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I113_XP_MP0 (VDD I1_I1206_P17_16 I1_I1206_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I111_XP_MP1 (I1_I1206_P15_12n I1_I1206_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I111_XP_MP0 (VDD I1_I1206_P15_14 I1_I1206_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I109_XP_MP1 (I1_I1206_P13_10n I1_I1206_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I109_XP_MP0 (VDD I1_I1206_P13_12 I1_I1206_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I168_XP_MP1 (I1_I1206_P17_2n I1_I1206_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I168_XP_MP0 (VDD I1_I1206_P17_10 I1_I1206_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I112_XP_MP1 (I1_I1206_P16_13n I1_I1206_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I112_XP_MP0 (VDD I1_I1206_P16_15 I1_I1206_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I171_XP_MP1 (I1_I1206_P20_5n I1_I1206_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I171_XP_MP0 (VDD I1_I1206_P20_13 I1_I1206_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I31_MP1 (I1_I884_gn31 I1_b7_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I31_MP0 (VDD I1_p6_30 I1_I884_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I22_MP1 (I1_I884_gn22 I1_b7_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I22_MP0 (VDD I1_p6_21 I1_I884_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I20_MP1 (I1_I884_gn20 I1_b7_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I20_MP0 (VDD I1_p6_19 I1_I884_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I18_MP1 (I1_I884_gn18 I1_b7_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I18_MP0 (VDD I1_p6_17 I1_I884_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I16_MP1 (I1_I884_gn16 I1_b7_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I16_MP0 (VDD I1_p6_15 I1_I884_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I14_MP1 (I1_I884_gn14 I1_b7_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I14_MP0 (VDD I1_p6_13 I1_I884_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I13_MP1 (I1_I884_gn13 I1_b7_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I13_MP0 (VDD I1_p6_12 I1_I884_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I11_MP1 (I1_I884_gn11 I1_b7_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I11_MP0 (VDD I1_p6_10 I1_I884_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I100_XP_MP1 (I1_I838_P4_1n I1_I838_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I100_XP_MP0 (VDD I1_I838_P4_3 I1_I838_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I4_MP1 (I1_I838_gn4 I1_b6_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I4_MP0 (VDD I1_p5_3 I1_I838_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I8_MP1 (I1_I792_gn8 I1_b5_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I8_MP0 (VDD I1_p4_7 I1_I792_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I100_XP_MP1 (I1_I746_P4_1n I1_I746_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I100_XP_MP0 (VDD I1_I746_P4_3 I1_I746_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I13_MP1 (I1_I792_gn13 I1_b5_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I13_MP0 (VDD I1_p4_12 I1_I792_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I102_XP_MP1 (I1_I746_P6_3n I1_I746_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I102_XP_MP0 (VDD I1_I746_P6_5 I1_I746_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I104_XP_MP1 (I1_I746_P8_5n I1_I746_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I104_XP_MP0 (VDD I1_I746_P8_7 I1_I746_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I168_XP_MP1 (I1_I746_P17_2n I1_I746_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I168_XP_MP0 (VDD I1_I746_P17_10 I1_I746_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I113_XP_MP1 (I1_I746_P17_14n I1_I746_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I113_XP_MP0 (VDD I1_I746_P17_16 I1_I746_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I176_XP_MP1 (I1_I746_P25_10n I1_I746_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I176_XP_MP0 (VDD I1_I746_P25_18 I1_I746_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I115_XP_MP1 (I1_I746_P19_16n I1_I746_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I115_XP_MP0 (VDD I1_I746_P19_18 I1_I746_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I117_XP_MP1 (I1_I746_P21_18n I1_I746_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I117_XP_MP0 (VDD I1_I746_P21_20 I1_I746_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I178_XP_MP1 (I1_I746_P27_12n I1_I746_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I178_XP_MP0 (VDD I1_I746_P27_20 I1_I746_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I119_XP_MP1 (I1_I746_P23_20n I1_I746_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I119_XP_MP0 (VDD I1_I746_P23_22 I1_I746_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I31_MP1 (I1_I746_gn31 I1_b4_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I31_MP0 (VDD I1_p3_30 I1_I746_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I27_MP1 (I1_I1390_gn27 I1_b18_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I27_MP0 (VDD I1_p17_26 I1_I1390_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I28_MP1 (I1_I1390_gn28 I1_b18_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I28_MP0 (VDD I1_p17_27 I1_I1390_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I25_MP1 (I1_I1390_gn25 I1_b18_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I25_MP0 (VDD I1_p17_24 I1_I1390_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I22_MP1 (I1_I1390_gn22 I1_b18_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I22_MP0 (VDD I1_p17_21 I1_I1390_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I175_XP_MP1 (I1_I1344_P24_9n I1_I1344_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I175_XP_MP0 (VDD I1_I1344_P24_17 I1_I1344_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I108_XP_MP1 (I1_I1344_P12_9n I1_I1344_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I108_XP_MP0 (VDD I1_I1344_P12_11 I1_I1344_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I9_MP1 (I1_I1344_gn9 I1_b17_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I9_MP0 (VDD I1_p16_8 I1_I1344_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I105_XP_MP1 (I1_I1298_P9_6n I1_I1298_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I105_XP_MP0 (VDD I1_I1298_P9_8 I1_I1298_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I175_XP_MP1 (I1_I1298_P24_9n I1_I1298_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I175_XP_MP0 (VDD I1_I1298_P24_17 I1_I1298_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I108_XP_MP1 (I1_I1298_P12_9n I1_I1298_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I108_XP_MP0 (VDD I1_I1298_P12_11 I1_I1298_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I11_MP1 (I1_I1298_gn11 I1_b16_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I11_MP0 (VDD I1_p15_10 I1_I1298_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I108_XP_MP1 (I1_I1252_P12_9n I1_I1252_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I108_XP_MP0 (VDD I1_I1252_P12_11 I1_I1252_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I168_XP_MP1 (I1_I1252_P17_2n I1_I1252_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I168_XP_MP0 (VDD I1_I1252_P17_10 I1_I1252_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I107_XP_MP1 (I1_I1252_P11_8n I1_I1252_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I107_XP_MP0 (VDD I1_I1252_P11_10 I1_I1252_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I109_XP_MP1 (I1_I1252_P13_10n I1_I1252_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I109_XP_MP0 (VDD I1_I1252_P13_12 I1_I1252_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I11_MP1 (I1_I1252_gn11 I1_b15_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I11_MP0 (VDD I1_p14_10 I1_I1252_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I12_MP1 (I1_I1252_gn12 I1_b15_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I12_MP0 (VDD I1_p14_11 I1_I1252_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I16_MP1 (I1_I1206_gn16 I1_b14_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I16_MP0 (VDD I1_p13_15 I1_I1206_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I15_MP1 (I1_I1206_gn15 I1_b14_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I15_MP0 (VDD I1_p13_14 I1_I1206_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I14_MP1 (I1_I1206_gn14 I1_b14_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I14_MP0 (VDD I1_p13_13 I1_I1206_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I107_XP_MP1 (I1_I1206_P11_8n I1_I1206_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I107_XP_MP0 (VDD I1_I1206_P11_10 I1_I1206_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I105_XP_MP1 (I1_I1206_P9_6n I1_I1206_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I105_XP_MP0 (VDD I1_I1206_P9_8 I1_I1206_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I110_XP_MP1 (I1_I1206_P14_11n I1_I1206_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I110_XP_MP0 (VDD I1_I1206_P14_13 I1_I1206_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I108_XP_MP1 (I1_I1206_P12_9n I1_I1206_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I108_XP_MP0 (VDD I1_I1206_P12_11 I1_I1206_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I30_MP1 (I1_I884_gn30 I1_b7_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I30_MP0 (VDD I1_p6_29 I1_I884_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I127_XP_MP1 (I1_I884_P31_28n I1_I884_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I127_XP_MP0 (VDD I1_I884_P31_30 I1_I884_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I125_XP_MP1 (I1_I884_P29_26n I1_I884_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I125_XP_MP0 (VDD I1_I884_P29_28 I1_I884_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I123_XP_MP1 (I1_I884_P27_24n I1_I884_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I123_XP_MP0 (VDD I1_I884_P27_26 I1_I884_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I121_XP_MP1 (I1_I884_P25_22n I1_I884_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I121_XP_MP0 (VDD I1_I884_P25_24 I1_I884_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I119_XP_MP1 (I1_I884_P23_20n I1_I884_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I119_XP_MP0 (VDD I1_I884_P23_22 I1_I884_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I117_XP_MP1 (I1_I884_P21_18n I1_I884_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I117_XP_MP0 (VDD I1_I884_P21_20 I1_I884_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I115_XP_MP1 (I1_I884_P19_16n I1_I884_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I115_XP_MP0 (VDD I1_I884_P19_18 I1_I884_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I113_XP_MP1 (I1_I884_P17_14n I1_I884_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I113_XP_MP0 (VDD I1_I884_P17_16 I1_I884_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I12_MP1 (I1_I884_gn12 I1_b7_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I12_MP0 (VDD I1_p6_11 I1_I884_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I10_MP1 (I1_I884_gn10 I1_b7_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I10_MP0 (VDD I1_p6_9 I1_I884_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I9_MP1 (I1_I884_gn9 I1_b7_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I9_MP0 (VDD I1_p6_8 I1_I884_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I3_MP1 (I1_I838_gn3 I1_b6_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I3_MP0 (VDD I1_p5_2 I1_I838_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I6_MP1 (I1_I792_gn6 I1_b5_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I6_MP0 (VDD I1_p4_5 I1_I792_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I7_MP1 (I1_I792_gn7 I1_b5_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I7_MP0 (VDD I1_p4_6 I1_I792_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I9_MP1 (I1_I792_gn9 I1_b5_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I9_MP0 (VDD I1_p4_8 I1_I792_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I103_XP_MP1 (I1_I746_P7_4n I1_I746_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I103_XP_MP0 (VDD I1_I746_P7_6 I1_I746_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I105_XP_MP1 (I1_I746_P9_6n I1_I746_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I105_XP_MP0 (VDD I1_I746_P9_8 I1_I746_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I107_XP_MP1 (I1_I746_P11_8n I1_I746_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I107_XP_MP0 (VDD I1_I746_P11_10 I1_I746_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I170_XP_MP1 (I1_I746_P19_4n I1_I746_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I170_XP_MP0 (VDD I1_I746_P19_12 I1_I746_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I109_XP_MP1 (I1_I746_P13_10n I1_I746_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I109_XP_MP0 (VDD I1_I746_P13_12 I1_I746_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I111_XP_MP1 (I1_I746_P15_12n I1_I746_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I111_XP_MP0 (VDD I1_I746_P15_14 I1_I746_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I174_XP_MP1 (I1_I746_P23_8n I1_I746_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I174_XP_MP0 (VDD I1_I746_P23_16 I1_I746_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I182_XP_MP1 (I1_I746_P31_16n I1_I746_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I182_XP_MP0 (VDD I1_I746_P31_24 I1_I746_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I31_MP1 (I1_I1390_gn31 I1_b18_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I31_MP0 (VDD I1_p17_30 I1_I1390_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I26_MP1 (I1_I1390_gn26 I1_b18_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I26_MP0 (VDD I1_p17_25 I1_I1390_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I24_MP1 (I1_I1390_gn24 I1_b18_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I24_MP0 (VDD I1_p17_23 I1_I1390_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I169_XP_MP1 (I1_I1344_P18_3n I1_I1344_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I169_XP_MP0 (VDD I1_I1344_P18_11 I1_I1344_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I106_XP_MP1 (I1_I1344_P10_7n I1_I1344_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I106_XP_MP0 (VDD I1_I1344_P10_9 I1_I1344_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I10_MP1 (I1_I1344_gn10 I1_b17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I10_MP0 (VDD I1_p16_9 I1_I1344_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I101_XP_MP1 (I1_I1344_P5_2n I1_I1344_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I101_XP_MP0 (VDD I1_I1344_P5_4 I1_I1344_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I103_XP_MP1 (I1_I1298_P7_4n I1_I1298_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I103_XP_MP0 (VDD I1_I1298_P7_6 I1_I1298_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I167_XP_MP1 (I1_I1298_P16_1n I1_I1298_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I167_XP_MP0 (VDD I1_I1298_P16_9 I1_I1298_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I106_XP_MP1 (I1_I1298_P10_7n I1_I1298_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I106_XP_MP0 (VDD I1_I1298_P10_9 I1_I1298_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I10_MP1 (I1_I1298_gn10 I1_b16_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I10_MP0 (VDD I1_p15_9 I1_I1298_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I9_MP1 (I1_I1298_gn9 I1_b16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I9_MP0 (VDD I1_p15_8 I1_I1298_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I167_XP_MP1 (I1_I1252_P16_1n I1_I1252_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I167_XP_MP0 (VDD I1_I1252_P16_9 I1_I1252_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I106_XP_MP1 (I1_I1252_P10_7n I1_I1252_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I106_XP_MP0 (VDD I1_I1252_P10_9 I1_I1252_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I105_XP_MP1 (I1_I1252_P9_6n I1_I1252_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I105_XP_MP0 (VDD I1_I1252_P9_8 I1_I1252_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I8_MP1 (I1_I1252_gn8 I1_b15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I8_MP0 (VDD I1_p14_7 I1_I1252_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I9_MP1 (I1_I1252_gn9 I1_b15_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I9_MP0 (VDD I1_p14_8 I1_I1252_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I10_MP1 (I1_I1252_gn10 I1_b15_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I10_MP0 (VDD I1_p14_9 I1_I1252_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I13_MP1 (I1_I1206_gn13 I1_b14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I13_MP0 (VDD I1_p13_12 I1_I1206_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I103_XP_MP1 (I1_I1206_P7_4n I1_I1206_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I103_XP_MP0 (VDD I1_I1206_P7_6 I1_I1206_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I101_XP_MP1 (I1_I1206_P5_2n I1_I1206_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I101_XP_MP0 (VDD I1_I1206_P5_4 I1_I1206_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I106_XP_MP1 (I1_I1206_P10_7n I1_I1206_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I106_XP_MP0 (VDD I1_I1206_P10_9 I1_I1206_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I167_XP_MP1 (I1_I1206_P16_1n I1_I1206_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I167_XP_MP0 (VDD I1_I1206_P16_9 I1_I1206_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I182_XP_MP1 (I1_I884_P31_16n I1_I884_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I182_XP_MP0 (VDD I1_I884_P31_24 I1_I884_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I180_XP_MP1 (I1_I884_P29_14n I1_I884_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I180_XP_MP0 (VDD I1_I884_P29_22 I1_I884_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I174_XP_MP1 (I1_I884_P23_8n I1_I884_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I174_XP_MP0 (VDD I1_I884_P23_16 I1_I884_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I178_XP_MP1 (I1_I884_P27_12n I1_I884_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I178_XP_MP0 (VDD I1_I884_P27_20 I1_I884_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I172_XP_MP1 (I1_I884_P21_6n I1_I884_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I172_XP_MP0 (VDD I1_I884_P21_14 I1_I884_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I170_XP_MP1 (I1_I884_P19_4n I1_I884_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I170_XP_MP0 (VDD I1_I884_P19_12 I1_I884_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I111_XP_MP1 (I1_I884_P15_12n I1_I884_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I111_XP_MP0 (VDD I1_I884_P15_14 I1_I884_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I109_XP_MP1 (I1_I884_P13_10n I1_I884_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I109_XP_MP0 (VDD I1_I884_P13_12 I1_I884_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I107_XP_MP1 (I1_I884_P11_8n I1_I884_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I107_XP_MP0 (VDD I1_I884_P11_10 I1_I884_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I8_MP1 (I1_I884_gn8 I1_b7_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I8_MP0 (VDD I1_p6_7 I1_I884_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I7_MP1 (I1_I884_gn7 I1_b7_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I7_MP0 (VDD I1_p6_6 I1_I884_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I6_MP1 (I1_I884_gn6 I1_b7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I6_MP0 (VDD I1_p6_5 I1_I884_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I5_MP1 (I1_I884_gn5 I1_b7_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I5_MP0 (VDD I1_p6_4 I1_I884_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I2_MP1 (I1_I838_gn2 I1_b6_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I2_MP0 (VDD I1_p5_1 I1_I838_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I4_MP1 (I1_I792_gn4 I1_b5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I4_MP0 (VDD I1_p4_3 I1_I792_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I5_MP1 (I1_I792_gn5 I1_b5_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I5_MP0 (VDD I1_p4_4 I1_I792_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I101_XP_MP1 (I1_I746_P5_2n I1_I746_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I101_XP_MP0 (VDD I1_I746_P5_4 I1_I746_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I12_MP1 (I1_I746_gn12 I1_b4_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I12_MP0 (VDD I1_p3_11 I1_I746_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I14_MP1 (I1_I746_gn14 I1_b4_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I14_MP0 (VDD I1_p3_13 I1_I746_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I16_MP1 (I1_I746_gn16 I1_b4_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I16_MP0 (VDD I1_p3_15 I1_I746_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I17_MP1 (I1_I746_gn17 I1_b4_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I17_MP0 (VDD I1_p3_16 I1_I746_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I18_MP1 (I1_I746_gn18 I1_b4_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I18_MP0 (VDD I1_p3_17 I1_I746_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I20_MP1 (I1_I746_gn20 I1_b4_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I20_MP0 (VDD I1_p3_19 I1_I746_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I21_MP1 (I1_I746_gn21 I1_b4_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I21_MP0 (VDD I1_p3_20 I1_I746_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I22_MP1 (I1_I746_gn22 I1_b4_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I22_MP0 (VDD I1_p3_21 I1_I746_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I23_MP1 (I1_I746_gn23 I1_b4_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I23_MP0 (VDD I1_p3_22 I1_I746_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I30_MP1 (I1_I1390_gn30 I1_b18_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I30_MP0 (VDD I1_p17_29 I1_I1390_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I23_MP1 (I1_I1390_gn23 I1_b18_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I23_MP0 (VDD I1_p17_22 I1_I1390_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I21_MP1 (I1_I1390_gn21 I1_b18_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I21_MP0 (VDD I1_p17_20 I1_I1390_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I20_MP1 (I1_I1390_gn20 I1_b18_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I20_MP0 (VDD I1_p17_19 I1_I1390_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I19_MP1 (I1_I1390_gn19 I1_b18_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I19_MP0 (VDD I1_p17_18 I1_I1390_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I17_MP1 (I1_I1390_gn17 I1_b18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I17_MP0 (VDD I1_p17_16 I1_I1390_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I167_XP_MP1 (I1_I1344_P16_1n I1_I1344_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I167_XP_MP0 (VDD I1_I1344_P16_9 I1_I1344_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I104_XP_MP1 (I1_I1344_P8_5n I1_I1344_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I104_XP_MP0 (VDD I1_I1344_P8_7 I1_I1344_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I8_MP1 (I1_I1344_gn8 I1_b17_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I8_MP0 (VDD I1_p16_7 I1_I1344_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I7_MP1 (I1_I1344_gn7 I1_b17_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I7_MP0 (VDD I1_p16_6 I1_I1344_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I101_XP_MP1 (I1_I1298_P5_2n I1_I1298_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I101_XP_MP0 (VDD I1_I1298_P5_4 I1_I1298_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I104_XP_MP1 (I1_I1298_P8_5n I1_I1298_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I104_XP_MP0 (VDD I1_I1298_P8_7 I1_I1298_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I7_MP1 (I1_I1298_gn7 I1_b16_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I7_MP0 (VDD I1_p15_6 I1_I1298_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I8_MP1 (I1_I1298_gn8 I1_b16_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I8_MP0 (VDD I1_p15_7 I1_I1298_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I104_XP_MP1 (I1_I1252_P8_5n I1_I1252_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I104_XP_MP0 (VDD I1_I1252_P8_7 I1_I1252_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I103_XP_MP1 (I1_I1252_P7_4n I1_I1252_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I103_XP_MP0 (VDD I1_I1252_P7_6 I1_I1252_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I6_MP1 (I1_I1252_gn6 I1_b15_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I6_MP0 (VDD I1_p14_5 I1_I1252_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I7_MP1 (I1_I1252_gn7 I1_b15_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I7_MP0 (VDD I1_p14_6 I1_I1252_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I12_MP1 (I1_I1206_gn12 I1_b14_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I12_MP0 (VDD I1_p13_11 I1_I1206_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I11_MP1 (I1_I1206_gn11 I1_b14_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I11_MP0 (VDD I1_p13_10 I1_I1206_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I10_MP1 (I1_I1206_gn10 I1_b14_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I10_MP0 (VDD I1_p13_9 I1_I1206_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I9_MP1 (I1_I1206_gn9 I1_b14_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I9_MP0 (VDD I1_p13_8 I1_I1206_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I8_MP1 (I1_I1206_gn8 I1_b14_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I8_MP0 (VDD I1_p13_7 I1_I1206_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I102_XP_MP1 (I1_I1206_P6_3n I1_I1206_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I102_XP_MP0 (VDD I1_I1206_P6_5 I1_I1206_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I104_XP_MP1 (I1_I1206_P8_5n I1_I1206_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I104_XP_MP0 (VDD I1_I1206_P8_7 I1_I1206_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I126_XP_MP1 (I1_I884_P30_27n I1_I884_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I126_XP_MP0 (VDD I1_I884_P30_29 I1_I884_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I176_XP_MP1 (I1_I884_P25_10n I1_I884_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I176_XP_MP0 (VDD I1_I884_P25_18 I1_I884_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I168_XP_MP1 (I1_I884_P17_2n I1_I884_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I168_XP_MP0 (VDD I1_I884_P17_10 I1_I884_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I105_XP_MP1 (I1_I884_P9_6n I1_I884_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I105_XP_MP0 (VDD I1_I884_P9_8 I1_I884_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I103_XP_MP1 (I1_I884_P7_4n I1_I884_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I103_XP_MP0 (VDD I1_I884_P7_6 I1_I884_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I4_MP1 (I1_I884_gn4 I1_b7_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I4_MP0 (VDD I1_p6_3 I1_I884_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I2_MP1 (I1_I792_gn2 I1_b5_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I2_MP0 (VDD I1_p4_1 I1_I792_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I3_MP1 (I1_I792_gn3 I1_b5_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I3_MP0 (VDD I1_p4_2 I1_I792_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I6_MP1 (I1_I746_gn6 I1_b4_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I6_MP0 (VDD I1_p3_5 I1_I746_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I9_MP1 (I1_I746_gn9 I1_b4_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I9_MP0 (VDD I1_p3_8 I1_I746_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I11_MP1 (I1_I746_gn11 I1_b4_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I11_MP0 (VDD I1_p3_10 I1_I746_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I10_MP1 (I1_I746_gn10 I1_b4_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I10_MP0 (VDD I1_p3_9 I1_I746_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I13_MP1 (I1_I746_gn13 I1_b4_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I13_MP0 (VDD I1_p3_12 I1_I746_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I15_MP1 (I1_I746_gn15 I1_b4_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I15_MP0 (VDD I1_p3_14 I1_I746_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I174_XP_MP1 (I1_I700_P23_8n I1_I700_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I174_XP_MP0 (VDD I1_I700_P23_16 I1_I700_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I182_XP_MP1 (I1_I700_P31_16n I1_I700_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I182_XP_MP0 (VDD I1_I700_P31_24 I1_I700_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I18_MP1 (I1_I1390_gn18 I1_b18_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I18_MP0 (VDD I1_p17_17 I1_I1390_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I16_MP1 (I1_I1390_gn16 I1_b18_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I16_MP0 (VDD I1_p17_15 I1_I1390_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I15_MP1 (I1_I1390_gn15 I1_b18_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I15_MP0 (VDD I1_p17_14 I1_I1390_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I102_XP_MP1 (I1_I1344_P6_3n I1_I1344_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I102_XP_MP0 (VDD I1_I1344_P6_5 I1_I1344_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I100_XP_MP1 (I1_I1344_P4_1n I1_I1344_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I100_XP_MP0 (VDD I1_I1344_P4_3 I1_I1344_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I6_MP1 (I1_I1344_gn6 I1_b17_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I6_MP0 (VDD I1_p16_5 I1_I1344_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I5_MP1 (I1_I1344_gn5 I1_b17_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I5_MP0 (VDD I1_p16_4 I1_I1344_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I102_XP_MP1 (I1_I1298_P6_3n I1_I1298_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I102_XP_MP0 (VDD I1_I1298_P6_5 I1_I1298_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I6_MP1 (I1_I1298_gn6 I1_b16_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I6_MP0 (VDD I1_p15_5 I1_I1298_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I100_XP_MP1 (I1_I1252_P4_1n I1_I1252_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I100_XP_MP0 (VDD I1_I1252_P4_3 I1_I1252_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I102_XP_MP1 (I1_I1252_P6_3n I1_I1252_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I102_XP_MP0 (VDD I1_I1252_P6_5 I1_I1252_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I101_XP_MP1 (I1_I1252_P5_2n I1_I1252_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I101_XP_MP0 (VDD I1_I1252_P5_4 I1_I1252_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I5_MP1 (I1_I1252_gn5 I1_b15_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I5_MP0 (VDD I1_p14_4 I1_I1252_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I178_XP_MP1 (I1_I1160_P27_12n I1_I1160_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I178_XP_MP0 (VDD I1_I1160_P27_20 I1_I1160_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I170_XP_MP1 (I1_I1160_P19_4n I1_I1160_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I170_XP_MP0 (VDD I1_I1160_P19_12 I1_I1160_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I6_MP1 (I1_I1206_gn6 I1_b14_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I6_MP0 (VDD I1_p13_5 I1_I1206_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I100_XP_MP1 (I1_I1206_P4_1n I1_I1206_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I100_XP_MP0 (VDD I1_I1206_P4_3 I1_I1206_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I124_XP_MP1 (I1_I884_P28_25n I1_I884_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I124_XP_MP0 (VDD I1_I884_P28_27 I1_I884_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I122_XP_MP1 (I1_I884_P26_23n I1_I884_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I122_XP_MP0 (VDD I1_I884_P26_25 I1_I884_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I120_XP_MP1 (I1_I884_P24_21n I1_I884_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I120_XP_MP0 (VDD I1_I884_P24_23 I1_I884_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I118_XP_MP1 (I1_I884_P22_19n I1_I884_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I118_XP_MP0 (VDD I1_I884_P22_21 I1_I884_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I116_XP_MP1 (I1_I884_P20_17n I1_I884_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I116_XP_MP0 (VDD I1_I884_P20_19 I1_I884_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I114_XP_MP1 (I1_I884_P18_15n I1_I884_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I114_XP_MP0 (VDD I1_I884_P18_17 I1_I884_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I112_XP_MP1 (I1_I884_P16_13n I1_I884_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I112_XP_MP0 (VDD I1_I884_P16_15 I1_I884_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I110_XP_MP1 (I1_I884_P14_11n I1_I884_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I110_XP_MP0 (VDD I1_I884_P14_13 I1_I884_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I108_XP_MP1 (I1_I884_P12_9n I1_I884_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I108_XP_MP0 (VDD I1_I884_P12_11 I1_I884_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I106_XP_MP1 (I1_I884_P10_7n I1_I884_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I106_XP_MP0 (VDD I1_I884_P10_9 I1_I884_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I104_XP_MP1 (I1_I884_P8_5n I1_I884_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I104_XP_MP0 (VDD I1_I884_P8_7 I1_I884_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I101_XP_MP1 (I1_I884_P5_2n I1_I884_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I101_XP_MP0 (VDD I1_I884_P5_4 I1_I884_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I3_MP1 (I1_I884_gn3 I1_b7_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I3_MP0 (VDD I1_p6_2 I1_I884_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I5_MP1 (I1_I746_gn5 I1_b4_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I5_MP0 (VDD I1_p3_4 I1_I746_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I7_MP1 (I1_I746_gn7 I1_b4_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I7_MP0 (VDD I1_p3_6 I1_I746_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I8_MP1 (I1_I746_gn8 I1_b4_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I8_MP0 (VDD I1_p3_7 I1_I746_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I170_XP_MP1 (I1_I700_P19_4n I1_I700_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I170_XP_MP0 (VDD I1_I700_P19_12 I1_I700_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I19_MP1 (I1_I746_gn19 I1_b4_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I19_MP0 (VDD I1_p3_18 I1_I746_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I172_XP_MP1 (I1_I700_P21_6n I1_I700_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I172_XP_MP0 (VDD I1_I700_P21_14 I1_I700_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I178_XP_MP1 (I1_I700_P27_12n I1_I700_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I178_XP_MP0 (VDD I1_I700_P27_20 I1_I700_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I180_XP_MP1 (I1_I700_P29_14n I1_I700_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I180_XP_MP0 (VDD I1_I700_P29_22 I1_I700_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I127_XP_MP1 (I1_I1390_P31_28n I1_I1390_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I127_XP_MP0 (VDD I1_I1390_P31_30 I1_I1390_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I125_XP_MP1 (I1_I1390_P29_26n I1_I1390_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I125_XP_MP0 (VDD I1_I1390_P29_28 I1_I1390_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I123_XP_MP1 (I1_I1390_P27_24n I1_I1390_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I123_XP_MP0 (VDD I1_I1390_P27_26 I1_I1390_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I121_XP_MP1 (I1_I1390_P25_22n I1_I1390_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I121_XP_MP0 (VDD I1_I1390_P25_24 I1_I1390_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I119_XP_MP1 (I1_I1390_P23_20n I1_I1390_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I119_XP_MP0 (VDD I1_I1390_P23_22 I1_I1390_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I117_XP_MP1 (I1_I1390_P21_18n I1_I1390_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I117_XP_MP0 (VDD I1_I1390_P21_20 I1_I1390_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I115_XP_MP1 (I1_I1390_P19_16n I1_I1390_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I115_XP_MP0 (VDD I1_I1390_P19_18 I1_I1390_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I14_MP1 (I1_I1390_gn14 I1_b18_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I14_MP0 (VDD I1_p17_13 I1_I1390_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I12_MP1 (I1_I1390_gn12 I1_b18_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I12_MP0 (VDD I1_p17_11 I1_I1390_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I13_MP1 (I1_I1390_gn13 I1_b18_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I13_MP0 (VDD I1_p17_12 I1_I1390_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I10_MP1 (I1_I1390_gn10 I1_b18_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I10_MP0 (VDD I1_p17_9 I1_I1390_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I4_MP1 (I1_I1344_gn4 I1_b17_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I4_MP0 (VDD I1_p16_3 I1_I1344_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I100_XP_MP1 (I1_I1298_P4_1n I1_I1298_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I100_XP_MP0 (VDD I1_I1298_P4_3 I1_I1298_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I4_MP1 (I1_I1298_gn4 I1_b16_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I4_MP0 (VDD I1_p15_3 I1_I1298_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I5_MP1 (I1_I1298_gn5 I1_b16_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I5_MP0 (VDD I1_p15_4 I1_I1298_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I3_MP1 (I1_I1252_gn3 I1_b15_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I3_MP0 (VDD I1_p14_2 I1_I1252_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I4_MP1 (I1_I1252_gn4 I1_b15_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I4_MP0 (VDD I1_p14_3 I1_I1252_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I174_XP_MP1 (I1_I1160_P23_8n I1_I1160_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I174_XP_MP0 (VDD I1_I1160_P23_16 I1_I1160_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I7_MP1 (I1_I1206_gn7 I1_b14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I7_MP0 (VDD I1_p13_6 I1_I1206_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I181_XP_MP1 (I1_I884_P30_15n I1_I884_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I181_XP_MP0 (VDD I1_I884_P30_23 I1_I884_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I179_XP_MP1 (I1_I884_P28_13n I1_I884_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I179_XP_MP0 (VDD I1_I884_P28_21 I1_I884_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I177_XP_MP1 (I1_I884_P26_11n I1_I884_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I177_XP_MP0 (VDD I1_I884_P26_19 I1_I884_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I173_XP_MP1 (I1_I884_P22_7n I1_I884_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I173_XP_MP0 (VDD I1_I884_P22_15 I1_I884_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I175_XP_MP1 (I1_I884_P24_9n I1_I884_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I175_XP_MP0 (VDD I1_I884_P24_17 I1_I884_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I171_XP_MP1 (I1_I884_P20_5n I1_I884_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I171_XP_MP0 (VDD I1_I884_P20_13 I1_I884_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I169_XP_MP1 (I1_I884_P18_3n I1_I884_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I169_XP_MP0 (VDD I1_I884_P18_11 I1_I884_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I167_XP_MP1 (I1_I884_P16_1n I1_I884_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I167_XP_MP0 (VDD I1_I884_P16_9 I1_I884_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I100_XP_MP1 (I1_I884_P4_1n I1_I884_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I100_XP_MP0 (VDD I1_I884_P4_3 I1_I884_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I102_XP_MP1 (I1_I884_P6_3n I1_I884_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I102_XP_MP0 (VDD I1_I884_P6_5 I1_I884_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I2_MP1 (I1_I884_gn2 I1_b7_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I2_MP0 (VDD I1_p6_1 I1_I884_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I1_MP1 (I1_I838_gn1 I1_b6_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I1_MP0 (VDD I1_p5_0 I1_I838_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I1_MP1 (I1_I792_gn1 I1_b5_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I1_MP0 (VDD I1_p4_0 I1_I792_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I3_MP1 (I1_I746_gn3 I1_b4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I3_MP0 (VDD I1_p3_2 I1_I746_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I101_XP_MP1 (I1_I700_P5_2n I1_I700_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I101_XP_MP0 (VDD I1_I700_P5_4 I1_I700_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I168_XP_MP1 (I1_I700_P17_2n I1_I700_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I168_XP_MP0 (VDD I1_I700_P17_10 I1_I700_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I109_XP_MP1 (I1_I700_P13_10n I1_I700_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I109_XP_MP0 (VDD I1_I700_P13_12 I1_I700_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I111_XP_MP1 (I1_I700_P15_12n I1_I700_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I111_XP_MP0 (VDD I1_I700_P15_14 I1_I700_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I113_XP_MP1 (I1_I700_P17_14n I1_I700_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I113_XP_MP0 (VDD I1_I700_P17_16 I1_I700_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I115_XP_MP1 (I1_I700_P19_16n I1_I700_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I115_XP_MP0 (VDD I1_I700_P19_18 I1_I700_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I117_XP_MP1 (I1_I700_P21_18n I1_I700_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I117_XP_MP0 (VDD I1_I700_P21_20 I1_I700_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I176_XP_MP1 (I1_I700_P25_10n I1_I700_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I176_XP_MP0 (VDD I1_I700_P25_18 I1_I700_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I119_XP_MP1 (I1_I700_P23_20n I1_I700_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I119_XP_MP0 (VDD I1_I700_P23_22 I1_I700_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I123_XP_MP1 (I1_I700_P27_24n I1_I700_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I123_XP_MP0 (VDD I1_I700_P27_26 I1_I700_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I125_XP_MP1 (I1_I700_P29_26n I1_I700_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I125_XP_MP0 (VDD I1_I700_P29_28 I1_I700_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I127_XP_MP1 (I1_I700_P31_28n I1_I700_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I127_XP_MP0 (VDD I1_I700_P31_30 I1_I700_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I182_XP_MP1 (I1_I1390_P31_16n I1_I1390_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I182_XP_MP0 (VDD I1_I1390_P31_24 I1_I1390_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I180_XP_MP1 (I1_I1390_P29_14n I1_I1390_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I180_XP_MP0 (VDD I1_I1390_P29_22 I1_I1390_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I178_XP_MP1 (I1_I1390_P27_12n I1_I1390_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I178_XP_MP0 (VDD I1_I1390_P27_20 I1_I1390_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I113_XP_MP1 (I1_I1390_P17_14n I1_I1390_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I113_XP_MP0 (VDD I1_I1390_P17_16 I1_I1390_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I111_XP_MP1 (I1_I1390_P15_12n I1_I1390_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I111_XP_MP0 (VDD I1_I1390_P15_14 I1_I1390_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I11_MP1 (I1_I1390_gn11 I1_b18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I11_MP0 (VDD I1_p17_10 I1_I1390_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I9_MP1 (I1_I1390_gn9 I1_b18_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I9_MP0 (VDD I1_p17_8 I1_I1390_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I3_MP1 (I1_I1298_gn3 I1_b16_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I3_MP0 (VDD I1_p15_2 I1_I1298_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I1_MP1 (I1_I1252_gn1 I1_b15_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I1_MP0 (VDD I1_p14_0 I1_I1252_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I2_MP1 (I1_I1252_gn2 I1_b15_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I2_MP0 (VDD I1_p14_1 I1_I1252_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I127_XP_MP1 (I1_I1160_P31_28n I1_I1160_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I127_XP_MP0 (VDD I1_I1160_P31_30 I1_I1160_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I182_XP_MP1 (I1_I1160_P31_16n I1_I1160_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I182_XP_MP0 (VDD I1_I1160_P31_24 I1_I1160_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I180_XP_MP1 (I1_I1160_P29_14n I1_I1160_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I180_XP_MP0 (VDD I1_I1160_P29_22 I1_I1160_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I172_XP_MP1 (I1_I1160_P21_6n I1_I1160_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I172_XP_MP0 (VDD I1_I1160_P21_14 I1_I1160_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I176_XP_MP1 (I1_I1160_P25_10n I1_I1160_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I176_XP_MP0 (VDD I1_I1160_P25_18 I1_I1160_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I168_XP_MP1 (I1_I1160_P17_2n I1_I1160_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I168_XP_MP0 (VDD I1_I1160_P17_10 I1_I1160_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I103_XP_MP1 (I1_I1160_P7_4n I1_I1160_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I103_XP_MP0 (VDD I1_I1160_P7_6 I1_I1160_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I5_MP1 (I1_I1206_gn5 I1_b14_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I5_MP0 (VDD I1_p13_4 I1_I1206_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I4_MP1 (I1_I1206_gn4 I1_b14_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I4_MP0 (VDD I1_p13_3 I1_I1206_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I3_MP1 (I1_I1206_gn3 I1_b14_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I3_MP0 (VDD I1_p13_2 I1_I1206_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I2_MP1 (I1_I1206_gn2 I1_b14_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I2_MP0 (VDD I1_p13_1 I1_I1206_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I1_MP1 (I1_I1206_gn1 I1_b14_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I1_MP0 (VDD I1_p13_0 I1_I1206_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I27_MP1 (I1_I930_gn27 I1_b8_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I27_MP0 (VDD I1_p7_26 I1_I930_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I20_MP1 (I1_I930_gn20 I1_b8_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I20_MP0 (VDD I1_p7_19 I1_I930_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I18_MP1 (I1_I930_gn18 I1_b8_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I18_MP0 (VDD I1_p7_17 I1_I930_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I17_MP1 (I1_I930_gn17 I1_b8_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I17_MP0 (VDD I1_p7_16 I1_I930_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I14_MP1 (I1_I930_gn14 I1_b8_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I14_MP0 (VDD I1_p7_13 I1_I930_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I1_MP1 (I1_I884_gn1 I1_b7_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I1_MP0 (VDD I1_p6_0 I1_I884_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I2_MP1 (I1_I746_gn2 I1_b4_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I2_MP0 (VDD I1_p3_1 I1_I746_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I4_MP1 (I1_I746_gn4 I1_b4_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I4_MP0 (VDD I1_p3_3 I1_I746_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I103_XP_MP1 (I1_I700_P7_4n I1_I700_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I103_XP_MP0 (VDD I1_I700_P7_6 I1_I700_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I105_XP_MP1 (I1_I700_P9_6n I1_I700_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I105_XP_MP0 (VDD I1_I700_P9_8 I1_I700_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I107_XP_MP1 (I1_I700_P11_8n I1_I700_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I107_XP_MP0 (VDD I1_I700_P11_10 I1_I700_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I121_XP_MP1 (I1_I700_P25_22n I1_I700_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I121_XP_MP0 (VDD I1_I700_P25_24 I1_I700_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I174_XP_MP1 (I1_I1390_P23_8n I1_I1390_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I174_XP_MP0 (VDD I1_I1390_P23_16 I1_I1390_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I176_XP_MP1 (I1_I1390_P25_10n I1_I1390_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I176_XP_MP0 (VDD I1_I1390_P25_18 I1_I1390_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I172_XP_MP1 (I1_I1390_P21_6n I1_I1390_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I172_XP_MP0 (VDD I1_I1390_P21_14 I1_I1390_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I170_XP_MP1 (I1_I1390_P19_4n I1_I1390_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I170_XP_MP0 (VDD I1_I1390_P19_12 I1_I1390_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I109_XP_MP1 (I1_I1390_P13_10n I1_I1390_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I109_XP_MP0 (VDD I1_I1390_P13_12 I1_I1390_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I107_XP_MP1 (I1_I1390_P11_8n I1_I1390_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I107_XP_MP0 (VDD I1_I1390_P11_10 I1_I1390_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I8_MP1 (I1_I1390_gn8 I1_b18_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I8_MP0 (VDD I1_p17_7 I1_I1390_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I7_MP1 (I1_I1390_gn7 I1_b18_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I7_MP0 (VDD I1_p17_6 I1_I1390_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I3_MP1 (I1_I1344_gn3 I1_b17_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I3_MP0 (VDD I1_p16_2 I1_I1344_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I2_MP1 (I1_I1344_gn2 I1_b17_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I2_MP0 (VDD I1_p16_1 I1_I1344_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I1_MP1 (I1_I1298_gn1 I1_b16_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I1_MP0 (VDD I1_p15_0 I1_I1298_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I2_MP1 (I1_I1298_gn2 I1_b16_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I2_MP0 (VDD I1_p15_1 I1_I1298_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I0_MP1 (I1_I1252_gn0 I1_b15_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I0_MP0 (VDD I1_aa16 I1_I1252_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I125_XP_MP1 (I1_I1160_P29_26n I1_I1160_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I125_XP_MP0 (VDD I1_I1160_P29_28 I1_I1160_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I123_XP_MP1 (I1_I1160_P27_24n I1_I1160_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I123_XP_MP0 (VDD I1_I1160_P27_26 I1_I1160_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I121_XP_MP1 (I1_I1160_P25_22n I1_I1160_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I121_XP_MP0 (VDD I1_I1160_P25_24 I1_I1160_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I119_XP_MP1 (I1_I1160_P23_20n I1_I1160_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I119_XP_MP0 (VDD I1_I1160_P23_22 I1_I1160_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I117_XP_MP1 (I1_I1160_P21_18n I1_I1160_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I117_XP_MP0 (VDD I1_I1160_P21_20 I1_I1160_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I115_XP_MP1 (I1_I1160_P19_16n I1_I1160_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I115_XP_MP0 (VDD I1_I1160_P19_18 I1_I1160_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I113_XP_MP1 (I1_I1160_P17_14n I1_I1160_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I113_XP_MP0 (VDD I1_I1160_P17_16 I1_I1160_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I111_XP_MP1 (I1_I1160_P15_12n I1_I1160_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I111_XP_MP0 (VDD I1_I1160_P15_14 I1_I1160_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I109_XP_MP1 (I1_I1160_P13_10n I1_I1160_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I109_XP_MP0 (VDD I1_I1160_P13_12 I1_I1160_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I107_XP_MP1 (I1_I1160_P11_8n I1_I1160_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I107_XP_MP0 (VDD I1_I1160_P11_10 I1_I1160_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I105_XP_MP1 (I1_I1160_P9_6n I1_I1160_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I105_XP_MP0 (VDD I1_I1160_P9_8 I1_I1160_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I101_XP_MP1 (I1_I1160_P5_2n I1_I1160_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I101_XP_MP0 (VDD I1_I1160_P5_4 I1_I1160_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I28_MP1 (I1_I930_gn28 I1_b8_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I28_MP0 (VDD I1_p7_27 I1_I930_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I26_MP1 (I1_I930_gn26 I1_b8_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I26_MP0 (VDD I1_p7_25 I1_I930_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I25_MP1 (I1_I930_gn25 I1_b8_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I25_MP0 (VDD I1_p7_24 I1_I930_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I24_MP1 (I1_I930_gn24 I1_b8_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I24_MP0 (VDD I1_p7_23 I1_I930_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I23_MP1 (I1_I930_gn23 I1_b8_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I23_MP0 (VDD I1_p7_22 I1_I930_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I22_MP1 (I1_I930_gn22 I1_b8_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I22_MP0 (VDD I1_p7_21 I1_I930_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I21_MP1 (I1_I930_gn21 I1_b8_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I21_MP0 (VDD I1_p7_20 I1_I930_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I19_MP1 (I1_I930_gn19 I1_b8_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I19_MP0 (VDD I1_p7_18 I1_I930_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I16_MP1 (I1_I930_gn16 I1_b8_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I16_MP0 (VDD I1_p7_15 I1_I930_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I15_MP1 (I1_I930_gn15 I1_b8_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I15_MP0 (VDD I1_p7_14 I1_I930_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I13_MP1 (I1_I930_gn13 I1_b8_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I13_MP0 (VDD I1_p7_12 I1_I930_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I12_MP1 (I1_I930_gn12 I1_b8_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I12_MP0 (VDD I1_p7_11 I1_I930_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I11_MP1 (I1_I930_gn11 I1_b8_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I11_MP0 (VDD I1_p7_10 I1_I930_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I9_MP1 (I1_I930_gn9 I1_b8_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I9_MP0 (VDD I1_p7_8 I1_I930_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I10_MP1 (I1_I930_gn10 I1_b8_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I10_MP0 (VDD I1_p7_9 I1_I930_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I7_MP1 (I1_I930_gn7 I1_b8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I7_MP0 (VDD I1_p7_6 I1_I930_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I0_MP1 (I1_I792_gn0 I1_b5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I0_MP0 (VDD I1_aa26 I1_I792_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I1_MP1 (I1_I746_gn1 I1_b4_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I1_MP0 (VDD I1_p3_0 I1_I746_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I100_XP_MP1 (I1_I700_P4_1n I1_I700_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I100_XP_MP0 (VDD I1_I700_P4_3 I1_I700_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I102_XP_MP1 (I1_I700_P6_3n I1_I700_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I102_XP_MP0 (VDD I1_I700_P6_5 I1_I700_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I104_XP_MP1 (I1_I700_P8_5n I1_I700_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I104_XP_MP0 (VDD I1_I700_P8_7 I1_I700_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I167_XP_MP1 (I1_I700_P16_1n I1_I700_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I167_XP_MP0 (VDD I1_I700_P16_9 I1_I700_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I175_XP_MP1 (I1_I700_P24_9n I1_I700_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I175_XP_MP0 (VDD I1_I700_P24_17 I1_I700_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I169_XP_MP1 (I1_I700_P18_3n I1_I700_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I169_XP_MP0 (VDD I1_I700_P18_11 I1_I700_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I171_XP_MP1 (I1_I700_P20_5n I1_I700_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I171_XP_MP0 (VDD I1_I700_P20_13 I1_I700_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I177_XP_MP1 (I1_I700_P26_11n I1_I700_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I177_XP_MP0 (VDD I1_I700_P26_19 I1_I700_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I173_XP_MP1 (I1_I700_P22_7n I1_I700_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I173_XP_MP0 (VDD I1_I700_P22_15 I1_I700_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I179_XP_MP1 (I1_I700_P28_13n I1_I700_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I179_XP_MP0 (VDD I1_I700_P28_21 I1_I700_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I181_XP_MP1 (I1_I700_P30_15n I1_I700_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I181_XP_MP0 (VDD I1_I700_P30_23 I1_I700_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I126_XP_MP1 (I1_I700_P30_27n I1_I700_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I126_XP_MP0 (VDD I1_I700_P30_29 I1_I700_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I126_XP_MP1 (I1_I1390_P30_27n I1_I1390_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I126_XP_MP0 (VDD I1_I1390_P30_29 I1_I1390_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I124_XP_MP1 (I1_I1390_P28_25n I1_I1390_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I124_XP_MP0 (VDD I1_I1390_P28_27 I1_I1390_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I122_XP_MP1 (I1_I1390_P26_23n I1_I1390_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I122_XP_MP0 (VDD I1_I1390_P26_25 I1_I1390_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I120_XP_MP1 (I1_I1390_P24_21n I1_I1390_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I120_XP_MP0 (VDD I1_I1390_P24_23 I1_I1390_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I118_XP_MP1 (I1_I1390_P22_19n I1_I1390_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I118_XP_MP0 (VDD I1_I1390_P22_21 I1_I1390_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I116_XP_MP1 (I1_I1390_P20_17n I1_I1390_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I116_XP_MP0 (VDD I1_I1390_P20_19 I1_I1390_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I168_XP_MP1 (I1_I1390_P17_2n I1_I1390_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I168_XP_MP0 (VDD I1_I1390_P17_10 I1_I1390_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I105_XP_MP1 (I1_I1390_P9_6n I1_I1390_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I105_XP_MP0 (VDD I1_I1390_P9_8 I1_I1390_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I103_XP_MP1 (I1_I1390_P7_4n I1_I1390_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I103_XP_MP0 (VDD I1_I1390_P7_6 I1_I1390_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I6_MP1 (I1_I1390_gn6 I1_b18_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I6_MP0 (VDD I1_p17_5 I1_I1390_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I5_MP1 (I1_I1390_gn5 I1_b18_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I5_MP0 (VDD I1_p17_4 I1_I1390_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I1_MP1 (I1_I1344_gn1 I1_b17_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I1_MP0 (VDD I1_p16_0 I1_I1344_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I0_MP1 (I1_I1298_gn0 I1_b16_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I0_MP0 (VDD I1_aa15 I1_I1298_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I31_MP1 (I1_I1160_gn31 I1_b13_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I31_MP0 (VDD I1_p12_30 I1_I1160_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I126_XP_MP1 (I1_I1160_P30_27n I1_I1160_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I126_XP_MP0 (VDD I1_I1160_P30_29 I1_I1160_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I171_XP_MP1 (I1_I1160_P20_5n I1_I1160_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I171_XP_MP0 (VDD I1_I1160_P20_13 I1_I1160_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I167_XP_MP1 (I1_I1160_P16_1n I1_I1160_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I167_XP_MP0 (VDD I1_I1160_P16_9 I1_I1160_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I0_MP1 (I1_I1206_gn0 I1_b14_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I0_MP0 (VDD I1_aa17 I1_I1206_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I31_MP1 (I1_I930_gn31 I1_b8_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I31_MP0 (VDD I1_p7_30 I1_I930_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I29_MP1 (I1_I930_gn29 I1_b8_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I29_MP0 (VDD I1_p7_28 I1_I930_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I123_XP_MP1 (I1_I930_P27_24n I1_I930_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I123_XP_MP0 (VDD I1_I930_P27_26 I1_I930_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I121_XP_MP1 (I1_I930_P25_22n I1_I930_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I121_XP_MP0 (VDD I1_I930_P25_24 I1_I930_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I119_XP_MP1 (I1_I930_P23_20n I1_I930_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I119_XP_MP0 (VDD I1_I930_P23_22 I1_I930_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I117_XP_MP1 (I1_I930_P21_18n I1_I930_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I117_XP_MP0 (VDD I1_I930_P21_20 I1_I930_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I115_XP_MP1 (I1_I930_P19_16n I1_I930_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I115_XP_MP0 (VDD I1_I930_P19_18 I1_I930_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I113_XP_MP1 (I1_I930_P17_14n I1_I930_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I113_XP_MP0 (VDD I1_I930_P17_16 I1_I930_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I111_XP_MP1 (I1_I930_P15_12n I1_I930_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I111_XP_MP0 (VDD I1_I930_P15_14 I1_I930_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I8_MP1 (I1_I930_gn8 I1_b8_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I8_MP0 (VDD I1_p7_7 I1_I930_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I6_MP1 (I1_I930_gn6 I1_b8_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I6_MP0 (VDD I1_p7_5 I1_I930_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I0_MP1 (I1_I838_gn0 I1_b6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I0_MP0 (VDD I1_aa25 I1_I838_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I1_MP1 (I1_I700_gn1 I1_b3_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I1_MP0 (VDD I1_p2_0 I1_I700_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I106_XP_MP1 (I1_I700_P10_7n I1_I700_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I106_XP_MP0 (VDD I1_I700_P10_9 I1_I700_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I108_XP_MP1 (I1_I700_P12_9n I1_I700_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I108_XP_MP0 (VDD I1_I700_P12_11 I1_I700_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I110_XP_MP1 (I1_I700_P14_11n I1_I700_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I110_XP_MP0 (VDD I1_I700_P14_13 I1_I700_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I112_XP_MP1 (I1_I700_P16_13n I1_I700_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I112_XP_MP0 (VDD I1_I700_P16_15 I1_I700_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I114_XP_MP1 (I1_I700_P18_15n I1_I700_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I114_XP_MP0 (VDD I1_I700_P18_17 I1_I700_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I116_XP_MP1 (I1_I700_P20_17n I1_I700_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I116_XP_MP0 (VDD I1_I700_P20_19 I1_I700_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I118_XP_MP1 (I1_I700_P22_19n I1_I700_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I118_XP_MP0 (VDD I1_I700_P22_21 I1_I700_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I120_XP_MP1 (I1_I700_P24_21n I1_I700_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I120_XP_MP0 (VDD I1_I700_P24_23 I1_I700_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I122_XP_MP1 (I1_I700_P26_23n I1_I700_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I122_XP_MP0 (VDD I1_I700_P26_25 I1_I700_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I124_XP_MP1 (I1_I700_P28_25n I1_I700_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I124_XP_MP0 (VDD I1_I700_P28_27 I1_I700_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I27_MP1 (I1_I700_gn27 I1_b3_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I27_MP0 (VDD I1_p2_26 I1_I700_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I181_XP_MP1 (I1_I1390_P30_15n I1_I1390_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I181_XP_MP0 (VDD I1_I1390_P30_23 I1_I1390_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I114_XP_MP1 (I1_I1390_P18_15n I1_I1390_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I114_XP_MP0 (VDD I1_I1390_P18_17 I1_I1390_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I112_XP_MP1 (I1_I1390_P16_13n I1_I1390_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I112_XP_MP0 (VDD I1_I1390_P16_15 I1_I1390_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I110_XP_MP1 (I1_I1390_P14_11n I1_I1390_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I110_XP_MP0 (VDD I1_I1390_P14_13 I1_I1390_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I108_XP_MP1 (I1_I1390_P12_9n I1_I1390_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I108_XP_MP0 (VDD I1_I1390_P12_11 I1_I1390_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I106_XP_MP1 (I1_I1390_P10_7n I1_I1390_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I106_XP_MP0 (VDD I1_I1390_P10_9 I1_I1390_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I101_XP_MP1 (I1_I1390_P5_2n I1_I1390_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I101_XP_MP0 (VDD I1_I1390_P5_4 I1_I1390_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I4_MP1 (I1_I1390_gn4 I1_b18_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I4_MP0 (VDD I1_p17_3 I1_I1390_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I3_MP1 (I1_I1390_gn3 I1_b18_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I3_MP0 (VDD I1_p17_2 I1_I1390_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I27_MP1 (I1_I1160_gn27 I1_b13_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I27_MP0 (VDD I1_p12_26 I1_I1160_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I29_MP1 (I1_I1160_gn29 I1_b13_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I29_MP0 (VDD I1_p12_28 I1_I1160_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I26_MP1 (I1_I1160_gn26 I1_b13_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I26_MP0 (VDD I1_p12_25 I1_I1160_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I30_MP1 (I1_I1160_gn30 I1_b13_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I30_MP0 (VDD I1_p12_29 I1_I1160_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I124_XP_MP1 (I1_I1160_P28_25n I1_I1160_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I124_XP_MP0 (VDD I1_I1160_P28_27 I1_I1160_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I122_XP_MP1 (I1_I1160_P26_23n I1_I1160_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I122_XP_MP0 (VDD I1_I1160_P26_25 I1_I1160_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I120_XP_MP1 (I1_I1160_P24_21n I1_I1160_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I120_XP_MP0 (VDD I1_I1160_P24_23 I1_I1160_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I181_XP_MP1 (I1_I1160_P30_15n I1_I1160_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I181_XP_MP0 (VDD I1_I1160_P30_23 I1_I1160_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I173_XP_MP1 (I1_I1160_P22_7n I1_I1160_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I173_XP_MP0 (VDD I1_I1160_P22_15 I1_I1160_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I179_XP_MP1 (I1_I1160_P28_13n I1_I1160_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I179_XP_MP0 (VDD I1_I1160_P28_21 I1_I1160_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I177_XP_MP1 (I1_I1160_P26_11n I1_I1160_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I177_XP_MP0 (VDD I1_I1160_P26_19 I1_I1160_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I169_XP_MP1 (I1_I1160_P18_3n I1_I1160_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I169_XP_MP0 (VDD I1_I1160_P18_11 I1_I1160_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I175_XP_MP1 (I1_I1160_P24_9n I1_I1160_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I175_XP_MP0 (VDD I1_I1160_P24_17 I1_I1160_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I104_XP_MP1 (I1_I1160_P8_5n I1_I1160_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I104_XP_MP0 (VDD I1_I1160_P8_7 I1_I1160_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I102_XP_MP1 (I1_I1160_P6_3n I1_I1160_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I102_XP_MP0 (VDD I1_I1160_P6_5 I1_I1160_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I100_XP_MP1 (I1_I1160_P4_1n I1_I1160_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I100_XP_MP0 (VDD I1_I1160_P4_3 I1_I1160_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I1_MP1 (I1_I1160_gn1 I1_b13_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I1_MP0 (VDD I1_p12_0 I1_I1160_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I30_MP1 (I1_I930_gn30 I1_b8_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I30_MP0 (VDD I1_p7_29 I1_I930_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I127_XP_MP1 (I1_I930_P31_28n I1_I930_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I127_XP_MP0 (VDD I1_I930_P31_30 I1_I930_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I125_XP_MP1 (I1_I930_P29_26n I1_I930_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I125_XP_MP0 (VDD I1_I930_P29_28 I1_I930_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I182_XP_MP1 (I1_I930_P31_16n I1_I930_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I182_XP_MP0 (VDD I1_I930_P31_24 I1_I930_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I180_XP_MP1 (I1_I930_P29_14n I1_I930_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I180_XP_MP0 (VDD I1_I930_P29_22 I1_I930_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I178_XP_MP1 (I1_I930_P27_12n I1_I930_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I178_XP_MP0 (VDD I1_I930_P27_20 I1_I930_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I174_XP_MP1 (I1_I930_P23_8n I1_I930_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I174_XP_MP0 (VDD I1_I930_P23_16 I1_I930_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I176_XP_MP1 (I1_I930_P25_10n I1_I930_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I176_XP_MP0 (VDD I1_I930_P25_18 I1_I930_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I109_XP_MP1 (I1_I930_P13_10n I1_I930_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I109_XP_MP0 (VDD I1_I930_P13_12 I1_I930_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I107_XP_MP1 (I1_I930_P11_8n I1_I930_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I107_XP_MP0 (VDD I1_I930_P11_10 I1_I930_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I105_XP_MP1 (I1_I930_P9_6n I1_I930_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I105_XP_MP0 (VDD I1_I930_P9_8 I1_I930_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I5_MP1 (I1_I930_gn5 I1_b8_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I5_MP0 (VDD I1_p7_4 I1_I930_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I2_MP1 (I1_I700_gn2 I1_b3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I2_MP0 (VDD I1_p2_1 I1_I700_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I3_MP1 (I1_I700_gn3 I1_b3_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I3_MP0 (VDD I1_p2_2 I1_I700_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I6_MP1 (I1_I700_gn6 I1_b3_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I6_MP0 (VDD I1_p2_5 I1_I700_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I7_MP1 (I1_I700_gn7 I1_b3_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I7_MP0 (VDD I1_p2_6 I1_I700_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I8_MP1 (I1_I700_gn8 I1_b3_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I8_MP0 (VDD I1_p2_7 I1_I700_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I15_MP1 (I1_I700_gn15 I1_b3_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I15_MP0 (VDD I1_p2_14 I1_I700_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I19_MP1 (I1_I700_gn19 I1_b3_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I19_MP0 (VDD I1_p2_18 I1_I700_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I23_MP1 (I1_I700_gn23 I1_b3_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I23_MP0 (VDD I1_p2_22 I1_I700_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I26_MP1 (I1_I700_gn26 I1_b3_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I26_MP0 (VDD I1_p2_25 I1_I700_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I28_MP1 (I1_I700_gn28 I1_b3_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I28_MP0 (VDD I1_p2_27 I1_I700_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I179_XP_MP1 (I1_I1390_P28_13n I1_I1390_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I179_XP_MP0 (VDD I1_I1390_P28_21 I1_I1390_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I173_XP_MP1 (I1_I1390_P22_7n I1_I1390_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I173_XP_MP0 (VDD I1_I1390_P22_15 I1_I1390_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I177_XP_MP1 (I1_I1390_P26_11n I1_I1390_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I177_XP_MP0 (VDD I1_I1390_P26_19 I1_I1390_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I175_XP_MP1 (I1_I1390_P24_9n I1_I1390_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I175_XP_MP0 (VDD I1_I1390_P24_17 I1_I1390_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I171_XP_MP1 (I1_I1390_P20_5n I1_I1390_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I171_XP_MP0 (VDD I1_I1390_P20_13 I1_I1390_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I169_XP_MP1 (I1_I1390_P18_3n I1_I1390_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I169_XP_MP0 (VDD I1_I1390_P18_11 I1_I1390_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I104_XP_MP1 (I1_I1390_P8_5n I1_I1390_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I104_XP_MP0 (VDD I1_I1390_P8_7 I1_I1390_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I102_XP_MP1 (I1_I1390_P6_3n I1_I1390_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I102_XP_MP0 (VDD I1_I1390_P6_5 I1_I1390_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I2_MP1 (I1_I1390_gn2 I1_b18_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I2_MP0 (VDD I1_p17_1 I1_I1390_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I0_MP1 (I1_I1344_gn0 I1_b17_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I0_MP0 (VDD I1_aa14 I1_I1344_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I23_MP1 (I1_I1160_gn23 I1_b13_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I23_MP0 (VDD I1_p12_22 I1_I1160_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I24_MP1 (I1_I1160_gn24 I1_b13_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I24_MP0 (VDD I1_p12_23 I1_I1160_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I118_XP_MP1 (I1_I1160_P22_19n I1_I1160_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I118_XP_MP0 (VDD I1_I1160_P22_21 I1_I1160_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I116_XP_MP1 (I1_I1160_P20_17n I1_I1160_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I116_XP_MP0 (VDD I1_I1160_P20_19 I1_I1160_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I114_XP_MP1 (I1_I1160_P18_15n I1_I1160_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I114_XP_MP0 (VDD I1_I1160_P18_17 I1_I1160_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I112_XP_MP1 (I1_I1160_P16_13n I1_I1160_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I112_XP_MP0 (VDD I1_I1160_P16_15 I1_I1160_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I110_XP_MP1 (I1_I1160_P14_11n I1_I1160_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I110_XP_MP0 (VDD I1_I1160_P14_13 I1_I1160_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I106_XP_MP1 (I1_I1160_P10_7n I1_I1160_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I106_XP_MP0 (VDD I1_I1160_P10_9 I1_I1160_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I4_MP1 (I1_I1160_gn4 I1_b13_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I4_MP0 (VDD I1_p12_3 I1_I1160_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I3_MP1 (I1_I1160_gn3 I1_b13_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I3_MP0 (VDD I1_p12_2 I1_I1160_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I2_MP1 (I1_I1160_gn2 I1_b13_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I2_MP0 (VDD I1_p12_1 I1_I1160_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I172_XP_MP1 (I1_I930_P21_6n I1_I930_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I172_XP_MP0 (VDD I1_I930_P21_14 I1_I930_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I170_XP_MP1 (I1_I930_P19_4n I1_I930_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I170_XP_MP0 (VDD I1_I930_P19_12 I1_I930_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I168_XP_MP1 (I1_I930_P17_2n I1_I930_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I168_XP_MP0 (VDD I1_I930_P17_10 I1_I930_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I103_XP_MP1 (I1_I930_P7_4n I1_I930_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I103_XP_MP0 (VDD I1_I930_P7_6 I1_I930_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I101_XP_MP1 (I1_I930_P5_2n I1_I930_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I101_XP_MP0 (VDD I1_I930_P5_4 I1_I930_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I4_MP1 (I1_I930_gn4 I1_b8_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I4_MP0 (VDD I1_p7_3 I1_I930_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I0_MP1 (I1_I746_gn0 I1_b4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I0_MP0 (VDD I1_aa27 I1_I746_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I4_MP1 (I1_I700_gn4 I1_b3_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I4_MP0 (VDD I1_p2_3 I1_I700_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I5_MP1 (I1_I700_gn5 I1_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I5_MP0 (VDD I1_p2_4 I1_I700_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I9_MP1 (I1_I700_gn9 I1_b3_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I9_MP0 (VDD I1_p2_8 I1_I700_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I11_MP1 (I1_I700_gn11 I1_b3_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I11_MP0 (VDD I1_p2_10 I1_I700_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I10_MP1 (I1_I700_gn10 I1_b3_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I10_MP0 (VDD I1_p2_9 I1_I700_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I12_MP1 (I1_I700_gn12 I1_b3_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I12_MP0 (VDD I1_p2_11 I1_I700_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I13_MP1 (I1_I700_gn13 I1_b3_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I13_MP0 (VDD I1_p2_12 I1_I700_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I14_MP1 (I1_I700_gn14 I1_b3_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I14_MP0 (VDD I1_p2_13 I1_I700_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I16_MP1 (I1_I700_gn16 I1_b3_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I16_MP0 (VDD I1_p2_15 I1_I700_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I18_MP1 (I1_I700_gn18 I1_b3_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I18_MP0 (VDD I1_p2_17 I1_I700_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I20_MP1 (I1_I700_gn20 I1_b3_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I20_MP0 (VDD I1_p2_19 I1_I700_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I21_MP1 (I1_I700_gn21 I1_b3_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I21_MP0 (VDD I1_p2_20 I1_I700_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I22_MP1 (I1_I700_gn22 I1_b3_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I22_MP0 (VDD I1_p2_21 I1_I700_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I24_MP1 (I1_I700_gn24 I1_b3_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I24_MP0 (VDD I1_p2_23 I1_I700_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I25_MP1 (I1_I700_gn25 I1_b3_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I25_MP0 (VDD I1_p2_24 I1_I700_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I29_MP1 (I1_I700_gn29 I1_b3_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I29_MP0 (VDD I1_p2_28 I1_I700_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I27_MP1 (I1_I1436_gn27 I1_b19_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I27_MP0 (VDD I1_p18_26 I1_I1436_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I23_MP1 (I1_I1436_gn23 I1_b19_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I23_MP0 (VDD I1_p18_22 I1_I1436_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I19_MP1 (I1_I1436_gn19 I1_b19_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I19_MP0 (VDD I1_p18_18 I1_I1436_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I17_MP1 (I1_I1436_gn17 I1_b19_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I17_MP0 (VDD I1_p18_16 I1_I1436_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I16_MP1 (I1_I1436_gn16 I1_b19_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I16_MP0 (VDD I1_p18_15 I1_I1436_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I13_MP1 (I1_I1436_gn13 I1_b19_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I13_MP0 (VDD I1_p18_12 I1_I1436_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I167_XP_MP1 (I1_I1390_P16_1n I1_I1390_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I167_XP_MP0 (VDD I1_I1390_P16_9 I1_I1390_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I100_XP_MP1 (I1_I1390_P4_1n I1_I1390_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I100_XP_MP0 (VDD I1_I1390_P4_3 I1_I1390_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I1_MP1 (I1_I1390_gn1 I1_b18_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I1_MP0 (VDD I1_p17_0 I1_I1390_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I22_MP1 (I1_I1160_gn22 I1_b13_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I22_MP0 (VDD I1_p12_21 I1_I1160_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I21_MP1 (I1_I1160_gn21 I1_b13_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I21_MP0 (VDD I1_p12_20 I1_I1160_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I20_MP1 (I1_I1160_gn20 I1_b13_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I20_MP0 (VDD I1_p12_19 I1_I1160_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I18_MP1 (I1_I1160_gn18 I1_b13_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I18_MP0 (VDD I1_p12_17 I1_I1160_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I108_XP_MP1 (I1_I1160_P12_9n I1_I1160_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I108_XP_MP0 (VDD I1_I1160_P12_11 I1_I1160_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I0_MP1 (I1_I1160_gn0 I1_b13_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I0_MP0 (VDD I1_aa18 I1_I1160_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I29_MP1 (I1_I976_gn29 I1_b9_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I29_MP0 (VDD I1_p8_28 I1_I976_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I126_XP_MP1 (I1_I930_P30_27n I1_I930_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I126_XP_MP0 (VDD I1_I930_P30_29 I1_I930_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I124_XP_MP1 (I1_I930_P28_25n I1_I930_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I124_XP_MP0 (VDD I1_I930_P28_27 I1_I930_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I122_XP_MP1 (I1_I930_P26_23n I1_I930_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I122_XP_MP0 (VDD I1_I930_P26_25 I1_I930_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I120_XP_MP1 (I1_I930_P24_21n I1_I930_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I120_XP_MP0 (VDD I1_I930_P24_23 I1_I930_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I118_XP_MP1 (I1_I930_P22_19n I1_I930_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I118_XP_MP0 (VDD I1_I930_P22_21 I1_I930_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I116_XP_MP1 (I1_I930_P20_17n I1_I930_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I116_XP_MP0 (VDD I1_I930_P20_19 I1_I930_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I114_XP_MP1 (I1_I930_P18_15n I1_I930_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I114_XP_MP0 (VDD I1_I930_P18_17 I1_I930_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I112_XP_MP1 (I1_I930_P16_13n I1_I930_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I112_XP_MP0 (VDD I1_I930_P16_15 I1_I930_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I110_XP_MP1 (I1_I930_P14_11n I1_I930_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I110_XP_MP0 (VDD I1_I930_P14_13 I1_I930_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I108_XP_MP1 (I1_I930_P12_9n I1_I930_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I108_XP_MP0 (VDD I1_I930_P12_11 I1_I930_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I106_XP_MP1 (I1_I930_P10_7n I1_I930_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I106_XP_MP0 (VDD I1_I930_P10_9 I1_I930_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I3_MP1 (I1_I930_gn3 I1_b8_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I3_MP0 (VDD I1_p7_2 I1_I930_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I0_MP1 (I1_I700_gn0 I1_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I0_MP0 (VDD I1_aa28 I1_I700_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I170_XP_MP1 (I1_I654_P19_4n I1_I654_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I170_XP_MP0 (VDD I1_I654_P19_12 I1_I654_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I17_MP1 (I1_I700_gn17 I1_b3_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I17_MP0 (VDD I1_p2_16 I1_I700_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I174_XP_MP1 (I1_I654_P23_8n I1_I654_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I174_XP_MP0 (VDD I1_I654_P23_16 I1_I654_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I30_MP1 (I1_I700_gn30 I1_b3_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I30_MP0 (VDD I1_p2_29 I1_I700_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I28_MP1 (I1_I1436_gn28 I1_b19_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I28_MP0 (VDD I1_p18_27 I1_I1436_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I26_MP1 (I1_I1436_gn26 I1_b19_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I26_MP0 (VDD I1_p18_25 I1_I1436_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I25_MP1 (I1_I1436_gn25 I1_b19_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I25_MP0 (VDD I1_p18_24 I1_I1436_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I22_MP1 (I1_I1436_gn22 I1_b19_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I22_MP0 (VDD I1_p18_21 I1_I1436_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I21_MP1 (I1_I1436_gn21 I1_b19_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I21_MP0 (VDD I1_p18_20 I1_I1436_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I20_MP1 (I1_I1436_gn20 I1_b19_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I20_MP0 (VDD I1_p18_19 I1_I1436_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I18_MP1 (I1_I1436_gn18 I1_b19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I18_MP0 (VDD I1_p18_17 I1_I1436_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I15_MP1 (I1_I1436_gn15 I1_b19_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I15_MP0 (VDD I1_p18_14 I1_I1436_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I14_MP1 (I1_I1436_gn14 I1_b19_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I14_MP0 (VDD I1_p18_13 I1_I1436_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I12_MP1 (I1_I1436_gn12 I1_b19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I12_MP0 (VDD I1_p18_11 I1_I1436_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I10_MP1 (I1_I1436_gn10 I1_b19_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I10_MP0 (VDD I1_p18_9 I1_I1436_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I11_MP1 (I1_I1436_gn11 I1_b19_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I11_MP0 (VDD I1_p18_10 I1_I1436_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I9_MP1 (I1_I1436_gn9 I1_b19_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I9_MP0 (VDD I1_p18_8 I1_I1436_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I4_MP1 (I1_I1436_gn4 I1_b19_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I4_MP0 (VDD I1_p18_3 I1_I1436_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I28_MP1 (I1_I1114_gn28 I1_b12_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I28_MP0 (VDD I1_p11_27 I1_I1114_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I27_MP1 (I1_I1114_gn27 I1_b12_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I27_MP0 (VDD I1_p11_26 I1_I1114_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I29_MP1 (I1_I1114_gn29 I1_b12_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I29_MP0 (VDD I1_p11_28 I1_I1114_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I16_MP1 (I1_I1160_gn16 I1_b13_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I16_MP0 (VDD I1_p12_15 I1_I1160_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I14_MP1 (I1_I1160_gn14 I1_b13_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I14_MP0 (VDD I1_p12_13 I1_I1160_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I13_MP1 (I1_I1160_gn13 I1_b13_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I13_MP0 (VDD I1_p12_12 I1_I1160_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I10_MP1 (I1_I1160_gn10 I1_b13_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I10_MP0 (VDD I1_p12_9 I1_I1160_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I9_MP1 (I1_I1160_gn9 I1_b13_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I9_MP0 (VDD I1_p12_8 I1_I1160_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I7_MP1 (I1_I1160_gn7 I1_b13_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I7_MP0 (VDD I1_p12_6 I1_I1160_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I6_MP1 (I1_I1160_gn6 I1_b13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I6_MP0 (VDD I1_p12_5 I1_I1160_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I5_MP1 (I1_I1160_gn5 I1_b13_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I5_MP0 (VDD I1_p12_4 I1_I1160_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I181_XP_MP1 (I1_I930_P30_15n I1_I930_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I181_XP_MP0 (VDD I1_I930_P30_23 I1_I930_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I179_XP_MP1 (I1_I930_P28_13n I1_I930_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I179_XP_MP0 (VDD I1_I930_P28_21 I1_I930_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I173_XP_MP1 (I1_I930_P22_7n I1_I930_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I173_XP_MP0 (VDD I1_I930_P22_15 I1_I930_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I20_MP1 (I1_I976_gn20 I1_b9_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I20_MP0 (VDD I1_p8_19 I1_I976_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I177_XP_MP1 (I1_I930_P26_11n I1_I930_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I177_XP_MP0 (VDD I1_I930_P26_19 I1_I930_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I171_XP_MP1 (I1_I930_P20_5n I1_I930_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I171_XP_MP0 (VDD I1_I930_P20_13 I1_I930_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I175_XP_MP1 (I1_I930_P24_9n I1_I930_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I175_XP_MP0 (VDD I1_I930_P24_17 I1_I930_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I169_XP_MP1 (I1_I930_P18_3n I1_I930_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I169_XP_MP0 (VDD I1_I930_P18_11 I1_I930_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I104_XP_MP1 (I1_I930_P8_5n I1_I930_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I104_XP_MP0 (VDD I1_I930_P8_7 I1_I930_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I102_XP_MP1 (I1_I930_P6_3n I1_I930_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I102_XP_MP0 (VDD I1_I930_P6_5 I1_I930_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I2_MP1 (I1_I930_gn2 I1_b8_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I2_MP0 (VDD I1_p7_1 I1_I930_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I101_XP_MP1 (I1_I654_P5_2n I1_I654_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I101_XP_MP0 (VDD I1_I654_P5_4 I1_I654_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I103_XP_MP1 (I1_I654_P7_4n I1_I654_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I103_XP_MP0 (VDD I1_I654_P7_6 I1_I654_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I105_XP_MP1 (I1_I654_P9_6n I1_I654_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I105_XP_MP0 (VDD I1_I654_P9_8 I1_I654_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I168_XP_MP1 (I1_I654_P17_2n I1_I654_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I168_XP_MP0 (VDD I1_I654_P17_10 I1_I654_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I107_XP_MP1 (I1_I654_P11_8n I1_I654_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I107_XP_MP0 (VDD I1_I654_P11_10 I1_I654_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I109_XP_MP1 (I1_I654_P13_10n I1_I654_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I109_XP_MP0 (VDD I1_I654_P13_12 I1_I654_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I176_XP_MP1 (I1_I654_P25_10n I1_I654_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I176_XP_MP0 (VDD I1_I654_P25_18 I1_I654_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I111_XP_MP1 (I1_I654_P15_12n I1_I654_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I111_XP_MP0 (VDD I1_I654_P15_14 I1_I654_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I113_XP_MP1 (I1_I654_P17_14n I1_I654_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I113_XP_MP0 (VDD I1_I654_P17_16 I1_I654_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I172_XP_MP1 (I1_I654_P21_6n I1_I654_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I172_XP_MP0 (VDD I1_I654_P21_14 I1_I654_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I178_XP_MP1 (I1_I654_P27_12n I1_I654_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I178_XP_MP0 (VDD I1_I654_P27_20 I1_I654_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I180_XP_MP1 (I1_I654_P29_14n I1_I654_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I180_XP_MP0 (VDD I1_I654_P29_22 I1_I654_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I182_XP_MP1 (I1_I654_P31_16n I1_I654_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I182_XP_MP0 (VDD I1_I654_P31_24 I1_I654_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I31_MP1 (I1_I700_gn31 I1_b3_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I31_MP0 (VDD I1_p2_30 I1_I700_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I24_MP1 (I1_I1436_gn24 I1_b19_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I24_MP0 (VDD I1_p18_23 I1_I1436_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I8_MP1 (I1_I1436_gn8 I1_b19_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I8_MP0 (VDD I1_p18_7 I1_I1436_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I7_MP1 (I1_I1436_gn7 I1_b19_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I7_MP0 (VDD I1_p18_6 I1_I1436_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I6_MP1 (I1_I1436_gn6 I1_b19_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I6_MP0 (VDD I1_p18_5 I1_I1436_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I5_MP1 (I1_I1436_gn5 I1_b19_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I5_MP0 (VDD I1_p18_4 I1_I1436_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I0_MP1 (I1_I1390_gn0 I1_b18_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I0_MP0 (VDD I1_aa13 I1_I1390_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I127_XP_MP1 (I1_I1114_P31_28n I1_I1114_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I127_XP_MP0 (VDD I1_I1114_P31_30 I1_I1114_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I125_XP_MP1 (I1_I1114_P29_26n I1_I1114_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I125_XP_MP0 (VDD I1_I1114_P29_28 I1_I1114_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I26_MP1 (I1_I1114_gn26 I1_b12_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I26_MP0 (VDD I1_p11_25 I1_I1114_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I126_XP_MP1 (I1_I1114_P30_27n I1_I1114_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I126_XP_MP0 (VDD I1_I1114_P30_29 I1_I1114_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I31_MP1 (I1_I1114_gn31 I1_b12_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I31_MP0 (VDD I1_p11_30 I1_I1114_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I30_MP1 (I1_I1114_gn30 I1_b12_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I30_MP0 (VDD I1_p11_29 I1_I1114_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I19_MP1 (I1_I1160_gn19 I1_b13_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I19_MP0 (VDD I1_p12_18 I1_I1160_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I17_MP1 (I1_I1160_gn17 I1_b13_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I17_MP0 (VDD I1_p12_16 I1_I1160_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I15_MP1 (I1_I1160_gn15 I1_b13_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I15_MP0 (VDD I1_p12_14 I1_I1160_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I12_MP1 (I1_I1160_gn12 I1_b13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I12_MP0 (VDD I1_p12_11 I1_I1160_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I11_MP1 (I1_I1160_gn11 I1_b13_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I11_MP0 (VDD I1_p12_10 I1_I1160_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I8_MP1 (I1_I1160_gn8 I1_b13_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I8_MP0 (VDD I1_p12_7 I1_I1160_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I28_MP1 (I1_I1068_gn28 I1_b11_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I28_MP0 (VDD I1_p10_27 I1_I1068_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I29_MP1 (I1_I1068_gn29 I1_b11_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I29_MP0 (VDD I1_p10_28 I1_I1068_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I27_MP1 (I1_I1068_gn27 I1_b11_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I27_MP0 (VDD I1_p10_26 I1_I1068_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I31_MP1 (I1_I976_gn31 I1_b9_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I31_MP0 (VDD I1_p8_30 I1_I976_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I24_MP1 (I1_I976_gn24 I1_b9_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I24_MP0 (VDD I1_p8_23 I1_I976_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I22_MP1 (I1_I976_gn22 I1_b9_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I22_MP0 (VDD I1_p8_21 I1_I976_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I17_MP1 (I1_I976_gn17 I1_b9_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I17_MP0 (VDD I1_p8_16 I1_I976_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I167_XP_MP1 (I1_I930_P16_1n I1_I930_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I167_XP_MP0 (VDD I1_I930_P16_9 I1_I930_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I100_XP_MP1 (I1_I930_P4_1n I1_I930_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I100_XP_MP0 (VDD I1_I930_P4_3 I1_I930_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I1_MP1 (I1_I654_gn1 I1_b2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I1_MP0 (VDD I1_p1_0 I1_I654_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I115_XP_MP1 (I1_I654_P19_16n I1_I654_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I115_XP_MP0 (VDD I1_I654_P19_18 I1_I654_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I117_XP_MP1 (I1_I654_P21_18n I1_I654_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I117_XP_MP0 (VDD I1_I654_P21_20 I1_I654_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I119_XP_MP1 (I1_I654_P23_20n I1_I654_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I119_XP_MP0 (VDD I1_I654_P23_22 I1_I654_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I121_XP_MP1 (I1_I654_P25_22n I1_I654_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I121_XP_MP0 (VDD I1_I654_P25_24 I1_I654_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I123_XP_MP1 (I1_I654_P27_24n I1_I654_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I123_XP_MP0 (VDD I1_I654_P27_26 I1_I654_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I125_XP_MP1 (I1_I654_P29_26n I1_I654_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I125_XP_MP0 (VDD I1_I654_P29_28 I1_I654_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I127_XP_MP1 (I1_I654_P31_28n I1_I654_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I127_XP_MP0 (VDD I1_I654_P31_30 I1_I654_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I29_MP1 (I1_I1436_gn29 I1_b19_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I29_MP0 (VDD I1_p18_28 I1_I1436_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I126_XP_MP1 (I1_I1436_P30_27n I1_I1436_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I126_XP_MP0 (VDD I1_I1436_P30_29 I1_I1436_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I124_XP_MP1 (I1_I1436_P28_25n I1_I1436_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I124_XP_MP0 (VDD I1_I1436_P28_27 I1_I1436_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I122_XP_MP1 (I1_I1436_P26_23n I1_I1436_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I122_XP_MP0 (VDD I1_I1436_P26_25 I1_I1436_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I120_XP_MP1 (I1_I1436_P24_21n I1_I1436_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I120_XP_MP0 (VDD I1_I1436_P24_23 I1_I1436_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I118_XP_MP1 (I1_I1436_P22_19n I1_I1436_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I118_XP_MP0 (VDD I1_I1436_P22_21 I1_I1436_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I116_XP_MP1 (I1_I1436_P20_17n I1_I1436_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I116_XP_MP0 (VDD I1_I1436_P20_19 I1_I1436_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I114_XP_MP1 (I1_I1436_P18_15n I1_I1436_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I114_XP_MP0 (VDD I1_I1436_P18_17 I1_I1436_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I112_XP_MP1 (I1_I1436_P16_13n I1_I1436_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I112_XP_MP0 (VDD I1_I1436_P16_15 I1_I1436_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I110_XP_MP1 (I1_I1436_P14_11n I1_I1436_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I110_XP_MP0 (VDD I1_I1436_P14_13 I1_I1436_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I108_XP_MP1 (I1_I1436_P12_9n I1_I1436_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I108_XP_MP0 (VDD I1_I1436_P12_11 I1_I1436_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I106_XP_MP1 (I1_I1436_P10_7n I1_I1436_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I106_XP_MP0 (VDD I1_I1436_P10_9 I1_I1436_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I3_MP1 (I1_I1436_gn3 I1_b19_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I3_MP0 (VDD I1_p18_2 I1_I1436_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I2_MP1 (I1_I1436_gn2 I1_b19_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I2_MP0 (VDD I1_p18_1 I1_I1436_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I123_XP_MP1 (I1_I1114_P27_24n I1_I1114_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I123_XP_MP0 (VDD I1_I1114_P27_26 I1_I1114_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I25_MP1 (I1_I1114_gn25 I1_b12_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I25_MP0 (VDD I1_p11_24 I1_I1114_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I24_MP1 (I1_I1114_gn24 I1_b12_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I24_MP0 (VDD I1_p11_23 I1_I1114_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I181_XP_MP1 (I1_I1114_P30_15n I1_I1114_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I181_XP_MP0 (VDD I1_I1114_P30_23 I1_I1114_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I23_MP1 (I1_I1114_gn23 I1_b12_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I23_MP0 (VDD I1_p11_22 I1_I1114_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I126_XP_MP1 (I1_I1068_P30_27n I1_I1068_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I126_XP_MP0 (VDD I1_I1068_P30_29 I1_I1068_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I127_XP_MP1 (I1_I1068_P31_28n I1_I1068_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I127_XP_MP0 (VDD I1_I1068_P31_30 I1_I1068_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I26_MP1 (I1_I1068_gn26 I1_b11_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I26_MP0 (VDD I1_p10_25 I1_I1068_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I30_MP1 (I1_I1068_gn30 I1_b11_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I30_MP0 (VDD I1_p10_29 I1_I1068_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I28_MP1 (I1_I1022_gn28 I1_b10_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I28_MP0 (VDD I1_p9_27 I1_I1022_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I30_MP1 (I1_I976_gn30 I1_b9_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I30_MP0 (VDD I1_p8_29 I1_I976_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I26_MP1 (I1_I976_gn26 I1_b9_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I26_MP0 (VDD I1_p8_25 I1_I976_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I25_MP1 (I1_I976_gn25 I1_b9_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I25_MP0 (VDD I1_p8_24 I1_I976_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I23_MP1 (I1_I976_gn23 I1_b9_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I23_MP0 (VDD I1_p8_22 I1_I976_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I21_MP1 (I1_I976_gn21 I1_b9_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I21_MP0 (VDD I1_p8_20 I1_I976_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I19_MP1 (I1_I976_gn19 I1_b9_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I19_MP0 (VDD I1_p8_18 I1_I976_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I18_MP1 (I1_I976_gn18 I1_b9_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I18_MP0 (VDD I1_p8_17 I1_I976_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I16_MP1 (I1_I976_gn16 I1_b9_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I16_MP0 (VDD I1_p8_15 I1_I976_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I15_MP1 (I1_I976_gn15 I1_b9_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I15_MP0 (VDD I1_p8_14 I1_I976_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I14_MP1 (I1_I976_gn14 I1_b9_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I14_MP0 (VDD I1_p8_13 I1_I976_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I13_MP1 (I1_I976_gn13 I1_b9_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I13_MP0 (VDD I1_p8_12 I1_I976_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I12_MP1 (I1_I976_gn12 I1_b9_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I12_MP0 (VDD I1_p8_11 I1_I976_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I11_MP1 (I1_I976_gn11 I1_b9_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I11_MP0 (VDD I1_p8_10 I1_I976_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I9_MP1 (I1_I976_gn9 I1_b9_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I9_MP0 (VDD I1_p8_8 I1_I976_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I0_MP1 (I1_I884_gn0 I1_b7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I0_MP0 (VDD I1_aa24 I1_I884_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I2_MP1 (I1_I654_gn2 I1_b2_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I2_MP0 (VDD I1_p1_1 I1_I654_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I100_XP_MP1 (I1_I654_P4_1n I1_I654_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I100_XP_MP0 (VDD I1_I654_P4_3 I1_I654_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I102_XP_MP1 (I1_I654_P6_3n I1_I654_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I102_XP_MP0 (VDD I1_I654_P6_5 I1_I654_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I104_XP_MP1 (I1_I654_P8_5n I1_I654_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I104_XP_MP0 (VDD I1_I654_P8_7 I1_I654_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I167_XP_MP1 (I1_I654_P16_1n I1_I654_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I167_XP_MP0 (VDD I1_I654_P16_9 I1_I654_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I175_XP_MP1 (I1_I654_P24_9n I1_I654_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I175_XP_MP0 (VDD I1_I654_P24_17 I1_I654_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I169_XP_MP1 (I1_I654_P18_3n I1_I654_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I169_XP_MP0 (VDD I1_I654_P18_11 I1_I654_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I171_XP_MP1 (I1_I654_P20_5n I1_I654_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I171_XP_MP0 (VDD I1_I654_P20_13 I1_I654_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I177_XP_MP1 (I1_I654_P26_11n I1_I654_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I177_XP_MP0 (VDD I1_I654_P26_19 I1_I654_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I179_XP_MP1 (I1_I654_P28_13n I1_I654_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I179_XP_MP0 (VDD I1_I654_P28_21 I1_I654_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I173_XP_MP1 (I1_I654_P22_7n I1_I654_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I173_XP_MP0 (VDD I1_I654_P22_15 I1_I654_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I181_XP_MP1 (I1_I654_P30_15n I1_I654_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I181_XP_MP0 (VDD I1_I654_P30_23 I1_I654_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I126_XP_MP1 (I1_I654_P30_27n I1_I654_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I126_XP_MP0 (VDD I1_I654_P30_29 I1_I654_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I30_MP1 (I1_I1436_gn30 I1_b19_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I30_MP0 (VDD I1_p18_29 I1_I1436_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I181_XP_MP1 (I1_I1436_P30_15n I1_I1436_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I181_XP_MP0 (VDD I1_I1436_P30_23 I1_I1436_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I179_XP_MP1 (I1_I1436_P28_13n I1_I1436_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I179_XP_MP0 (VDD I1_I1436_P28_21 I1_I1436_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I173_XP_MP1 (I1_I1436_P22_7n I1_I1436_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I173_XP_MP0 (VDD I1_I1436_P22_15 I1_I1436_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I177_XP_MP1 (I1_I1436_P26_11n I1_I1436_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I177_XP_MP0 (VDD I1_I1436_P26_19 I1_I1436_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I171_XP_MP1 (I1_I1436_P20_5n I1_I1436_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I171_XP_MP0 (VDD I1_I1436_P20_13 I1_I1436_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I169_XP_MP1 (I1_I1436_P18_3n I1_I1436_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I169_XP_MP0 (VDD I1_I1436_P18_11 I1_I1436_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I104_XP_MP1 (I1_I1436_P8_5n I1_I1436_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I104_XP_MP0 (VDD I1_I1436_P8_7 I1_I1436_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I102_XP_MP1 (I1_I1436_P6_3n I1_I1436_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I102_XP_MP0 (VDD I1_I1436_P6_5 I1_I1436_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I1_MP1 (I1_I1436_gn1 I1_b19_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I1_MP0 (VDD I1_p18_0 I1_I1436_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I182_XP_MP1 (I1_I1114_P31_16n I1_I1114_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I182_XP_MP0 (VDD I1_I1114_P31_24 I1_I1114_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I121_XP_MP1 (I1_I1114_P25_22n I1_I1114_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I121_XP_MP0 (VDD I1_I1114_P25_24 I1_I1114_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I124_XP_MP1 (I1_I1114_P28_25n I1_I1114_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I124_XP_MP0 (VDD I1_I1114_P28_27 I1_I1114_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I122_XP_MP1 (I1_I1114_P26_23n I1_I1114_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I122_XP_MP0 (VDD I1_I1114_P26_25 I1_I1114_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I173_XP_MP1 (I1_I1114_P22_7n I1_I1114_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I173_XP_MP0 (VDD I1_I1114_P22_15 I1_I1114_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I22_MP1 (I1_I1114_gn22 I1_b12_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I22_MP0 (VDD I1_p11_21 I1_I1114_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I181_XP_MP1 (I1_I1068_P30_15n I1_I1068_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I181_XP_MP0 (VDD I1_I1068_P30_23 I1_I1068_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I122_XP_MP1 (I1_I1068_P26_23n I1_I1068_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I122_XP_MP0 (VDD I1_I1068_P26_25 I1_I1068_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I124_XP_MP1 (I1_I1068_P28_25n I1_I1068_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I124_XP_MP0 (VDD I1_I1068_P28_27 I1_I1068_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I125_XP_MP1 (I1_I1068_P29_26n I1_I1068_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I125_XP_MP0 (VDD I1_I1068_P29_28 I1_I1068_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I24_MP1 (I1_I1068_gn24 I1_b11_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I24_MP0 (VDD I1_p10_23 I1_I1068_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I25_MP1 (I1_I1068_gn25 I1_b11_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I25_MP0 (VDD I1_p10_24 I1_I1068_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I31_MP1 (I1_I1068_gn31 I1_b11_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I31_MP0 (VDD I1_p10_30 I1_I1068_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I29_MP1 (I1_I1022_gn29 I1_b10_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I29_MP0 (VDD I1_p9_28 I1_I1022_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I125_XP_MP1 (I1_I976_P29_26n I1_I976_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I125_XP_MP0 (VDD I1_I976_P29_28 I1_I976_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I123_XP_MP1 (I1_I976_P27_24n I1_I976_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I123_XP_MP0 (VDD I1_I976_P27_26 I1_I976_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I121_XP_MP1 (I1_I976_P25_22n I1_I976_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I121_XP_MP0 (VDD I1_I976_P25_24 I1_I976_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I119_XP_MP1 (I1_I976_P23_20n I1_I976_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I119_XP_MP0 (VDD I1_I976_P23_22 I1_I976_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I117_XP_MP1 (I1_I976_P21_18n I1_I976_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I117_XP_MP0 (VDD I1_I976_P21_20 I1_I976_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I176_XP_MP1 (I1_I976_P25_10n I1_I976_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I176_XP_MP0 (VDD I1_I976_P25_18 I1_I976_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I10_MP1 (I1_I976_gn10 I1_b9_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I10_MP0 (VDD I1_p8_9 I1_I976_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I8_MP1 (I1_I976_gn8 I1_b9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I8_MP0 (VDD I1_p8_7 I1_I976_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I7_MP1 (I1_I976_gn7 I1_b9_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I7_MP0 (VDD I1_p8_6 I1_I976_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I1_MP1 (I1_I930_gn1 I1_b8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I1_MP0 (VDD I1_p7_0 I1_I930_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I3_MP1 (I1_I654_gn3 I1_b2_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I3_MP0 (VDD I1_p1_2 I1_I654_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I4_MP1 (I1_I654_gn4 I1_b2_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I4_MP0 (VDD I1_p1_3 I1_I654_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I106_XP_MP1 (I1_I654_P10_7n I1_I654_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I106_XP_MP0 (VDD I1_I654_P10_9 I1_I654_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I108_XP_MP1 (I1_I654_P12_9n I1_I654_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I108_XP_MP0 (VDD I1_I654_P12_11 I1_I654_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I110_XP_MP1 (I1_I654_P14_11n I1_I654_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I110_XP_MP0 (VDD I1_I654_P14_13 I1_I654_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I112_XP_MP1 (I1_I654_P16_13n I1_I654_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I112_XP_MP0 (VDD I1_I654_P16_15 I1_I654_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I114_XP_MP1 (I1_I654_P18_15n I1_I654_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I114_XP_MP0 (VDD I1_I654_P18_17 I1_I654_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I116_XP_MP1 (I1_I654_P20_17n I1_I654_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I116_XP_MP0 (VDD I1_I654_P20_19 I1_I654_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I118_XP_MP1 (I1_I654_P22_19n I1_I654_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I118_XP_MP0 (VDD I1_I654_P22_21 I1_I654_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I120_XP_MP1 (I1_I654_P24_21n I1_I654_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I120_XP_MP0 (VDD I1_I654_P24_23 I1_I654_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I122_XP_MP1 (I1_I654_P26_23n I1_I654_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I122_XP_MP0 (VDD I1_I654_P26_25 I1_I654_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I124_XP_MP1 (I1_I654_P28_25n I1_I654_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I124_XP_MP0 (VDD I1_I654_P28_27 I1_I654_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I121_XP_MP1 (I1_I1436_P25_22n I1_I1436_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I121_XP_MP0 (VDD I1_I1436_P25_24 I1_I1436_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I119_XP_MP1 (I1_I1436_P23_20n I1_I1436_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I119_XP_MP0 (VDD I1_I1436_P23_22 I1_I1436_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I117_XP_MP1 (I1_I1436_P21_18n I1_I1436_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I117_XP_MP0 (VDD I1_I1436_P21_20 I1_I1436_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I175_XP_MP1 (I1_I1436_P24_9n I1_I1436_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I175_XP_MP0 (VDD I1_I1436_P24_17 I1_I1436_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I167_XP_MP1 (I1_I1436_P16_1n I1_I1436_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I167_XP_MP0 (VDD I1_I1436_P16_9 I1_I1436_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I100_XP_MP1 (I1_I1436_P4_1n I1_I1436_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I100_XP_MP0 (VDD I1_I1436_P4_3 I1_I1436_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I119_XP_MP1 (I1_I1114_P23_20n I1_I1114_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I119_XP_MP0 (VDD I1_I1114_P23_22 I1_I1114_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I180_XP_MP1 (I1_I1114_P29_14n I1_I1114_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I180_XP_MP0 (VDD I1_I1114_P29_22 I1_I1114_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I120_XP_MP1 (I1_I1114_P24_21n I1_I1114_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I120_XP_MP0 (VDD I1_I1114_P24_23 I1_I1114_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I118_XP_MP1 (I1_I1114_P22_19n I1_I1114_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I118_XP_MP0 (VDD I1_I1114_P22_21 I1_I1114_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I21_MP1 (I1_I1114_gn21 I1_b12_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I21_MP0 (VDD I1_p11_20 I1_I1114_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I18_MP1 (I1_I1114_gn18 I1_b12_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I18_MP0 (VDD I1_p11_17 I1_I1114_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I20_MP1 (I1_I1114_gn20 I1_b12_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I20_MP0 (VDD I1_p11_19 I1_I1114_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I19_MP1 (I1_I1114_gn19 I1_b12_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I19_MP0 (VDD I1_p11_18 I1_I1114_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I179_XP_MP1 (I1_I1068_P28_13n I1_I1068_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I179_XP_MP0 (VDD I1_I1068_P28_21 I1_I1068_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I120_XP_MP1 (I1_I1068_P24_21n I1_I1068_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I120_XP_MP0 (VDD I1_I1068_P24_23 I1_I1068_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I180_XP_MP1 (I1_I1068_P29_14n I1_I1068_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I180_XP_MP0 (VDD I1_I1068_P29_22 I1_I1068_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I182_XP_MP1 (I1_I1068_P31_16n I1_I1068_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I182_XP_MP0 (VDD I1_I1068_P31_24 I1_I1068_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I123_XP_MP1 (I1_I1068_P27_24n I1_I1068_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I123_XP_MP0 (VDD I1_I1068_P27_26 I1_I1068_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I23_MP1 (I1_I1068_gn23 I1_b11_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I23_MP0 (VDD I1_p10_22 I1_I1068_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I27_MP1 (I1_I1022_gn27 I1_b10_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I27_MP0 (VDD I1_p9_26 I1_I1022_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I30_MP1 (I1_I1022_gn30 I1_b10_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I30_MP0 (VDD I1_p9_29 I1_I1022_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I31_MP1 (I1_I1022_gn31 I1_b10_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I31_MP0 (VDD I1_p9_30 I1_I1022_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I127_XP_MP1 (I1_I976_P31_28n I1_I976_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I127_XP_MP0 (VDD I1_I976_P31_30 I1_I976_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I182_XP_MP1 (I1_I976_P31_16n I1_I976_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I182_XP_MP0 (VDD I1_I976_P31_24 I1_I976_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I174_XP_MP1 (I1_I976_P23_8n I1_I976_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I174_XP_MP0 (VDD I1_I976_P23_16 I1_I976_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I180_XP_MP1 (I1_I976_P29_14n I1_I976_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I180_XP_MP0 (VDD I1_I976_P29_22 I1_I976_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I115_XP_MP1 (I1_I976_P19_16n I1_I976_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I115_XP_MP0 (VDD I1_I976_P19_18 I1_I976_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I113_XP_MP1 (I1_I976_P17_14n I1_I976_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I113_XP_MP0 (VDD I1_I976_P17_16 I1_I976_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I111_XP_MP1 (I1_I976_P15_12n I1_I976_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I111_XP_MP0 (VDD I1_I976_P15_14 I1_I976_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I109_XP_MP1 (I1_I976_P13_10n I1_I976_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I109_XP_MP0 (VDD I1_I976_P13_12 I1_I976_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I6_MP1 (I1_I976_gn6 I1_b9_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I6_MP0 (VDD I1_p8_5 I1_I976_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I5_MP1 (I1_I654_gn5 I1_b2_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I5_MP0 (VDD I1_p1_4 I1_I654_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I7_MP1 (I1_I654_gn7 I1_b2_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I7_MP0 (VDD I1_p1_6 I1_I654_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I8_MP1 (I1_I654_gn8 I1_b2_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I8_MP0 (VDD I1_p1_7 I1_I654_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I9_MP1 (I1_I654_gn9 I1_b2_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I9_MP0 (VDD I1_p1_8 I1_I654_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I17_MP1 (I1_I654_gn17 I1_b2_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I17_MP0 (VDD I1_p1_16 I1_I654_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I24_MP1 (I1_I654_gn24 I1_b2_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I24_MP0 (VDD I1_p1_23 I1_I654_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I25_MP1 (I1_I654_gn25 I1_b2_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I25_MP0 (VDD I1_p1_24 I1_I654_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I27_MP1 (I1_I654_gn27 I1_b2_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I27_MP0 (VDD I1_p1_26 I1_I654_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I28_MP1 (I1_I654_gn28 I1_b2_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I28_MP0 (VDD I1_p1_27 I1_I654_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I29_MP1 (I1_I654_gn29 I1_b2_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I29_MP0 (VDD I1_p1_28 I1_I654_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I31_MP1 (I1_I1436_gn31 I1_b19_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I31_MP0 (VDD I1_p18_30 I1_I1436_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I127_XP_MP1 (I1_I1436_P31_28n I1_I1436_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I127_XP_MP0 (VDD I1_I1436_P31_30 I1_I1436_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I125_XP_MP1 (I1_I1436_P29_26n I1_I1436_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I125_XP_MP0 (VDD I1_I1436_P29_28 I1_I1436_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I123_XP_MP1 (I1_I1436_P27_24n I1_I1436_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I123_XP_MP0 (VDD I1_I1436_P27_26 I1_I1436_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I180_XP_MP1 (I1_I1436_P29_14n I1_I1436_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I180_XP_MP0 (VDD I1_I1436_P29_22 I1_I1436_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I172_XP_MP1 (I1_I1436_P21_6n I1_I1436_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I172_XP_MP0 (VDD I1_I1436_P21_14 I1_I1436_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I115_XP_MP1 (I1_I1436_P19_16n I1_I1436_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I115_XP_MP0 (VDD I1_I1436_P19_18 I1_I1436_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I109_XP_MP1 (I1_I1436_P13_10n I1_I1436_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I109_XP_MP0 (VDD I1_I1436_P13_12 I1_I1436_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I168_XP_MP1 (I1_I1436_P17_2n I1_I1436_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I168_XP_MP0 (VDD I1_I1436_P17_10 I1_I1436_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I107_XP_MP1 (I1_I1436_P11_8n I1_I1436_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I107_XP_MP0 (VDD I1_I1436_P11_10 I1_I1436_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I105_XP_MP1 (I1_I1436_P9_6n I1_I1436_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I105_XP_MP0 (VDD I1_I1436_P9_8 I1_I1436_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I103_XP_MP1 (I1_I1436_P7_4n I1_I1436_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I103_XP_MP0 (VDD I1_I1436_P7_6 I1_I1436_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I101_XP_MP1 (I1_I1436_P5_2n I1_I1436_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I101_XP_MP0 (VDD I1_I1436_P5_4 I1_I1436_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I174_XP_MP1 (I1_I1114_P23_8n I1_I1114_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I174_XP_MP0 (VDD I1_I1114_P23_16 I1_I1114_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I117_XP_MP1 (I1_I1114_P21_18n I1_I1114_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I117_XP_MP0 (VDD I1_I1114_P21_20 I1_I1114_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I177_XP_MP1 (I1_I1114_P26_11n I1_I1114_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I177_XP_MP0 (VDD I1_I1114_P26_19 I1_I1114_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I116_XP_MP1 (I1_I1114_P20_17n I1_I1114_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I116_XP_MP0 (VDD I1_I1114_P20_19 I1_I1114_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I114_XP_MP1 (I1_I1114_P18_15n I1_I1114_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I114_XP_MP0 (VDD I1_I1114_P18_17 I1_I1114_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I17_MP1 (I1_I1114_gn17 I1_b12_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I17_MP0 (VDD I1_p11_16 I1_I1114_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I173_XP_MP1 (I1_I1068_P22_7n I1_I1068_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I173_XP_MP0 (VDD I1_I1068_P22_15 I1_I1068_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I118_XP_MP1 (I1_I1068_P22_19n I1_I1068_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I118_XP_MP0 (VDD I1_I1068_P22_21 I1_I1068_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I174_XP_MP1 (I1_I1068_P23_8n I1_I1068_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I174_XP_MP0 (VDD I1_I1068_P23_16 I1_I1068_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I121_XP_MP1 (I1_I1068_P25_22n I1_I1068_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I121_XP_MP0 (VDD I1_I1068_P25_24 I1_I1068_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I119_XP_MP1 (I1_I1068_P23_20n I1_I1068_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I119_XP_MP0 (VDD I1_I1068_P23_22 I1_I1068_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I22_MP1 (I1_I1068_gn22 I1_b11_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I22_MP0 (VDD I1_p10_21 I1_I1068_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I21_MP1 (I1_I1068_gn21 I1_b11_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I21_MP0 (VDD I1_p10_20 I1_I1068_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I26_MP1 (I1_I1022_gn26 I1_b10_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I26_MP0 (VDD I1_p9_25 I1_I1022_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I127_XP_MP1 (I1_I1022_P31_28n I1_I1022_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I127_XP_MP0 (VDD I1_I1022_P31_30 I1_I1022_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I25_MP1 (I1_I1022_gn25 I1_b10_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I25_MP0 (VDD I1_p9_24 I1_I1022_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I24_MP1 (I1_I1022_gn24 I1_b10_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I24_MP0 (VDD I1_p9_23 I1_I1022_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I126_XP_MP1 (I1_I976_P30_27n I1_I976_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I126_XP_MP0 (VDD I1_I976_P30_29 I1_I976_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I124_XP_MP1 (I1_I976_P28_25n I1_I976_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I124_XP_MP0 (VDD I1_I976_P28_27 I1_I976_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I178_XP_MP1 (I1_I976_P27_12n I1_I976_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I178_XP_MP0 (VDD I1_I976_P27_20 I1_I976_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I172_XP_MP1 (I1_I976_P21_6n I1_I976_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I172_XP_MP0 (VDD I1_I976_P21_14 I1_I976_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I107_XP_MP1 (I1_I976_P11_8n I1_I976_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I107_XP_MP0 (VDD I1_I976_P11_10 I1_I976_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I105_XP_MP1 (I1_I976_P9_6n I1_I976_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I105_XP_MP0 (VDD I1_I976_P9_8 I1_I976_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I0_MP1 (I1_I654_gn0 I1_b2_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I0_MP0 (VDD I1_aa29 I1_I654_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I6_MP1 (I1_I654_gn6 I1_b2_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I6_MP0 (VDD I1_p1_5 I1_I654_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I10_MP1 (I1_I654_gn10 I1_b2_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I10_MP0 (VDD I1_p1_9 I1_I654_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I11_MP1 (I1_I654_gn11 I1_b2_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I11_MP0 (VDD I1_p1_10 I1_I654_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I12_MP1 (I1_I654_gn12 I1_b2_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I12_MP0 (VDD I1_p1_11 I1_I654_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I13_MP1 (I1_I654_gn13 I1_b2_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I13_MP0 (VDD I1_p1_12 I1_I654_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I14_MP1 (I1_I654_gn14 I1_b2_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I14_MP0 (VDD I1_p1_13 I1_I654_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I15_MP1 (I1_I654_gn15 I1_b2_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I15_MP0 (VDD I1_p1_14 I1_I654_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I16_MP1 (I1_I654_gn16 I1_b2_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I16_MP0 (VDD I1_p1_15 I1_I654_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I19_MP1 (I1_I654_gn19 I1_b2_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I19_MP0 (VDD I1_p1_18 I1_I654_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I20_MP1 (I1_I654_gn20 I1_b2_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I20_MP0 (VDD I1_p1_19 I1_I654_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I21_MP1 (I1_I654_gn21 I1_b2_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I21_MP0 (VDD I1_p1_20 I1_I654_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I22_MP1 (I1_I654_gn22 I1_b2_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I22_MP0 (VDD I1_p1_21 I1_I654_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I23_MP1 (I1_I654_gn23 I1_b2_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I23_MP0 (VDD I1_p1_22 I1_I654_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I26_MP1 (I1_I654_gn26 I1_b2_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I26_MP0 (VDD I1_p1_25 I1_I654_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I30_MP1 (I1_I654_gn30 I1_b2_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I30_MP0 (VDD I1_p1_29 I1_I654_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I182_XP_MP1 (I1_I1436_P31_16n I1_I1436_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I182_XP_MP0 (VDD I1_I1436_P31_24 I1_I1436_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I178_XP_MP1 (I1_I1436_P27_12n I1_I1436_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I178_XP_MP0 (VDD I1_I1436_P27_20 I1_I1436_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I174_XP_MP1 (I1_I1436_P23_8n I1_I1436_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I174_XP_MP0 (VDD I1_I1436_P23_16 I1_I1436_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I176_XP_MP1 (I1_I1436_P25_10n I1_I1436_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I176_XP_MP0 (VDD I1_I1436_P25_18 I1_I1436_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I170_XP_MP1 (I1_I1436_P19_4n I1_I1436_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I170_XP_MP0 (VDD I1_I1436_P19_12 I1_I1436_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I8_MP1 (I1_I1482_gn8 I1_b20_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I8_MP0 (VDD I1_p19_7 I1_I1482_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I6_MP1 (I1_I1482_gn6 I1_b20_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I6_MP0 (VDD I1_p19_5 I1_I1482_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I0_MP1 (I1_I1436_gn0 I1_b19_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I0_MP0 (VDD I1_aa12 I1_I1436_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I178_XP_MP1 (I1_I1114_P27_12n I1_I1114_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I178_XP_MP0 (VDD I1_I1114_P27_20 I1_I1114_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I115_XP_MP1 (I1_I1114_P19_16n I1_I1114_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I115_XP_MP0 (VDD I1_I1114_P19_18 I1_I1114_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I176_XP_MP1 (I1_I1114_P25_10n I1_I1114_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I176_XP_MP0 (VDD I1_I1114_P25_18 I1_I1114_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I113_XP_MP1 (I1_I1114_P17_14n I1_I1114_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I113_XP_MP0 (VDD I1_I1114_P17_16 I1_I1114_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I172_XP_MP1 (I1_I1114_P21_6n I1_I1114_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I172_XP_MP0 (VDD I1_I1114_P21_14 I1_I1114_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I179_XP_MP1 (I1_I1114_P28_13n I1_I1114_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I179_XP_MP0 (VDD I1_I1114_P28_21 I1_I1114_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I169_XP_MP1 (I1_I1114_P18_3n I1_I1114_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I169_XP_MP0 (VDD I1_I1114_P18_11 I1_I1114_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I16_MP1 (I1_I1114_gn16 I1_b12_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I16_MP0 (VDD I1_p11_15 I1_I1114_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I177_XP_MP1 (I1_I1068_P26_11n I1_I1068_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I177_XP_MP0 (VDD I1_I1068_P26_19 I1_I1068_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I172_XP_MP1 (I1_I1068_P21_6n I1_I1068_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I172_XP_MP0 (VDD I1_I1068_P21_14 I1_I1068_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I178_XP_MP1 (I1_I1068_P27_12n I1_I1068_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I178_XP_MP0 (VDD I1_I1068_P27_20 I1_I1068_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I20_MP1 (I1_I1068_gn20 I1_b11_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I20_MP0 (VDD I1_p10_19 I1_I1068_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I126_XP_MP1 (I1_I1022_P30_27n I1_I1022_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I126_XP_MP0 (VDD I1_I1022_P30_29 I1_I1022_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I125_XP_MP1 (I1_I1022_P29_26n I1_I1022_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I125_XP_MP0 (VDD I1_I1022_P29_28 I1_I1022_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I23_MP1 (I1_I1022_gn23 I1_b10_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I23_MP0 (VDD I1_p9_22 I1_I1022_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I22_MP1 (I1_I1022_gn22 I1_b10_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I22_MP0 (VDD I1_p9_21 I1_I1022_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I122_XP_MP1 (I1_I976_P26_23n I1_I976_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I122_XP_MP0 (VDD I1_I976_P26_25 I1_I976_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I120_XP_MP1 (I1_I976_P24_21n I1_I976_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I120_XP_MP0 (VDD I1_I976_P24_23 I1_I976_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I118_XP_MP1 (I1_I976_P22_19n I1_I976_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I118_XP_MP0 (VDD I1_I976_P22_21 I1_I976_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I116_XP_MP1 (I1_I976_P20_17n I1_I976_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I116_XP_MP0 (VDD I1_I976_P20_19 I1_I976_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I114_XP_MP1 (I1_I976_P18_15n I1_I976_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I114_XP_MP0 (VDD I1_I976_P18_17 I1_I976_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I112_XP_MP1 (I1_I976_P16_13n I1_I976_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I112_XP_MP0 (VDD I1_I976_P16_15 I1_I976_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I170_XP_MP1 (I1_I976_P19_4n I1_I976_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I170_XP_MP0 (VDD I1_I976_P19_12 I1_I976_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I168_XP_MP1 (I1_I976_P17_2n I1_I976_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I168_XP_MP0 (VDD I1_I976_P17_10 I1_I976_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I103_XP_MP1 (I1_I976_P7_4n I1_I976_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I103_XP_MP0 (VDD I1_I976_P7_6 I1_I976_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I5_MP1 (I1_I976_gn5 I1_b9_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I5_MP0 (VDD I1_p8_4 I1_I976_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I167_XP_MP1 (I1_I608_P16_1n I1_I608_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I167_XP_MP0 (VDD I1_I608_P16_9 I1_I608_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I175_XP_MP1 (I1_I608_P24_9n I1_I608_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I175_XP_MP0 (VDD I1_I608_P24_17 I1_I608_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I18_MP1 (I1_I654_gn18 I1_b2_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I18_MP0 (VDD I1_p1_17 I1_I654_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I31_MP1 (I1_I654_gn31 I1_b2_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I31_MP0 (VDD I1_p1_30 I1_I654_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I20_MP1 (I1_I1482_gn20 I1_b20_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I20_MP0 (VDD I1_p19_19 I1_I1482_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I18_MP1 (I1_I1482_gn18 I1_b20_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I18_MP0 (VDD I1_p19_17 I1_I1482_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I16_MP1 (I1_I1482_gn16 I1_b20_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I16_MP0 (VDD I1_p19_15 I1_I1482_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I15_MP1 (I1_I1482_gn15 I1_b20_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I15_MP0 (VDD I1_p19_14 I1_I1482_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I14_MP1 (I1_I1482_gn14 I1_b20_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I14_MP0 (VDD I1_p19_13 I1_I1482_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I13_MP1 (I1_I1482_gn13 I1_b20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I13_MP0 (VDD I1_p19_12 I1_I1482_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I12_MP1 (I1_I1482_gn12 I1_b20_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I12_MP0 (VDD I1_p19_11 I1_I1482_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I11_MP1 (I1_I1482_gn11 I1_b20_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I11_MP0 (VDD I1_p19_10 I1_I1482_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I10_MP1 (I1_I1482_gn10 I1_b20_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I10_MP0 (VDD I1_p19_9 I1_I1482_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I7_MP1 (I1_I1482_gn7 I1_b20_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I7_MP0 (VDD I1_p19_6 I1_I1482_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I5_MP1 (I1_I1482_gn5 I1_b20_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I5_MP0 (VDD I1_p19_4 I1_I1482_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I3_MP1 (I1_I1482_gn3 I1_b20_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I3_MP0 (VDD I1_p19_2 I1_I1482_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I4_MP1 (I1_I1482_gn4 I1_b20_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I4_MP0 (VDD I1_p19_3 I1_I1482_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I111_XP_MP1 (I1_I1114_P15_12n I1_I1114_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I111_XP_MP0 (VDD I1_I1114_P15_14 I1_I1114_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I175_XP_MP1 (I1_I1114_P24_9n I1_I1114_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I175_XP_MP0 (VDD I1_I1114_P24_17 I1_I1114_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I171_XP_MP1 (I1_I1114_P20_5n I1_I1114_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I171_XP_MP0 (VDD I1_I1114_P20_13 I1_I1114_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I112_XP_MP1 (I1_I1114_P16_13n I1_I1114_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I112_XP_MP0 (VDD I1_I1114_P16_15 I1_I1114_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I15_MP1 (I1_I1114_gn15 I1_b12_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I15_MP0 (VDD I1_p11_14 I1_I1114_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I14_MP1 (I1_I1114_gn14 I1_b12_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I14_MP0 (VDD I1_p11_13 I1_I1114_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I171_XP_MP1 (I1_I1068_P20_5n I1_I1068_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I171_XP_MP0 (VDD I1_I1068_P20_13 I1_I1068_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I116_XP_MP1 (I1_I1068_P20_17n I1_I1068_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I116_XP_MP0 (VDD I1_I1068_P20_19 I1_I1068_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I115_XP_MP1 (I1_I1068_P19_16n I1_I1068_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I115_XP_MP0 (VDD I1_I1068_P19_18 I1_I1068_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I117_XP_MP1 (I1_I1068_P21_18n I1_I1068_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I117_XP_MP0 (VDD I1_I1068_P21_20 I1_I1068_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I19_MP1 (I1_I1068_gn19 I1_b11_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I19_MP0 (VDD I1_p10_18 I1_I1068_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I17_MP1 (I1_I1068_gn17 I1_b11_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I17_MP0 (VDD I1_p10_16 I1_I1068_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I18_MP1 (I1_I1068_gn18 I1_b11_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I18_MP0 (VDD I1_p10_17 I1_I1068_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I124_XP_MP1 (I1_I1022_P28_25n I1_I1022_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I124_XP_MP0 (VDD I1_I1022_P28_27 I1_I1022_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I122_XP_MP1 (I1_I1022_P26_23n I1_I1022_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I122_XP_MP0 (VDD I1_I1022_P26_25 I1_I1022_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I123_XP_MP1 (I1_I1022_P27_24n I1_I1022_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I123_XP_MP0 (VDD I1_I1022_P27_26 I1_I1022_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I21_MP1 (I1_I1022_gn21 I1_b10_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I21_MP0 (VDD I1_p9_20 I1_I1022_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I181_XP_MP1 (I1_I976_P30_15n I1_I976_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I181_XP_MP0 (VDD I1_I976_P30_23 I1_I976_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I173_XP_MP1 (I1_I976_P22_7n I1_I976_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I173_XP_MP0 (VDD I1_I976_P22_15 I1_I976_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I177_XP_MP1 (I1_I976_P26_11n I1_I976_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I177_XP_MP0 (VDD I1_I976_P26_19 I1_I976_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I110_XP_MP1 (I1_I976_P14_11n I1_I976_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I110_XP_MP0 (VDD I1_I976_P14_13 I1_I976_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I108_XP_MP1 (I1_I976_P12_9n I1_I976_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I108_XP_MP0 (VDD I1_I976_P12_11 I1_I976_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I101_XP_MP1 (I1_I976_P5_2n I1_I976_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I101_XP_MP0 (VDD I1_I976_P5_4 I1_I976_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I4_MP1 (I1_I976_gn4 I1_b9_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I4_MP0 (VDD I1_p8_3 I1_I976_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I3_MP1 (I1_I976_gn3 I1_b9_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I3_MP0 (VDD I1_p8_2 I1_I976_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I100_XP_MP1 (I1_I608_P4_1n I1_I608_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I100_XP_MP0 (VDD I1_I608_P4_3 I1_I608_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I102_XP_MP1 (I1_I608_P6_3n I1_I608_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I102_XP_MP0 (VDD I1_I608_P6_5 I1_I608_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I104_XP_MP1 (I1_I608_P8_5n I1_I608_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I104_XP_MP0 (VDD I1_I608_P8_7 I1_I608_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I169_XP_MP1 (I1_I608_P18_3n I1_I608_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I169_XP_MP0 (VDD I1_I608_P18_11 I1_I608_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I171_XP_MP1 (I1_I608_P20_5n I1_I608_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I171_XP_MP0 (VDD I1_I608_P20_13 I1_I608_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I177_XP_MP1 (I1_I608_P26_11n I1_I608_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I177_XP_MP0 (VDD I1_I608_P26_19 I1_I608_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I173_XP_MP1 (I1_I608_P22_7n I1_I608_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I173_XP_MP0 (VDD I1_I608_P22_15 I1_I608_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I179_XP_MP1 (I1_I608_P28_13n I1_I608_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I179_XP_MP0 (VDD I1_I608_P28_21 I1_I608_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I181_XP_MP1 (I1_I608_P30_15n I1_I608_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I181_XP_MP0 (VDD I1_I608_P30_23 I1_I608_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I124_XP_MP1 (I1_I608_P28_25n I1_I608_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I124_XP_MP0 (VDD I1_I608_P28_27 I1_I608_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I126_XP_MP1 (I1_I608_P30_27n I1_I608_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I126_XP_MP0 (VDD I1_I608_P30_29 I1_I608_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I23_MP1 (I1_I1482_gn23 I1_b20_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I23_MP0 (VDD I1_p19_22 I1_I1482_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I22_MP1 (I1_I1482_gn22 I1_b20_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I22_MP0 (VDD I1_p19_21 I1_I1482_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I21_MP1 (I1_I1482_gn21 I1_b20_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I21_MP0 (VDD I1_p19_20 I1_I1482_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I19_MP1 (I1_I1482_gn19 I1_b20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I19_MP0 (VDD I1_p19_18 I1_I1482_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I17_MP1 (I1_I1482_gn17 I1_b20_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I17_MP0 (VDD I1_p19_16 I1_I1482_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I9_MP1 (I1_I1482_gn9 I1_b20_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I9_MP0 (VDD I1_p19_8 I1_I1482_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I2_MP1 (I1_I1482_gn2 I1_b20_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I2_MP0 (VDD I1_p19_1 I1_I1482_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I170_XP_MP1 (I1_I1114_P19_4n I1_I1114_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I170_XP_MP0 (VDD I1_I1114_P19_12 I1_I1114_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I168_XP_MP1 (I1_I1114_P17_2n I1_I1114_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I168_XP_MP0 (VDD I1_I1114_P17_10 I1_I1114_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I109_XP_MP1 (I1_I1114_P13_10n I1_I1114_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I109_XP_MP0 (VDD I1_I1114_P13_12 I1_I1114_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I110_XP_MP1 (I1_I1114_P14_11n I1_I1114_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I110_XP_MP0 (VDD I1_I1114_P14_13 I1_I1114_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I13_MP1 (I1_I1114_gn13 I1_b12_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I13_MP0 (VDD I1_p11_12 I1_I1114_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I114_XP_MP1 (I1_I1068_P18_15n I1_I1068_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I114_XP_MP0 (VDD I1_I1068_P18_17 I1_I1068_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I170_XP_MP1 (I1_I1068_P19_4n I1_I1068_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I170_XP_MP0 (VDD I1_I1068_P19_12 I1_I1068_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I111_XP_MP1 (I1_I1068_P15_12n I1_I1068_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I111_XP_MP0 (VDD I1_I1068_P15_14 I1_I1068_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I113_XP_MP1 (I1_I1068_P17_14n I1_I1068_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I113_XP_MP0 (VDD I1_I1068_P17_16 I1_I1068_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I16_MP1 (I1_I1068_gn16 I1_b11_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I16_MP0 (VDD I1_p10_15 I1_I1068_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I181_XP_MP1 (I1_I1022_P30_15n I1_I1022_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I181_XP_MP0 (VDD I1_I1022_P30_23 I1_I1022_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I120_XP_MP1 (I1_I1022_P24_21n I1_I1022_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I120_XP_MP0 (VDD I1_I1022_P24_23 I1_I1022_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I182_XP_MP1 (I1_I1022_P31_16n I1_I1022_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I182_XP_MP0 (VDD I1_I1022_P31_24 I1_I1022_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I121_XP_MP1 (I1_I1022_P25_22n I1_I1022_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I121_XP_MP0 (VDD I1_I1022_P25_24 I1_I1022_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I20_MP1 (I1_I1022_gn20 I1_b10_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I20_MP0 (VDD I1_p9_19 I1_I1022_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I19_MP1 (I1_I1022_gn19 I1_b10_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I19_MP0 (VDD I1_p9_18 I1_I1022_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I179_XP_MP1 (I1_I976_P28_13n I1_I976_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I179_XP_MP0 (VDD I1_I976_P28_21 I1_I976_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I171_XP_MP1 (I1_I976_P20_5n I1_I976_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I171_XP_MP0 (VDD I1_I976_P20_13 I1_I976_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I169_XP_MP1 (I1_I976_P18_3n I1_I976_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I169_XP_MP0 (VDD I1_I976_P18_11 I1_I976_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I175_XP_MP1 (I1_I976_P24_9n I1_I976_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I175_XP_MP0 (VDD I1_I976_P24_17 I1_I976_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I106_XP_MP1 (I1_I976_P10_7n I1_I976_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I106_XP_MP0 (VDD I1_I976_P10_9 I1_I976_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I104_XP_MP1 (I1_I976_P8_5n I1_I976_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I104_XP_MP0 (VDD I1_I976_P8_7 I1_I976_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I1_MP1 (I1_I608_gn1 I1_b1_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I1_MP0 (VDD I1_p0_0 I1_I608_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I106_XP_MP1 (I1_I608_P10_7n I1_I608_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I106_XP_MP0 (VDD I1_I608_P10_9 I1_I608_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I108_XP_MP1 (I1_I608_P12_9n I1_I608_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I108_XP_MP0 (VDD I1_I608_P12_11 I1_I608_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I110_XP_MP1 (I1_I608_P14_11n I1_I608_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I110_XP_MP0 (VDD I1_I608_P14_13 I1_I608_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I112_XP_MP1 (I1_I608_P16_13n I1_I608_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I112_XP_MP0 (VDD I1_I608_P16_15 I1_I608_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I114_XP_MP1 (I1_I608_P18_15n I1_I608_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I114_XP_MP0 (VDD I1_I608_P18_17 I1_I608_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I116_XP_MP1 (I1_I608_P20_17n I1_I608_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I116_XP_MP0 (VDD I1_I608_P20_19 I1_I608_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I118_XP_MP1 (I1_I608_P22_19n I1_I608_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I118_XP_MP0 (VDD I1_I608_P22_21 I1_I608_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I120_XP_MP1 (I1_I608_P24_21n I1_I608_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I120_XP_MP0 (VDD I1_I608_P24_23 I1_I608_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I122_XP_MP1 (I1_I608_P26_23n I1_I608_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I122_XP_MP0 (VDD I1_I608_P26_25 I1_I608_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I25_MP1 (I1_I1482_gn25 I1_b20_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I25_MP0 (VDD I1_p19_24 I1_I1482_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I24_MP1 (I1_I1482_gn24 I1_b20_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I24_MP0 (VDD I1_p19_23 I1_I1482_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I119_XP_MP1 (I1_I1482_P23_20n I1_I1482_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I119_XP_MP0 (VDD I1_I1482_P23_22 I1_I1482_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I117_XP_MP1 (I1_I1482_P21_18n I1_I1482_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I117_XP_MP0 (VDD I1_I1482_P21_20 I1_I1482_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I115_XP_MP1 (I1_I1482_P19_16n I1_I1482_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I115_XP_MP0 (VDD I1_I1482_P19_18 I1_I1482_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I113_XP_MP1 (I1_I1482_P17_14n I1_I1482_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I113_XP_MP0 (VDD I1_I1482_P17_16 I1_I1482_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I111_XP_MP1 (I1_I1482_P15_12n I1_I1482_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I111_XP_MP0 (VDD I1_I1482_P15_14 I1_I1482_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I109_XP_MP1 (I1_I1482_P13_10n I1_I1482_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I109_XP_MP0 (VDD I1_I1482_P13_12 I1_I1482_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I107_XP_MP1 (I1_I1482_P11_8n I1_I1482_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I107_XP_MP0 (VDD I1_I1482_P11_10 I1_I1482_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I105_XP_MP1 (I1_I1482_P9_6n I1_I1482_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I105_XP_MP0 (VDD I1_I1482_P9_8 I1_I1482_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I103_XP_MP1 (I1_I1482_P7_4n I1_I1482_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I103_XP_MP0 (VDD I1_I1482_P7_6 I1_I1482_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I101_XP_MP1 (I1_I1482_P5_2n I1_I1482_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I101_XP_MP0 (VDD I1_I1482_P5_4 I1_I1482_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I1_MP1 (I1_I1482_gn1 I1_b20_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I1_MP0 (VDD I1_p19_0 I1_I1482_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I107_XP_MP1 (I1_I1114_P11_8n I1_I1114_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I107_XP_MP0 (VDD I1_I1114_P11_10 I1_I1114_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I108_XP_MP1 (I1_I1114_P12_9n I1_I1114_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I108_XP_MP0 (VDD I1_I1114_P12_11 I1_I1114_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I106_XP_MP1 (I1_I1114_P10_7n I1_I1114_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I106_XP_MP0 (VDD I1_I1114_P10_9 I1_I1114_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I167_XP_MP1 (I1_I1114_P16_1n I1_I1114_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I167_XP_MP0 (VDD I1_I1114_P16_9 I1_I1114_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I12_MP1 (I1_I1114_gn12 I1_b12_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I12_MP0 (VDD I1_p11_11 I1_I1114_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I169_XP_MP1 (I1_I1068_P18_3n I1_I1068_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I169_XP_MP0 (VDD I1_I1068_P18_11 I1_I1068_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I112_XP_MP1 (I1_I1068_P16_13n I1_I1068_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I112_XP_MP0 (VDD I1_I1068_P16_15 I1_I1068_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I110_XP_MP1 (I1_I1068_P14_11n I1_I1068_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I110_XP_MP0 (VDD I1_I1068_P14_13 I1_I1068_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I176_XP_MP1 (I1_I1068_P25_10n I1_I1068_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I176_XP_MP0 (VDD I1_I1068_P25_18 I1_I1068_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I109_XP_MP1 (I1_I1068_P13_10n I1_I1068_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I109_XP_MP0 (VDD I1_I1068_P13_12 I1_I1068_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I14_MP1 (I1_I1068_gn14 I1_b11_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I14_MP0 (VDD I1_p10_13 I1_I1068_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I15_MP1 (I1_I1068_gn15 I1_b11_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I15_MP0 (VDD I1_p10_14 I1_I1068_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I118_XP_MP1 (I1_I1022_P22_19n I1_I1022_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I118_XP_MP0 (VDD I1_I1022_P22_21 I1_I1022_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I174_XP_MP1 (I1_I1022_P23_8n I1_I1022_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I174_XP_MP0 (VDD I1_I1022_P23_16 I1_I1022_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I119_XP_MP1 (I1_I1022_P23_20n I1_I1022_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I119_XP_MP0 (VDD I1_I1022_P23_22 I1_I1022_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I18_MP1 (I1_I1022_gn18 I1_b10_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I18_MP0 (VDD I1_p9_17 I1_I1022_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I16_MP1 (I1_I1022_gn16 I1_b10_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I16_MP0 (VDD I1_p9_15 I1_I1022_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I17_MP1 (I1_I1022_gn17 I1_b10_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I17_MP0 (VDD I1_p9_16 I1_I1022_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I167_XP_MP1 (I1_I976_P16_1n I1_I976_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I167_XP_MP0 (VDD I1_I976_P16_9 I1_I976_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I102_XP_MP1 (I1_I976_P6_3n I1_I976_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I102_XP_MP0 (VDD I1_I976_P6_5 I1_I976_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I2_MP1 (I1_I976_gn2 I1_b9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I2_MP0 (VDD I1_p8_1 I1_I976_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I2_MP1 (I1_I608_gn2 I1_b1_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I2_MP0 (VDD I1_p0_1 I1_I608_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I101_XP_MP1 (I1_I608_P5_2n I1_I608_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I101_XP_MP0 (VDD I1_I608_P5_4 I1_I608_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I103_XP_MP1 (I1_I608_P7_4n I1_I608_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I103_XP_MP0 (VDD I1_I608_P7_6 I1_I608_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I168_XP_MP1 (I1_I608_P17_2n I1_I608_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I168_XP_MP0 (VDD I1_I608_P17_10 I1_I608_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I170_XP_MP1 (I1_I608_P19_4n I1_I608_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I170_XP_MP0 (VDD I1_I608_P19_12 I1_I608_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I176_XP_MP1 (I1_I608_P25_10n I1_I608_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I176_XP_MP0 (VDD I1_I608_P25_18 I1_I608_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I172_XP_MP1 (I1_I608_P21_6n I1_I608_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I172_XP_MP0 (VDD I1_I608_P21_14 I1_I608_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I178_XP_MP1 (I1_I608_P27_12n I1_I608_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I178_XP_MP0 (VDD I1_I608_P27_20 I1_I608_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I174_XP_MP1 (I1_I608_P23_8n I1_I608_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I174_XP_MP0 (VDD I1_I608_P23_16 I1_I608_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I180_XP_MP1 (I1_I608_P29_14n I1_I608_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I180_XP_MP0 (VDD I1_I608_P29_22 I1_I608_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I182_XP_MP1 (I1_I608_P31_16n I1_I608_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I182_XP_MP0 (VDD I1_I608_P31_24 I1_I608_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I127_XP_MP1 (I1_I608_P31_28n I1_I608_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I127_XP_MP0 (VDD I1_I608_P31_30 I1_I608_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I31_MP1 (I1_I608_gn31 I1_b1_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I31_MP0 (VDD I1_p0_30 I1_I608_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I30_MP1 (I1_I608_gn30 I1_b1_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I30_MP0 (VDD I1_p0_29 I1_I608_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I182_XP_MP1 (I1_I1482_P31_16n I1_I1482_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I182_XP_MP0 (VDD I1_I1482_P31_24 I1_I1482_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I123_XP_MP1 (I1_I1482_P27_24n I1_I1482_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I123_XP_MP0 (VDD I1_I1482_P27_26 I1_I1482_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I121_XP_MP1 (I1_I1482_P25_22n I1_I1482_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I121_XP_MP0 (VDD I1_I1482_P25_24 I1_I1482_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I174_XP_MP1 (I1_I1482_P23_8n I1_I1482_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I174_XP_MP0 (VDD I1_I1482_P23_16 I1_I1482_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I172_XP_MP1 (I1_I1482_P21_6n I1_I1482_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I172_XP_MP0 (VDD I1_I1482_P21_14 I1_I1482_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I170_XP_MP1 (I1_I1482_P19_4n I1_I1482_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I170_XP_MP0 (VDD I1_I1482_P19_12 I1_I1482_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I168_XP_MP1 (I1_I1482_P17_2n I1_I1482_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I168_XP_MP0 (VDD I1_I1482_P17_10 I1_I1482_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I7_MP1 (I1_I1528_gn7 I1_b21_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I7_MP0 (VDD I1_p20_6 I1_I1528_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I103_XP_MP1 (I1_I1114_P7_4n I1_I1114_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I103_XP_MP0 (VDD I1_I1114_P7_6 I1_I1114_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I105_XP_MP1 (I1_I1114_P9_6n I1_I1114_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I105_XP_MP0 (VDD I1_I1114_P9_8 I1_I1114_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I101_XP_MP1 (I1_I1114_P5_2n I1_I1114_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I101_XP_MP0 (VDD I1_I1114_P5_4 I1_I1114_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I104_XP_MP1 (I1_I1114_P8_5n I1_I1114_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I104_XP_MP0 (VDD I1_I1114_P8_7 I1_I1114_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I11_MP1 (I1_I1114_gn11 I1_b12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I11_MP0 (VDD I1_p11_10 I1_I1114_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I175_XP_MP1 (I1_I1068_P24_9n I1_I1068_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I175_XP_MP0 (VDD I1_I1068_P24_17 I1_I1068_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I108_XP_MP1 (I1_I1068_P12_9n I1_I1068_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I108_XP_MP0 (VDD I1_I1068_P12_11 I1_I1068_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I168_XP_MP1 (I1_I1068_P17_2n I1_I1068_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I168_XP_MP0 (VDD I1_I1068_P17_10 I1_I1068_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I107_XP_MP1 (I1_I1068_P11_8n I1_I1068_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I107_XP_MP0 (VDD I1_I1068_P11_10 I1_I1068_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I173_XP_MP1 (I1_I1022_P22_7n I1_I1022_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I173_XP_MP0 (VDD I1_I1022_P22_15 I1_I1022_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I179_XP_MP1 (I1_I1022_P28_13n I1_I1022_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I179_XP_MP0 (VDD I1_I1022_P28_21 I1_I1022_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I116_XP_MP1 (I1_I1022_P20_17n I1_I1022_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I116_XP_MP0 (VDD I1_I1022_P20_19 I1_I1022_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I114_XP_MP1 (I1_I1022_P18_15n I1_I1022_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I114_XP_MP0 (VDD I1_I1022_P18_17 I1_I1022_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I178_XP_MP1 (I1_I1022_P27_12n I1_I1022_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I178_XP_MP0 (VDD I1_I1022_P27_20 I1_I1022_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I117_XP_MP1 (I1_I1022_P21_18n I1_I1022_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I117_XP_MP0 (VDD I1_I1022_P21_20 I1_I1022_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I115_XP_MP1 (I1_I1022_P19_16n I1_I1022_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I115_XP_MP0 (VDD I1_I1022_P19_18 I1_I1022_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I14_MP1 (I1_I1022_gn14 I1_b10_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I14_MP0 (VDD I1_p9_13 I1_I1022_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I100_XP_MP1 (I1_I976_P4_1n I1_I976_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I100_XP_MP0 (VDD I1_I976_P4_3 I1_I976_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I0_MP1 (I1_I930_gn0 I1_b8_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I0_MP0 (VDD I1_aa23 I1_I930_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I0_MP1 (I1_I608_gn0 I1_b1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I0_MP0 (VDD I1_aa30 I1_I608_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I3_MP1 (I1_I608_gn3 I1_b1_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I3_MP0 (VDD I1_p0_2 I1_I608_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I4_MP1 (I1_I608_gn4 I1_b1_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I4_MP0 (VDD I1_p0_3 I1_I608_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I5_MP1 (I1_I608_gn5 I1_b1_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I5_MP0 (VDD I1_p0_4 I1_I608_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I105_XP_MP1 (I1_I608_P9_6n I1_I608_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I105_XP_MP0 (VDD I1_I608_P9_8 I1_I608_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I107_XP_MP1 (I1_I608_P11_8n I1_I608_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I107_XP_MP0 (VDD I1_I608_P11_10 I1_I608_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I109_XP_MP1 (I1_I608_P13_10n I1_I608_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I109_XP_MP0 (VDD I1_I608_P13_12 I1_I608_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I111_XP_MP1 (I1_I608_P15_12n I1_I608_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I111_XP_MP0 (VDD I1_I608_P15_14 I1_I608_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I113_XP_MP1 (I1_I608_P17_14n I1_I608_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I113_XP_MP0 (VDD I1_I608_P17_16 I1_I608_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I115_XP_MP1 (I1_I608_P19_16n I1_I608_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I115_XP_MP0 (VDD I1_I608_P19_18 I1_I608_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I119_XP_MP1 (I1_I608_P23_20n I1_I608_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I119_XP_MP0 (VDD I1_I608_P23_22 I1_I608_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I121_XP_MP1 (I1_I608_P25_22n I1_I608_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I121_XP_MP0 (VDD I1_I608_P25_24 I1_I608_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I123_XP_MP1 (I1_I608_P27_24n I1_I608_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I123_XP_MP0 (VDD I1_I608_P27_26 I1_I608_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I125_XP_MP1 (I1_I608_P29_26n I1_I608_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I125_XP_MP0 (VDD I1_I608_P29_28 I1_I608_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I29_MP1 (I1_I608_gn29 I1_b1_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I29_MP0 (VDD I1_p0_28 I1_I608_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I125_XP_MP1 (I1_I1482_P29_26n I1_I1482_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I125_XP_MP0 (VDD I1_I1482_P29_28 I1_I1482_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I180_XP_MP1 (I1_I1482_P29_14n I1_I1482_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I180_XP_MP0 (VDD I1_I1482_P29_22 I1_I1482_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I178_XP_MP1 (I1_I1482_P27_12n I1_I1482_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I178_XP_MP0 (VDD I1_I1482_P27_20 I1_I1482_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I176_XP_MP1 (I1_I1482_P25_10n I1_I1482_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I176_XP_MP0 (VDD I1_I1482_P25_18 I1_I1482_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I106_XP_MP1 (I1_I1482_P10_7n I1_I1482_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I106_XP_MP0 (VDD I1_I1482_P10_9 I1_I1482_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I104_XP_MP1 (I1_I1482_P8_5n I1_I1482_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I104_XP_MP0 (VDD I1_I1482_P8_7 I1_I1482_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I102_XP_MP1 (I1_I1482_P6_3n I1_I1482_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I102_XP_MP0 (VDD I1_I1482_P6_5 I1_I1482_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I100_XP_MP1 (I1_I1482_P4_1n I1_I1482_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I100_XP_MP0 (VDD I1_I1482_P4_3 I1_I1482_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I9_MP1 (I1_I1528_gn9 I1_b21_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I9_MP0 (VDD I1_p20_8 I1_I1528_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I6_MP1 (I1_I1528_gn6 I1_b21_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I6_MP0 (VDD I1_p20_5 I1_I1528_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I0_MP1 (I1_I1482_gn0 I1_b20_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I0_MP0 (VDD I1_aa11 I1_I1482_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I10_MP1 (I1_I1114_gn10 I1_b12_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I10_MP0 (VDD I1_p11_9 I1_I1114_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I102_XP_MP1 (I1_I1114_P6_3n I1_I1114_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I102_XP_MP0 (VDD I1_I1114_P6_5 I1_I1114_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I100_XP_MP1 (I1_I1114_P4_1n I1_I1114_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I100_XP_MP0 (VDD I1_I1114_P4_3 I1_I1114_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I167_XP_MP1 (I1_I1068_P16_1n I1_I1068_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I167_XP_MP0 (VDD I1_I1068_P16_9 I1_I1068_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I106_XP_MP1 (I1_I1068_P10_7n I1_I1068_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I106_XP_MP0 (VDD I1_I1068_P10_9 I1_I1068_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I105_XP_MP1 (I1_I1068_P9_6n I1_I1068_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I105_XP_MP0 (VDD I1_I1068_P9_8 I1_I1068_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I9_MP1 (I1_I1068_gn9 I1_b11_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I9_MP0 (VDD I1_p10_8 I1_I1068_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I10_MP1 (I1_I1068_gn10 I1_b11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I10_MP0 (VDD I1_p10_9 I1_I1068_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I12_MP1 (I1_I1068_gn12 I1_b11_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I12_MP0 (VDD I1_p10_11 I1_I1068_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I11_MP1 (I1_I1068_gn11 I1_b11_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I11_MP0 (VDD I1_p10_10 I1_I1068_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I13_MP1 (I1_I1068_gn13 I1_b11_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I13_MP0 (VDD I1_p10_12 I1_I1068_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I177_XP_MP1 (I1_I1022_P26_11n I1_I1022_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I177_XP_MP0 (VDD I1_I1022_P26_19 I1_I1022_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I112_XP_MP1 (I1_I1022_P16_13n I1_I1022_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I112_XP_MP0 (VDD I1_I1022_P16_15 I1_I1022_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I180_XP_MP1 (I1_I1022_P29_14n I1_I1022_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I180_XP_MP0 (VDD I1_I1022_P29_22 I1_I1022_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I170_XP_MP1 (I1_I1022_P19_4n I1_I1022_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I170_XP_MP0 (VDD I1_I1022_P19_12 I1_I1022_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I113_XP_MP1 (I1_I1022_P17_14n I1_I1022_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I113_XP_MP0 (VDD I1_I1022_P17_16 I1_I1022_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I111_XP_MP1 (I1_I1022_P15_12n I1_I1022_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I111_XP_MP0 (VDD I1_I1022_P15_14 I1_I1022_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I15_MP1 (I1_I1022_gn15 I1_b10_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I15_MP0 (VDD I1_p9_14 I1_I1022_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I12_MP1 (I1_I1022_gn12 I1_b10_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I12_MP0 (VDD I1_p9_11 I1_I1022_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I13_MP1 (I1_I1022_gn13 I1_b10_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I13_MP0 (VDD I1_p9_12 I1_I1022_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I10_MP1 (I1_I1022_gn10 I1_b10_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I10_MP0 (VDD I1_p9_9 I1_I1022_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I11_MP1 (I1_I1022_gn11 I1_b10_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I11_MP0 (VDD I1_p9_10 I1_I1022_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I1_MP1 (I1_I976_gn1 I1_b9_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I1_MP0 (VDD I1_p8_0 I1_I976_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I6_MP1 (I1_I608_gn6 I1_b1_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I6_MP0 (VDD I1_p0_5 I1_I608_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I7_MP1 (I1_I608_gn7 I1_b1_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I7_MP0 (VDD I1_p0_6 I1_I608_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I9_MP1 (I1_I608_gn9 I1_b1_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I9_MP0 (VDD I1_p0_8 I1_I608_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I10_MP1 (I1_I608_gn10 I1_b1_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I10_MP0 (VDD I1_p0_9 I1_I608_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I117_XP_MP1 (I1_I608_P21_18n I1_I608_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I117_XP_MP0 (VDD I1_I608_P21_20 I1_I608_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I24_MP1 (I1_I608_gn24 I1_b1_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I24_MP0 (VDD I1_p0_23 I1_I608_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I27_MP1 (I1_I608_gn27 I1_b1_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I27_MP0 (VDD I1_p0_26 I1_I608_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I28_MP1 (I1_I608_gn28 I1_b1_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I28_MP0 (VDD I1_p0_27 I1_I608_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I27_MP1 (I1_I1482_gn27 I1_b20_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I27_MP0 (VDD I1_p19_26 I1_I1482_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I26_MP1 (I1_I1482_gn26 I1_b20_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I26_MP0 (VDD I1_p19_25 I1_I1482_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I120_XP_MP1 (I1_I1482_P24_21n I1_I1482_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I120_XP_MP0 (VDD I1_I1482_P24_23 I1_I1482_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I118_XP_MP1 (I1_I1482_P22_19n I1_I1482_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I118_XP_MP0 (VDD I1_I1482_P22_21 I1_I1482_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I116_XP_MP1 (I1_I1482_P20_17n I1_I1482_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I116_XP_MP0 (VDD I1_I1482_P20_19 I1_I1482_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I114_XP_MP1 (I1_I1482_P18_15n I1_I1482_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I114_XP_MP0 (VDD I1_I1482_P18_17 I1_I1482_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I175_XP_MP1 (I1_I1482_P24_9n I1_I1482_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I175_XP_MP0 (VDD I1_I1482_P24_17 I1_I1482_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I112_XP_MP1 (I1_I1482_P16_13n I1_I1482_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I112_XP_MP0 (VDD I1_I1482_P16_15 I1_I1482_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I110_XP_MP1 (I1_I1482_P14_11n I1_I1482_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I110_XP_MP0 (VDD I1_I1482_P14_13 I1_I1482_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I108_XP_MP1 (I1_I1482_P12_9n I1_I1482_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I108_XP_MP0 (VDD I1_I1482_P12_11 I1_I1482_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I167_XP_MP1 (I1_I1482_P16_1n I1_I1482_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I167_XP_MP0 (VDD I1_I1482_P16_9 I1_I1482_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I13_MP1 (I1_I1528_gn13 I1_b21_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I13_MP0 (VDD I1_p20_12 I1_I1528_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I10_MP1 (I1_I1528_gn10 I1_b21_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I10_MP0 (VDD I1_p20_9 I1_I1528_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I8_MP1 (I1_I1528_gn8 I1_b21_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I8_MP0 (VDD I1_p20_7 I1_I1528_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I5_MP1 (I1_I1528_gn5 I1_b21_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I5_MP0 (VDD I1_p20_4 I1_I1528_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I4_MP1 (I1_I1528_gn4 I1_b21_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I4_MP0 (VDD I1_p20_3 I1_I1528_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I9_MP1 (I1_I1114_gn9 I1_b12_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I9_MP0 (VDD I1_p11_8 I1_I1114_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I8_MP1 (I1_I1114_gn8 I1_b12_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I8_MP0 (VDD I1_p11_7 I1_I1114_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I7_MP1 (I1_I1114_gn7 I1_b12_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I7_MP0 (VDD I1_p11_6 I1_I1114_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I2_MP1 (I1_I1114_gn2 I1_b12_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I2_MP0 (VDD I1_p11_1 I1_I1114_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I1_MP1 (I1_I1114_gn1 I1_b12_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I1_MP0 (VDD I1_p11_0 I1_I1114_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I104_XP_MP1 (I1_I1068_P8_5n I1_I1068_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I104_XP_MP0 (VDD I1_I1068_P8_7 I1_I1068_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I101_XP_MP1 (I1_I1068_P5_2n I1_I1068_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I101_XP_MP0 (VDD I1_I1068_P5_4 I1_I1068_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I103_XP_MP1 (I1_I1068_P7_4n I1_I1068_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I103_XP_MP0 (VDD I1_I1068_P7_6 I1_I1068_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I0_MP1 (I1_I1114_gn0 I1_b12_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I0_MP0 (VDD I1_aa19 I1_I1114_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I169_XP_MP1 (I1_I1022_P18_3n I1_I1022_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I169_XP_MP0 (VDD I1_I1022_P18_11 I1_I1022_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I175_XP_MP1 (I1_I1022_P24_9n I1_I1022_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I175_XP_MP0 (VDD I1_I1022_P24_17 I1_I1022_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I110_XP_MP1 (I1_I1022_P14_11n I1_I1022_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I110_XP_MP0 (VDD I1_I1022_P14_13 I1_I1022_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I108_XP_MP1 (I1_I1022_P12_9n I1_I1022_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I108_XP_MP0 (VDD I1_I1022_P12_11 I1_I1022_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I172_XP_MP1 (I1_I1022_P21_6n I1_I1022_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I172_XP_MP0 (VDD I1_I1022_P21_14 I1_I1022_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I176_XP_MP1 (I1_I1022_P25_10n I1_I1022_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I176_XP_MP0 (VDD I1_I1022_P25_18 I1_I1022_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I109_XP_MP1 (I1_I1022_P13_10n I1_I1022_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I109_XP_MP0 (VDD I1_I1022_P13_12 I1_I1022_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I107_XP_MP1 (I1_I1022_P11_8n I1_I1022_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I107_XP_MP0 (VDD I1_I1022_P11_10 I1_I1022_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I8_MP1 (I1_I1022_gn8 I1_b10_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I8_MP0 (VDD I1_p9_7 I1_I1022_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I9_MP1 (I1_I1022_gn9 I1_b10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I9_MP0 (VDD I1_p9_8 I1_I1022_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I5_MP1 (I1_I1022_gn5 I1_b10_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I5_MP0 (VDD I1_p9_4 I1_I1022_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I1_MP1 (I1_I562_gn1 I1_b0_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I1_MP0 (VDD VSS I1_I562_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I8_MP1 (I1_I608_gn8 I1_b1_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I8_MP0 (VDD I1_p0_7 I1_I608_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I11_MP1 (I1_I608_gn11 I1_b1_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I11_MP0 (VDD I1_p0_10 I1_I608_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I12_MP1 (I1_I608_gn12 I1_b1_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I12_MP0 (VDD I1_p0_11 I1_I608_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I13_MP1 (I1_I608_gn13 I1_b1_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I13_MP0 (VDD I1_p0_12 I1_I608_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I14_MP1 (I1_I608_gn14 I1_b1_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I14_MP0 (VDD I1_p0_13 I1_I608_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I15_MP1 (I1_I608_gn15 I1_b1_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I15_MP0 (VDD I1_p0_14 I1_I608_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I16_MP1 (I1_I608_gn16 I1_b1_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I16_MP0 (VDD I1_p0_15 I1_I608_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I19_MP1 (I1_I608_gn19 I1_b1_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I19_MP0 (VDD I1_p0_18 I1_I608_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I20_MP1 (I1_I608_gn20 I1_b1_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I20_MP0 (VDD I1_p0_19 I1_I608_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I21_MP1 (I1_I608_gn21 I1_b1_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I21_MP0 (VDD I1_p0_20 I1_I608_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I22_MP1 (I1_I608_gn22 I1_b1_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I22_MP0 (VDD I1_p0_21 I1_I608_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I23_MP1 (I1_I608_gn23 I1_b1_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I23_MP0 (VDD I1_p0_22 I1_I608_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I25_MP1 (I1_I608_gn25 I1_b1_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I25_MP0 (VDD I1_p0_24 I1_I608_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I26_MP1 (I1_I608_gn26 I1_b1_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I26_MP0 (VDD I1_p0_25 I1_I608_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I28_MP1 (I1_I1482_gn28 I1_b20_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I28_MP0 (VDD I1_p19_27 I1_I1482_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I127_XP_MP1 (I1_I1482_P31_28n I1_I1482_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I127_XP_MP0 (VDD I1_I1482_P31_30 I1_I1482_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I124_XP_MP1 (I1_I1482_P28_25n I1_I1482_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I124_XP_MP0 (VDD I1_I1482_P28_27 I1_I1482_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I122_XP_MP1 (I1_I1482_P26_23n I1_I1482_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I122_XP_MP0 (VDD I1_I1482_P26_25 I1_I1482_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I179_XP_MP1 (I1_I1482_P28_13n I1_I1482_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I179_XP_MP0 (VDD I1_I1482_P28_21 I1_I1482_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I171_XP_MP1 (I1_I1482_P20_5n I1_I1482_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I171_XP_MP0 (VDD I1_I1482_P20_13 I1_I1482_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I169_XP_MP1 (I1_I1482_P18_3n I1_I1482_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I169_XP_MP0 (VDD I1_I1482_P18_11 I1_I1482_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I17_MP1 (I1_I1528_gn17 I1_b21_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I17_MP0 (VDD I1_p20_16 I1_I1528_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I15_MP1 (I1_I1528_gn15 I1_b21_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I15_MP0 (VDD I1_p20_14 I1_I1528_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I14_MP1 (I1_I1528_gn14 I1_b21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I14_MP0 (VDD I1_p20_13 I1_I1528_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I12_MP1 (I1_I1528_gn12 I1_b21_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I12_MP0 (VDD I1_p20_11 I1_I1528_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I11_MP1 (I1_I1528_gn11 I1_b21_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I11_MP0 (VDD I1_p20_10 I1_I1528_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I6_MP1 (I1_I1114_gn6 I1_b12_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I6_MP0 (VDD I1_p11_5 I1_I1114_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I5_MP1 (I1_I1114_gn5 I1_b12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I5_MP0 (VDD I1_p11_4 I1_I1114_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I100_XP_MP1 (I1_I1068_P4_1n I1_I1068_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I100_XP_MP0 (VDD I1_I1068_P4_3 I1_I1068_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I102_XP_MP1 (I1_I1068_P6_3n I1_I1068_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I102_XP_MP0 (VDD I1_I1068_P6_5 I1_I1068_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I8_MP1 (I1_I1068_gn8 I1_b11_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I8_MP0 (VDD I1_p10_7 I1_I1068_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I6_MP1 (I1_I1068_gn6 I1_b11_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I6_MP0 (VDD I1_p10_5 I1_I1068_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I7_MP1 (I1_I1068_gn7 I1_b11_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I7_MP0 (VDD I1_p10_6 I1_I1068_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I171_XP_MP1 (I1_I1022_P20_5n I1_I1022_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I171_XP_MP0 (VDD I1_I1022_P20_13 I1_I1022_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I104_XP_MP1 (I1_I1022_P8_5n I1_I1022_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I104_XP_MP0 (VDD I1_I1022_P8_7 I1_I1022_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I106_XP_MP1 (I1_I1022_P10_7n I1_I1022_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I106_XP_MP0 (VDD I1_I1022_P10_9 I1_I1022_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I168_XP_MP1 (I1_I1022_P17_2n I1_I1022_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I168_XP_MP0 (VDD I1_I1022_P17_10 I1_I1022_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I105_XP_MP1 (I1_I1022_P9_6n I1_I1022_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I105_XP_MP0 (VDD I1_I1022_P9_8 I1_I1022_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I103_XP_MP1 (I1_I1022_P7_4n I1_I1022_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I103_XP_MP0 (VDD I1_I1022_P7_6 I1_I1022_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I6_MP1 (I1_I1022_gn6 I1_b10_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I6_MP0 (VDD I1_p9_5 I1_I1022_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I7_MP1 (I1_I1022_gn7 I1_b10_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I7_MP0 (VDD I1_p9_6 I1_I1022_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I4_MP1 (I1_I1022_gn4 I1_b10_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I4_MP0 (VDD I1_p9_3 I1_I1022_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I3_MP1 (I1_I1022_gn3 I1_b10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I3_MP0 (VDD I1_p9_2 I1_I1022_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I17_MP1 (I1_I608_gn17 I1_b1_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I17_MP0 (VDD I1_p0_16 I1_I608_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I18_MP1 (I1_I608_gn18 I1_b1_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I18_MP0 (VDD I1_p0_17 I1_I608_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I29_MP1 (I1_I1482_gn29 I1_b20_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I29_MP0 (VDD I1_p19_28 I1_I1482_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I126_XP_MP1 (I1_I1482_P30_27n I1_I1482_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I126_XP_MP0 (VDD I1_I1482_P30_29 I1_I1482_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I181_XP_MP1 (I1_I1482_P30_15n I1_I1482_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I181_XP_MP0 (VDD I1_I1482_P30_23 I1_I1482_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I173_XP_MP1 (I1_I1482_P22_7n I1_I1482_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I173_XP_MP0 (VDD I1_I1482_P22_15 I1_I1482_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I177_XP_MP1 (I1_I1482_P26_11n I1_I1482_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I177_XP_MP0 (VDD I1_I1482_P26_19 I1_I1482_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I20_MP1 (I1_I1528_gn20 I1_b21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I20_MP0 (VDD I1_p20_19 I1_I1528_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I18_MP1 (I1_I1528_gn18 I1_b21_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I18_MP0 (VDD I1_p20_17 I1_I1528_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I16_MP1 (I1_I1528_gn16 I1_b21_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I16_MP0 (VDD I1_p20_15 I1_I1528_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I112_XP_MP1 (I1_I1528_P16_13n I1_I1528_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I112_XP_MP0 (VDD I1_I1528_P16_15 I1_I1528_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I110_XP_MP1 (I1_I1528_P14_11n I1_I1528_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I110_XP_MP0 (VDD I1_I1528_P14_13 I1_I1528_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I108_XP_MP1 (I1_I1528_P12_9n I1_I1528_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I108_XP_MP0 (VDD I1_I1528_P12_11 I1_I1528_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I106_XP_MP1 (I1_I1528_P10_7n I1_I1528_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I106_XP_MP0 (VDD I1_I1528_P10_9 I1_I1528_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I104_XP_MP1 (I1_I1528_P8_5n I1_I1528_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I104_XP_MP0 (VDD I1_I1528_P8_7 I1_I1528_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I102_XP_MP1 (I1_I1528_P6_3n I1_I1528_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I102_XP_MP0 (VDD I1_I1528_P6_5 I1_I1528_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I3_MP1 (I1_I1528_gn3 I1_b21_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I3_MP0 (VDD I1_p20_2 I1_I1528_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I2_MP1 (I1_I1528_gn2 I1_b21_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I2_MP0 (VDD I1_p20_1 I1_I1528_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I4_MP1 (I1_I1114_gn4 I1_b12_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I4_MP0 (VDD I1_p11_3 I1_I1114_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I3_MP1 (I1_I1114_gn3 I1_b12_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I3_MP0 (VDD I1_p11_2 I1_I1114_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I4_MP1 (I1_I1068_gn4 I1_b11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
