    I_MXI1_I1022_I72_XP_MP0 (XI1_I1022_I72_XP_p1 I1_I1022_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I72_XP_MP1 (I1_I1022_P6_5 I1_I1022_pn5 XI1_I1022_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I138_XP_MP0 (XI1_I1022_I138_XP_p1 I1_I1022_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I138_XP_MP1 (I1_I1022_P13_6 I1_I1022_P9_6n XI1_I1022_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I134_XP_MP0 (XI1_I1022_I134_XP_p1 I1_I1022_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I134_XP_MP1 (I1_I1022_P9_2 I1_I1022_P5_2n XI1_I1022_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I73_XP_MP0 (XI1_I1022_I73_XP_p1 I1_I1022_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I73_XP_MP1 (I1_I1022_P7_6 I1_I1022_pn6 XI1_I1022_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I95_XP_MP0 (XI1_I1482_I95_XP_p1 I1_I1482_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I95_XP_MP1 (I1_I1482_P29_28 I1_I1482_pn28 XI1_I1482_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I94_XP_MP0 (XI1_I1482_I94_XP_p1 I1_I1482_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I94_XP_MP1 (I1_I1482_P28_27 I1_I1482_pn27 XI1_I1482_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I155_XP_MP0 (XI1_I1482_I155_XP_p1 I1_I1482_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I155_XP_MP1 (I1_I1482_P30_23 I1_I1482_P26_23n XI1_I1482_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I151_XP_MP0 (XI1_I1482_I151_XP_p1 I1_I1482_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I151_XP_MP1 (I1_I1482_P26_19 I1_I1482_P22_19n XI1_I1482_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I143_XP_MP0 (XI1_I1482_I143_XP_p1 I1_I1482_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I143_XP_MP1 (I1_I1482_P18_11 I1_I1482_P14_11n XI1_I1482_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I139_XP_MP0 (XI1_I1482_I139_XP_p1 I1_I1482_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I139_XP_MP1 (I1_I1482_P14_7 I1_I1482_P10_7n XI1_I1482_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I82_XP_MP0 (XI1_I1528_I82_XP_p1 I1_I1528_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I82_XP_MP1 (I1_I1528_P16_15 I1_I1528_pn15 XI1_I1528_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I80_XP_MP0 (XI1_I1528_I80_XP_p1 I1_I1528_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I80_XP_MP1 (I1_I1528_P14_13 I1_I1528_pn13 XI1_I1528_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I78_XP_MP0 (XI1_I1528_I78_XP_p1 I1_I1528_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I78_XP_MP1 (I1_I1528_P12_11 I1_I1528_pn11 XI1_I1528_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I72_XP_MP0 (XI1_I1528_I72_XP_p1 I1_I1528_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I72_XP_MP1 (I1_I1528_P6_5 I1_I1528_pn5 XI1_I1528_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I68_XP_MP0 (XI1_I1068_I68_XP_p1 I1_I1068_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I68_XP_MP1 (I1_I1068_P2_1 I1_I1068_pn1 XI1_I1068_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I70_XP_MP0 (XI1_I1068_I70_XP_p1 I1_I1068_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I70_XP_MP1 (I1_I1068_P4_3 I1_I1068_pn3 XI1_I1068_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I69_XP_MP0 (XI1_I1068_I69_XP_p1 I1_I1068_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I69_XP_MP1 (I1_I1068_P3_2 I1_I1068_pn2 XI1_I1068_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I133_XP_MP0 (XI1_I1022_I133_XP_p1 I1_I1022_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I133_XP_MP1 (I1_I1022_P8_1 I1_I1022_P4_1n XI1_I1022_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I70_XP_MP0 (XI1_I1022_I70_XP_p1 I1_I1022_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I70_XP_MP1 (I1_I1022_P4_3 I1_I1022_pn3 XI1_I1022_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I68_XP_MP0 (XI1_I1022_I68_XP_p1 I1_I1022_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I68_XP_MP1 (I1_I1022_P2_1 I1_I1022_pn1 XI1_I1022_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I69_XP_MP0 (XI1_I1022_I69_XP_p1 I1_I1022_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I69_XP_MP1 (I1_I1022_P3_2 I1_I1022_pn2 XI1_I1022_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1022_I71_XP_MP0 (XI1_I1022_I71_XP_p1 I1_I1022_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1022_I71_XP_MP1 (I1_I1022_P5_4 I1_I1022_pn4 XI1_I1022_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I68_XP_MP0 (XI1_I562_I68_XP_p1 I1_I562_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I68_XP_MP1 (I1_I562_P2_1 I1_I562_pn1 XI1_I562_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I69_XP_MP0 (XI1_I562_I69_XP_p1 I1_I562_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I69_XP_MP1 (I1_I562_P3_2 I1_I562_pn2 XI1_I562_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I97_XP_MP0 (XI1_I1482_I97_XP_p1 I1_I1482_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I97_XP_MP1 (I1_I1482_P31_30 I1_I1482_pn30 XI1_I1482_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1482_I96_XP_MP0 (XI1_I1482_I96_XP_p1 I1_I1482_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1482_I96_XP_MP1 (I1_I1482_P30_29 I1_I1482_pn29 XI1_I1482_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I86_XP_MP0 (XI1_I1528_I86_XP_p1 I1_I1528_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I86_XP_MP1 (I1_I1528_P20_19 I1_I1528_pn19 XI1_I1528_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I84_XP_MP0 (XI1_I1528_I84_XP_p1 I1_I1528_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I84_XP_MP1 (I1_I1528_P18_17 I1_I1528_pn17 XI1_I1528_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I149_XP_MP0 (XI1_I1528_I149_XP_p1 I1_I1528_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I149_XP_MP1 (I1_I1528_P24_17 I1_I1528_P20_17n XI1_I1528_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I145_XP_MP0 (XI1_I1528_I145_XP_p1 I1_I1528_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I145_XP_MP1 (I1_I1528_P20_13 I1_I1528_P16_13n XI1_I1528_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I143_XP_MP0 (XI1_I1528_I143_XP_p1 I1_I1528_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I143_XP_MP1 (I1_I1528_P18_11 I1_I1528_P14_11n XI1_I1528_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I139_XP_MP0 (XI1_I1528_I139_XP_p1 I1_I1528_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I139_XP_MP1 (I1_I1528_P14_7 I1_I1528_P10_7n XI1_I1528_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I141_XP_MP0 (XI1_I1528_I141_XP_p1 I1_I1528_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I141_XP_MP1 (I1_I1528_P16_9 I1_I1528_P12_9n XI1_I1528_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I137_XP_MP0 (XI1_I1528_I137_XP_p1 I1_I1528_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I137_XP_MP1 (I1_I1528_P12_5 I1_I1528_P8_5n XI1_I1528_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I135_XP_MP0 (XI1_I1528_I135_XP_p1 I1_I1528_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I135_XP_MP1 (I1_I1528_P10_3 I1_I1528_P6_3n XI1_I1528_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I133_XP_MP0 (XI1_I1528_I133_XP_p1 I1_I1528_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I133_XP_MP1 (I1_I1528_P8_1 I1_I1528_P4_1n XI1_I1528_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I70_XP_MP0 (XI1_I1528_I70_XP_p1 I1_I1528_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I70_XP_MP1 (I1_I1528_P4_3 I1_I1528_pn3 XI1_I1528_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I68_XP_MP0 (XI1_I1528_I68_XP_p1 I1_I1528_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I68_XP_MP1 (I1_I1528_P2_1 I1_I1528_pn1 XI1_I1528_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I70_XP_MP0 (XI1_I562_I70_XP_p1 I1_I562_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I70_XP_MP1 (I1_I562_P4_3 I1_I562_pn3 XI1_I562_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I72_XP_MP0 (XI1_I562_I72_XP_p1 I1_I562_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I72_XP_MP1 (I1_I562_P6_5 I1_I562_pn5 XI1_I562_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I133_XP_MP0 (XI1_I562_I133_XP_p1 I1_I562_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I133_XP_MP1 (I1_I562_P8_1 I1_I562_P4_1n XI1_I562_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I135_XP_MP0 (XI1_I562_I135_XP_p1 I1_I562_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I135_XP_MP1 (I1_I562_P10_3 I1_I562_P6_3n XI1_I562_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I137_XP_MP0 (XI1_I562_I137_XP_p1 I1_I562_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I137_XP_MP1 (I1_I562_P12_5 I1_I562_P8_5n XI1_I562_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I141_XP_MP0 (XI1_I562_I141_XP_p1 I1_I562_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I141_XP_MP1 (I1_I562_P16_9 I1_I562_P12_9n XI1_I562_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I90_XP_MP0 (XI1_I1528_I90_XP_p1 I1_I1528_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I90_XP_MP1 (I1_I1528_P24_23 I1_I1528_pn23 XI1_I1528_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I88_XP_MP0 (XI1_I1528_I88_XP_p1 I1_I1528_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I88_XP_MP1 (I1_I1528_P22_21 I1_I1528_pn21 XI1_I1528_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I151_XP_MP0 (XI1_I1528_I151_XP_p1 I1_I1528_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I151_XP_MP1 (I1_I1528_P26_19 I1_I1528_P22_19n XI1_I1528_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I147_XP_MP0 (XI1_I1528_I147_XP_p1 I1_I1528_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I147_XP_MP1 (I1_I1528_P22_15 I1_I1528_P18_15n XI1_I1528_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I69_XP_MP0 (XI1_I1528_I69_XP_p1 I1_I1528_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I69_XP_MP1 (I1_I1528_P3_2 I1_I1528_pn2 XI1_I1528_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I116_MP0 (XI2_I2_I116_p1 A_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I116_MP1 (I2_I2_nor19 B_19 XI2_I2_I116_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I74_XP_MP0 (XI1_I562_I74_XP_p1 I1_I562_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I74_XP_MP1 (I1_I562_P8_7 I1_I562_pn7 XI1_I562_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I76_XP_MP0 (XI1_I562_I76_XP_p1 I1_I562_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I76_XP_MP1 (I1_I562_P10_9 I1_I562_pn9 XI1_I562_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I78_XP_MP0 (XI1_I562_I78_XP_p1 I1_I562_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I78_XP_MP1 (I1_I562_P12_11 I1_I562_pn11 XI1_I562_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I139_XP_MP0 (XI1_I562_I139_XP_p1 I1_I562_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I139_XP_MP1 (I1_I562_P14_7 I1_I562_P10_7n XI1_I562_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I143_XP_MP0 (XI1_I562_I143_XP_p1 I1_I562_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I143_XP_MP1 (I1_I562_P18_11 I1_I562_P14_11n XI1_I562_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I145_XP_MP0 (XI1_I562_I145_XP_p1 I1_I562_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I145_XP_MP1 (I1_I562_P20_13 I1_I562_P16_13n XI1_I562_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I149_XP_MP0 (XI1_I562_I149_XP_p1 I1_I562_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I149_XP_MP1 (I1_I562_P24_17 I1_I562_P20_17n XI1_I562_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I151_XP_MP0 (XI1_I562_I151_XP_p1 I1_I562_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I151_XP_MP1 (I1_I562_P26_19 I1_I562_P22_19n XI1_I562_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I147_XP_MP0 (XI1_I562_I147_XP_p1 I1_I562_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I147_XP_MP1 (I1_I562_P22_15 I1_I562_P18_15n XI1_I562_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I153_XP_MP0 (XI1_I562_I153_XP_p1 I1_I562_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I153_XP_MP1 (I1_I562_P28_21 I1_I562_P24_21n XI1_I562_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I155_XP_MP0 (XI1_I562_I155_XP_p1 I1_I562_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I155_XP_MP1 (I1_I562_P30_23 I1_I562_P26_23n XI1_I562_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I96_XP_MP0 (XI1_I562_I96_XP_p1 I1_I562_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I96_XP_MP1 (I1_I562_P30_29 I1_I562_pn29 XI1_I562_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I92_XP_MP0 (XI1_I1528_I92_XP_p1 I1_I1528_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I92_XP_MP1 (I1_I1528_P26_25 I1_I1528_pn25 XI1_I1528_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I89_XP_MP0 (XI1_I1528_I89_XP_p1 I1_I1528_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I89_XP_MP1 (I1_I1528_P23_22 I1_I1528_pn22 XI1_I1528_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I155_XP_MP0 (XI1_I1528_I155_XP_p1 I1_I1528_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I155_XP_MP1 (I1_I1528_P30_23 I1_I1528_P26_23n XI1_I1528_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I87_XP_MP0 (XI1_I1528_I87_XP_p1 I1_I1528_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I87_XP_MP1 (I1_I1528_P21_20 I1_I1528_pn20 XI1_I1528_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I153_XP_MP0 (XI1_I1528_I153_XP_p1 I1_I1528_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I153_XP_MP1 (I1_I1528_P28_21 I1_I1528_P24_21n XI1_I1528_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I85_XP_MP0 (XI1_I1528_I85_XP_p1 I1_I1528_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I85_XP_MP1 (I1_I1528_P19_18 I1_I1528_pn18 XI1_I1528_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I83_XP_MP0 (XI1_I1528_I83_XP_p1 I1_I1528_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I83_XP_MP1 (I1_I1528_P17_16 I1_I1528_pn16 XI1_I1528_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I79_XP_MP0 (XI1_I1528_I79_XP_p1 I1_I1528_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I79_XP_MP1 (I1_I1528_P13_12 I1_I1528_pn12 XI1_I1528_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I77_XP_MP0 (XI1_I1528_I77_XP_p1 I1_I1528_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I77_XP_MP1 (I1_I1528_P11_10 I1_I1528_pn10 XI1_I1528_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I75_XP_MP0 (XI1_I1528_I75_XP_p1 I1_I1528_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I75_XP_MP1 (I1_I1528_P9_8 I1_I1528_pn8 XI1_I1528_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I73_XP_MP0 (XI1_I1528_I73_XP_p1 I1_I1528_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I73_XP_MP1 (I1_I1528_P7_6 I1_I1528_pn6 XI1_I1528_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I71_XP_MP0 (XI1_I1528_I71_XP_p1 I1_I1528_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I71_XP_MP1 (I1_I1528_P5_4 I1_I1528_pn4 XI1_I1528_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I77_XP_MP0 (XI1_I1574_I77_XP_p1 I1_I1574_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I77_XP_MP1 (I1_I1574_P11_10 I1_I1574_pn10 XI1_I1574_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I319_MP0 (XI2_I3_I319_p1 I2_I3_o19_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I319_MP1 (I2_I3_q19_1 I2_I3_o19_1 XI2_I3_I319_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I331_MP0 (XI2_I3_I331_p1 I2_I3_o20_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I331_MP1 (I2_I3_q20_1 I2_I3_o20_1 XI2_I3_I331_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I10_MP0 (XI2_I4_I10_p1 Y_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I10_MP1 (I2_I4_z0_10 Y_21 XI2_I4_I10_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I11_MP0 (XI2_I4_I11_p1 Y_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I11_MP1 (I2_I4_z0_11 Y_23 XI2_I4_I11_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I71_XP_MP0 (XI1_I562_I71_XP_p1 I1_I562_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I71_XP_MP1 (I1_I562_P5_4 I1_I562_pn4 XI1_I562_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I73_XP_MP0 (XI1_I562_I73_XP_p1 I1_I562_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I73_XP_MP1 (I1_I562_P7_6 I1_I562_pn6 XI1_I562_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I75_XP_MP0 (XI1_I562_I75_XP_p1 I1_I562_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I75_XP_MP1 (I1_I562_P9_8 I1_I562_pn8 XI1_I562_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I77_XP_MP0 (XI1_I562_I77_XP_p1 I1_I562_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I77_XP_MP1 (I1_I562_P11_10 I1_I562_pn10 XI1_I562_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I80_XP_MP0 (XI1_I562_I80_XP_p1 I1_I562_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I80_XP_MP1 (I1_I562_P14_13 I1_I562_pn13 XI1_I562_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I82_XP_MP0 (XI1_I562_I82_XP_p1 I1_I562_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I82_XP_MP1 (I1_I562_P16_15 I1_I562_pn15 XI1_I562_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I84_XP_MP0 (XI1_I562_I84_XP_p1 I1_I562_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I84_XP_MP1 (I1_I562_P18_17 I1_I562_pn17 XI1_I562_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I86_XP_MP0 (XI1_I562_I86_XP_p1 I1_I562_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I86_XP_MP1 (I1_I562_P20_19 I1_I562_pn19 XI1_I562_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I88_XP_MP0 (XI1_I562_I88_XP_p1 I1_I562_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I88_XP_MP1 (I1_I562_P22_21 I1_I562_pn21 XI1_I562_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I94_XP_MP0 (XI1_I562_I94_XP_p1 I1_I562_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I94_XP_MP1 (I1_I562_P28_27 I1_I562_pn27 XI1_I562_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I97_XP_MP0 (XI1_I562_I97_XP_p1 I1_I562_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I97_XP_MP1 (I1_I562_P31_30 I1_I562_pn30 XI1_I562_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I97_XP_MP0 (XI1_I1528_I97_XP_p1 I1_I1528_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I97_XP_MP1 (I1_I1528_P31_30 I1_I1528_pn30 XI1_I1528_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I95_XP_MP0 (XI1_I1528_I95_XP_p1 I1_I1528_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I95_XP_MP1 (I1_I1528_P29_28 I1_I1528_pn28 XI1_I1528_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I93_XP_MP0 (XI1_I1528_I93_XP_p1 I1_I1528_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I93_XP_MP1 (I1_I1528_P27_26 I1_I1528_pn26 XI1_I1528_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I91_XP_MP0 (XI1_I1528_I91_XP_p1 I1_I1528_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I91_XP_MP1 (I1_I1528_P25_24 I1_I1528_pn24 XI1_I1528_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I96_XP_MP0 (XI1_I1528_I96_XP_p1 I1_I1528_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I96_XP_MP1 (I1_I1528_P30_29 I1_I1528_pn29 XI1_I1528_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I94_XP_MP0 (XI1_I1528_I94_XP_p1 I1_I1528_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I94_XP_MP1 (I1_I1528_P28_27 I1_I1528_pn27 XI1_I1528_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I150_XP_MP0 (XI1_I1528_I150_XP_p1 I1_I1528_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I150_XP_MP1 (I1_I1528_P25_18 I1_I1528_P21_18n XI1_I1528_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I81_XP_MP0 (XI1_I1528_I81_XP_p1 I1_I1528_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I81_XP_MP1 (I1_I1528_P15_14 I1_I1528_pn14 XI1_I1528_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I138_XP_MP0 (XI1_I1528_I138_XP_p1 I1_I1528_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I138_XP_MP1 (I1_I1528_P13_6 I1_I1528_P9_6n XI1_I1528_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I134_XP_MP0 (XI1_I1528_I134_XP_p1 I1_I1528_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I134_XP_MP1 (I1_I1528_P9_2 I1_I1528_P5_2n XI1_I1528_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I144_XP_MP0 (XI1_I1574_I144_XP_p1 I1_I1574_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I144_XP_MP1 (I1_I1574_P19_12 I1_I1574_P15_12n XI1_I1574_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I140_XP_MP0 (XI1_I1574_I140_XP_p1 I1_I1574_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I140_XP_MP1 (I1_I1574_P15_8 I1_I1574_P11_8n XI1_I1574_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I79_XP_MP0 (XI1_I1574_I79_XP_p1 I1_I1574_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I79_XP_MP1 (I1_I1574_P13_12 I1_I1574_pn12 XI1_I1574_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2277_MP0 (XI1_I2277_p1 B_30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2277_MP1 (I1_z0_15 I1_B_31_b3_5 XI1_I2277_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2276_MP0 (XI1_I2276_p1 B_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2276_MP1 (I1_z0_14 B_29 XI1_I2276_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I128_MP0 (XI2_I2_I128_p1 A_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I128_MP1 (I2_I2_nor21 B_21 XI2_I2_I128_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I343_MP0 (XI2_I3_I343_p1 I2_I3_o21_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I343_MP1 (I2_I3_q21_1 I2_I3_o21_1 XI2_I3_I343_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I307_MP0 (XI2_I3_I307_p1 I2_I3_o18_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I307_MP1 (I2_I3_q18_1 I2_I3_o18_1 XI2_I3_I307_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I122_MP0 (XI2_I2_I122_p1 A_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I122_MP1 (I2_I2_nor20 B_20 XI2_I2_I122_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I9_MP0 (XI2_I4_I9_p1 Y_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I9_MP1 (I2_I4_z0_9 Y_19 XI2_I4_I9_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I79_XP_MP0 (XI1_I562_I79_XP_p1 I1_I562_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I79_XP_MP1 (I1_I562_P13_12 I1_I562_pn12 XI1_I562_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I81_XP_MP0 (XI1_I562_I81_XP_p1 I1_I562_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I81_XP_MP1 (I1_I562_P15_14 I1_I562_pn14 XI1_I562_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I83_XP_MP0 (XI1_I562_I83_XP_p1 I1_I562_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I83_XP_MP1 (I1_I562_P17_16 I1_I562_pn16 XI1_I562_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I90_XP_MP0 (XI1_I562_I90_XP_p1 I1_I562_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I90_XP_MP1 (I1_I562_P24_23 I1_I562_pn23 XI1_I562_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I92_XP_MP0 (XI1_I562_I92_XP_p1 I1_I562_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I92_XP_MP1 (I1_I562_P26_25 I1_I562_pn25 XI1_I562_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I95_XP_MP0 (XI1_I562_I95_XP_p1 I1_I562_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I95_XP_MP1 (I1_I562_P29_28 I1_I562_pn28 XI1_I562_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I156_XP_MP0 (XI1_I1712_I156_XP_p1 I1_I1712_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I156_XP_MP1 (I1_I1712_P31_24 I1_I1712_P27_24n XI1_I1712_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I152_XP_MP0 (XI1_I1712_I152_XP_p1 I1_I1712_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I152_XP_MP1 (I1_I1712_P27_20 I1_I1712_P23_20n XI1_I1712_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I148_XP_MP0 (XI1_I1712_I148_XP_p1 I1_I1712_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I148_XP_MP1 (I1_I1712_P23_16 I1_I1712_P19_16n XI1_I1712_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I144_XP_MP0 (XI1_I1712_I144_XP_p1 I1_I1712_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I144_XP_MP1 (I1_I1712_P19_12 I1_I1712_P15_12n XI1_I1712_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I140_XP_MP0 (XI1_I1712_I140_XP_p1 I1_I1712_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I140_XP_MP1 (I1_I1712_P15_8 I1_I1712_P11_8n XI1_I1712_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I156_XP_MP0 (XI1_I1528_I156_XP_p1 I1_I1528_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I156_XP_MP1 (I1_I1528_P31_24 I1_I1528_P27_24n XI1_I1528_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I136_XP_MP0 (XI1_I1712_I136_XP_p1 I1_I1712_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I136_XP_MP1 (I1_I1712_P11_4 I1_I1712_P7_4n XI1_I1712_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I154_XP_MP0 (XI1_I1528_I154_XP_p1 I1_I1528_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I154_XP_MP1 (I1_I1528_P29_22 I1_I1528_P25_22n XI1_I1528_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I152_XP_MP0 (XI1_I1528_I152_XP_p1 I1_I1528_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I152_XP_MP1 (I1_I1528_P27_20 I1_I1528_P23_20n XI1_I1528_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I148_XP_MP0 (XI1_I1528_I148_XP_p1 I1_I1528_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I148_XP_MP1 (I1_I1528_P23_16 I1_I1528_P19_16n XI1_I1528_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I144_XP_MP0 (XI1_I1528_I144_XP_p1 I1_I1528_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I144_XP_MP1 (I1_I1528_P19_12 I1_I1528_P15_12n XI1_I1528_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I146_XP_MP0 (XI1_I1528_I146_XP_p1 I1_I1528_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I146_XP_MP1 (I1_I1528_P21_14 I1_I1528_P17_14n XI1_I1528_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I140_XP_MP0 (XI1_I1528_I140_XP_p1 I1_I1528_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I140_XP_MP1 (I1_I1528_P15_8 I1_I1528_P11_8n XI1_I1528_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I142_XP_MP0 (XI1_I1528_I142_XP_p1 I1_I1528_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I142_XP_MP1 (I1_I1528_P17_10 I1_I1528_P13_10n XI1_I1528_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1528_I136_XP_MP0 (XI1_I1528_I136_XP_p1 I1_I1528_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1528_I136_XP_MP1 (I1_I1528_P11_4 I1_I1528_P7_4n XI1_I1528_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I152_XP_MP0 (XI1_I1574_I152_XP_p1 I1_I1574_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I152_XP_MP1 (I1_I1574_P27_20 I1_I1574_P23_20n XI1_I1574_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I148_XP_MP0 (XI1_I1574_I148_XP_p1 I1_I1574_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I148_XP_MP1 (I1_I1574_P23_16 I1_I1574_P19_16n XI1_I1574_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I81_XP_MP0 (XI1_I1574_I81_XP_p1 I1_I1574_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I81_XP_MP1 (I1_I1574_P15_14 I1_I1574_pn14 XI1_I1574_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I78_XP_MP0 (XI1_I1574_I78_XP_p1 I1_I1574_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I78_XP_MP1 (I1_I1574_P12_11 I1_I1574_pn11 XI1_I1574_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I136_XP_MP0 (XI1_I1574_I136_XP_p1 I1_I1574_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I136_XP_MP1 (I1_I1574_P11_4 I1_I1574_P7_4n XI1_I1574_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I75_XP_MP0 (XI1_I1574_I75_XP_p1 I1_I1574_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I75_XP_MP1 (I1_I1574_P9_8 I1_I1574_pn8 XI1_I1574_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I73_XP_MP0 (XI1_I1574_I73_XP_p1 I1_I1574_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I73_XP_MP1 (I1_I1574_P7_6 I1_I1574_pn6 XI1_I1574_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2275_MP0 (XI1_I2275_p1 B_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2275_MP1 (I1_z0_13 B_27 XI1_I2275_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2274_MP0 (XI1_I2274_p1 B_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2274_MP1 (I1_z0_12 B_25 XI1_I2274_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2289_MP0 (XI1_I2289_p1 I1_z1_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2289_MP1 (I1_z2_3 I1_z1_7 XI1_I2289_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I295_MP0 (XI2_I3_I295_p1 I2_I3_o17_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I295_MP1 (I2_I3_q17_1 I2_I3_o17_1 XI2_I3_I295_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I110_MP0 (XI2_I2_I110_p1 A_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I110_MP1 (I2_I2_nor18 B_18 XI2_I2_I110_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I283_MP0 (XI2_I3_I283_p1 I2_I3_o16_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I283_MP1 (I2_I3_q16_1 I2_I3_o16_1 XI2_I3_I283_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I140_MP0 (XI2_I2_I140_p1 A_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I140_MP1 (I2_I2_nor23 B_23 XI2_I2_I140_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I367_MP0 (XI2_I3_I367_p1 I2_I3_o23_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I367_MP1 (I2_I3_q23_1 I2_I3_o23_1 XI2_I3_I367_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I355_MP0 (XI2_I3_I355_p1 I2_I3_o22_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I355_MP1 (I2_I3_q22_1 I2_I3_o22_1 XI2_I3_I355_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I50_MP0 (XI2_I4_I50_p1 I2_I4_z1_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I50_MP1 (I2_I4_z2_2 I2_I4_z1_5 XI2_I4_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I134_MP0 (XI2_I2_I134_p1 A_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I134_MP1 (I2_I2_nor22 B_22 XI2_I2_I134_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I8_MP0 (XI2_I4_I8_p1 Y_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I8_MP1 (I2_I4_z0_8 Y_17 XI2_I4_I8_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I164_MP0 (XI2_I2_I164_p1 A_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I164_MP1 (I2_I2_nor27 B_27 XI2_I2_I164_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I176_MP0 (XI2_I2_I176_p1 A_29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I176_MP1 (I2_I2_nor29 B_29 XI2_I2_I176_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I134_XP_MP0 (XI1_I562_I134_XP_p1 I1_I562_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I134_XP_MP1 (I1_I562_P9_2 I1_I562_P5_2n XI1_I562_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I85_XP_MP0 (XI1_I562_I85_XP_p1 I1_I562_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I85_XP_MP1 (I1_I562_P19_18 I1_I562_pn18 XI1_I562_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I87_XP_MP0 (XI1_I562_I87_XP_p1 I1_I562_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I87_XP_MP1 (I1_I562_P21_20 I1_I562_pn20 XI1_I562_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I89_XP_MP0 (XI1_I562_I89_XP_p1 I1_I562_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I89_XP_MP1 (I1_I562_P23_22 I1_I562_pn22 XI1_I562_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I93_XP_MP0 (XI1_I562_I93_XP_p1 I1_I562_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I93_XP_MP1 (I1_I562_P27_26 I1_I562_pn26 XI1_I562_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I97_XP_MP0 (XI1_I1712_I97_XP_p1 I1_I1712_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I97_XP_MP1 (I1_I1712_P31_30 I1_I1712_pn30 XI1_I1712_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I154_XP_MP0 (XI1_I1712_I154_XP_p1 I1_I1712_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I154_XP_MP1 (I1_I1712_P29_22 I1_I1712_P25_22n XI1_I1712_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I150_XP_MP0 (XI1_I1712_I150_XP_p1 I1_I1712_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I150_XP_MP1 (I1_I1712_P25_18 I1_I1712_P21_18n XI1_I1712_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I146_XP_MP0 (XI1_I1712_I146_XP_p1 I1_I1712_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I146_XP_MP1 (I1_I1712_P21_14 I1_I1712_P17_14n XI1_I1712_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I134_XP_MP0 (XI1_I1712_I134_XP_p1 I1_I1712_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I134_XP_MP1 (I1_I1712_P9_2 I1_I1712_P5_2n XI1_I1712_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I156_XP_MP0 (XI1_I1574_I156_XP_p1 I1_I1574_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I156_XP_MP1 (I1_I1574_P31_24 I1_I1574_P27_24n XI1_I1574_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I146_XP_MP0 (XI1_I1574_I146_XP_p1 I1_I1574_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I146_XP_MP1 (I1_I1574_P21_14 I1_I1574_P17_14n XI1_I1574_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I142_XP_MP0 (XI1_I1574_I142_XP_p1 I1_I1574_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I142_XP_MP1 (I1_I1574_P17_10 I1_I1574_P13_10n XI1_I1574_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I138_XP_MP0 (XI1_I1574_I138_XP_p1 I1_I1574_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I138_XP_MP1 (I1_I1574_P13_6 I1_I1574_P9_6n XI1_I1574_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I134_XP_MP0 (XI1_I1574_I134_XP_p1 I1_I1574_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I134_XP_MP1 (I1_I1574_P9_2 I1_I1574_P5_2n XI1_I1574_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I71_XP_MP0 (XI1_I1574_I71_XP_p1 I1_I1574_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I71_XP_MP1 (I1_I1574_P5_4 I1_I1574_pn4 XI1_I1574_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2266_MP0 (XI1_I2266_p1 B_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2266_MP1 (I1_z0_4 B_9 XI1_I2266_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2287_MP0 (XI1_I2287_p1 I1_z1_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2287_MP1 (I1_z2_1 I1_z1_3 XI1_I2287_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2268_MP0 (XI1_I2268_p1 B_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2268_MP1 (I1_z0_6 B_13 XI1_I2268_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2269_MP0 (XI1_I2269_p1 B_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2269_MP1 (I1_z0_7 B_15 XI1_I2269_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I82_XP_MP0 (XI2_I1_I42_I82_XP_p1 I2_I1_I42_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I82_XP_MP1 (I2_I1_I42_P16_15 I2_I1_I42_pn15 XI2_I1_I42_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I83_XP_MP0 (XI2_I1_I42_I83_XP_p1 I2_I1_I42_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I83_XP_MP1 (I2_I1_I42_P17_16 I2_I1_I42_pn16 XI2_I1_I42_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I84_XP_MP0 (XI2_I1_I42_I84_XP_p1 I2_I1_I42_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I84_XP_MP1 (I2_I1_I42_P18_17 I2_I1_I42_pn17 XI2_I1_I42_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I104_MP0 (XI2_I2_I104_p1 A_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I104_MP1 (I2_I2_nor17 B_17 XI2_I2_I104_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I98_MP0 (XI2_I2_I98_p1 A_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I98_MP1 (I2_I2_nor16 B_16 XI2_I2_I98_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2288_MP0 (XI1_I2288_p1 I1_z1_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2288_MP1 (I1_z2_2 I1_z1_5 XI1_I2288_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2273_MP0 (XI1_I2273_p1 B_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2273_MP1 (I1_z0_11 B_23 XI1_I2273_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2272_MP0 (XI1_I2272_p1 B_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2272_MP1 (I1_z0_10 B_21 XI1_I2272_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I152_MP0 (XI2_I2_I152_p1 A_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I152_MP1 (I2_I2_nor25 B_25 XI2_I2_I152_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I391_MP0 (XI2_I3_I391_p1 I2_I3_o25_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I391_MP1 (I2_I3_q25_1 I2_I3_o25_1 XI2_I3_I391_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I136_XP_MP0 (XI1_I562_I136_XP_p1 I1_I562_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I136_XP_MP1 (I1_I562_P11_4 I1_I562_P7_4n XI1_I562_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I138_XP_MP0 (XI1_I562_I138_XP_p1 I1_I562_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I138_XP_MP1 (I1_I562_P13_6 I1_I562_P9_6n XI1_I562_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I142_XP_MP0 (XI1_I562_I142_XP_p1 I1_I562_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I142_XP_MP1 (I1_I562_P17_10 I1_I562_P13_10n XI1_I562_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I146_XP_MP0 (XI1_I562_I146_XP_p1 I1_I562_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I146_XP_MP1 (I1_I562_P21_14 I1_I562_P17_14n XI1_I562_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I150_XP_MP0 (XI1_I562_I150_XP_p1 I1_I562_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I150_XP_MP1 (I1_I562_P25_18 I1_I562_P21_18n XI1_I562_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I148_XP_MP0 (XI1_I562_I148_XP_p1 I1_I562_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I148_XP_MP1 (I1_I562_P23_16 I1_I562_P19_16n XI1_I562_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I154_XP_MP0 (XI1_I562_I154_XP_p1 I1_I562_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I154_XP_MP1 (I1_I562_P29_22 I1_I562_P25_22n XI1_I562_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I91_XP_MP0 (XI1_I562_I91_XP_p1 I1_I562_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I91_XP_MP1 (I1_I562_P25_24 I1_I562_pn24 XI1_I562_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I95_XP_MP0 (XI1_I1712_I95_XP_p1 I1_I1712_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I95_XP_MP1 (I1_I1712_P29_28 I1_I1712_pn28 XI1_I1712_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I93_XP_MP0 (XI1_I1712_I93_XP_p1 I1_I1712_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I93_XP_MP1 (I1_I1712_P27_26 I1_I1712_pn26 XI1_I1712_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I142_XP_MP0 (XI1_I1712_I142_XP_p1 I1_I1712_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I142_XP_MP1 (I1_I1712_P17_10 I1_I1712_P13_10n XI1_I1712_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I138_XP_MP0 (XI1_I1712_I138_XP_p1 I1_I1712_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I138_XP_MP1 (I1_I1712_P13_6 I1_I1712_P9_6n XI1_I1712_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I97_XP_MP0 (XI1_I1574_I97_XP_p1 I1_I1574_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I97_XP_MP1 (I1_I1574_P31_30 I1_I1574_pn30 XI1_I1574_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I154_XP_MP0 (XI1_I1574_I154_XP_p1 I1_I1574_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I154_XP_MP1 (I1_I1574_P29_22 I1_I1574_P25_22n XI1_I1574_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I150_XP_MP0 (XI1_I1574_I150_XP_p1 I1_I1574_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I150_XP_MP1 (I1_I1574_P25_18 I1_I1574_P21_18n XI1_I1574_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I83_XP_MP0 (XI1_I1574_I83_XP_p1 I1_I1574_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I83_XP_MP1 (I1_I1574_P17_16 I1_I1574_pn16 XI1_I1574_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I80_XP_MP0 (XI1_I1574_I80_XP_p1 I1_I1574_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I80_XP_MP1 (I1_I1574_P14_13 I1_I1574_pn13 XI1_I1574_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I76_XP_MP0 (XI1_I1574_I76_XP_p1 I1_I1574_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I76_XP_MP1 (I1_I1574_P10_9 I1_I1574_pn9 XI1_I1574_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I74_XP_MP0 (XI1_I1574_I74_XP_p1 I1_I1574_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I74_XP_MP1 (I1_I1574_P8_7 I1_I1574_pn7 XI1_I1574_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I72_XP_MP0 (XI1_I1574_I72_XP_p1 I1_I1574_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I72_XP_MP1 (I1_I1574_P6_5 I1_I1574_pn5 XI1_I1574_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I69_XP_MP0 (XI1_I1574_I69_XP_p1 I1_I1574_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I69_XP_MP1 (I1_I1574_P3_2 I1_I1574_pn2 XI1_I1574_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I80_MP0 (XI2_I2_I80_p1 A_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I80_MP1 (I2_I2_nor13 B_13 XI2_I2_I80_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I247_MP0 (XI2_I3_I247_p1 I2_I3_o13_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I247_MP1 (I2_I3_q13_1 I2_I3_o13_1 XI2_I3_I247_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I271_MP0 (XI2_I3_I271_p1 I2_I3_o15_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I271_MP1 (I2_I3_q15_1 I2_I3_o15_1 XI2_I3_I271_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I92_MP0 (XI2_I2_I92_p1 A_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I92_MP1 (I2_I2_nor15 B_15 XI2_I2_I92_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2267_MP0 (XI1_I2267_p1 B_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2267_MP1 (I1_z0_5 B_11 XI1_I2267_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I80_XP_MP0 (XI2_I1_I42_I80_XP_p1 I2_I1_I42_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I80_XP_MP1 (I2_I1_I42_P14_13 I2_I1_I42_pn13 XI2_I1_I42_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I145_XP_MP0 (XI2_I1_I42_I145_XP_p1 I2_I1_I42_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I145_XP_MP1 (I2_I1_I42_P20_13 I2_I1_I42_P16_13n XI2_I1_I42_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I149_XP_MP0 (XI2_I1_I42_I149_XP_p1 I2_I1_I42_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I149_XP_MP1 (I2_I1_I42_P24_17 I2_I1_I42_P20_17n XI2_I1_I42_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I147_XP_MP0 (XI2_I1_I42_I147_XP_p1 I2_I1_I42_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I147_XP_MP1 (I2_I1_I42_P22_15 I2_I1_I42_P18_15n XI2_I1_I42_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I153_XP_MP0 (XI2_I1_I42_I153_XP_p1 I2_I1_I42_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I153_XP_MP1 (I2_I1_I42_P28_21 I2_I1_I42_P24_21n XI2_I1_I42_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I89_XP_MP0 (XI2_I1_I42_I89_XP_p1 I2_I1_I42_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I89_XP_MP1 (I2_I1_I42_P23_22 I2_I1_I42_pn22 XI2_I1_I42_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I90_XP_MP0 (XI2_I1_I42_I90_XP_p1 I2_I1_I42_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I90_XP_MP1 (I2_I1_I42_P24_23 I2_I1_I42_pn23 XI2_I1_I42_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I92_XP_MP0 (XI2_I1_I42_I92_XP_p1 I2_I1_I42_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I92_XP_MP1 (I2_I1_I42_P26_25 I2_I1_I42_pn25 XI2_I1_I42_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2292_MP0 (XI1_I2292_p1 I1_z3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2292_MP1 (DIVDZ I1_z3_1 XI1_I2292_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2295_MP0 (XI1_I2295_p1 I1_vn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2295_MP1 (DIVV DIVDZ XI1_I2295_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2271_MP0 (XI1_I2271_p1 B_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2271_MP1 (I1_z0_9 B_19 XI1_I2271_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2270_MP0 (XI1_I2270_p1 B_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2270_MP1 (I1_z0_8 B_17 XI1_I2270_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I379_MP0 (XI2_I3_I379_p1 I2_I3_o24_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I379_MP1 (I2_I3_q24_1 I2_I3_o24_1 XI2_I3_I379_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I415_MP0 (XI2_I3_I415_p1 I2_I3_o27_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I415_MP1 (I2_I3_q27_1 I2_I3_o27_1 XI2_I3_I415_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I439_MP0 (XI2_I3_I439_p1 I2_I3_o29_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I439_MP1 (I2_I3_q29_1 I2_I3_o29_1 XI2_I3_I439_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I427_MP0 (XI2_I3_I427_p1 I2_I3_o28_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I427_MP1 (I2_I3_q28_1 I2_I3_o28_1 XI2_I3_I427_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I140_XP_MP0 (XI1_I562_I140_XP_p1 I1_I562_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I140_XP_MP1 (I1_I562_P15_8 I1_I562_P11_8n XI1_I562_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I144_XP_MP0 (XI1_I562_I144_XP_p1 I1_I562_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I144_XP_MP1 (I1_I562_P19_12 I1_I562_P15_12n XI1_I562_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I152_XP_MP0 (XI1_I562_I152_XP_p1 I1_I562_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I152_XP_MP1 (I1_I562_P27_20 I1_I562_P23_20n XI1_I562_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I156_XP_MP0 (XI1_I562_I156_XP_p1 I1_I562_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I562_I156_XP_MP1 (I1_I562_P31_24 I1_I562_P27_24n XI1_I562_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I94_XP_MP0 (XI1_I1712_I94_XP_p1 I1_I1712_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I94_XP_MP1 (I1_I1712_P28_27 I1_I1712_pn27 XI1_I1712_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I92_XP_MP0 (XI1_I1712_I92_XP_p1 I1_I1712_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I92_XP_MP1 (I1_I1712_P26_25 I1_I1712_pn25 XI1_I1712_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I91_XP_MP0 (XI1_I1712_I91_XP_p1 I1_I1712_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I91_XP_MP1 (I1_I1712_P25_24 I1_I1712_pn24 XI1_I1712_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I153_XP_MP0 (XI1_I1712_I153_XP_p1 I1_I1712_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I153_XP_MP1 (I1_I1712_P28_21 I1_I1712_P24_21n XI1_I1712_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I137_XP_MP0 (XI1_I1712_I137_XP_p1 I1_I1712_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I137_XP_MP1 (I1_I1712_P12_5 I1_I1712_P8_5n XI1_I1712_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I77_XP_MP0 (XI1_I1712_I77_XP_p1 I1_I1712_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I77_XP_MP1 (I1_I1712_P11_10 I1_I1712_pn10 XI1_I1712_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I75_XP_MP0 (XI1_I1712_I75_XP_p1 I1_I1712_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I75_XP_MP1 (I1_I1712_P9_8 I1_I1712_pn8 XI1_I1712_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I73_XP_MP0 (XI1_I1712_I73_XP_p1 I1_I1712_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I73_XP_MP1 (I1_I1712_P7_6 I1_I1712_pn6 XI1_I1712_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I133_XP_MP0 (XI1_I1712_I133_XP_p1 I1_I1712_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I133_XP_MP1 (I1_I1712_P8_1 I1_I1712_P4_1n XI1_I1712_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I71_XP_MP0 (XI1_I1712_I71_XP_p1 I1_I1712_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I71_XP_MP1 (I1_I1712_P5_4 I1_I1712_pn4 XI1_I1712_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I72_XP_MP0 (XI1_I1712_I72_XP_p1 I1_I1712_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I72_XP_MP1 (I1_I1712_P6_5 I1_I1712_pn5 XI1_I1712_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I70_XP_MP0 (XI1_I1712_I70_XP_p1 I1_I1712_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I70_XP_MP1 (I1_I1712_P4_3 I1_I1712_pn3 XI1_I1712_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I69_XP_MP0 (XI1_I1712_I69_XP_p1 I1_I1712_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I69_XP_MP1 (I1_I1712_P3_2 I1_I1712_pn2 XI1_I1712_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I95_XP_MP0 (XI1_I1574_I95_XP_p1 I1_I1574_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I95_XP_MP1 (I1_I1574_P29_28 I1_I1574_pn28 XI1_I1574_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I93_XP_MP0 (XI1_I1574_I93_XP_p1 I1_I1574_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I93_XP_MP1 (I1_I1574_P27_26 I1_I1574_pn26 XI1_I1574_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I96_XP_MP0 (XI1_I1574_I96_XP_p1 I1_I1574_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I96_XP_MP1 (I1_I1574_P30_29 I1_I1574_pn29 XI1_I1574_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I94_XP_MP0 (XI1_I1574_I94_XP_p1 I1_I1574_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I94_XP_MP1 (I1_I1574_P28_27 I1_I1574_pn27 XI1_I1574_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I85_XP_MP0 (XI1_I1574_I85_XP_p1 I1_I1574_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I85_XP_MP1 (I1_I1574_P19_18 I1_I1574_pn18 XI1_I1574_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I82_XP_MP0 (XI1_I1574_I82_XP_p1 I1_I1574_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I82_XP_MP1 (I1_I1574_P16_15 I1_I1574_pn15 XI1_I1574_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I70_XP_MP0 (XI1_I1574_I70_XP_p1 I1_I1574_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I70_XP_MP1 (I1_I1574_P4_3 I1_I1574_pn3 XI1_I1574_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I259_MP0 (XI2_I3_I259_p1 I2_I3_o14_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I259_MP1 (I2_I3_q14_1 I2_I3_o14_1 XI2_I3_I259_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I79_XP_MP0 (XI2_I1_I42_I79_XP_p1 I2_I1_I42_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I79_XP_MP1 (I2_I1_I42_P13_12 I2_I1_I42_pn12 XI2_I1_I42_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I139_XP_MP0 (XI2_I1_I42_I139_XP_p1 I2_I1_I42_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I139_XP_MP1 (I2_I1_I42_P14_7 I2_I1_I42_P10_7n XI2_I1_I42_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I81_XP_MP0 (XI2_I1_I42_I81_XP_p1 I2_I1_I42_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I81_XP_MP1 (I2_I1_I42_P15_14 I2_I1_I42_pn14 XI2_I1_I42_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I143_XP_MP0 (XI2_I1_I42_I143_XP_p1 I2_I1_I42_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I143_XP_MP1 (I2_I1_I42_P18_11 I2_I1_I42_P14_11n XI2_I1_I42_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I151_XP_MP0 (XI2_I1_I42_I151_XP_p1 I2_I1_I42_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I151_XP_MP1 (I2_I1_I42_P26_19 I2_I1_I42_P22_19n XI2_I1_I42_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I155_XP_MP0 (XI2_I1_I42_I155_XP_p1 I2_I1_I42_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I155_XP_MP1 (I2_I1_I42_P30_23 I2_I1_I42_P26_23n XI2_I1_I42_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I91_XP_MP0 (XI2_I1_I42_I91_XP_p1 I2_I1_I42_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I91_XP_MP1 (I2_I1_I42_P25_24 I2_I1_I42_pn24 XI2_I1_I42_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I93_XP_MP0 (XI2_I1_I42_I93_XP_p1 I2_I1_I42_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I93_XP_MP1 (I2_I1_I42_P27_26 I2_I1_I42_pn26 XI2_I1_I42_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I94_XP_MP0 (XI2_I1_I42_I94_XP_p1 I2_I1_I42_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I94_XP_MP1 (I2_I1_I42_P28_27 I2_I1_I42_pn27 XI2_I1_I42_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I96_XP_MP0 (XI2_I1_I42_I96_XP_p1 I2_I1_I42_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I96_XP_MP1 (I2_I1_I42_P30_29 I2_I1_I42_pn29 XI2_I1_I42_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I0_I13_MP0 (XI2_I0_I13_p1 I2_I0_h00 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I0_I13_MP1 (I2_SEL_OR I2_I0_l11 XI2_I0_I13_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I0_I14_MP0 (XI2_I0_I14_p1 I2_I0_h01 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I0_I14_MP1 (I2_SEL_XOR I2_I0_l00 XI2_I0_I14_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I0_I12_MP0 (XI2_I0_I12_p1 I2_I0_h00 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I0_I12_MP1 (I2_SEL_AND I2_I0_l10 XI2_I0_I12_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I146_MP0 (XI2_I2_I146_p1 A_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I146_MP1 (I2_I2_nor24 B_24 XI2_I2_I146_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I403_MP0 (XI2_I3_I403_p1 I2_I3_o26_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I403_MP1 (I2_I3_q26_1 I2_I3_o26_1 XI2_I3_I403_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I158_MP0 (XI2_I2_I158_p1 A_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I158_MP1 (I2_I2_nor26 B_26 XI2_I2_I158_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I170_MP0 (XI2_I2_I170_p1 A_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I170_MP1 (I2_I2_nor28 B_28 XI2_I2_I170_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I463_MP0 (XI2_I3_I463_p1 I2_I3_o31_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I463_MP1 (I2_I3_q31_1 I2_I3_o31_1 XI2_I3_I463_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I51_MP0 (XI2_I4_I51_p1 I2_I4_z1_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I51_MP1 (I2_I4_z2_3 I2_I4_z1_7 XI2_I4_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I13_MP0 (XI2_I4_I13_p1 Y_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I13_MP1 (I2_I4_z0_13 Y_27 XI2_I4_I13_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I15_MP0 (XI2_I4_I15_p1 Y_30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I15_MP1 (I2_I4_z0_15 Y_31 XI2_I4_I15_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I96_XP_MP0 (XI1_I1712_I96_XP_p1 I1_I1712_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I96_XP_MP1 (I1_I1712_P30_29 I1_I1712_pn29 XI1_I1712_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I151_XP_MP0 (XI1_I1712_I151_XP_p1 I1_I1712_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I151_XP_MP1 (I1_I1712_P26_19 I1_I1712_P22_19n XI1_I1712_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I149_XP_MP0 (XI1_I1712_I149_XP_p1 I1_I1712_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I149_XP_MP1 (I1_I1712_P24_17 I1_I1712_P20_17n XI1_I1712_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I145_XP_MP0 (XI1_I1712_I145_XP_p1 I1_I1712_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I145_XP_MP1 (I1_I1712_P20_13 I1_I1712_P16_13n XI1_I1712_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I141_XP_MP0 (XI1_I1712_I141_XP_p1 I1_I1712_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I141_XP_MP1 (I1_I1712_P16_9 I1_I1712_P12_9n XI1_I1712_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I68_XP_MP0 (XI1_I1712_I68_XP_p1 I1_I1712_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I68_XP_MP1 (I1_I1712_P2_1 I1_I1712_pn1 XI1_I1712_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I91_XP_MP0 (XI1_I1574_I91_XP_p1 I1_I1574_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I91_XP_MP1 (I1_I1574_P25_24 I1_I1574_pn24 XI1_I1574_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I92_XP_MP0 (XI1_I1574_I92_XP_p1 I1_I1574_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I92_XP_MP1 (I1_I1574_P26_25 I1_I1574_pn25 XI1_I1574_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I84_XP_MP0 (XI1_I1574_I84_XP_p1 I1_I1574_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I84_XP_MP1 (I1_I1574_P18_17 I1_I1574_pn17 XI1_I1574_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I153_XP_MP0 (XI1_I1574_I153_XP_p1 I1_I1574_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I153_XP_MP1 (I1_I1574_P28_21 I1_I1574_P24_21n XI1_I1574_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I145_XP_MP0 (XI1_I1574_I145_XP_p1 I1_I1574_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I145_XP_MP1 (I1_I1574_P20_13 I1_I1574_P16_13n XI1_I1574_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I141_XP_MP0 (XI1_I1574_I141_XP_p1 I1_I1574_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I141_XP_MP1 (I1_I1574_P16_9 I1_I1574_P12_9n XI1_I1574_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I137_XP_MP0 (XI1_I1574_I137_XP_p1 I1_I1574_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I137_XP_MP1 (I1_I1574_P12_5 I1_I1574_P8_5n XI1_I1574_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I133_XP_MP0 (XI1_I1574_I133_XP_p1 I1_I1574_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I133_XP_MP1 (I1_I1574_P8_1 I1_I1574_P4_1n XI1_I1574_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I7_MP0 (XI2_I4_I7_p1 Y_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I7_MP1 (I2_I4_z0_7 Y_15 XI2_I4_I7_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I6_MP0 (XI2_I4_I6_p1 Y_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I6_MP1 (I2_I4_z0_6 Y_13 XI2_I4_I6_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I235_MP0 (XI2_I3_I235_p1 I2_I3_o12_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I235_MP1 (I2_I3_q12_1 I2_I3_o12_1 XI2_I3_I235_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I86_MP0 (XI2_I2_I86_p1 A_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I86_MP1 (I2_I2_nor14 B_14 XI2_I2_I86_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I78_XP_MP0 (XI2_I1_I42_I78_XP_p1 I2_I1_I42_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I78_XP_MP1 (I2_I1_I42_P12_11 I2_I1_I42_pn11 XI2_I1_I42_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I141_XP_MP0 (XI2_I1_I42_I141_XP_p1 I2_I1_I42_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I141_XP_MP1 (I2_I1_I42_P16_9 I2_I1_I42_P12_9n XI2_I1_I42_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I144_XP_MP0 (XI2_I1_I42_I144_XP_p1 I2_I1_I42_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I144_XP_MP1 (I2_I1_I42_P19_12 I2_I1_I42_P15_12n XI2_I1_I42_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I148_XP_MP0 (XI2_I1_I42_I148_XP_p1 I2_I1_I42_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I148_XP_MP1 (I2_I1_I42_P23_16 I2_I1_I42_P19_16n XI2_I1_I42_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I152_XP_MP0 (XI2_I1_I42_I152_XP_p1 I2_I1_I42_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I152_XP_MP1 (I2_I1_I42_P27_20 I2_I1_I42_P23_20n XI2_I1_I42_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I154_XP_MP0 (XI2_I1_I42_I154_XP_p1 I2_I1_I42_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I154_XP_MP1 (I2_I1_I42_P29_22 I2_I1_I42_P25_22n XI2_I1_I42_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I95_XP_MP0 (XI2_I1_I42_I95_XP_p1 I2_I1_I42_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I95_XP_MP1 (I2_I1_I42_P29_28 I2_I1_I42_pn28 XI2_I1_I42_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I97_XP_MP0 (XI2_I1_I42_I97_XP_p1 I2_I1_I42_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I97_XP_MP1 (I2_I1_I42_P31_30 I2_I1_I42_pn30 XI2_I1_I42_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I0_I11_MP0 (XI2_I0_I11_p1 I2_I0_h00 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I0_I11_MP1 (I2_SEL_AS OP_1 XI2_I0_I11_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I0_I17_MP0 (XI2_I0_I17_p1 I2_I0_h10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I0_I17_MP1 (I2_SEL_DIV I2_I0_l11 XI2_I0_I17_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I0_I16_MP0 (XI2_I0_I16_p1 I2_I0_h10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I0_I16_MP1 (I2_SEL_MUL I2_I0_l01 XI2_I0_I16_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I0_I15_MP0 (XI2_I0_I15_p1 I2_I0_h01 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I0_I15_MP1 (I2_SEL_NOT I2_I0_l01 XI2_I0_I15_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I182_MP0 (XI2_I2_I182_p1 A_30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I182_MP1 (I2_I2_nor30 B_30 XI2_I2_I182_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I451_MP0 (XI2_I3_I451_p1 I2_I3_o30_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I451_MP1 (I2_I3_q30_1 I2_I3_o30_1 XI2_I3_I451_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I188_MP0 (XI2_I2_I188_p1 A_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I188_MP1 (I2_I2_nor31 B_31 XI2_I2_I188_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I90_XP_MP0 (XI1_I1712_I90_XP_p1 I1_I1712_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I90_XP_MP1 (I1_I1712_P24_23 I1_I1712_pn23 XI1_I1712_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I155_XP_MP0 (XI1_I1712_I155_XP_p1 I1_I1712_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I155_XP_MP1 (I1_I1712_P30_23 I1_I1712_P26_23n XI1_I1712_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I147_XP_MP0 (XI1_I1712_I147_XP_p1 I1_I1712_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I147_XP_MP1 (I1_I1712_P22_15 I1_I1712_P18_15n XI1_I1712_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I143_XP_MP0 (XI1_I1712_I143_XP_p1 I1_I1712_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I143_XP_MP1 (I1_I1712_P18_11 I1_I1712_P14_11n XI1_I1712_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I139_XP_MP0 (XI1_I1712_I139_XP_p1 I1_I1712_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I139_XP_MP1 (I1_I1712_P14_7 I1_I1712_P10_7n XI1_I1712_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I135_XP_MP0 (XI1_I1712_I135_XP_p1 I1_I1712_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I135_XP_MP1 (I1_I1712_P10_3 I1_I1712_P6_3n XI1_I1712_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I74_XP_MP0 (XI1_I1712_I74_XP_p1 I1_I1712_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I74_XP_MP1 (I1_I1712_P8_7 I1_I1712_pn7 XI1_I1712_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I89_XP_MP0 (XI1_I1574_I89_XP_p1 I1_I1574_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I89_XP_MP1 (I1_I1574_P23_22 I1_I1574_pn22 XI1_I1574_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I90_XP_MP0 (XI1_I1574_I90_XP_p1 I1_I1574_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I90_XP_MP1 (I1_I1574_P24_23 I1_I1574_pn23 XI1_I1574_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I149_XP_MP0 (XI1_I1574_I149_XP_p1 I1_I1574_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I149_XP_MP1 (I1_I1574_P24_17 I1_I1574_P20_17n XI1_I1574_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I68_XP_MP0 (XI1_I1574_I68_XP_p1 I1_I1574_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I68_XP_MP1 (I1_I1574_P2_1 I1_I1574_pn1 XI1_I1574_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I74_MP0 (XI2_I2_I74_p1 A_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I74_MP1 (I2_I2_nor12 B_12 XI2_I2_I74_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I68_MP0 (XI2_I2_I68_p1 A_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I68_MP1 (I2_I2_nor11 B_11 XI2_I2_I68_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I223_MP0 (XI2_I3_I223_p1 I2_I3_o11_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I223_MP1 (I2_I3_q11_1 I2_I3_o11_1 XI2_I3_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2265_MP0 (XI1_I2265_p1 B_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2265_MP1 (I1_z0_3 B_7 XI1_I2265_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I77_XP_MP0 (XI2_I1_I42_I77_XP_p1 I2_I1_I42_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I77_XP_MP1 (I2_I1_I42_P11_10 I2_I1_I42_pn10 XI2_I1_I42_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I137_XP_MP0 (XI2_I1_I42_I137_XP_p1 I2_I1_I42_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I137_XP_MP1 (I2_I1_I42_P12_5 I2_I1_I42_P8_5n XI2_I1_I42_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I140_XP_MP0 (XI2_I1_I42_I140_XP_p1 I2_I1_I42_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I140_XP_MP1 (I2_I1_I42_P15_8 I2_I1_I42_P11_8n XI2_I1_I42_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I146_XP_MP0 (XI2_I1_I42_I146_XP_p1 I2_I1_I42_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I146_XP_MP1 (I2_I1_I42_P21_14 I2_I1_I42_P17_14n XI2_I1_I42_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I150_XP_MP0 (XI2_I1_I42_I150_XP_p1 I2_I1_I42_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I150_XP_MP1 (I2_I1_I42_P25_18 I2_I1_I42_P21_18n XI2_I1_I42_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I156_XP_MP0 (XI2_I1_I42_I156_XP_p1 I2_I1_I42_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I156_XP_MP1 (I2_I1_I42_P31_24 I2_I1_I42_P27_24n XI2_I1_I42_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I89_XP_MP0 (XI1_I1712_I89_XP_p1 I1_I1712_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I89_XP_MP1 (I1_I1712_P23_22 I1_I1712_pn22 XI1_I1712_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I88_XP_MP0 (XI1_I1712_I88_XP_p1 I1_I1712_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I88_XP_MP1 (I1_I1712_P22_21 I1_I1712_pn21 XI1_I1712_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I86_XP_MP0 (XI1_I1712_I86_XP_p1 I1_I1712_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I86_XP_MP1 (I1_I1712_P20_19 I1_I1712_pn19 XI1_I1712_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I85_XP_MP0 (XI1_I1712_I85_XP_p1 I1_I1712_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I85_XP_MP1 (I1_I1712_P19_18 I1_I1712_pn18 XI1_I1712_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I78_XP_MP0 (XI1_I1712_I78_XP_p1 I1_I1712_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I78_XP_MP1 (I1_I1712_P12_11 I1_I1712_pn11 XI1_I1712_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I76_XP_MP0 (XI1_I1712_I76_XP_p1 I1_I1712_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I76_XP_MP1 (I1_I1712_P10_9 I1_I1712_pn9 XI1_I1712_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I87_XP_MP0 (XI1_I1574_I87_XP_p1 I1_I1574_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I87_XP_MP1 (I1_I1574_P21_20 I1_I1574_pn20 XI1_I1574_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I86_XP_MP0 (XI1_I1574_I86_XP_p1 I1_I1574_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I86_XP_MP1 (I1_I1574_P20_19 I1_I1574_pn19 XI1_I1574_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I155_XP_MP0 (XI1_I1574_I155_XP_p1 I1_I1574_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I155_XP_MP1 (I1_I1574_P30_23 I1_I1574_P26_23n XI1_I1574_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I88_XP_MP0 (XI1_I1574_I88_XP_p1 I1_I1574_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I88_XP_MP1 (I1_I1574_P22_21 I1_I1574_pn21 XI1_I1574_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I151_XP_MP0 (XI1_I1574_I151_XP_p1 I1_I1574_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I151_XP_MP1 (I1_I1574_P26_19 I1_I1574_P22_19n XI1_I1574_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I147_XP_MP0 (XI1_I1574_I147_XP_p1 I1_I1574_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I147_XP_MP1 (I1_I1574_P22_15 I1_I1574_P18_15n XI1_I1574_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I143_XP_MP0 (XI1_I1574_I143_XP_p1 I1_I1574_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I143_XP_MP1 (I1_I1574_P18_11 I1_I1574_P14_11n XI1_I1574_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I139_XP_MP0 (XI1_I1574_I139_XP_p1 I1_I1574_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I139_XP_MP1 (I1_I1574_P14_7 I1_I1574_P10_7n XI1_I1574_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I135_XP_MP0 (XI1_I1574_I135_XP_p1 I1_I1574_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1574_I135_XP_MP1 (I1_I1574_P10_3 I1_I1574_P6_3n XI1_I1574_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2286_MP0 (XI1_I2286_p1 I1_z1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2286_MP1 (I1_z2_0 I1_z1_1 XI1_I2286_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2263_MP0 (XI1_I2263_p1 B_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2263_MP1 (I1_z0_1 B_3 XI1_I2263_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2264_MP0 (XI1_I2264_p1 B_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2264_MP1 (I1_z0_2 B_5 XI1_I2264_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I76_XP_MP0 (XI2_I1_I42_I76_XP_p1 I2_I1_I42_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I76_XP_MP1 (I2_I1_I42_P10_9 I2_I1_I42_pn9 XI2_I1_I42_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I135_XP_MP0 (XI2_I1_I42_I135_XP_p1 I2_I1_I42_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I135_XP_MP1 (I2_I1_I42_P10_3 I2_I1_I42_P6_3n XI2_I1_I42_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I138_XP_MP0 (XI2_I1_I42_I138_XP_p1 I2_I1_I42_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I138_XP_MP1 (I2_I1_I42_P13_6 I2_I1_I42_P9_6n XI2_I1_I42_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I136_XP_MP0 (XI2_I1_I42_I136_XP_p1 I2_I1_I42_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I136_XP_MP1 (I2_I1_I42_P11_4 I2_I1_I42_P7_4n XI2_I1_I42_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I142_XP_MP0 (XI2_I1_I42_I142_XP_p1 I2_I1_I42_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I142_XP_MP1 (I2_I1_I42_P17_10 I2_I1_I42_P13_10n XI2_I1_I42_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I87_XP_MP0 (XI1_I1712_I87_XP_p1 I1_I1712_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I87_XP_MP1 (I1_I1712_P21_20 I1_I1712_pn20 XI1_I1712_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I84_XP_MP0 (XI1_I1712_I84_XP_p1 I1_I1712_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I84_XP_MP1 (I1_I1712_P18_17 I1_I1712_pn17 XI1_I1712_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I81_XP_MP0 (XI1_I1712_I81_XP_p1 I1_I1712_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I81_XP_MP1 (I1_I1712_P15_14 I1_I1712_pn14 XI1_I1712_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I83_XP_MP0 (XI1_I1712_I83_XP_p1 I1_I1712_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I83_XP_MP1 (I1_I1712_P17_16 I1_I1712_pn16 XI1_I1712_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I82_XP_MP0 (XI1_I1712_I82_XP_p1 I1_I1712_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I82_XP_MP1 (I1_I1712_P16_15 I1_I1712_pn15 XI1_I1712_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I79_XP_MP0 (XI1_I1712_I79_XP_p1 I1_I1712_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I79_XP_MP1 (I1_I1712_P13_12 I1_I1712_pn12 XI1_I1712_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I80_XP_MP0 (XI1_I1712_I80_XP_p1 I1_I1712_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1712_I80_XP_MP1 (I1_I1712_P14_13 I1_I1712_pn13 XI1_I1712_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I68_XP_MP0 (XI1_I1666_I68_XP_p1 I1_I1666_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I68_XP_MP1 (I1_I1666_P2_1 I1_I1666_pn1 XI1_I1666_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I70_XP_MP0 (XI1_I1666_I70_XP_p1 I1_I1666_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I70_XP_MP1 (I1_I1666_P4_3 I1_I1666_pn3 XI1_I1666_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I69_XP_MP0 (XI1_I1666_I69_XP_p1 I1_I1666_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I69_XP_MP1 (I1_I1666_P3_2 I1_I1666_pn2 XI1_I1666_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2262_MP0 (XI1_I2262_p1 I1_B_0_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2262_MP1 (I1_z0_0 B_1 XI1_I2262_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I75_XP_MP0 (XI2_I1_I42_I75_XP_p1 I2_I1_I42_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I75_XP_MP1 (I2_I1_I42_P9_8 I2_I1_I42_pn8 XI2_I1_I42_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I74_XP_MP0 (XI2_I1_I42_I74_XP_p1 I2_I1_I42_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I74_XP_MP1 (I2_I1_I42_P8_7 I2_I1_I42_pn7 XI2_I1_I42_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I133_XP_MP0 (XI2_I1_I42_I133_XP_p1 I2_I1_I42_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I133_XP_MP1 (I2_I1_I42_P8_1 I2_I1_I42_P4_1n XI2_I1_I42_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I134_XP_MP0 (XI2_I1_I42_I134_XP_p1 I2_I1_I42_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I134_XP_MP1 (I2_I1_I42_P9_2 I2_I1_I42_P5_2n XI2_I1_I42_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I72_XP_MP0 (XI1_I1666_I72_XP_p1 I1_I1666_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I72_XP_MP1 (I1_I1666_P6_5 I1_I1666_pn5 XI1_I1666_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I71_XP_MP0 (XI1_I1666_I71_XP_p1 I1_I1666_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I71_XP_MP1 (I1_I1666_P5_4 I1_I1666_pn4 XI1_I1666_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I73_XP_MP0 (XI2_I1_I42_I73_XP_p1 I2_I1_I42_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I73_XP_MP1 (I2_I1_I42_P7_6 I2_I1_I42_pn6 XI2_I1_I42_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I72_XP_MP0 (XI2_I1_I42_I72_XP_p1 I2_I1_I42_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I72_XP_MP1 (I2_I1_I42_P6_5 I2_I1_I42_pn5 XI2_I1_I42_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I135_XP_MP0 (XI1_I1666_I135_XP_p1 I1_I1666_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I135_XP_MP1 (I1_I1666_P10_3 I1_I1666_P6_3n XI1_I1666_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I133_XP_MP0 (XI1_I1666_I133_XP_p1 I1_I1666_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I133_XP_MP1 (I1_I1666_P8_1 I1_I1666_P4_1n XI1_I1666_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I74_XP_MP0 (XI1_I1666_I74_XP_p1 I1_I1666_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I74_XP_MP1 (I1_I1666_P8_7 I1_I1666_pn7 XI1_I1666_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I73_XP_MP0 (XI1_I1666_I73_XP_p1 I1_I1666_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I73_XP_MP1 (I1_I1666_P7_6 I1_I1666_pn6 XI1_I1666_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I75_XP_MP0 (XI1_I1666_I75_XP_p1 I1_I1666_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I75_XP_MP1 (I1_I1666_P9_8 I1_I1666_pn8 XI1_I1666_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I71_XP_MP0 (XI2_I1_I42_I71_XP_p1 I2_I1_I42_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I71_XP_MP1 (I2_I1_I42_P5_4 I2_I1_I42_pn4 XI2_I1_I42_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I137_XP_MP0 (XI1_I1666_I137_XP_p1 I1_I1666_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I137_XP_MP1 (I1_I1666_P12_5 I1_I1666_P8_5n XI1_I1666_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I76_XP_MP0 (XI1_I1666_I76_XP_p1 I1_I1666_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I76_XP_MP1 (I1_I1666_P10_9 I1_I1666_pn9 XI1_I1666_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I134_XP_MP0 (XI1_I1666_I134_XP_p1 I1_I1666_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I134_XP_MP1 (I1_I1666_P9_2 I1_I1666_P5_2n XI1_I1666_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I77_XP_MP0 (XI1_I1666_I77_XP_p1 I1_I1666_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I77_XP_MP1 (I1_I1666_P11_10 I1_I1666_pn10 XI1_I1666_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I56_MP0 (XI2_I2_I56_p1 A_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I56_MP1 (I2_I2_nor9 B_9 XI2_I2_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I50_MP0 (XI2_I2_I50_p1 A_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I50_MP1 (I2_I2_nor8 B_8 XI2_I2_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I70_XP_MP0 (XI2_I1_I42_I70_XP_p1 I2_I1_I42_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I70_XP_MP1 (I2_I1_I42_P4_3 I2_I1_I42_pn3 XI2_I1_I42_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I69_XP_MP0 (XI2_I1_I42_I69_XP_p1 I2_I1_I42_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I69_XP_MP1 (I2_I1_I42_P3_2 I2_I1_I42_pn2 XI2_I1_I42_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I141_XP_MP0 (XI1_I1666_I141_XP_p1 I1_I1666_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I141_XP_MP1 (I1_I1666_P16_9 I1_I1666_P12_9n XI1_I1666_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I78_XP_MP0 (XI1_I1666_I78_XP_p1 I1_I1666_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I78_XP_MP1 (I1_I1666_P12_11 I1_I1666_pn11 XI1_I1666_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I136_XP_MP0 (XI1_I1666_I136_XP_p1 I1_I1666_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I136_XP_MP1 (I1_I1666_P11_4 I1_I1666_P7_4n XI1_I1666_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I138_XP_MP0 (XI1_I1666_I138_XP_p1 I1_I1666_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I138_XP_MP1 (I1_I1666_P13_6 I1_I1666_P9_6n XI1_I1666_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I79_XP_MP0 (XI1_I1666_I79_XP_p1 I1_I1666_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I79_XP_MP1 (I1_I1666_P13_12 I1_I1666_pn12 XI1_I1666_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I74_XP_MP0 (XI1_I1620_I74_XP_p1 I1_I1620_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I74_XP_MP1 (I1_I1620_P8_7 I1_I1620_pn7 XI1_I1620_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I73_XP_MP0 (XI1_I1620_I73_XP_p1 I1_I1620_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I73_XP_MP1 (I1_I1620_P7_6 I1_I1620_pn6 XI1_I1620_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I72_XP_MP0 (XI1_I1620_I72_XP_p1 I1_I1620_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I72_XP_MP1 (I1_I1620_P6_5 I1_I1620_pn5 XI1_I1620_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I69_XP_MP0 (XI1_I1620_I69_XP_p1 I1_I1620_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I69_XP_MP1 (I1_I1620_P3_2 I1_I1620_pn2 XI1_I1620_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I68_XP_MP0 (XI1_I1620_I68_XP_p1 I1_I1620_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I68_XP_MP1 (I1_I1620_P2_1 I1_I1620_pn1 XI1_I1620_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I68_XP_MP0 (XI2_I1_I42_I68_XP_p1 I2_I1_I42_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I1_I42_I68_XP_MP1 (I2_I1_I42_P2_1 I2_I1_I42_pn1 XI2_I1_I42_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I91_XP_MP0 (XI1_I1758_I91_XP_p1 I1_I1758_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I91_XP_MP1 (I1_I1758_P25_24 I1_I1758_pn24 XI1_I1758_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I143_XP_MP0 (XI1_I1666_I143_XP_p1 I1_I1666_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I143_XP_MP1 (I1_I1666_P18_11 I1_I1666_P14_11n XI1_I1666_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I139_XP_MP0 (XI1_I1666_I139_XP_p1 I1_I1666_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I139_XP_MP1 (I1_I1666_P14_7 I1_I1666_P10_7n XI1_I1666_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I145_XP_MP0 (XI1_I1666_I145_XP_p1 I1_I1666_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I145_XP_MP1 (I1_I1666_P20_13 I1_I1666_P16_13n XI1_I1666_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I80_XP_MP0 (XI1_I1666_I80_XP_p1 I1_I1666_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I80_XP_MP1 (I1_I1666_P14_13 I1_I1666_pn13 XI1_I1666_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I142_XP_MP0 (XI1_I1666_I142_XP_p1 I1_I1666_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I142_XP_MP1 (I1_I1666_P17_10 I1_I1666_P13_10n XI1_I1666_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I81_XP_MP0 (XI1_I1666_I81_XP_p1 I1_I1666_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I81_XP_MP1 (I1_I1666_P15_14 I1_I1666_pn14 XI1_I1666_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I80_XP_MP0 (XI1_I1620_I80_XP_p1 I1_I1620_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I80_XP_MP1 (I1_I1620_P14_13 I1_I1620_pn13 XI1_I1620_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I79_XP_MP0 (XI1_I1620_I79_XP_p1 I1_I1620_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I79_XP_MP1 (I1_I1620_P13_12 I1_I1620_pn12 XI1_I1620_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I78_XP_MP0 (XI1_I1620_I78_XP_p1 I1_I1620_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I78_XP_MP1 (I1_I1620_P12_11 I1_I1620_pn11 XI1_I1620_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I77_XP_MP0 (XI1_I1620_I77_XP_p1 I1_I1620_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I77_XP_MP1 (I1_I1620_P11_10 I1_I1620_pn10 XI1_I1620_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I76_XP_MP0 (XI1_I1620_I76_XP_p1 I1_I1620_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I76_XP_MP1 (I1_I1620_P10_9 I1_I1620_pn9 XI1_I1620_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I75_XP_MP0 (XI1_I1620_I75_XP_p1 I1_I1620_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I75_XP_MP1 (I1_I1620_P9_8 I1_I1620_pn8 XI1_I1620_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I71_XP_MP0 (XI1_I1620_I71_XP_p1 I1_I1620_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I71_XP_MP1 (I1_I1620_P5_4 I1_I1620_pn4 XI1_I1620_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I70_XP_MP0 (XI1_I1620_I70_XP_p1 I1_I1620_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I70_XP_MP1 (I1_I1620_P4_3 I1_I1620_pn3 XI1_I1620_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I62_MP0 (XI2_I2_I62_p1 A_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I62_MP1 (I2_I2_nor10 B_10 XI2_I2_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I93_XP_MP0 (XI1_I1758_I93_XP_p1 I1_I1758_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I93_XP_MP1 (I1_I1758_P27_26 I1_I1758_pn26 XI1_I1758_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I89_XP_MP0 (XI1_I1758_I89_XP_p1 I1_I1758_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I89_XP_MP1 (I1_I1758_P23_22 I1_I1758_pn22 XI1_I1758_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I87_XP_MP0 (XI1_I1758_I87_XP_p1 I1_I1758_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I87_XP_MP1 (I1_I1758_P21_20 I1_I1758_pn20 XI1_I1758_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I85_XP_MP0 (XI1_I1758_I85_XP_p1 I1_I1758_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I85_XP_MP1 (I1_I1758_P19_18 I1_I1758_pn18 XI1_I1758_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I83_XP_MP0 (XI1_I1758_I83_XP_p1 I1_I1758_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I83_XP_MP1 (I1_I1758_P17_16 I1_I1758_pn16 XI1_I1758_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I81_XP_MP0 (XI1_I1758_I81_XP_p1 I1_I1758_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I81_XP_MP1 (I1_I1758_P15_14 I1_I1758_pn14 XI1_I1758_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I149_XP_MP0 (XI1_I1666_I149_XP_p1 I1_I1666_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I149_XP_MP1 (I1_I1666_P24_17 I1_I1666_P20_17n XI1_I1666_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I82_XP_MP0 (XI1_I1666_I82_XP_p1 I1_I1666_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I82_XP_MP1 (I1_I1666_P16_15 I1_I1666_pn15 XI1_I1666_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I140_XP_MP0 (XI1_I1666_I140_XP_p1 I1_I1666_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I140_XP_MP1 (I1_I1666_P15_8 I1_I1666_P11_8n XI1_I1666_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I83_XP_MP0 (XI1_I1666_I83_XP_p1 I1_I1666_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I83_XP_MP1 (I1_I1666_P17_16 I1_I1666_pn16 XI1_I1666_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I139_XP_MP0 (XI1_I1620_I139_XP_p1 I1_I1620_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I139_XP_MP1 (I1_I1620_P14_7 I1_I1620_P10_7n XI1_I1620_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I135_XP_MP0 (XI1_I1620_I135_XP_p1 I1_I1620_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I135_XP_MP1 (I1_I1620_P10_3 I1_I1620_P6_3n XI1_I1620_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I82_XP_MP0 (XI1_I1620_I82_XP_p1 I1_I1620_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I82_XP_MP1 (I1_I1620_P16_15 I1_I1620_pn15 XI1_I1620_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I137_XP_MP0 (XI1_I1620_I137_XP_p1 I1_I1620_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I137_XP_MP1 (I1_I1620_P12_5 I1_I1620_P8_5n XI1_I1620_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I133_XP_MP0 (XI1_I1620_I133_XP_p1 I1_I1620_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I133_XP_MP1 (I1_I1620_P8_1 I1_I1620_P4_1n XI1_I1620_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I211_MP0 (XI2_I3_I211_p1 I2_I3_o10_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I211_MP1 (I2_I3_q10_1 I2_I3_o10_1 XI2_I3_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I175_MP0 (XI2_I3_I175_p1 I2_I3_o7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I175_MP1 (I2_I3_q7_1 I2_I3_o7_1 XI2_I3_I175_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I44_MP0 (XI2_I2_I44_p1 A_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I44_MP1 (I2_I2_nor7 B_7 XI2_I2_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I163_MP0 (XI2_I3_I163_p1 I2_I3_o6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I163_MP1 (I2_I3_q6_1 I2_I3_o6_1 XI2_I3_I163_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I38_MP0 (XI2_I2_I38_p1 A_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I38_MP1 (I2_I2_nor6 B_6 XI2_I2_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I97_XP_MP0 (XI1_I1758_I97_XP_p1 I1_I1758_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I97_XP_MP1 (I1_I1758_P31_30 I1_I1758_pn30 XI1_I1758_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I95_XP_MP0 (XI1_I1758_I95_XP_p1 I1_I1758_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I95_XP_MP1 (I1_I1758_P29_28 I1_I1758_pn28 XI1_I1758_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I156_XP_MP0 (XI1_I1758_I156_XP_p1 I1_I1758_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I156_XP_MP1 (I1_I1758_P31_24 I1_I1758_P27_24n XI1_I1758_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I154_XP_MP0 (XI1_I1758_I154_XP_p1 I1_I1758_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I154_XP_MP1 (I1_I1758_P29_22 I1_I1758_P25_22n XI1_I1758_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I148_XP_MP0 (XI1_I1758_I148_XP_p1 I1_I1758_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I148_XP_MP1 (I1_I1758_P23_16 I1_I1758_P19_16n XI1_I1758_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I152_XP_MP0 (XI1_I1758_I152_XP_p1 I1_I1758_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I152_XP_MP1 (I1_I1758_P27_20 I1_I1758_P23_20n XI1_I1758_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I150_XP_MP0 (XI1_I1758_I150_XP_p1 I1_I1758_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I150_XP_MP1 (I1_I1758_P25_18 I1_I1758_P21_18n XI1_I1758_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I144_XP_MP0 (XI1_I1758_I144_XP_p1 I1_I1758_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I144_XP_MP1 (I1_I1758_P19_12 I1_I1758_P15_12n XI1_I1758_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I79_XP_MP0 (XI1_I1758_I79_XP_p1 I1_I1758_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I79_XP_MP1 (I1_I1758_P13_12 I1_I1758_pn12 XI1_I1758_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I77_XP_MP0 (XI1_I1758_I77_XP_p1 I1_I1758_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I77_XP_MP1 (I1_I1758_P11_10 I1_I1758_pn10 XI1_I1758_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I147_XP_MP0 (XI1_I1666_I147_XP_p1 I1_I1666_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I147_XP_MP1 (I1_I1666_P22_15 I1_I1666_P18_15n XI1_I1666_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I84_XP_MP0 (XI1_I1666_I84_XP_p1 I1_I1666_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I84_XP_MP1 (I1_I1666_P18_17 I1_I1666_pn17 XI1_I1666_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I86_XP_MP0 (XI1_I1666_I86_XP_p1 I1_I1666_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I86_XP_MP1 (I1_I1666_P20_19 I1_I1666_pn19 XI1_I1666_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I150_XP_MP0 (XI1_I1666_I150_XP_p1 I1_I1666_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I150_XP_MP1 (I1_I1666_P25_18 I1_I1666_P21_18n XI1_I1666_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I85_XP_MP0 (XI1_I1666_I85_XP_p1 I1_I1666_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I85_XP_MP1 (I1_I1666_P19_18 I1_I1666_pn18 XI1_I1666_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I143_XP_MP0 (XI1_I1620_I143_XP_p1 I1_I1620_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I143_XP_MP1 (I1_I1620_P18_11 I1_I1620_P14_11n XI1_I1620_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I81_XP_MP0 (XI1_I1620_I81_XP_p1 I1_I1620_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I81_XP_MP1 (I1_I1620_P15_14 I1_I1620_pn14 XI1_I1620_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I141_XP_MP0 (XI1_I1620_I141_XP_p1 I1_I1620_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I141_XP_MP1 (I1_I1620_P16_9 I1_I1620_P12_9n XI1_I1620_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I134_XP_MP0 (XI1_I1620_I134_XP_p1 I1_I1620_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I134_XP_MP1 (I1_I1620_P9_2 I1_I1620_P5_2n XI1_I1620_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I146_XP_MP0 (XI1_I1758_I146_XP_p1 I1_I1758_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I146_XP_MP1 (I1_I1758_P21_14 I1_I1758_P17_14n XI1_I1758_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I140_XP_MP0 (XI1_I1758_I140_XP_p1 I1_I1758_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I140_XP_MP1 (I1_I1758_P15_8 I1_I1758_P11_8n XI1_I1758_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I142_XP_MP0 (XI1_I1758_I142_XP_p1 I1_I1758_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I142_XP_MP1 (I1_I1758_P17_10 I1_I1758_P13_10n XI1_I1758_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I136_XP_MP0 (XI1_I1758_I136_XP_p1 I1_I1758_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I136_XP_MP1 (I1_I1758_P11_4 I1_I1758_P7_4n XI1_I1758_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I75_XP_MP0 (XI1_I1758_I75_XP_p1 I1_I1758_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I75_XP_MP1 (I1_I1758_P9_8 I1_I1758_pn8 XI1_I1758_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I73_XP_MP0 (XI1_I1758_I73_XP_p1 I1_I1758_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I73_XP_MP1 (I1_I1758_P7_6 I1_I1758_pn6 XI1_I1758_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I151_XP_MP0 (XI1_I1666_I151_XP_p1 I1_I1666_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I151_XP_MP1 (I1_I1666_P26_19 I1_I1666_P22_19n XI1_I1666_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I152_XP_MP0 (XI1_I1666_I152_XP_p1 I1_I1666_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I152_XP_MP1 (I1_I1666_P27_20 I1_I1666_P23_20n XI1_I1666_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I148_XP_MP0 (XI1_I1666_I148_XP_p1 I1_I1666_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I148_XP_MP1 (I1_I1666_P23_16 I1_I1666_P19_16n XI1_I1666_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I87_XP_MP0 (XI1_I1666_I87_XP_p1 I1_I1666_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I87_XP_MP1 (I1_I1666_P21_20 I1_I1666_pn20 XI1_I1666_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I147_XP_MP0 (XI1_I1620_I147_XP_p1 I1_I1620_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I147_XP_MP1 (I1_I1620_P22_15 I1_I1620_P18_15n XI1_I1620_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I84_XP_MP0 (XI1_I1620_I84_XP_p1 I1_I1620_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I84_XP_MP1 (I1_I1620_P18_17 I1_I1620_pn17 XI1_I1620_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I83_XP_MP0 (XI1_I1620_I83_XP_p1 I1_I1620_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I83_XP_MP1 (I1_I1620_P17_16 I1_I1620_pn16 XI1_I1620_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I145_XP_MP0 (XI1_I1620_I145_XP_p1 I1_I1620_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I145_XP_MP1 (I1_I1620_P20_13 I1_I1620_P16_13n XI1_I1620_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I136_XP_MP0 (XI1_I1620_I136_XP_p1 I1_I1620_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I136_XP_MP1 (I1_I1620_P11_4 I1_I1620_P7_4n XI1_I1620_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I199_MP0 (XI2_I3_I199_p1 I2_I3_o9_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I199_MP1 (I2_I3_q9_1 I2_I3_o9_1 XI2_I3_I199_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I187_MP0 (XI2_I3_I187_p1 I2_I3_o8_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I187_MP1 (I2_I3_q8_1 I2_I3_o8_1 XI2_I3_I187_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I96_XP_MP0 (XI1_I1758_I96_XP_p1 I1_I1758_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I96_XP_MP1 (I1_I1758_P30_29 I1_I1758_pn29 XI1_I1758_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I92_XP_MP0 (XI1_I1758_I92_XP_p1 I1_I1758_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I92_XP_MP1 (I1_I1758_P26_25 I1_I1758_pn25 XI1_I1758_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I90_XP_MP0 (XI1_I1758_I90_XP_p1 I1_I1758_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I90_XP_MP1 (I1_I1758_P24_23 I1_I1758_pn23 XI1_I1758_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I86_XP_MP0 (XI1_I1758_I86_XP_p1 I1_I1758_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I86_XP_MP1 (I1_I1758_P20_19 I1_I1758_pn19 XI1_I1758_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I82_XP_MP0 (XI1_I1758_I82_XP_p1 I1_I1758_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I82_XP_MP1 (I1_I1758_P16_15 I1_I1758_pn15 XI1_I1758_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I138_XP_MP0 (XI1_I1758_I138_XP_p1 I1_I1758_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I138_XP_MP1 (I1_I1758_P13_6 I1_I1758_P9_6n XI1_I1758_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I80_XP_MP0 (XI1_I1758_I80_XP_p1 I1_I1758_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I80_XP_MP1 (I1_I1758_P14_13 I1_I1758_pn13 XI1_I1758_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I134_XP_MP0 (XI1_I1758_I134_XP_p1 I1_I1758_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I134_XP_MP1 (I1_I1758_P9_2 I1_I1758_P5_2n XI1_I1758_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I155_XP_MP0 (XI1_I1666_I155_XP_p1 I1_I1666_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I155_XP_MP1 (I1_I1666_P30_23 I1_I1666_P26_23n XI1_I1666_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I153_XP_MP0 (XI1_I1666_I153_XP_p1 I1_I1666_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I153_XP_MP1 (I1_I1666_P28_21 I1_I1666_P24_21n XI1_I1666_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I90_XP_MP0 (XI1_I1666_I90_XP_p1 I1_I1666_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I90_XP_MP1 (I1_I1666_P24_23 I1_I1666_pn23 XI1_I1666_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I88_XP_MP0 (XI1_I1666_I88_XP_p1 I1_I1666_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I88_XP_MP1 (I1_I1666_P22_21 I1_I1666_pn21 XI1_I1666_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I154_XP_MP0 (XI1_I1666_I154_XP_p1 I1_I1666_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I154_XP_MP1 (I1_I1666_P29_22 I1_I1666_P25_22n XI1_I1666_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I89_XP_MP0 (XI1_I1666_I89_XP_p1 I1_I1666_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I89_XP_MP1 (I1_I1666_P23_22 I1_I1666_pn22 XI1_I1666_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I151_XP_MP0 (XI1_I1620_I151_XP_p1 I1_I1620_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I151_XP_MP1 (I1_I1620_P26_19 I1_I1620_P22_19n XI1_I1620_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I86_XP_MP0 (XI1_I1620_I86_XP_p1 I1_I1620_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I86_XP_MP1 (I1_I1620_P20_19 I1_I1620_pn19 XI1_I1620_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I85_XP_MP0 (XI1_I1620_I85_XP_p1 I1_I1620_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I85_XP_MP1 (I1_I1620_P19_18 I1_I1620_pn18 XI1_I1620_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I149_XP_MP0 (XI1_I1620_I149_XP_p1 I1_I1620_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I149_XP_MP1 (I1_I1620_P24_17 I1_I1620_P20_17n XI1_I1620_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I140_XP_MP0 (XI1_I1620_I140_XP_p1 I1_I1620_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I140_XP_MP1 (I1_I1620_P15_8 I1_I1620_P11_8n XI1_I1620_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I142_XP_MP0 (XI1_I1620_I142_XP_p1 I1_I1620_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I142_XP_MP1 (I1_I1620_P17_10 I1_I1620_P13_10n XI1_I1620_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I138_XP_MP0 (XI1_I1620_I138_XP_p1 I1_I1620_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I138_XP_MP1 (I1_I1620_P13_6 I1_I1620_P9_6n XI1_I1620_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I32_MP0 (XI2_I2_I32_p1 A_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I32_MP1 (I2_I2_nor5 B_5 XI2_I2_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I49_MP0 (XI2_I4_I49_p1 I2_I4_z1_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I49_MP1 (I2_I4_z2_1 I2_I4_z1_3 XI2_I4_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I5_MP0 (XI2_I4_I5_p1 Y_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I5_MP1 (I2_I4_z0_5 Y_11 XI2_I4_I5_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I155_XP_MP0 (XI1_I1758_I155_XP_p1 I1_I1758_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I155_XP_MP1 (I1_I1758_P30_23 I1_I1758_P26_23n XI1_I1758_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I94_XP_MP0 (XI1_I1758_I94_XP_p1 I1_I1758_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I94_XP_MP1 (I1_I1758_P28_27 I1_I1758_pn27 XI1_I1758_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I151_XP_MP0 (XI1_I1758_I151_XP_p1 I1_I1758_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I151_XP_MP1 (I1_I1758_P26_19 I1_I1758_P22_19n XI1_I1758_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I88_XP_MP0 (XI1_I1758_I88_XP_p1 I1_I1758_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I88_XP_MP1 (I1_I1758_P22_21 I1_I1758_pn21 XI1_I1758_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I84_XP_MP0 (XI1_I1758_I84_XP_p1 I1_I1758_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I84_XP_MP1 (I1_I1758_P18_17 I1_I1758_pn17 XI1_I1758_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I76_XP_MP0 (XI1_I1758_I76_XP_p1 I1_I1758_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I76_XP_MP1 (I1_I1758_P10_9 I1_I1758_pn9 XI1_I1758_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I74_XP_MP0 (XI1_I1758_I74_XP_p1 I1_I1758_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I74_XP_MP1 (I1_I1758_P8_7 I1_I1758_pn7 XI1_I1758_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I72_XP_MP0 (XI1_I1758_I72_XP_p1 I1_I1758_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I72_XP_MP1 (I1_I1758_P6_5 I1_I1758_pn5 XI1_I1758_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I71_XP_MP0 (XI1_I1758_I71_XP_p1 I1_I1758_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I71_XP_MP1 (I1_I1758_P5_4 I1_I1758_pn4 XI1_I1758_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I92_XP_MP0 (XI1_I1666_I92_XP_p1 I1_I1666_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I92_XP_MP1 (I1_I1666_P26_25 I1_I1666_pn25 XI1_I1666_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I95_XP_MP0 (XI1_I1666_I95_XP_p1 I1_I1666_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I95_XP_MP1 (I1_I1666_P29_28 I1_I1666_pn28 XI1_I1666_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I156_XP_MP0 (XI1_I1666_I156_XP_p1 I1_I1666_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I156_XP_MP1 (I1_I1666_P31_24 I1_I1666_P27_24n XI1_I1666_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I91_XP_MP0 (XI1_I1666_I91_XP_p1 I1_I1666_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I91_XP_MP1 (I1_I1666_P25_24 I1_I1666_pn24 XI1_I1666_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I88_XP_MP0 (XI1_I1620_I88_XP_p1 I1_I1620_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I88_XP_MP1 (I1_I1620_P22_21 I1_I1620_pn21 XI1_I1620_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I87_XP_MP0 (XI1_I1620_I87_XP_p1 I1_I1620_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I87_XP_MP1 (I1_I1620_P21_20 I1_I1620_pn20 XI1_I1620_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I144_XP_MP0 (XI1_I1620_I144_XP_p1 I1_I1620_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I144_XP_MP1 (I1_I1620_P19_12 I1_I1620_P15_12n XI1_I1620_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I146_XP_MP0 (XI1_I1620_I146_XP_p1 I1_I1620_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I146_XP_MP1 (I1_I1620_P21_14 I1_I1620_P17_14n XI1_I1620_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I4_MP0 (XI2_I4_I4_p1 Y_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I4_MP1 (I2_I4_z0_4 Y_9 XI2_I4_I4_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I2_MP0 (XI2_I2_I2_p1 A_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I2_MP1 (I2_I2_nor0 B_0 XI2_I2_I2_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I153_XP_MP0 (XI1_I1758_I153_XP_p1 I1_I1758_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I153_XP_MP1 (I1_I1758_P28_21 I1_I1758_P24_21n XI1_I1758_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I147_XP_MP0 (XI1_I1758_I147_XP_p1 I1_I1758_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I147_XP_MP1 (I1_I1758_P22_15 I1_I1758_P18_15n XI1_I1758_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I149_XP_MP0 (XI1_I1758_I149_XP_p1 I1_I1758_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I149_XP_MP1 (I1_I1758_P24_17 I1_I1758_P20_17n XI1_I1758_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I145_XP_MP0 (XI1_I1758_I145_XP_p1 I1_I1758_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I145_XP_MP1 (I1_I1758_P20_13 I1_I1758_P16_13n XI1_I1758_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I143_XP_MP0 (XI1_I1758_I143_XP_p1 I1_I1758_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I143_XP_MP1 (I1_I1758_P18_11 I1_I1758_P14_11n XI1_I1758_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I139_XP_MP0 (XI1_I1758_I139_XP_p1 I1_I1758_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I139_XP_MP1 (I1_I1758_P14_7 I1_I1758_P10_7n XI1_I1758_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I141_XP_MP0 (XI1_I1758_I141_XP_p1 I1_I1758_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I141_XP_MP1 (I1_I1758_P16_9 I1_I1758_P12_9n XI1_I1758_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I78_XP_MP0 (XI1_I1758_I78_XP_p1 I1_I1758_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I78_XP_MP1 (I1_I1758_P12_11 I1_I1758_pn11 XI1_I1758_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I69_XP_MP0 (XI1_I1758_I69_XP_p1 I1_I1758_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I69_XP_MP1 (I1_I1758_P3_2 I1_I1758_pn2 XI1_I1758_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I97_XP_MP0 (XI1_I1666_I97_XP_p1 I1_I1666_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I97_XP_MP1 (I1_I1666_P31_30 I1_I1666_pn30 XI1_I1666_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I94_XP_MP0 (XI1_I1666_I94_XP_p1 I1_I1666_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I94_XP_MP1 (I1_I1666_P28_27 I1_I1666_pn27 XI1_I1666_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I93_XP_MP0 (XI1_I1666_I93_XP_p1 I1_I1666_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I93_XP_MP1 (I1_I1666_P27_26 I1_I1666_pn26 XI1_I1666_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I89_XP_MP0 (XI1_I1620_I89_XP_p1 I1_I1620_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I89_XP_MP1 (I1_I1620_P23_22 I1_I1620_pn22 XI1_I1620_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I153_XP_MP0 (XI1_I1620_I153_XP_p1 I1_I1620_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I153_XP_MP1 (I1_I1620_P28_21 I1_I1620_P24_21n XI1_I1620_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I148_XP_MP0 (XI1_I1620_I148_XP_p1 I1_I1620_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I148_XP_MP1 (I1_I1620_P23_16 I1_I1620_P19_16n XI1_I1620_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I150_XP_MP0 (XI1_I1620_I150_XP_p1 I1_I1620_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I150_XP_MP1 (I1_I1620_P25_18 I1_I1620_P21_18n XI1_I1620_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I151_MP0 (XI2_I3_I151_p1 I2_I3_o5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I151_MP1 (I2_I3_q5_1 I2_I3_o5_1 XI2_I3_I151_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I91_MP0 (XI2_I3_I91_p1 I2_I3_o0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I91_MP1 (I2_I3_q0_1 I2_I3_o0_1 XI2_I3_I91_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I137_XP_MP0 (XI1_I1758_I137_XP_p1 I1_I1758_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I137_XP_MP1 (I1_I1758_P12_5 I1_I1758_P8_5n XI1_I1758_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I135_XP_MP0 (XI1_I1758_I135_XP_p1 I1_I1758_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I135_XP_MP1 (I1_I1758_P10_3 I1_I1758_P6_3n XI1_I1758_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I133_XP_MP0 (XI1_I1758_I133_XP_p1 I1_I1758_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I133_XP_MP1 (I1_I1758_P8_1 I1_I1758_P4_1n XI1_I1758_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I70_XP_MP0 (XI1_I1758_I70_XP_p1 I1_I1758_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I70_XP_MP1 (I1_I1758_P4_3 I1_I1758_pn3 XI1_I1758_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I96_XP_MP0 (XI1_I1666_I96_XP_p1 I1_I1666_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1666_I96_XP_MP1 (I1_I1666_P30_29 I1_I1666_pn29 XI1_I1666_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I155_XP_MP0 (XI1_I1620_I155_XP_p1 I1_I1620_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I155_XP_MP1 (I1_I1620_P30_23 I1_I1620_P26_23n XI1_I1620_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I90_XP_MP0 (XI1_I1620_I90_XP_p1 I1_I1620_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I90_XP_MP1 (I1_I1620_P24_23 I1_I1620_pn23 XI1_I1620_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I8_MP0 (XI2_I2_I8_p1 A_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I8_MP1 (I2_I2_nor1 B_1 XI2_I2_I8_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I14_MP0 (XI2_I2_I14_p1 A_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I14_MP1 (I2_I2_nor2 B_2 XI2_I2_I14_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I26_MP0 (XI2_I2_I26_p1 A_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I26_MP1 (I2_I2_nor4 B_4 XI2_I2_I26_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I68_XP_MP0 (XI1_I1758_I68_XP_p1 I1_I1758_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1758_I68_XP_MP1 (I1_I1758_P2_1 I1_I1758_pn1 XI1_I1758_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I92_XP_MP0 (XI1_I1620_I92_XP_p1 I1_I1620_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I92_XP_MP1 (I1_I1620_P26_25 I1_I1620_pn25 XI1_I1620_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I91_XP_MP0 (XI1_I1620_I91_XP_p1 I1_I1620_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I91_XP_MP1 (I1_I1620_P25_24 I1_I1620_pn24 XI1_I1620_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I156_XP_MP0 (XI1_I1620_I156_XP_p1 I1_I1620_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I156_XP_MP1 (I1_I1620_P31_24 I1_I1620_P27_24n XI1_I1620_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I152_XP_MP0 (XI1_I1620_I152_XP_p1 I1_I1620_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I152_XP_MP1 (I1_I1620_P27_20 I1_I1620_P23_20n XI1_I1620_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I154_XP_MP0 (XI1_I1620_I154_XP_p1 I1_I1620_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I154_XP_MP1 (I1_I1620_P29_22 I1_I1620_P25_22n XI1_I1620_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I2_I20_MP0 (XI2_I2_I20_p1 A_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I2_I20_MP1 (I2_I2_nor3 B_3 XI2_I2_I20_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I139_MP0 (XI2_I3_I139_p1 I2_I3_o4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I139_MP1 (I2_I3_q4_1 I2_I3_o4_1 XI2_I3_I139_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I97_XP_MP0 (XI1_I1620_I97_XP_p1 I1_I1620_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I97_XP_MP1 (I1_I1620_P31_30 I1_I1620_pn30 XI1_I1620_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I96_XP_MP0 (XI1_I1620_I96_XP_p1 I1_I1620_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I96_XP_MP1 (I1_I1620_P30_29 I1_I1620_pn29 XI1_I1620_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I95_XP_MP0 (XI1_I1620_I95_XP_p1 I1_I1620_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I95_XP_MP1 (I1_I1620_P29_28 I1_I1620_pn28 XI1_I1620_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I94_XP_MP0 (XI1_I1620_I94_XP_p1 I1_I1620_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I94_XP_MP1 (I1_I1620_P28_27 I1_I1620_pn27 XI1_I1620_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I93_XP_MP0 (XI1_I1620_I93_XP_p1 I1_I1620_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1620_I93_XP_MP1 (I1_I1620_P27_26 I1_I1620_pn26 XI1_I1620_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I103_MP0 (XI2_I3_I103_p1 I2_I3_o1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I103_MP1 (I2_I3_q1_1 I2_I3_o1_1 XI2_I3_I103_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I127_MP0 (XI2_I3_I127_p1 I2_I3_o3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I127_MP1 (I2_I3_q3_1 I2_I3_o3_1 XI2_I3_I127_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I3_I115_MP0 (XI2_I3_I115_p1 I2_I3_o2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I3_I115_MP1 (I2_I3_q2_1 I2_I3_o2_1 XI2_I3_I115_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I84_XP_MP0 (XI1_I1804_I84_XP_p1 I1_I1804_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I84_XP_MP1 (I1_I1804_P18_17 I1_I1804_pn17 XI1_I1804_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I80_XP_MP0 (XI1_I1804_I80_XP_p1 I1_I1804_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I80_XP_MP1 (I1_I1804_P14_13 I1_I1804_pn13 XI1_I1804_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I78_XP_MP0 (XI1_I1804_I78_XP_p1 I1_I1804_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I78_XP_MP1 (I1_I1804_P12_11 I1_I1804_pn11 XI1_I1804_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I48_MP0 (XI2_I4_I48_p1 I2_I4_z1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I48_MP1 (I2_I4_z2_0 I2_I4_z1_1 XI2_I4_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I3_MP0 (XI2_I4_I3_p1 Y_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I3_MP1 (I2_I4_z0_3 Y_7 XI2_I4_I3_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I2_MP0 (XI2_I4_I2_p1 Y_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I2_MP1 (I2_I4_z0_2 Y_5 XI2_I4_I2_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I60_MP0 (XI2_I4_I60_p1 I2_I4_z3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I60_MP1 (I2_I4_z4_0 I2_I4_z3_1 XI2_I4_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I90_XP_MP0 (XI1_I1804_I90_XP_p1 I1_I1804_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I90_XP_MP1 (I1_I1804_P24_23 I1_I1804_pn23 XI1_I1804_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I88_XP_MP0 (XI1_I1804_I88_XP_p1 I1_I1804_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I88_XP_MP1 (I1_I1804_P22_21 I1_I1804_pn21 XI1_I1804_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I86_XP_MP0 (XI1_I1804_I86_XP_p1 I1_I1804_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I86_XP_MP1 (I1_I1804_P20_19 I1_I1804_pn19 XI1_I1804_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I82_XP_MP0 (XI1_I1804_I82_XP_p1 I1_I1804_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I82_XP_MP1 (I1_I1804_P16_15 I1_I1804_pn15 XI1_I1804_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I76_XP_MP0 (XI1_I1804_I76_XP_p1 I1_I1804_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I76_XP_MP1 (I1_I1804_P10_9 I1_I1804_pn9 XI1_I1804_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I74_XP_MP0 (XI1_I1804_I74_XP_p1 I1_I1804_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I74_XP_MP1 (I1_I1804_P8_7 I1_I1804_pn7 XI1_I1804_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I72_XP_MP0 (XI1_I1804_I72_XP_p1 I1_I1804_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I72_XP_MP1 (I1_I1804_P6_5 I1_I1804_pn5 XI1_I1804_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I70_XP_MP0 (XI1_I1804_I70_XP_p1 I1_I1804_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I70_XP_MP1 (I1_I1804_P4_3 I1_I1804_pn3 XI1_I1804_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I68_XP_MP0 (XI1_I1804_I68_XP_p1 I1_I1804_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I68_XP_MP1 (I1_I1804_P2_1 I1_I1804_pn1 XI1_I1804_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I1_MP0 (XI2_I4_I1_p1 Y_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I1_MP1 (I2_I4_z0_1 Y_3 XI2_I4_I1_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I94_XP_MP0 (XI1_I1804_I94_XP_p1 I1_I1804_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I94_XP_MP1 (I1_I1804_P28_27 I1_I1804_pn27 XI1_I1804_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I92_XP_MP0 (XI1_I1804_I92_XP_p1 I1_I1804_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I92_XP_MP1 (I1_I1804_P26_25 I1_I1804_pn25 XI1_I1804_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I153_XP_MP0 (XI1_I1804_I153_XP_p1 I1_I1804_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I153_XP_MP1 (I1_I1804_P28_21 I1_I1804_P24_21n XI1_I1804_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I151_XP_MP0 (XI1_I1804_I151_XP_p1 I1_I1804_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I151_XP_MP1 (I1_I1804_P26_19 I1_I1804_P22_19n XI1_I1804_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I147_XP_MP0 (XI1_I1804_I147_XP_p1 I1_I1804_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I147_XP_MP1 (I1_I1804_P22_15 I1_I1804_P18_15n XI1_I1804_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I149_XP_MP0 (XI1_I1804_I149_XP_p1 I1_I1804_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I149_XP_MP1 (I1_I1804_P24_17 I1_I1804_P20_17n XI1_I1804_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I145_XP_MP0 (XI1_I1804_I145_XP_p1 I1_I1804_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I145_XP_MP1 (I1_I1804_P20_13 I1_I1804_P16_13n XI1_I1804_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I141_XP_MP0 (XI1_I1804_I141_XP_p1 I1_I1804_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I141_XP_MP1 (I1_I1804_P16_9 I1_I1804_P12_9n XI1_I1804_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I137_XP_MP0 (XI1_I1804_I137_XP_p1 I1_I1804_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I137_XP_MP1 (I1_I1804_P12_5 I1_I1804_P8_5n XI1_I1804_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I133_XP_MP0 (XI1_I1804_I133_XP_p1 I1_I1804_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I133_XP_MP1 (I1_I1804_P8_1 I1_I1804_P4_1n XI1_I1804_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I69_XP_MP0 (XI1_I1804_I69_XP_p1 I1_I1804_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I69_XP_MP1 (I1_I1804_P3_2 I1_I1804_pn2 XI1_I1804_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I68_XP_MP0 (XI1_I1896_I68_XP_p1 I1_I1896_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I68_XP_MP1 (I1_I1896_P2_1 I1_I1896_pn1 XI1_I1896_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I70_XP_MP0 (XI1_I1942_I70_XP_p1 I1_I1942_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I70_XP_MP1 (I1_I1942_P4_3 I1_I1942_pn3 XI1_I1942_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I69_XP_MP0 (XI1_I1942_I69_XP_p1 I1_I1942_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I69_XP_MP1 (I1_I1942_P3_2 I1_I1942_pn2 XI1_I1942_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I68_XP_MP0 (XI1_I1942_I68_XP_p1 I1_I1942_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I68_XP_MP1 (I1_I1942_P2_1 I1_I1942_pn1 XI1_I1942_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I0_MP0 (XI2_I4_I0_p1 Y_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I0_MP1 (I2_I4_z0_0 Y_1 XI2_I4_I0_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I96_XP_MP0 (XI1_I1804_I96_XP_p1 I1_I1804_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I96_XP_MP1 (I1_I1804_P30_29 I1_I1804_pn29 XI1_I1804_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I155_XP_MP0 (XI1_I1804_I155_XP_p1 I1_I1804_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I155_XP_MP1 (I1_I1804_P30_23 I1_I1804_P26_23n XI1_I1804_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I143_XP_MP0 (XI1_I1804_I143_XP_p1 I1_I1804_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I143_XP_MP1 (I1_I1804_P18_11 I1_I1804_P14_11n XI1_I1804_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I139_XP_MP0 (XI1_I1804_I139_XP_p1 I1_I1804_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I139_XP_MP1 (I1_I1804_P14_7 I1_I1804_P10_7n XI1_I1804_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I135_XP_MP0 (XI1_I1804_I135_XP_p1 I1_I1804_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I135_XP_MP1 (I1_I1804_P10_3 I1_I1804_P6_3n XI1_I1804_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I73_XP_MP0 (XI1_I1804_I73_XP_p1 I1_I1804_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I73_XP_MP1 (I1_I1804_P7_6 I1_I1804_pn6 XI1_I1804_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I71_XP_MP0 (XI1_I1804_I71_XP_p1 I1_I1804_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I71_XP_MP1 (I1_I1804_P5_4 I1_I1804_pn4 XI1_I1804_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I69_XP_MP0 (XI1_I1896_I69_XP_p1 I1_I1896_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I69_XP_MP1 (I1_I1896_P3_2 I1_I1896_pn2 XI1_I1896_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I71_XP_MP0 (XI1_I1942_I71_XP_p1 I1_I1942_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I71_XP_MP1 (I1_I1942_P5_4 I1_I1942_pn4 XI1_I1942_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I72_XP_MP0 (XI1_I1942_I72_XP_p1 I1_I1942_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I72_XP_MP1 (I1_I1942_P6_5 I1_I1942_pn5 XI1_I1942_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I71_XP_MP0 (XI1_I1988_I71_XP_p1 I1_I1988_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I71_XP_MP1 (I1_I1988_P5_4 I1_I1988_pn4 XI1_I1988_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I69_XP_MP0 (XI1_I1988_I69_XP_p1 I1_I1988_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I69_XP_MP1 (I1_I1988_P3_2 I1_I1988_pn2 XI1_I1988_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I70_XP_MP0 (XI1_I1988_I70_XP_p1 I1_I1988_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I70_XP_MP1 (I1_I1988_P4_3 I1_I1988_pn3 XI1_I1988_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I68_XP_MP0 (XI1_I1988_I68_XP_p1 I1_I1988_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I68_XP_MP1 (I1_I1988_P2_1 I1_I1988_pn1 XI1_I1988_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I137_XP_MP0 (XI0_I1660_I137_XP_p1 I0_I1660_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I137_XP_MP1 (I0_I1660_P7_6 I0_I1660_pn6 XI0_I1660_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I138_XP_MP0 (XI0_I1660_I138_XP_p1 I0_I1660_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I138_XP_MP1 (I0_I1660_P8_7 I0_I1660_pn7 XI0_I1660_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I139_XP_MP0 (XI0_I1660_I139_XP_p1 I0_I1660_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I139_XP_MP1 (I0_I1660_P9_8 I0_I1660_pn8 XI0_I1660_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I140_XP_MP0 (XI0_I1660_I140_XP_p1 I0_I1660_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I140_XP_MP1 (I0_I1660_P10_9 I0_I1660_pn9 XI0_I1660_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I141_XP_MP0 (XI0_I1660_I141_XP_p1 I0_I1660_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I141_XP_MP1 (I0_I1660_P11_10 I0_I1660_pn10 XI0_I1660_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I142_XP_MP0 (XI0_I1660_I142_XP_p1 I0_I1660_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I142_XP_MP1 (I0_I1660_P12_11 I0_I1660_pn11 XI0_I1660_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I143_XP_MP0 (XI0_I1660_I143_XP_p1 I0_I1660_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I143_XP_MP1 (I0_I1660_P13_12 I0_I1660_pn12 XI0_I1660_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I144_XP_MP0 (XI0_I1660_I144_XP_p1 I0_I1660_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I144_XP_MP1 (I0_I1660_P14_13 I0_I1660_pn13 XI0_I1660_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I145_XP_MP0 (XI0_I1660_I145_XP_p1 I0_I1660_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I145_XP_MP1 (I0_I1660_P15_14 I0_I1660_pn14 XI0_I1660_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I146_XP_MP0 (XI0_I1660_I146_XP_p1 I0_I1660_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I146_XP_MP1 (I0_I1660_P16_15 I0_I1660_pn15 XI0_I1660_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I147_XP_MP0 (XI0_I1660_I147_XP_p1 I0_I1660_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I147_XP_MP1 (I0_I1660_P17_16 I0_I1660_pn16 XI0_I1660_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I148_XP_MP0 (XI0_I1660_I148_XP_p1 I0_I1660_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I148_XP_MP1 (I0_I1660_P18_17 I0_I1660_pn17 XI0_I1660_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I149_XP_MP0 (XI0_I1660_I149_XP_p1 I0_I1660_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I149_XP_MP1 (I0_I1660_P19_18 I0_I1660_pn18 XI0_I1660_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I150_XP_MP0 (XI0_I1660_I150_XP_p1 I0_I1660_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I150_XP_MP1 (I0_I1660_P20_19 I0_I1660_pn19 XI0_I1660_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I151_XP_MP0 (XI0_I1660_I151_XP_p1 I0_I1660_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I151_XP_MP1 (I0_I1660_P21_20 I0_I1660_pn20 XI0_I1660_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I152_XP_MP0 (XI0_I1660_I152_XP_p1 I0_I1660_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I152_XP_MP1 (I0_I1660_P22_21 I0_I1660_pn21 XI0_I1660_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I153_XP_MP0 (XI0_I1660_I153_XP_p1 I0_I1660_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I153_XP_MP1 (I0_I1660_P23_22 I0_I1660_pn22 XI0_I1660_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I154_XP_MP0 (XI0_I1660_I154_XP_p1 I0_I1660_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I154_XP_MP1 (I0_I1660_P24_23 I0_I1660_pn23 XI0_I1660_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I155_XP_MP0 (XI0_I1660_I155_XP_p1 I0_I1660_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I155_XP_MP1 (I0_I1660_P25_24 I0_I1660_pn24 XI0_I1660_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I156_XP_MP0 (XI0_I1660_I156_XP_p1 I0_I1660_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I156_XP_MP1 (I0_I1660_P26_25 I0_I1660_pn25 XI0_I1660_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I157_XP_MP0 (XI0_I1660_I157_XP_p1 I0_I1660_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I157_XP_MP1 (I0_I1660_P27_26 I0_I1660_pn26 XI0_I1660_I157_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I158_XP_MP0 (XI0_I1660_I158_XP_p1 I0_I1660_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I158_XP_MP1 (I0_I1660_P28_27 I0_I1660_pn27 XI0_I1660_I158_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I159_XP_MP0 (XI0_I1660_I159_XP_p1 I0_I1660_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I159_XP_MP1 (I0_I1660_P29_28 I0_I1660_pn28 XI0_I1660_I159_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I97_XP_MP0 (XI1_I1804_I97_XP_p1 I1_I1804_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I97_XP_MP1 (I1_I1804_P31_30 I1_I1804_pn30 XI1_I1804_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I95_XP_MP0 (XI1_I1804_I95_XP_p1 I1_I1804_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I95_XP_MP1 (I1_I1804_P29_28 I1_I1804_pn28 XI1_I1804_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I93_XP_MP0 (XI1_I1804_I93_XP_p1 I1_I1804_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I93_XP_MP1 (I1_I1804_P27_26 I1_I1804_pn26 XI1_I1804_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I91_XP_MP0 (XI1_I1804_I91_XP_p1 I1_I1804_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I91_XP_MP1 (I1_I1804_P25_24 I1_I1804_pn24 XI1_I1804_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I89_XP_MP0 (XI1_I1804_I89_XP_p1 I1_I1804_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I89_XP_MP1 (I1_I1804_P23_22 I1_I1804_pn22 XI1_I1804_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I87_XP_MP0 (XI1_I1804_I87_XP_p1 I1_I1804_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I87_XP_MP1 (I1_I1804_P21_20 I1_I1804_pn20 XI1_I1804_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I83_XP_MP0 (XI1_I1804_I83_XP_p1 I1_I1804_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I83_XP_MP1 (I1_I1804_P17_16 I1_I1804_pn16 XI1_I1804_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I81_XP_MP0 (XI1_I1804_I81_XP_p1 I1_I1804_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I81_XP_MP1 (I1_I1804_P15_14 I1_I1804_pn14 XI1_I1804_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I79_XP_MP0 (XI1_I1804_I79_XP_p1 I1_I1804_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I79_XP_MP1 (I1_I1804_P13_12 I1_I1804_pn12 XI1_I1804_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I77_XP_MP0 (XI1_I1804_I77_XP_p1 I1_I1804_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I77_XP_MP1 (I1_I1804_P11_10 I1_I1804_pn10 XI1_I1804_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I75_XP_MP0 (XI1_I1804_I75_XP_p1 I1_I1804_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I75_XP_MP1 (I1_I1804_P9_8 I1_I1804_pn8 XI1_I1804_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I69_XP_MP0 (XI1_I1850_I69_XP_p1 I1_I1850_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I69_XP_MP1 (I1_I1850_P3_2 I1_I1850_pn2 XI1_I1850_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I68_XP_MP0 (XI1_I1850_I68_XP_p1 I1_I1850_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I68_XP_MP1 (I1_I1850_P2_1 I1_I1850_pn1 XI1_I1850_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I71_XP_MP0 (XI1_I1896_I71_XP_p1 I1_I1896_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I71_XP_MP1 (I1_I1896_P5_4 I1_I1896_pn4 XI1_I1896_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I72_XP_MP0 (XI1_I1896_I72_XP_p1 I1_I1896_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I72_XP_MP1 (I1_I1896_P6_5 I1_I1896_pn5 XI1_I1896_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I70_XP_MP0 (XI1_I1896_I70_XP_p1 I1_I1896_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I70_XP_MP1 (I1_I1896_P4_3 I1_I1896_pn3 XI1_I1896_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I73_XP_MP0 (XI1_I1942_I73_XP_p1 I1_I1942_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I73_XP_MP1 (I1_I1942_P7_6 I1_I1942_pn6 XI1_I1942_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I74_XP_MP0 (XI1_I1942_I74_XP_p1 I1_I1942_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I74_XP_MP1 (I1_I1942_P8_7 I1_I1942_pn7 XI1_I1942_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I133_XP_MP0 (XI1_I1942_I133_XP_p1 I1_I1942_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I133_XP_MP1 (I1_I1942_P8_1 I1_I1942_P4_1n XI1_I1942_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I73_XP_MP0 (XI1_I1988_I73_XP_p1 I1_I1988_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I73_XP_MP1 (I1_I1988_P7_6 I1_I1988_pn6 XI1_I1988_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I134_XP_MP0 (XI1_I1988_I134_XP_p1 I1_I1988_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I134_XP_MP1 (I1_I1988_P9_2 I1_I1988_P5_2n XI1_I1988_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I72_XP_MP0 (XI1_I1988_I72_XP_p1 I1_I1988_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I72_XP_MP1 (I1_I1988_P6_5 I1_I1988_pn5 XI1_I1988_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I133_XP_MP0 (XI1_I1988_I133_XP_p1 I1_I1988_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I133_XP_MP1 (I1_I1988_P8_1 I1_I1988_P4_1n XI1_I1988_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I135_XP_MP0 (XI0_I1660_I135_XP_p1 I0_I1660_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I135_XP_MP1 (I0_I1660_P5_4 I0_I1660_pn4 XI0_I1660_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I136_XP_MP0 (XI0_I1660_I136_XP_p1 I0_I1660_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I136_XP_MP1 (I0_I1660_P6_5 I0_I1660_pn5 XI0_I1660_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I264_XP_MP0 (XI0_I1660_I264_XP_p1 I0_I1660_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I264_XP_MP1 (I0_I1660_P11_4 I0_I1660_P7_4n XI0_I1660_I264_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I262_XP_MP0 (XI0_I1660_I262_XP_p1 I0_I1660_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I262_XP_MP1 (I0_I1660_P9_2 I0_I1660_P5_2n XI0_I1660_I262_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I266_XP_MP0 (XI0_I1660_I266_XP_p1 I0_I1660_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I266_XP_MP1 (I0_I1660_P13_6 I0_I1660_P9_6n XI0_I1660_I266_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I270_XP_MP0 (XI0_I1660_I270_XP_p1 I0_I1660_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I270_XP_MP1 (I0_I1660_P17_10 I0_I1660_P13_10n XI0_I1660_I270_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I268_XP_MP0 (XI0_I1660_I268_XP_p1 I0_I1660_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I268_XP_MP1 (I0_I1660_P15_8 I0_I1660_P11_8n XI0_I1660_I268_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I272_XP_MP0 (XI0_I1660_I272_XP_p1 I0_I1660_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I272_XP_MP1 (I0_I1660_P19_12 I0_I1660_P15_12n XI0_I1660_I272_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I274_XP_MP0 (XI0_I1660_I274_XP_p1 I0_I1660_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I274_XP_MP1 (I0_I1660_P21_14 I0_I1660_P17_14n XI0_I1660_I274_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I276_XP_MP0 (XI0_I1660_I276_XP_p1 I0_I1660_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I276_XP_MP1 (I0_I1660_P23_16 I0_I1660_P19_16n XI0_I1660_I276_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I278_XP_MP0 (XI0_I1660_I278_XP_p1 I0_I1660_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I278_XP_MP1 (I0_I1660_P25_18 I0_I1660_P21_18n XI0_I1660_I278_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I280_XP_MP0 (XI0_I1660_I280_XP_p1 I0_I1660_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I280_XP_MP1 (I0_I1660_P27_20 I0_I1660_P23_20n XI0_I1660_I280_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I282_XP_MP0 (XI0_I1660_I282_XP_p1 I0_I1660_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I282_XP_MP1 (I0_I1660_P29_22 I0_I1660_P25_22n XI0_I1660_I282_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I160_XP_MP0 (XI0_I1660_I160_XP_p1 I0_I1660_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I160_XP_MP1 (I0_I1660_P30_29 I0_I1660_pn29 XI0_I1660_I160_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I284_XP_MP0 (XI0_I1660_I284_XP_p1 I0_I1660_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I284_XP_MP1 (I0_I1660_P31_24 I0_I1660_P27_24n XI0_I1660_I284_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I154_XP_MP0 (XI1_I1804_I154_XP_p1 I1_I1804_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I154_XP_MP1 (I1_I1804_P29_22 I1_I1804_P25_22n XI1_I1804_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I150_XP_MP0 (XI1_I1804_I150_XP_p1 I1_I1804_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I150_XP_MP1 (I1_I1804_P25_18 I1_I1804_P21_18n XI1_I1804_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I146_XP_MP0 (XI1_I1804_I146_XP_p1 I1_I1804_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I146_XP_MP1 (I1_I1804_P21_14 I1_I1804_P17_14n XI1_I1804_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I85_XP_MP0 (XI1_I1804_I85_XP_p1 I1_I1804_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I85_XP_MP1 (I1_I1804_P19_18 I1_I1804_pn18 XI1_I1804_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I134_XP_MP0 (XI1_I1804_I134_XP_p1 I1_I1804_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I134_XP_MP1 (I1_I1804_P9_2 I1_I1804_P5_2n XI1_I1804_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I71_XP_MP0 (XI1_I1850_I71_XP_p1 I1_I1850_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I71_XP_MP1 (I1_I1850_P5_4 I1_I1850_pn4 XI1_I1850_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I70_XP_MP0 (XI1_I1850_I70_XP_p1 I1_I1850_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I70_XP_MP1 (I1_I1850_P4_3 I1_I1850_pn3 XI1_I1850_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I73_XP_MP0 (XI1_I1896_I73_XP_p1 I1_I1896_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I73_XP_MP1 (I1_I1896_P7_6 I1_I1896_pn6 XI1_I1896_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I74_XP_MP0 (XI1_I1896_I74_XP_p1 I1_I1896_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I74_XP_MP1 (I1_I1896_P8_7 I1_I1896_pn7 XI1_I1896_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I75_XP_MP0 (XI1_I1942_I75_XP_p1 I1_I1942_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I75_XP_MP1 (I1_I1942_P9_8 I1_I1942_pn8 XI1_I1942_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I134_XP_MP0 (XI1_I1942_I134_XP_p1 I1_I1942_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I134_XP_MP1 (I1_I1942_P9_2 I1_I1942_P5_2n XI1_I1942_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I76_XP_MP0 (XI1_I1942_I76_XP_p1 I1_I1942_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I76_XP_MP1 (I1_I1942_P10_9 I1_I1942_pn9 XI1_I1942_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I135_XP_MP0 (XI1_I1942_I135_XP_p1 I1_I1942_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I135_XP_MP1 (I1_I1942_P10_3 I1_I1942_P6_3n XI1_I1942_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I75_XP_MP0 (XI1_I1988_I75_XP_p1 I1_I1988_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I75_XP_MP1 (I1_I1988_P9_8 I1_I1988_pn8 XI1_I1988_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I74_XP_MP0 (XI1_I1988_I74_XP_p1 I1_I1988_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I74_XP_MP1 (I1_I1988_P8_7 I1_I1988_pn7 XI1_I1988_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I132_XP_MP0 (XI0_I1660_I132_XP_p1 I0_I1660_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I132_XP_MP1 (I0_I1660_P2_1 I0_I1660_pn1 XI0_I1660_I132_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I133_XP_MP0 (XI0_I1660_I133_XP_p1 I0_I1660_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I133_XP_MP1 (I0_I1660_P3_2 I0_I1660_pn2 XI0_I1660_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I134_XP_MP0 (XI0_I1660_I134_XP_p1 I0_I1660_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I134_XP_MP1 (I0_I1660_P4_3 I0_I1660_pn3 XI0_I1660_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I398_XP_MP0 (XI0_I1660_I398_XP_p1 I0_I1660_P35_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I398_XP_MP1 (I0_I1660_P35_4 I0_I1660_P19_4n XI0_I1660_I398_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I402_XP_MP0 (XI0_I1660_I402_XP_p1 I0_I1660_P39_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I402_XP_MP1 (I0_I1660_P39_8 I0_I1660_P23_8n XI0_I1660_I402_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I161_XP_MP0 (XI0_I1660_I161_XP_p1 I0_I1660_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I161_XP_MP1 (I0_I1660_P31_30 I0_I1660_pn30 XI0_I1660_I161_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I156_XP_MP0 (XI1_I1804_I156_XP_p1 I1_I1804_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I156_XP_MP1 (I1_I1804_P31_24 I1_I1804_P27_24n XI1_I1804_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I144_XP_MP0 (XI1_I1804_I144_XP_p1 I1_I1804_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I144_XP_MP1 (I1_I1804_P19_12 I1_I1804_P15_12n XI1_I1804_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I142_XP_MP0 (XI1_I1804_I142_XP_p1 I1_I1804_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I142_XP_MP1 (I1_I1804_P17_10 I1_I1804_P13_10n XI1_I1804_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I138_XP_MP0 (XI1_I1804_I138_XP_p1 I1_I1804_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I138_XP_MP1 (I1_I1804_P13_6 I1_I1804_P9_6n XI1_I1804_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I72_XP_MP0 (XI1_I1850_I72_XP_p1 I1_I1850_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I72_XP_MP1 (I1_I1850_P6_5 I1_I1850_pn5 XI1_I1850_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I133_XP_MP0 (XI1_I1896_I133_XP_p1 I1_I1896_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I133_XP_MP1 (I1_I1896_P8_1 I1_I1896_P4_1n XI1_I1896_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I77_XP_MP0 (XI1_I1942_I77_XP_p1 I1_I1942_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I77_XP_MP1 (I1_I1942_P11_10 I1_I1942_pn10 XI1_I1942_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I136_XP_MP0 (XI1_I1942_I136_XP_p1 I1_I1942_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I136_XP_MP1 (I1_I1942_P11_4 I1_I1942_P7_4n XI1_I1942_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I77_XP_MP0 (XI1_I1988_I77_XP_p1 I1_I1988_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I77_XP_MP1 (I1_I1988_P11_10 I1_I1988_pn10 XI1_I1988_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I76_XP_MP0 (XI1_I1988_I76_XP_p1 I1_I1988_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I76_XP_MP1 (I1_I1988_P10_9 I1_I1988_pn9 XI1_I1988_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I141_XP_MP0 (XI1_I1988_I141_XP_p1 I1_I1988_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I141_XP_MP1 (I1_I1988_P16_9 I1_I1988_P12_9n XI1_I1988_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I135_XP_MP0 (XI1_I1988_I135_XP_p1 I1_I1988_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I135_XP_MP1 (I1_I1988_P10_3 I1_I1988_P6_3n XI1_I1988_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I70_XP_MP0 (XI1_I2066_I70_XP_p1 I1_I2066_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I70_XP_MP1 (I1_I2066_P4_3 I1_I2066_pn3 XI1_I2066_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I68_XP_MP0 (XI1_I2066_I68_XP_p1 I1_I2066_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I68_XP_MP1 (I1_I2066_P2_1 I1_I2066_pn1 XI1_I2066_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I69_XP_MP0 (XI1_I2066_I69_XP_p1 I1_I2066_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I69_XP_MP1 (I1_I2066_P3_2 I1_I2066_pn2 XI1_I2066_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I261_XP_MP0 (XI0_I1660_I261_XP_p1 I0_I1660_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I261_XP_MP1 (I0_I1660_P8_1 I0_I1660_P4_1n XI0_I1660_I261_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I265_XP_MP0 (XI0_I1660_I265_XP_p1 I0_I1660_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I265_XP_MP1 (I0_I1660_P12_5 I0_I1660_P8_5n XI0_I1660_I265_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I269_XP_MP0 (XI0_I1660_I269_XP_p1 I0_I1660_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I269_XP_MP1 (I0_I1660_P16_9 I0_I1660_P12_9n XI0_I1660_I269_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I396_XP_MP0 (XI0_I1660_I396_XP_p1 I0_I1660_P33_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I396_XP_MP1 (I0_I1660_P33_2 I0_I1660_P17_2n XI0_I1660_I396_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I273_XP_MP0 (XI0_I1660_I273_XP_p1 I0_I1660_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I273_XP_MP1 (I0_I1660_P20_13 I0_I1660_P16_13n XI0_I1660_I273_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I277_XP_MP0 (XI0_I1660_I277_XP_p1 I0_I1660_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I277_XP_MP1 (I0_I1660_P24_17 I0_I1660_P20_17n XI0_I1660_I277_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I281_XP_MP0 (XI0_I1660_I281_XP_p1 I0_I1660_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I281_XP_MP1 (I0_I1660_P28_21 I0_I1660_P24_21n XI0_I1660_I281_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I400_XP_MP0 (XI0_I1660_I400_XP_p1 I0_I1660_P37_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I400_XP_MP1 (I0_I1660_P37_6 I0_I1660_P21_6n XI0_I1660_I400_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I164_XP_MP0 (XI0_I1660_I164_XP_p1 I0_I1660_pn34 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I164_XP_MP1 (I0_I1660_P34_33 I0_I1660_pn33 XI0_I1660_I164_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I412_XP_MP0 (XI0_I1660_I412_XP_p1 I0_I1660_P49_34n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I412_XP_MP1 (I0_I1660_P49_18 I0_I1660_P33_18n XI0_I1660_I412_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I286_XP_MP0 (XI0_I1660_I286_XP_p1 I0_I1660_P33_30n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I286_XP_MP1 (I0_I1660_P33_26 I0_I1660_P29_26n XI0_I1660_I286_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I162_XP_MP0 (XI0_I1660_I162_XP_p1 I0_I1660_pn32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I162_XP_MP1 (I0_I1660_P32_31 I0_I1660_pn31 XI0_I1660_I162_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I288_XP_MP0 (XI0_I1660_I288_XP_p1 I0_I1660_P35_32n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I288_XP_MP1 (I0_I1660_P35_28 I0_I1660_P31_28n XI0_I1660_I288_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I163_XP_MP0 (XI0_I1660_I163_XP_p1 I0_I1660_pn33 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I163_XP_MP1 (I0_I1660_P33_32 I0_I1660_pn32 XI0_I1660_I163_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I152_XP_MP0 (XI1_I1804_I152_XP_p1 I1_I1804_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I152_XP_MP1 (I1_I1804_P27_20 I1_I1804_P23_20n XI1_I1804_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I148_XP_MP0 (XI1_I1804_I148_XP_p1 I1_I1804_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I148_XP_MP1 (I1_I1804_P23_16 I1_I1804_P19_16n XI1_I1804_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I140_XP_MP0 (XI1_I1804_I140_XP_p1 I1_I1804_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I140_XP_MP1 (I1_I1804_P15_8 I1_I1804_P11_8n XI1_I1804_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I136_XP_MP0 (XI1_I1804_I136_XP_p1 I1_I1804_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1804_I136_XP_MP1 (I1_I1804_P11_4 I1_I1804_P7_4n XI1_I1804_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I73_XP_MP0 (XI1_I1850_I73_XP_p1 I1_I1850_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I73_XP_MP1 (I1_I1850_P7_6 I1_I1850_pn6 XI1_I1850_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I77_XP_MP0 (XI1_I1896_I77_XP_p1 I1_I1896_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I77_XP_MP1 (I1_I1896_P11_10 I1_I1896_pn10 XI1_I1896_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I75_XP_MP0 (XI1_I1896_I75_XP_p1 I1_I1896_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I75_XP_MP1 (I1_I1896_P9_8 I1_I1896_pn8 XI1_I1896_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I134_XP_MP0 (XI1_I1896_I134_XP_p1 I1_I1896_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I134_XP_MP1 (I1_I1896_P9_2 I1_I1896_P5_2n XI1_I1896_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I76_XP_MP0 (XI1_I1896_I76_XP_p1 I1_I1896_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I76_XP_MP1 (I1_I1896_P10_9 I1_I1896_pn9 XI1_I1896_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I135_XP_MP0 (XI1_I1896_I135_XP_p1 I1_I1896_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I135_XP_MP1 (I1_I1896_P10_3 I1_I1896_P6_3n XI1_I1896_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I79_XP_MP0 (XI1_I1942_I79_XP_p1 I1_I1942_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I79_XP_MP1 (I1_I1942_P13_12 I1_I1942_pn12 XI1_I1942_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I78_XP_MP0 (XI1_I1942_I78_XP_p1 I1_I1942_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I78_XP_MP1 (I1_I1942_P12_11 I1_I1942_pn11 XI1_I1942_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I141_XP_MP0 (XI1_I1942_I141_XP_p1 I1_I1942_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I141_XP_MP1 (I1_I1942_P16_9 I1_I1942_P12_9n XI1_I1942_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I137_XP_MP0 (XI1_I1942_I137_XP_p1 I1_I1942_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I137_XP_MP1 (I1_I1942_P12_5 I1_I1942_P8_5n XI1_I1942_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I138_XP_MP0 (XI1_I1988_I138_XP_p1 I1_I1988_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I138_XP_MP1 (I1_I1988_P13_6 I1_I1988_P9_6n XI1_I1988_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I136_XP_MP0 (XI1_I1988_I136_XP_p1 I1_I1988_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I136_XP_MP1 (I1_I1988_P11_4 I1_I1988_P7_4n XI1_I1988_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I78_XP_MP0 (XI1_I1988_I78_XP_p1 I1_I1988_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I78_XP_MP1 (I1_I1988_P12_11 I1_I1988_pn11 XI1_I1988_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I137_XP_MP0 (XI1_I1988_I137_XP_p1 I1_I1988_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I137_XP_MP1 (I1_I1988_P12_5 I1_I1988_P8_5n XI1_I1988_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I74_XP_MP0 (XI1_I2066_I74_XP_p1 I1_I2066_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I74_XP_MP1 (I1_I2066_P8_7 I1_I2066_pn7 XI1_I2066_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I72_XP_MP0 (XI1_I2066_I72_XP_p1 I1_I2066_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I72_XP_MP1 (I1_I2066_P6_5 I1_I2066_pn5 XI1_I2066_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I133_XP_MP0 (XI1_I2066_I133_XP_p1 I1_I2066_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I133_XP_MP1 (I1_I2066_P8_1 I1_I2066_P4_1n XI1_I2066_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I71_XP_MP0 (XI1_I2066_I71_XP_p1 I1_I2066_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I71_XP_MP1 (I1_I2066_P5_4 I1_I2066_pn4 XI1_I2066_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I263_XP_MP0 (XI0_I1660_I263_XP_p1 I0_I1660_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I263_XP_MP1 (I0_I1660_P10_3 I0_I1660_P6_3n XI0_I1660_I263_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I395_XP_MP0 (XI0_I1660_I395_XP_p1 I0_I1660_P32_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I395_XP_MP1 (I0_I1660_P32_1 I0_I1660_P16_1n XI0_I1660_I395_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I285_XP_MP0 (XI0_I1660_I285_XP_p1 I0_I1660_P32_29n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I285_XP_MP1 (I0_I1660_P32_25 I0_I1660_P28_25n XI0_I1660_I285_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I166_XP_MP0 (XI0_I1660_I166_XP_p1 I0_I1660_pn36 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I166_XP_MP1 (I0_I1660_P36_35 I0_I1660_pn35 XI0_I1660_I166_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I404_XP_MP0 (XI0_I1660_I404_XP_p1 I0_I1660_P41_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I404_XP_MP1 (I0_I1660_P41_10 I0_I1660_P25_10n XI0_I1660_I404_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I414_XP_MP0 (XI0_I1660_I414_XP_p1 I0_I1660_P51_36n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I414_XP_MP1 (I0_I1660_P51_20 I0_I1660_P35_20n XI0_I1660_I414_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I406_XP_MP0 (XI0_I1660_I406_XP_p1 I0_I1660_P43_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I406_XP_MP1 (I0_I1660_P43_12 I0_I1660_P27_12n XI0_I1660_I406_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I410_XP_MP0 (XI0_I1660_I410_XP_p1 I0_I1660_P47_32n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I410_XP_MP1 (I0_I1660_P47_16 I0_I1660_P31_16n XI0_I1660_I410_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I296_XP_MP0 (XI0_I1660_I296_XP_p1 I0_I1660_P43_40n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I296_XP_MP1 (I0_I1660_P43_36 I0_I1660_P39_36n XI0_I1660_I296_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I165_XP_MP0 (XI0_I1660_I165_XP_p1 I0_I1660_pn35 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I165_XP_MP1 (I0_I1660_P35_34 I0_I1660_pn34 XI0_I1660_I165_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I167_XP_MP0 (XI0_I1660_I167_XP_p1 I0_I1660_pn37 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I167_XP_MP1 (I0_I1660_P37_36 I0_I1660_pn36 XI0_I1660_I167_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I136_XP_MP0 (XI1_I1850_I136_XP_p1 I1_I1850_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I136_XP_MP1 (I1_I1850_P11_4 I1_I1850_P7_4n XI1_I1850_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I77_XP_MP0 (XI1_I1850_I77_XP_p1 I1_I1850_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I77_XP_MP1 (I1_I1850_P11_10 I1_I1850_pn10 XI1_I1850_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I76_XP_MP0 (XI1_I1850_I76_XP_p1 I1_I1850_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I76_XP_MP1 (I1_I1850_P10_9 I1_I1850_pn9 XI1_I1850_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I75_XP_MP0 (XI1_I1850_I75_XP_p1 I1_I1850_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I75_XP_MP1 (I1_I1850_P9_8 I1_I1850_pn8 XI1_I1850_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I74_XP_MP0 (XI1_I1850_I74_XP_p1 I1_I1850_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I74_XP_MP1 (I1_I1850_P8_7 I1_I1850_pn7 XI1_I1850_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I136_XP_MP0 (XI1_I1896_I136_XP_p1 I1_I1896_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I136_XP_MP1 (I1_I1896_P11_4 I1_I1896_P7_4n XI1_I1896_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I78_XP_MP0 (XI1_I1896_I78_XP_p1 I1_I1896_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I78_XP_MP1 (I1_I1896_P12_11 I1_I1896_pn11 XI1_I1896_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I142_XP_MP0 (XI1_I1942_I142_XP_p1 I1_I1942_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I142_XP_MP1 (I1_I1942_P17_10 I1_I1942_P13_10n XI1_I1942_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I138_XP_MP0 (XI1_I1942_I138_XP_p1 I1_I1942_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I138_XP_MP1 (I1_I1942_P13_6 I1_I1942_P9_6n XI1_I1942_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I80_XP_MP0 (XI1_I1942_I80_XP_p1 I1_I1942_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I80_XP_MP1 (I1_I1942_P14_13 I1_I1942_pn13 XI1_I1942_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I139_XP_MP0 (XI1_I1942_I139_XP_p1 I1_I1942_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I139_XP_MP1 (I1_I1942_P14_7 I1_I1942_P10_7n XI1_I1942_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I79_XP_MP0 (XI1_I1988_I79_XP_p1 I1_I1988_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I79_XP_MP1 (I1_I1988_P13_12 I1_I1988_pn12 XI1_I1988_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I142_XP_MP0 (XI1_I1988_I142_XP_p1 I1_I1988_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I142_XP_MP1 (I1_I1988_P17_10 I1_I1988_P13_10n XI1_I1988_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I80_XP_MP0 (XI1_I1988_I80_XP_p1 I1_I1988_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I80_XP_MP1 (I1_I1988_P14_13 I1_I1988_pn13 XI1_I1988_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I143_XP_MP0 (XI1_I1988_I143_XP_p1 I1_I1988_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I143_XP_MP1 (I1_I1988_P18_11 I1_I1988_P14_11n XI1_I1988_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I139_XP_MP0 (XI1_I1988_I139_XP_p1 I1_I1988_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I139_XP_MP1 (I1_I1988_P14_7 I1_I1988_P10_7n XI1_I1988_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I76_XP_MP0 (XI1_I2066_I76_XP_p1 I1_I2066_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I76_XP_MP1 (I1_I2066_P10_9 I1_I2066_pn9 XI1_I2066_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I137_XP_MP0 (XI1_I2066_I137_XP_p1 I1_I2066_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I137_XP_MP1 (I1_I2066_P12_5 I1_I2066_P8_5n XI1_I2066_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I75_XP_MP0 (XI1_I2066_I75_XP_p1 I1_I2066_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I75_XP_MP1 (I1_I2066_P9_8 I1_I2066_pn8 XI1_I2066_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I73_XP_MP0 (XI1_I2066_I73_XP_p1 I1_I2066_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I73_XP_MP1 (I1_I2066_P7_6 I1_I2066_pn6 XI1_I2066_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I267_XP_MP0 (XI0_I1660_I267_XP_p1 I0_I1660_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I267_XP_MP1 (I0_I1660_P14_7 I0_I1660_P10_7n XI0_I1660_I267_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I271_XP_MP0 (XI0_I1660_I271_XP_p1 I0_I1660_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I271_XP_MP1 (I0_I1660_P18_11 I0_I1660_P14_11n XI0_I1660_I271_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I399_XP_MP0 (XI0_I1660_I399_XP_p1 I0_I1660_P36_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I399_XP_MP1 (I0_I1660_P36_5 I0_I1660_P20_5n XI0_I1660_I399_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I411_XP_MP0 (XI0_I1660_I411_XP_p1 I0_I1660_P48_33n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I411_XP_MP1 (I0_I1660_P48_17 I0_I1660_P32_17n XI0_I1660_I411_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I403_XP_MP0 (XI0_I1660_I403_XP_p1 I0_I1660_P40_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I403_XP_MP1 (I0_I1660_P40_9 I0_I1660_P24_9n XI0_I1660_I403_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I289_XP_MP0 (XI0_I1660_I289_XP_p1 I0_I1660_P36_33n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I289_XP_MP1 (I0_I1660_P36_29 I0_I1660_P32_29n XI0_I1660_I289_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I293_XP_MP0 (XI0_I1660_I293_XP_p1 I0_I1660_P40_37n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I293_XP_MP1 (I0_I1660_P40_33 I0_I1660_P36_33n XI0_I1660_I293_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I168_XP_MP0 (XI0_I1660_I168_XP_p1 I0_I1660_pn38 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I168_XP_MP1 (I0_I1660_P38_37 I0_I1660_pn37 XI0_I1660_I168_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I294_XP_MP0 (XI0_I1660_I294_XP_p1 I0_I1660_P41_38n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I294_XP_MP1 (I0_I1660_P41_34 I0_I1660_P37_34n XI0_I1660_I294_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I171_XP_MP0 (XI0_I1660_I171_XP_p1 I0_I1660_pn41 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I171_XP_MP1 (I0_I1660_P41_40 I0_I1660_pn40 XI0_I1660_I171_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I169_XP_MP0 (XI0_I1660_I169_XP_p1 I0_I1660_pn39 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I169_XP_MP1 (I0_I1660_P39_38 I0_I1660_pn38 XI0_I1660_I169_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I138_XP_MP0 (XI1_I1850_I138_XP_p1 I1_I1850_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I138_XP_MP1 (I1_I1850_P13_6 I1_I1850_P9_6n XI1_I1850_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I134_XP_MP0 (XI1_I1850_I134_XP_p1 I1_I1850_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I134_XP_MP1 (I1_I1850_P9_2 I1_I1850_P5_2n XI1_I1850_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I79_XP_MP0 (XI1_I1850_I79_XP_p1 I1_I1850_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I79_XP_MP1 (I1_I1850_P13_12 I1_I1850_pn12 XI1_I1850_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I78_XP_MP0 (XI1_I1850_I78_XP_p1 I1_I1850_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I78_XP_MP1 (I1_I1850_P12_11 I1_I1850_pn11 XI1_I1850_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I133_XP_MP0 (XI1_I1850_I133_XP_p1 I1_I1850_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I133_XP_MP1 (I1_I1850_P8_1 I1_I1850_P4_1n XI1_I1850_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I79_XP_MP0 (XI1_I1896_I79_XP_p1 I1_I1896_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I79_XP_MP1 (I1_I1896_P13_12 I1_I1896_pn12 XI1_I1896_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I138_XP_MP0 (XI1_I1896_I138_XP_p1 I1_I1896_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I138_XP_MP1 (I1_I1896_P13_6 I1_I1896_P9_6n XI1_I1896_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I137_XP_MP0 (XI1_I1896_I137_XP_p1 I1_I1896_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I137_XP_MP1 (I1_I1896_P12_5 I1_I1896_P8_5n XI1_I1896_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I81_XP_MP0 (XI1_I1942_I81_XP_p1 I1_I1942_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I81_XP_MP1 (I1_I1942_P15_14 I1_I1942_pn14 XI1_I1942_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I140_XP_MP0 (XI1_I1942_I140_XP_p1 I1_I1942_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I140_XP_MP1 (I1_I1942_P15_8 I1_I1942_P11_8n XI1_I1942_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I143_XP_MP0 (XI1_I1942_I143_XP_p1 I1_I1942_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I143_XP_MP1 (I1_I1942_P18_11 I1_I1942_P14_11n XI1_I1942_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I81_XP_MP0 (XI1_I1988_I81_XP_p1 I1_I1988_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I81_XP_MP1 (I1_I1988_P15_14 I1_I1988_pn14 XI1_I1988_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I140_XP_MP0 (XI1_I1988_I140_XP_p1 I1_I1988_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I140_XP_MP1 (I1_I1988_P15_8 I1_I1988_P11_8n XI1_I1988_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I82_XP_MP0 (XI1_I1988_I82_XP_p1 I1_I1988_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I82_XP_MP1 (I1_I1988_P16_15 I1_I1988_pn15 XI1_I1988_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I145_XP_MP0 (XI1_I1988_I145_XP_p1 I1_I1988_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I145_XP_MP1 (I1_I1988_P20_13 I1_I1988_P16_13n XI1_I1988_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I78_XP_MP0 (XI1_I2066_I78_XP_p1 I1_I2066_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I78_XP_MP1 (I1_I2066_P12_11 I1_I2066_pn11 XI1_I2066_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I141_XP_MP0 (XI1_I2066_I141_XP_p1 I1_I2066_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I141_XP_MP1 (I1_I2066_P16_9 I1_I2066_P12_9n XI1_I2066_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I134_XP_MP0 (XI1_I2066_I134_XP_p1 I1_I2066_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I134_XP_MP1 (I1_I2066_P9_2 I1_I2066_P5_2n XI1_I2066_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I397_XP_MP0 (XI0_I1660_I397_XP_p1 I0_I1660_P34_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I397_XP_MP1 (I0_I1660_P34_3 I0_I1660_P18_3n XI0_I1660_I397_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I275_XP_MP0 (XI0_I1660_I275_XP_p1 I0_I1660_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I275_XP_MP1 (I0_I1660_P22_15 I0_I1660_P18_15n XI0_I1660_I275_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I279_XP_MP0 (XI0_I1660_I279_XP_p1 I0_I1660_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I279_XP_MP1 (I0_I1660_P26_19 I0_I1660_P22_19n XI0_I1660_I279_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I297_XP_MP0 (XI0_I1660_I297_XP_p1 I0_I1660_P44_41n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I297_XP_MP1 (I0_I1660_P44_37 I0_I1660_P40_37n XI0_I1660_I297_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I170_XP_MP0 (XI0_I1660_I170_XP_p1 I0_I1660_pn40 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I170_XP_MP1 (I0_I1660_P40_39 I0_I1660_pn39 XI0_I1660_I170_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I416_XP_MP0 (XI0_I1660_I416_XP_p1 I0_I1660_P53_38n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I416_XP_MP1 (I0_I1660_P53_22 I0_I1660_P37_22n XI0_I1660_I416_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I418_XP_MP0 (XI0_I1660_I418_XP_p1 I0_I1660_P55_40n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I418_XP_MP1 (I0_I1660_P55_24 I0_I1660_P39_24n XI0_I1660_I418_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I426_XP_MP0 (XI0_I1660_I426_XP_p1 I0_I1660_P63_48n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I426_XP_MP1 (I0_I1660_P63_32 I0_I1660_P47_32n XI0_I1660_I426_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I300_XP_MP0 (XI0_I1660_I300_XP_p1 I0_I1660_P47_44n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I300_XP_MP1 (I0_I1660_P47_40 I0_I1660_P43_40n XI0_I1660_I300_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I298_XP_MP0 (XI0_I1660_I298_XP_p1 I0_I1660_P45_42n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I298_XP_MP1 (I0_I1660_P45_38 I0_I1660_P41_38n XI0_I1660_I298_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I173_XP_MP0 (XI0_I1660_I173_XP_p1 I0_I1660_pn43 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I173_XP_MP1 (I0_I1660_P43_42 I0_I1660_pn42 XI0_I1660_I173_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I144_XP_MP0 (XI1_I1850_I144_XP_p1 I1_I1850_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I144_XP_MP1 (I1_I1850_P19_12 I1_I1850_P15_12n XI1_I1850_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I140_XP_MP0 (XI1_I1850_I140_XP_p1 I1_I1850_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I140_XP_MP1 (I1_I1850_P15_8 I1_I1850_P11_8n XI1_I1850_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I142_XP_MP0 (XI1_I1850_I142_XP_p1 I1_I1850_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I142_XP_MP1 (I1_I1850_P17_10 I1_I1850_P13_10n XI1_I1850_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I81_XP_MP0 (XI1_I1850_I81_XP_p1 I1_I1850_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I81_XP_MP1 (I1_I1850_P15_14 I1_I1850_pn14 XI1_I1850_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I80_XP_MP0 (XI1_I1850_I80_XP_p1 I1_I1850_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I80_XP_MP1 (I1_I1850_P14_13 I1_I1850_pn13 XI1_I1850_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I137_XP_MP0 (XI1_I1850_I137_XP_p1 I1_I1850_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I137_XP_MP1 (I1_I1850_P12_5 I1_I1850_P8_5n XI1_I1850_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I135_XP_MP0 (XI1_I1850_I135_XP_p1 I1_I1850_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I135_XP_MP1 (I1_I1850_P10_3 I1_I1850_P6_3n XI1_I1850_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I81_XP_MP0 (XI1_I1896_I81_XP_p1 I1_I1896_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I81_XP_MP1 (I1_I1896_P15_14 I1_I1896_pn14 XI1_I1896_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I142_XP_MP0 (XI1_I1896_I142_XP_p1 I1_I1896_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I142_XP_MP1 (I1_I1896_P17_10 I1_I1896_P13_10n XI1_I1896_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I80_XP_MP0 (XI1_I1896_I80_XP_p1 I1_I1896_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I80_XP_MP1 (I1_I1896_P14_13 I1_I1896_pn13 XI1_I1896_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I141_XP_MP0 (XI1_I1896_I141_XP_p1 I1_I1896_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I141_XP_MP1 (I1_I1896_P16_9 I1_I1896_P12_9n XI1_I1896_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I139_XP_MP0 (XI1_I1896_I139_XP_p1 I1_I1896_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I139_XP_MP1 (I1_I1896_P14_7 I1_I1896_P10_7n XI1_I1896_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I83_XP_MP0 (XI1_I1942_I83_XP_p1 I1_I1942_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I83_XP_MP1 (I1_I1942_P17_16 I1_I1942_pn16 XI1_I1942_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I144_XP_MP0 (XI1_I1942_I144_XP_p1 I1_I1942_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I144_XP_MP1 (I1_I1942_P19_12 I1_I1942_P15_12n XI1_I1942_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I82_XP_MP0 (XI1_I1942_I82_XP_p1 I1_I1942_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I82_XP_MP1 (I1_I1942_P16_15 I1_I1942_pn15 XI1_I1942_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I145_XP_MP0 (XI1_I1942_I145_XP_p1 I1_I1942_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I145_XP_MP1 (I1_I1942_P20_13 I1_I1942_P16_13n XI1_I1942_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I149_XP_MP0 (XI1_I1942_I149_XP_p1 I1_I1942_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I149_XP_MP1 (I1_I1942_P24_17 I1_I1942_P20_17n XI1_I1942_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I83_XP_MP0 (XI1_I1988_I83_XP_p1 I1_I1988_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I83_XP_MP1 (I1_I1988_P17_16 I1_I1988_pn16 XI1_I1988_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I146_XP_MP0 (XI1_I1988_I146_XP_p1 I1_I1988_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I146_XP_MP1 (I1_I1988_P21_14 I1_I1988_P17_14n XI1_I1988_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I144_XP_MP0 (XI1_I1988_I144_XP_p1 I1_I1988_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I144_XP_MP1 (I1_I1988_P19_12 I1_I1988_P15_12n XI1_I1988_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I84_XP_MP0 (XI1_I1988_I84_XP_p1 I1_I1988_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I84_XP_MP1 (I1_I1988_P18_17 I1_I1988_pn17 XI1_I1988_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I149_XP_MP0 (XI1_I1988_I149_XP_p1 I1_I1988_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I149_XP_MP1 (I1_I1988_P24_17 I1_I1988_P20_17n XI1_I1988_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I80_XP_MP0 (XI1_I2066_I80_XP_p1 I1_I2066_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I80_XP_MP1 (I1_I2066_P14_13 I1_I2066_pn13 XI1_I2066_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I135_XP_MP0 (XI1_I2066_I135_XP_p1 I1_I2066_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I135_XP_MP1 (I1_I2066_P10_3 I1_I2066_P6_3n XI1_I2066_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I77_XP_MP0 (XI1_I2066_I77_XP_p1 I1_I2066_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I77_XP_MP1 (I1_I2066_P11_10 I1_I2066_pn10 XI1_I2066_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I79_XP_MP0 (XI1_I2066_I79_XP_p1 I1_I2066_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I79_XP_MP1 (I1_I2066_P13_12 I1_I2066_pn12 XI1_I2066_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I138_XP_MP0 (XI1_I2066_I138_XP_p1 I1_I2066_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I138_XP_MP1 (I1_I2066_P13_6 I1_I2066_P9_6n XI1_I2066_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I415_XP_MP0 (XI0_I1660_I415_XP_p1 I0_I1660_P52_37n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I415_XP_MP1 (I0_I1660_P52_21 I0_I1660_P36_21n XI0_I1660_I415_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I287_XP_MP0 (XI0_I1660_I287_XP_p1 I0_I1660_P34_31n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I287_XP_MP1 (I0_I1660_P34_27 I0_I1660_P30_27n XI0_I1660_I287_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I419_XP_MP0 (XI0_I1660_I419_XP_p1 I0_I1660_P56_41n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I419_XP_MP1 (I0_I1660_P56_25 I0_I1660_P40_25n XI0_I1660_I419_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I172_XP_MP0 (XI0_I1660_I172_XP_p1 I0_I1660_pn42 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I172_XP_MP1 (I0_I1660_P42_41 I0_I1660_pn41 XI0_I1660_I172_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I408_XP_MP0 (XI0_I1660_I408_XP_p1 I0_I1660_P45_30n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I408_XP_MP1 (I0_I1660_P45_14 I0_I1660_P29_14n XI0_I1660_I408_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I422_XP_MP0 (XI0_I1660_I422_XP_p1 I0_I1660_P59_44n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I422_XP_MP1 (I0_I1660_P59_28 I0_I1660_P43_28n XI0_I1660_I422_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I302_XP_MP0 (XI0_I1660_I302_XP_p1 I0_I1660_P49_46n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I302_XP_MP1 (I0_I1660_P49_42 I0_I1660_P45_42n XI0_I1660_I302_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I304_XP_MP0 (XI0_I1660_I304_XP_p1 I0_I1660_P51_48n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I304_XP_MP1 (I0_I1660_P51_44 I0_I1660_P47_44n XI0_I1660_I304_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I175_XP_MP0 (XI0_I1660_I175_XP_p1 I0_I1660_pn45 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I175_XP_MP1 (I0_I1660_P45_44 I0_I1660_pn44 XI0_I1660_I175_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I148_XP_MP0 (XI1_I1850_I148_XP_p1 I1_I1850_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I148_XP_MP1 (I1_I1850_P23_16 I1_I1850_P19_16n XI1_I1850_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I146_XP_MP0 (XI1_I1850_I146_XP_p1 I1_I1850_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I146_XP_MP1 (I1_I1850_P21_14 I1_I1850_P17_14n XI1_I1850_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I83_XP_MP0 (XI1_I1850_I83_XP_p1 I1_I1850_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I83_XP_MP1 (I1_I1850_P17_16 I1_I1850_pn16 XI1_I1850_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I84_XP_MP0 (XI1_I1850_I84_XP_p1 I1_I1850_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I84_XP_MP1 (I1_I1850_P18_17 I1_I1850_pn17 XI1_I1850_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I82_XP_MP0 (XI1_I1850_I82_XP_p1 I1_I1850_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I82_XP_MP1 (I1_I1850_P16_15 I1_I1850_pn15 XI1_I1850_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I141_XP_MP0 (XI1_I1850_I141_XP_p1 I1_I1850_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I141_XP_MP1 (I1_I1850_P16_9 I1_I1850_P12_9n XI1_I1850_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I83_XP_MP0 (XI1_I1896_I83_XP_p1 I1_I1896_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I83_XP_MP1 (I1_I1896_P17_16 I1_I1896_pn16 XI1_I1896_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I140_XP_MP0 (XI1_I1896_I140_XP_p1 I1_I1896_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I140_XP_MP1 (I1_I1896_P15_8 I1_I1896_P11_8n XI1_I1896_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I82_XP_MP0 (XI1_I1896_I82_XP_p1 I1_I1896_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I82_XP_MP1 (I1_I1896_P16_15 I1_I1896_pn15 XI1_I1896_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I84_XP_MP0 (XI1_I1896_I84_XP_p1 I1_I1896_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I84_XP_MP1 (I1_I1896_P18_17 I1_I1896_pn17 XI1_I1896_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I143_XP_MP0 (XI1_I1896_I143_XP_p1 I1_I1896_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I143_XP_MP1 (I1_I1896_P18_11 I1_I1896_P14_11n XI1_I1896_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I85_XP_MP0 (XI1_I1942_I85_XP_p1 I1_I1942_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I85_XP_MP1 (I1_I1942_P19_18 I1_I1942_pn18 XI1_I1942_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I146_XP_MP0 (XI1_I1942_I146_XP_p1 I1_I1942_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I146_XP_MP1 (I1_I1942_P21_14 I1_I1942_P17_14n XI1_I1942_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I84_XP_MP0 (XI1_I1942_I84_XP_p1 I1_I1942_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I84_XP_MP1 (I1_I1942_P18_17 I1_I1942_pn17 XI1_I1942_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I85_XP_MP0 (XI1_I1988_I85_XP_p1 I1_I1988_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I85_XP_MP1 (I1_I1988_P19_18 I1_I1988_pn18 XI1_I1988_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I150_XP_MP0 (XI1_I1988_I150_XP_p1 I1_I1988_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I150_XP_MP1 (I1_I1988_P25_18 I1_I1988_P21_18n XI1_I1988_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I86_XP_MP0 (XI1_I1988_I86_XP_p1 I1_I1988_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I86_XP_MP1 (I1_I1988_P20_19 I1_I1988_pn19 XI1_I1988_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I82_XP_MP0 (XI1_I2066_I82_XP_p1 I1_I2066_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I82_XP_MP1 (I1_I2066_P16_15 I1_I2066_pn15 XI1_I2066_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I143_XP_MP0 (XI1_I2066_I143_XP_p1 I1_I2066_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I143_XP_MP1 (I1_I2066_P18_11 I1_I2066_P14_11n XI1_I2066_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I139_XP_MP0 (XI1_I2066_I139_XP_p1 I1_I2066_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I139_XP_MP1 (I1_I2066_P14_7 I1_I2066_P10_7n XI1_I2066_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I81_XP_MP0 (XI1_I2066_I81_XP_p1 I1_I2066_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I81_XP_MP1 (I1_I2066_P15_14 I1_I2066_pn14 XI1_I2066_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I142_XP_MP0 (XI1_I2066_I142_XP_p1 I1_I2066_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I142_XP_MP1 (I1_I2066_P17_10 I1_I2066_P13_10n XI1_I2066_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I140_XP_MP0 (XI1_I2066_I140_XP_p1 I1_I2066_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I140_XP_MP1 (I1_I2066_P15_8 I1_I2066_P11_8n XI1_I2066_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I136_XP_MP0 (XI1_I2066_I136_XP_p1 I1_I2066_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I136_XP_MP1 (I1_I2066_P11_4 I1_I2066_P7_4n XI1_I2066_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I401_XP_MP0 (XI0_I1660_I401_XP_p1 I0_I1660_P38_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I401_XP_MP1 (I0_I1660_P38_7 I0_I1660_P22_7n XI0_I1660_I401_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I405_XP_MP0 (XI0_I1660_I405_XP_p1 I0_I1660_P42_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I405_XP_MP1 (I0_I1660_P42_11 I0_I1660_P26_11n XI0_I1660_I405_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I291_XP_MP0 (XI0_I1660_I291_XP_p1 I0_I1660_P38_35n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I291_XP_MP1 (I0_I1660_P38_31 I0_I1660_P34_31n XI0_I1660_I291_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I295_XP_MP0 (XI0_I1660_I295_XP_p1 I0_I1660_P42_39n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I295_XP_MP1 (I0_I1660_P42_35 I0_I1660_P38_35n XI0_I1660_I295_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I301_XP_MP0 (XI0_I1660_I301_XP_p1 I0_I1660_P48_45n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I301_XP_MP1 (I0_I1660_P48_41 I0_I1660_P44_41n XI0_I1660_I301_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I174_XP_MP0 (XI0_I1660_I174_XP_p1 I0_I1660_pn44 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I174_XP_MP1 (I0_I1660_P44_43 I0_I1660_pn43 XI0_I1660_I174_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I420_XP_MP0 (XI0_I1660_I420_XP_p1 I0_I1660_P57_42n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I420_XP_MP1 (I0_I1660_P57_26 I0_I1660_P41_26n XI0_I1660_I420_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I308_XP_MP0 (XI0_I1660_I308_XP_p1 I0_I1660_P55_52n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I308_XP_MP1 (I0_I1660_P55_48 I0_I1660_P51_48n XI0_I1660_I308_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I177_XP_MP0 (XI0_I1660_I177_XP_p1 I0_I1660_pn47 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I177_XP_MP1 (I0_I1660_P47_46 I0_I1660_pn46 XI0_I1660_I177_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I150_XP_MP0 (XI1_I1850_I150_XP_p1 I1_I1850_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I150_XP_MP1 (I1_I1850_P25_18 I1_I1850_P21_18n XI1_I1850_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I85_XP_MP0 (XI1_I1850_I85_XP_p1 I1_I1850_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I85_XP_MP1 (I1_I1850_P19_18 I1_I1850_pn18 XI1_I1850_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I139_XP_MP0 (XI1_I1850_I139_XP_p1 I1_I1850_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I139_XP_MP1 (I1_I1850_P14_7 I1_I1850_P10_7n XI1_I1850_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I85_XP_MP0 (XI1_I1896_I85_XP_p1 I1_I1896_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I85_XP_MP1 (I1_I1896_P19_18 I1_I1896_pn18 XI1_I1896_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I146_XP_MP0 (XI1_I1896_I146_XP_p1 I1_I1896_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I146_XP_MP1 (I1_I1896_P21_14 I1_I1896_P17_14n XI1_I1896_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I144_XP_MP0 (XI1_I1896_I144_XP_p1 I1_I1896_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I144_XP_MP1 (I1_I1896_P19_12 I1_I1896_P15_12n XI1_I1896_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I145_XP_MP0 (XI1_I1896_I145_XP_p1 I1_I1896_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I145_XP_MP1 (I1_I1896_P20_13 I1_I1896_P16_13n XI1_I1896_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I150_XP_MP0 (XI1_I1942_I150_XP_p1 I1_I1942_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I150_XP_MP1 (I1_I1942_P25_18 I1_I1942_P21_18n XI1_I1942_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I86_XP_MP0 (XI1_I1942_I86_XP_p1 I1_I1942_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I86_XP_MP1 (I1_I1942_P20_19 I1_I1942_pn19 XI1_I1942_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I151_XP_MP0 (XI1_I1942_I151_XP_p1 I1_I1942_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I151_XP_MP1 (I1_I1942_P26_19 I1_I1942_P22_19n XI1_I1942_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I147_XP_MP0 (XI1_I1942_I147_XP_p1 I1_I1942_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I147_XP_MP1 (I1_I1942_P22_15 I1_I1942_P18_15n XI1_I1942_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I87_XP_MP0 (XI1_I1988_I87_XP_p1 I1_I1988_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I87_XP_MP1 (I1_I1988_P21_20 I1_I1988_pn20 XI1_I1988_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I148_XP_MP0 (XI1_I1988_I148_XP_p1 I1_I1988_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I148_XP_MP1 (I1_I1988_P23_16 I1_I1988_P19_16n XI1_I1988_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I152_XP_MP0 (XI1_I1988_I152_XP_p1 I1_I1988_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I152_XP_MP1 (I1_I1988_P27_20 I1_I1988_P23_20n XI1_I1988_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I151_XP_MP0 (XI1_I1988_I151_XP_p1 I1_I1988_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I151_XP_MP1 (I1_I1988_P26_19 I1_I1988_P22_19n XI1_I1988_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I147_XP_MP0 (XI1_I1988_I147_XP_p1 I1_I1988_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I147_XP_MP1 (I1_I1988_P22_15 I1_I1988_P18_15n XI1_I1988_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I84_XP_MP0 (XI1_I2066_I84_XP_p1 I1_I2066_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I84_XP_MP1 (I1_I2066_P18_17 I1_I2066_pn17 XI1_I2066_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I149_XP_MP0 (XI1_I2066_I149_XP_p1 I1_I2066_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I149_XP_MP1 (I1_I2066_P24_17 I1_I2066_P20_17n XI1_I2066_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I145_XP_MP0 (XI1_I2066_I145_XP_p1 I1_I2066_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I145_XP_MP1 (I1_I2066_P20_13 I1_I2066_P16_13n XI1_I2066_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I83_XP_MP0 (XI1_I2066_I83_XP_p1 I1_I2066_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I83_XP_MP1 (I1_I2066_P17_16 I1_I2066_pn16 XI1_I2066_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I413_XP_MP0 (XI0_I1660_I413_XP_p1 I0_I1660_P50_35n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I413_XP_MP1 (I0_I1660_P50_19 I0_I1660_P34_19n XI0_I1660_I413_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I423_XP_MP0 (XI0_I1660_I423_XP_p1 I0_I1660_P60_45n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I423_XP_MP1 (I0_I1660_P60_29 I0_I1660_P44_29n XI0_I1660_I423_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I305_XP_MP0 (XI0_I1660_I305_XP_p1 I0_I1660_P52_49n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I305_XP_MP1 (I0_I1660_P52_45 I0_I1660_P48_45n XI0_I1660_I305_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I176_XP_MP0 (XI0_I1660_I176_XP_p1 I0_I1660_pn46 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I176_XP_MP1 (I0_I1660_P46_45 I0_I1660_pn45 XI0_I1660_I176_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I424_XP_MP0 (XI0_I1660_I424_XP_p1 I0_I1660_P61_46n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I424_XP_MP1 (I0_I1660_P61_30 I0_I1660_P45_30n XI0_I1660_I424_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I310_XP_MP0 (XI0_I1660_I310_XP_p1 I0_I1660_P57_54n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I310_XP_MP1 (I0_I1660_P57_50 I0_I1660_P53_50n XI0_I1660_I310_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I306_XP_MP0 (XI0_I1660_I306_XP_p1 I0_I1660_P53_50n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I306_XP_MP1 (I0_I1660_P53_46 I0_I1660_P49_46n XI0_I1660_I306_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I312_XP_MP0 (XI0_I1660_I312_XP_p1 I0_I1660_P59_56n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I312_XP_MP1 (I0_I1660_P59_52 I0_I1660_P55_52n XI0_I1660_I312_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I179_XP_MP0 (XI0_I1660_I179_XP_p1 I0_I1660_pn49 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I179_XP_MP1 (I0_I1660_P49_48 I0_I1660_pn48 XI0_I1660_I179_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I152_XP_MP0 (XI1_I1850_I152_XP_p1 I1_I1850_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I152_XP_MP1 (I1_I1850_P27_20 I1_I1850_P23_20n XI1_I1850_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I87_XP_MP0 (XI1_I1850_I87_XP_p1 I1_I1850_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I87_XP_MP1 (I1_I1850_P21_20 I1_I1850_pn20 XI1_I1850_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I86_XP_MP0 (XI1_I1850_I86_XP_p1 I1_I1850_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I86_XP_MP1 (I1_I1850_P20_19 I1_I1850_pn19 XI1_I1850_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I145_XP_MP0 (XI1_I1850_I145_XP_p1 I1_I1850_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I145_XP_MP1 (I1_I1850_P20_13 I1_I1850_P16_13n XI1_I1850_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I143_XP_MP0 (XI1_I1850_I143_XP_p1 I1_I1850_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I143_XP_MP1 (I1_I1850_P18_11 I1_I1850_P14_11n XI1_I1850_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I150_XP_MP0 (XI1_I1896_I150_XP_p1 I1_I1896_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I150_XP_MP1 (I1_I1896_P25_18 I1_I1896_P21_18n XI1_I1896_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I86_XP_MP0 (XI1_I1896_I86_XP_p1 I1_I1896_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I86_XP_MP1 (I1_I1896_P20_19 I1_I1896_pn19 XI1_I1896_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I149_XP_MP0 (XI1_I1896_I149_XP_p1 I1_I1896_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I149_XP_MP1 (I1_I1896_P24_17 I1_I1896_P20_17n XI1_I1896_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I87_XP_MP0 (XI1_I1942_I87_XP_p1 I1_I1942_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I87_XP_MP1 (I1_I1942_P21_20 I1_I1942_pn20 XI1_I1942_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I148_XP_MP0 (XI1_I1942_I148_XP_p1 I1_I1942_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I148_XP_MP1 (I1_I1942_P23_16 I1_I1942_P19_16n XI1_I1942_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I152_XP_MP0 (XI1_I1942_I152_XP_p1 I1_I1942_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I152_XP_MP1 (I1_I1942_P27_20 I1_I1942_P23_20n XI1_I1942_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I88_XP_MP0 (XI1_I1942_I88_XP_p1 I1_I1942_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I88_XP_MP1 (I1_I1942_P22_21 I1_I1942_pn21 XI1_I1942_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I89_XP_MP0 (XI1_I1988_I89_XP_p1 I1_I1988_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I89_XP_MP1 (I1_I1988_P23_22 I1_I1988_pn22 XI1_I1988_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I88_XP_MP0 (XI1_I1988_I88_XP_p1 I1_I1988_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I88_XP_MP1 (I1_I1988_P22_21 I1_I1988_pn21 XI1_I1988_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I85_XP_MP0 (XI1_I2066_I85_XP_p1 I1_I2066_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I85_XP_MP1 (I1_I2066_P19_18 I1_I2066_pn18 XI1_I2066_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I150_XP_MP0 (XI1_I2066_I150_XP_p1 I1_I2066_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I150_XP_MP1 (I1_I2066_P25_18 I1_I2066_P21_18n XI1_I2066_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I146_XP_MP0 (XI1_I2066_I146_XP_p1 I1_I2066_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I146_XP_MP1 (I1_I2066_P21_14 I1_I2066_P17_14n XI1_I2066_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I144_XP_MP0 (XI1_I2066_I144_XP_p1 I1_I2066_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I144_XP_MP1 (I1_I2066_P19_12 I1_I2066_P15_12n XI1_I2066_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I409_XP_MP0 (XI0_I1660_I409_XP_p1 I0_I1660_P46_31n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I409_XP_MP1 (I0_I1660_P46_15 I0_I1660_P30_15n XI0_I1660_I409_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I421_XP_MP0 (XI0_I1660_I421_XP_p1 I0_I1660_P58_43n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I421_XP_MP1 (I0_I1660_P58_27 I0_I1660_P42_27n XI0_I1660_I421_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I299_XP_MP0 (XI0_I1660_I299_XP_p1 I0_I1660_P46_43n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I299_XP_MP1 (I0_I1660_P46_39 I0_I1660_P42_39n XI0_I1660_I299_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I303_XP_MP0 (XI0_I1660_I303_XP_p1 I0_I1660_P50_47n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I303_XP_MP1 (I0_I1660_P50_43 I0_I1660_P46_43n XI0_I1660_I303_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I309_XP_MP0 (XI0_I1660_I309_XP_p1 I0_I1660_P56_53n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I309_XP_MP1 (I0_I1660_P56_49 I0_I1660_P52_49n XI0_I1660_I309_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I178_XP_MP0 (XI0_I1660_I178_XP_p1 I0_I1660_pn48 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I178_XP_MP1 (I0_I1660_P48_47 I0_I1660_pn47 XI0_I1660_I178_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I180_XP_MP0 (XI0_I1660_I180_XP_p1 I0_I1660_pn50 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I180_XP_MP1 (I0_I1660_P50_49 I0_I1660_pn49 XI0_I1660_I180_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I314_XP_MP0 (XI0_I1660_I314_XP_p1 I0_I1660_P61_58n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I314_XP_MP1 (I0_I1660_P61_54 I0_I1660_P57_54n XI0_I1660_I314_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I316_XP_MP0 (XI0_I1660_I316_XP_p1 I0_I1660_P63_60n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I316_XP_MP1 (I0_I1660_P63_56 I0_I1660_P59_56n XI0_I1660_I316_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I181_XP_MP0 (XI0_I1660_I181_XP_p1 I0_I1660_pn51 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I181_XP_MP1 (I0_I1660_P51_50 I0_I1660_pn50 XI0_I1660_I181_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I156_XP_MP0 (XI1_I1850_I156_XP_p1 I1_I1850_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I156_XP_MP1 (I1_I1850_P31_24 I1_I1850_P27_24n XI1_I1850_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I154_XP_MP0 (XI1_I1850_I154_XP_p1 I1_I1850_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I154_XP_MP1 (I1_I1850_P29_22 I1_I1850_P25_22n XI1_I1850_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I89_XP_MP0 (XI1_I1850_I89_XP_p1 I1_I1850_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I89_XP_MP1 (I1_I1850_P23_22 I1_I1850_pn22 XI1_I1850_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I88_XP_MP0 (XI1_I1850_I88_XP_p1 I1_I1850_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I88_XP_MP1 (I1_I1850_P22_21 I1_I1850_pn21 XI1_I1850_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I147_XP_MP0 (XI1_I1850_I147_XP_p1 I1_I1850_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I147_XP_MP1 (I1_I1850_P22_15 I1_I1850_P18_15n XI1_I1850_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I149_XP_MP0 (XI1_I1850_I149_XP_p1 I1_I1850_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I149_XP_MP1 (I1_I1850_P24_17 I1_I1850_P20_17n XI1_I1850_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I87_XP_MP0 (XI1_I1896_I87_XP_p1 I1_I1896_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I87_XP_MP1 (I1_I1896_P21_20 I1_I1896_pn20 XI1_I1896_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I152_XP_MP0 (XI1_I1896_I152_XP_p1 I1_I1896_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I152_XP_MP1 (I1_I1896_P27_20 I1_I1896_P23_20n XI1_I1896_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I148_XP_MP0 (XI1_I1896_I148_XP_p1 I1_I1896_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I148_XP_MP1 (I1_I1896_P23_16 I1_I1896_P19_16n XI1_I1896_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I88_XP_MP0 (XI1_I1896_I88_XP_p1 I1_I1896_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I88_XP_MP1 (I1_I1896_P22_21 I1_I1896_pn21 XI1_I1896_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I151_XP_MP0 (XI1_I1896_I151_XP_p1 I1_I1896_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I151_XP_MP1 (I1_I1896_P26_19 I1_I1896_P22_19n XI1_I1896_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I147_XP_MP0 (XI1_I1896_I147_XP_p1 I1_I1896_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I147_XP_MP1 (I1_I1896_P22_15 I1_I1896_P18_15n XI1_I1896_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I89_XP_MP0 (XI1_I1942_I89_XP_p1 I1_I1942_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I89_XP_MP1 (I1_I1942_P23_22 I1_I1942_pn22 XI1_I1942_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I154_XP_MP0 (XI1_I1942_I154_XP_p1 I1_I1942_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I154_XP_MP1 (I1_I1942_P29_22 I1_I1942_P25_22n XI1_I1942_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I153_XP_MP0 (XI1_I1942_I153_XP_p1 I1_I1942_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I153_XP_MP1 (I1_I1942_P28_21 I1_I1942_P24_21n XI1_I1942_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I154_XP_MP0 (XI1_I1988_I154_XP_p1 I1_I1988_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I154_XP_MP1 (I1_I1988_P29_22 I1_I1988_P25_22n XI1_I1988_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I90_XP_MP0 (XI1_I1988_I90_XP_p1 I1_I1988_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I90_XP_MP1 (I1_I1988_P24_23 I1_I1988_pn23 XI1_I1988_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I153_XP_MP0 (XI1_I1988_I153_XP_p1 I1_I1988_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I153_XP_MP1 (I1_I1988_P28_21 I1_I1988_P24_21n XI1_I1988_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I88_XP_MP0 (XI1_I2066_I88_XP_p1 I1_I2066_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I88_XP_MP1 (I1_I2066_P22_21 I1_I2066_pn21 XI1_I2066_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I86_XP_MP0 (XI1_I2066_I86_XP_p1 I1_I2066_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I86_XP_MP1 (I1_I2066_P20_19 I1_I2066_pn19 XI1_I2066_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I153_XP_MP0 (XI1_I2066_I153_XP_p1 I1_I2066_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I153_XP_MP1 (I1_I2066_P28_21 I1_I2066_P24_21n XI1_I2066_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I147_XP_MP0 (XI1_I2066_I147_XP_p1 I1_I2066_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I147_XP_MP1 (I1_I2066_P22_15 I1_I2066_P18_15n XI1_I2066_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I87_XP_MP0 (XI1_I2066_I87_XP_p1 I1_I2066_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I87_XP_MP1 (I1_I2066_P21_20 I1_I2066_pn20 XI1_I2066_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I20_MP0 (XI2_I4_I20_p1 Y_40 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I20_MP1 (I2_I4_z0_20 Y_41 XI2_I4_I20_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I21_MP0 (XI2_I4_I21_p1 Y_42 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I21_MP1 (I2_I4_z0_21 Y_43 XI2_I4_I21_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I417_XP_MP0 (XI0_I1660_I417_XP_p1 I0_I1660_P54_39n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I417_XP_MP1 (I0_I1660_P54_23 I0_I1660_P38_23n XI0_I1660_I417_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I307_XP_MP0 (XI0_I1660_I307_XP_p1 I0_I1660_P54_51n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I307_XP_MP1 (I0_I1660_P54_47 I0_I1660_P50_47n XI0_I1660_I307_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I313_XP_MP0 (XI0_I1660_I313_XP_p1 I0_I1660_P60_57n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I313_XP_MP1 (I0_I1660_P60_53 I0_I1660_P56_53n XI0_I1660_I313_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I91_XP_MP0 (XI1_I1850_I91_XP_p1 I1_I1850_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I91_XP_MP1 (I1_I1850_P25_24 I1_I1850_pn24 XI1_I1850_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I90_XP_MP0 (XI1_I1850_I90_XP_p1 I1_I1850_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I90_XP_MP1 (I1_I1850_P24_23 I1_I1850_pn23 XI1_I1850_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I151_XP_MP0 (XI1_I1850_I151_XP_p1 I1_I1850_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I151_XP_MP1 (I1_I1850_P26_19 I1_I1850_P22_19n XI1_I1850_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I89_XP_MP0 (XI1_I1896_I89_XP_p1 I1_I1896_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I89_XP_MP1 (I1_I1896_P23_22 I1_I1896_pn22 XI1_I1896_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I154_XP_MP0 (XI1_I1896_I154_XP_p1 I1_I1896_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I154_XP_MP1 (I1_I1896_P29_22 I1_I1896_P25_22n XI1_I1896_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I90_XP_MP0 (XI1_I1896_I90_XP_p1 I1_I1896_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I90_XP_MP1 (I1_I1896_P24_23 I1_I1896_pn23 XI1_I1896_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I153_XP_MP0 (XI1_I1896_I153_XP_p1 I1_I1896_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I153_XP_MP1 (I1_I1896_P28_21 I1_I1896_P24_21n XI1_I1896_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I91_XP_MP0 (XI1_I1942_I91_XP_p1 I1_I1942_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I91_XP_MP1 (I1_I1942_P25_24 I1_I1942_pn24 XI1_I1942_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I156_XP_MP0 (XI1_I1942_I156_XP_p1 I1_I1942_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I156_XP_MP1 (I1_I1942_P31_24 I1_I1942_P27_24n XI1_I1942_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I90_XP_MP0 (XI1_I1942_I90_XP_p1 I1_I1942_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I90_XP_MP1 (I1_I1942_P24_23 I1_I1942_pn23 XI1_I1942_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I155_XP_MP0 (XI1_I1942_I155_XP_p1 I1_I1942_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I155_XP_MP1 (I1_I1942_P30_23 I1_I1942_P26_23n XI1_I1942_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I91_XP_MP0 (XI1_I1988_I91_XP_p1 I1_I1988_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I91_XP_MP1 (I1_I1988_P25_24 I1_I1988_pn24 XI1_I1988_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I156_XP_MP0 (XI1_I1988_I156_XP_p1 I1_I1988_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I156_XP_MP1 (I1_I1988_P31_24 I1_I1988_P27_24n XI1_I1988_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I155_XP_MP0 (XI1_I1988_I155_XP_p1 I1_I1988_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I155_XP_MP1 (I1_I1988_P30_23 I1_I1988_P26_23n XI1_I1988_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I151_XP_MP0 (XI1_I2066_I151_XP_p1 I1_I2066_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I151_XP_MP1 (I1_I2066_P26_19 I1_I2066_P22_19n XI1_I2066_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I89_XP_MP0 (XI1_I2066_I89_XP_p1 I1_I2066_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I89_XP_MP1 (I1_I2066_P23_22 I1_I2066_pn22 XI1_I2066_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I148_XP_MP0 (XI1_I2066_I148_XP_p1 I1_I2066_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I148_XP_MP1 (I1_I2066_P23_16 I1_I2066_P19_16n XI1_I2066_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I22_MP0 (XI2_I4_I22_p1 Y_44 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I22_MP1 (I2_I4_z0_22 Y_45 XI2_I4_I22_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I425_XP_MP0 (XI0_I1660_I425_XP_p1 I0_I1660_P62_47n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I425_XP_MP1 (I0_I1660_P62_31 I0_I1660_P46_31n XI0_I1660_I425_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I311_XP_MP0 (XI0_I1660_I311_XP_p1 I0_I1660_P58_55n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I311_XP_MP1 (I0_I1660_P58_51 I0_I1660_P54_51n XI0_I1660_I311_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I182_XP_MP0 (XI0_I1660_I182_XP_p1 I0_I1660_pn52 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I182_XP_MP1 (I0_I1660_P52_51 I0_I1660_pn51 XI0_I1660_I182_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I189_XP_MP0 (XI0_I1660_I189_XP_p1 I0_I1660_pn59 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I189_XP_MP1 (I0_I1660_P59_58 I0_I1660_pn58 XI0_I1660_I189_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I187_XP_MP0 (XI0_I1660_I187_XP_p1 I0_I1660_pn57 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I187_XP_MP1 (I0_I1660_P57_56 I0_I1660_pn56 XI0_I1660_I187_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I183_XP_MP0 (XI0_I1660_I183_XP_p1 I0_I1660_pn53 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I183_XP_MP1 (I0_I1660_P53_52 I0_I1660_pn52 XI0_I1660_I183_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I153_XP_MP0 (XI1_I1850_I153_XP_p1 I1_I1850_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I153_XP_MP1 (I1_I1850_P28_21 I1_I1850_P24_21n XI1_I1850_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I91_XP_MP0 (XI1_I1896_I91_XP_p1 I1_I1896_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I91_XP_MP1 (I1_I1896_P25_24 I1_I1896_pn24 XI1_I1896_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I156_XP_MP0 (XI1_I1896_I156_XP_p1 I1_I1896_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I156_XP_MP1 (I1_I1896_P31_24 I1_I1896_P27_24n XI1_I1896_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I92_XP_MP0 (XI1_I1896_I92_XP_p1 I1_I1896_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I92_XP_MP1 (I1_I1896_P26_25 I1_I1896_pn25 XI1_I1896_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I155_XP_MP0 (XI1_I1896_I155_XP_p1 I1_I1896_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I155_XP_MP1 (I1_I1896_P30_23 I1_I1896_P26_23n XI1_I1896_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I93_XP_MP0 (XI1_I1942_I93_XP_p1 I1_I1942_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I93_XP_MP1 (I1_I1942_P27_26 I1_I1942_pn26 XI1_I1942_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I92_XP_MP0 (XI1_I1942_I92_XP_p1 I1_I1942_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I92_XP_MP1 (I1_I1942_P26_25 I1_I1942_pn25 XI1_I1942_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I93_XP_MP0 (XI1_I1988_I93_XP_p1 I1_I1988_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I93_XP_MP1 (I1_I1988_P27_26 I1_I1988_pn26 XI1_I1988_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I92_XP_MP0 (XI1_I1988_I92_XP_p1 I1_I1988_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I92_XP_MP1 (I1_I1988_P26_25 I1_I1988_pn25 XI1_I1988_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I90_XP_MP0 (XI1_I2066_I90_XP_p1 I1_I2066_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I90_XP_MP1 (I1_I2066_P24_23 I1_I2066_pn23 XI1_I2066_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I155_XP_MP0 (XI1_I2066_I155_XP_p1 I1_I2066_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I155_XP_MP1 (I1_I2066_P30_23 I1_I2066_P26_23n XI1_I2066_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I91_XP_MP0 (XI1_I2066_I91_XP_p1 I1_I2066_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I91_XP_MP1 (I1_I2066_P25_24 I1_I2066_pn24 XI1_I2066_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I154_XP_MP0 (XI1_I2066_I154_XP_p1 I1_I2066_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I154_XP_MP1 (I1_I2066_P29_22 I1_I2066_P25_22n XI1_I2066_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I152_XP_MP0 (XI1_I2066_I152_XP_p1 I1_I2066_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I152_XP_MP1 (I1_I2066_P27_20 I1_I2066_P23_20n XI1_I2066_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I53_MP0 (XI2_I4_I53_p1 I2_I4_z1_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I53_MP1 (I2_I4_z2_5 I2_I4_z1_11 XI2_I4_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I25_MP0 (XI2_I4_I25_p1 Y_50 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I25_MP1 (I2_I4_z0_25 Y_51 XI2_I4_I25_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I23_MP0 (XI2_I4_I23_p1 Y_46 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I23_MP1 (I2_I4_z0_23 Y_47 XI2_I4_I23_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I315_XP_MP0 (XI0_I1660_I315_XP_p1 I0_I1660_P62_59n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I315_XP_MP1 (I0_I1660_P62_55 I0_I1660_P58_55n XI0_I1660_I315_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I184_XP_MP0 (XI0_I1660_I184_XP_p1 I0_I1660_pn54 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I184_XP_MP1 (I0_I1660_P54_53 I0_I1660_pn53 XI0_I1660_I184_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I188_XP_MP0 (XI0_I1660_I188_XP_p1 I0_I1660_pn58 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I188_XP_MP1 (I0_I1660_P58_57 I0_I1660_pn57 XI0_I1660_I188_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I186_XP_MP0 (XI0_I1660_I186_XP_p1 I0_I1660_pn56 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I186_XP_MP1 (I0_I1660_P56_55 I0_I1660_pn55 XI0_I1660_I186_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I191_XP_MP0 (XI0_I1660_I191_XP_p1 I0_I1660_pn61 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I191_XP_MP1 (I0_I1660_P61_60 I0_I1660_pn60 XI0_I1660_I191_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I185_XP_MP0 (XI0_I1660_I185_XP_p1 I0_I1660_pn55 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I185_XP_MP1 (I0_I1660_P55_54 I0_I1660_pn54 XI0_I1660_I185_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I97_XP_MP0 (XI1_I1850_I97_XP_p1 I1_I1850_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I97_XP_MP1 (I1_I1850_P31_30 I1_I1850_pn30 XI1_I1850_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I95_XP_MP0 (XI1_I1850_I95_XP_p1 I1_I1850_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I95_XP_MP1 (I1_I1850_P29_28 I1_I1850_pn28 XI1_I1850_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I96_XP_MP0 (XI1_I1850_I96_XP_p1 I1_I1850_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I96_XP_MP1 (I1_I1850_P30_29 I1_I1850_pn29 XI1_I1850_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I93_XP_MP0 (XI1_I1850_I93_XP_p1 I1_I1850_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I93_XP_MP1 (I1_I1850_P27_26 I1_I1850_pn26 XI1_I1850_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I92_XP_MP0 (XI1_I1850_I92_XP_p1 I1_I1850_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I92_XP_MP1 (I1_I1850_P26_25 I1_I1850_pn25 XI1_I1850_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I155_XP_MP0 (XI1_I1850_I155_XP_p1 I1_I1850_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I155_XP_MP1 (I1_I1850_P30_23 I1_I1850_P26_23n XI1_I1850_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I93_XP_MP0 (XI1_I1896_I93_XP_p1 I1_I1896_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I93_XP_MP1 (I1_I1896_P27_26 I1_I1896_pn26 XI1_I1896_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I95_XP_MP0 (XI1_I1942_I95_XP_p1 I1_I1942_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I95_XP_MP1 (I1_I1942_P29_28 I1_I1942_pn28 XI1_I1942_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I97_XP_MP0 (XI1_I1942_I97_XP_p1 I1_I1942_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I97_XP_MP1 (I1_I1942_P31_30 I1_I1942_pn30 XI1_I1942_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I94_XP_MP0 (XI1_I1942_I94_XP_p1 I1_I1942_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I94_XP_MP1 (I1_I1942_P28_27 I1_I1942_pn27 XI1_I1942_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I96_XP_MP0 (XI1_I1942_I96_XP_p1 I1_I1942_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1942_I96_XP_MP1 (I1_I1942_P30_29 I1_I1942_pn29 XI1_I1942_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I95_XP_MP0 (XI1_I1988_I95_XP_p1 I1_I1988_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I95_XP_MP1 (I1_I1988_P29_28 I1_I1988_pn28 XI1_I1988_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I94_XP_MP0 (XI1_I1988_I94_XP_p1 I1_I1988_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I94_XP_MP1 (I1_I1988_P28_27 I1_I1988_pn27 XI1_I1988_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I96_XP_MP0 (XI1_I1988_I96_XP_p1 I1_I1988_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I96_XP_MP1 (I1_I1988_P30_29 I1_I1988_pn29 XI1_I1988_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I92_XP_MP0 (XI1_I2066_I92_XP_p1 I1_I2066_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I92_XP_MP1 (I1_I2066_P26_25 I1_I2066_pn25 XI1_I2066_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I94_XP_MP0 (XI1_I2066_I94_XP_p1 I1_I2066_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I94_XP_MP1 (I1_I2066_P28_27 I1_I2066_pn27 XI1_I2066_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I93_XP_MP0 (XI1_I2066_I93_XP_p1 I1_I2066_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I93_XP_MP1 (I1_I2066_P27_26 I1_I2066_pn26 XI1_I2066_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I156_XP_MP0 (XI1_I2066_I156_XP_p1 I1_I2066_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I156_XP_MP1 (I1_I2066_P31_24 I1_I2066_P27_24n XI1_I2066_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I16_MP0 (XI2_I4_I16_p1 Y_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I16_MP1 (I2_I4_z0_16 Y_33 XI2_I4_I16_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I52_MP0 (XI2_I4_I52_p1 I2_I4_z1_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I52_MP1 (I2_I4_z2_4 I2_I4_z1_9 XI2_I4_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I24_MP0 (XI2_I4_I24_p1 Y_48 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I24_MP1 (I2_I4_z0_24 Y_49 XI2_I4_I24_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I54_MP0 (XI2_I4_I54_p1 I2_I4_z1_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I54_MP1 (I2_I4_z2_6 I2_I4_z1_13 XI2_I4_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I26_MP0 (XI2_I4_I26_p1 Y_52 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I26_MP1 (I2_I4_z0_26 Y_53 XI2_I4_I26_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I27_MP0 (XI2_I4_I27_p1 Y_54 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I27_MP1 (I2_I4_z0_27 Y_55 XI2_I4_I27_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I190_XP_MP0 (XI0_I1660_I190_XP_p1 I0_I1660_pn60 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I190_XP_MP1 (I0_I1660_P60_59 I0_I1660_pn59 XI0_I1660_I190_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I94_XP_MP0 (XI1_I1850_I94_XP_p1 I1_I1850_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1850_I94_XP_MP1 (I1_I1850_P28_27 I1_I1850_pn27 XI1_I1850_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I95_XP_MP0 (XI1_I1896_I95_XP_p1 I1_I1896_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I95_XP_MP1 (I1_I1896_P29_28 I1_I1896_pn28 XI1_I1896_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I97_XP_MP0 (XI1_I1896_I97_XP_p1 I1_I1896_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I97_XP_MP1 (I1_I1896_P31_30 I1_I1896_pn30 XI1_I1896_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I96_XP_MP0 (XI1_I1896_I96_XP_p1 I1_I1896_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I96_XP_MP1 (I1_I1896_P30_29 I1_I1896_pn29 XI1_I1896_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I94_XP_MP0 (XI1_I1896_I94_XP_p1 I1_I1896_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1896_I94_XP_MP1 (I1_I1896_P28_27 I1_I1896_pn27 XI1_I1896_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I97_XP_MP0 (XI1_I1988_I97_XP_p1 I1_I1988_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1988_I97_XP_MP1 (I1_I1988_P31_30 I1_I1988_pn30 XI1_I1988_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I96_XP_MP0 (XI1_I2066_I96_XP_p1 I1_I2066_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I96_XP_MP1 (I1_I2066_P30_29 I1_I2066_pn29 XI1_I2066_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I97_XP_MP0 (XI1_I2066_I97_XP_p1 I1_I2066_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I97_XP_MP1 (I1_I2066_P31_30 I1_I2066_pn30 XI1_I2066_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I95_XP_MP0 (XI1_I2066_I95_XP_p1 I1_I2066_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I2066_I95_XP_MP1 (I1_I2066_P29_28 I1_I2066_pn28 XI1_I2066_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I17_MP0 (XI2_I4_I17_p1 Y_34 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I17_MP1 (I2_I4_z0_17 Y_35 XI2_I4_I17_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I19_MP0 (XI2_I4_I19_p1 Y_38 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I19_MP1 (I2_I4_z0_19 Y_39 XI2_I4_I19_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I18_MP0 (XI2_I4_I18_p1 Y_36 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I18_MP1 (I2_I4_z0_18 Y_37 XI2_I4_I18_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I61_MP0 (XI2_I4_I61_p1 I2_I4_z3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I61_MP1 (I2_I4_z4_1 I2_I4_z3_3 XI2_I4_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I28_MP0 (XI2_I4_I28_p1 Y_56 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I28_MP1 (I2_I4_z0_28 Y_57 XI2_I4_I28_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I55_MP0 (XI2_I4_I55_p1 I2_I4_z1_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I55_MP1 (I2_I4_z2_7 I2_I4_z1_15 XI2_I4_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I29_MP0 (XI2_I4_I29_p1 Y_58 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I29_MP1 (I2_I4_z0_29 Y_59 XI2_I4_I29_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I31_MP0 (XI2_I4_I31_p1 Y_62 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I31_MP1 (I2_I4_z0_31 Y_63 XI2_I4_I31_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI2_I4_I30_MP0 (XI2_I4_I30_p1 Y_60 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI2_I4_I30_MP1 (I2_I4_z0_30 Y_61 XI2_I4_I30_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I192_XP_MP0 (XI0_I1660_I192_XP_p1 I0_I1660_pn62 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I192_XP_MP1 (I0_I1660_P62_61 I0_I1660_pn61 XI0_I1660_I192_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I193_XP_MP0 (XI0_I1660_I193_XP_p1 I0_I1660_pn63 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1660_I193_XP_MP1 (I0_I1660_P63_62 I0_I1660_pn62 XI0_I1660_I193_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1438_MP50 (VDD XI0_I1438_s1 XI0_I1438_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1438_MP47 (XI0_I1438_bp3 I0_pp3_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1438_MP49 (XI0_I1438_bsn XI0_I1438_bcon XI0_I1438_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1438_MP52 (XI0_I1438_bp5 I0_cm73_2 XI0_I1438_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1438_MP51 (XI0_I1438_bp4 I0_pp3_28 XI0_I1438_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1438_MP51_1 (XI0_I1438_bp5 I0_pp3_28 XI0_I1438_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1438_MP52_1 (XI0_I1438_bsn I0_cm73_2 XI0_I1438_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1438_MP54 (VDD XI0_I1438_bsn I0_cm77_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1438_MP41 (XI0_I1438_bp1 XI0_I1438_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1438_MP42 (XI0_I1438_bcon I0_pp3_28 XI0_I1438_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1438_MP45 (XI0_I1438_bp2 I0_cm73_2 XI0_I1438_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1438_MP43 (VDD XI0_I1438_s1 XI0_I1438_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1438_MP44 (XI0_I1438_bp2 I0_pp3_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1438_MP56 (VDD XI0_I1438_bcon I0_cm77_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1438_MP46 (XI0_I1438_bp3 XI0_I1438_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1438_MP48 (VDD I0_cm73_2 XI0_I1438_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1438_MP50_1 (XI0_I1438_bp4 XI0_I1438_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1438_MP26 (VDD XI0_I1438_asn XI0_I1438_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1438_MP18 (XI0_I1438_ap3 I0_pp0_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1438_MP21 (XI0_I1438_asn XI0_I1438_acon XI0_I1438_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1438_MP24 (XI0_I1438_ap5 I0_pp2_30 XI0_I1438_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1438_MP23 (XI0_I1438_ap4 I0_pp1_32 XI0_I1438_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1438_MP22 (VDD I0_pp0_32 XI0_I1438_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1438_MP22_1 (XI0_I1438_ap4 I0_pp0_32 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1438_MP23_1 (XI0_I1438_ap5 I0_pp1_32 XI0_I1438_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1438_MP24_1 (XI0_I1438_asn I0_pp2_30 XI0_I1438_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1438_MP17 (XI0_I1438_acon I0_pp2_30 XI0_I1438_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1438_MP14 (XI0_I1438_ap1 I0_pp1_32 XI0_I1438_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1438_MP13 (VDD I0_pp0_32 XI0_I1438_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1438_MP15 (XI0_I1438_ap2 I0_pp0_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1438_MP16 (VDD I0_pp1_32 XI0_I1438_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1438_MP28 (I0_cm77_2 XI0_I1438_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1438_MP19 (XI0_I1438_ap3 I0_pp1_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1438_MP20 (VDD I0_pp2_30 XI0_I1438_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1442_MP50 (VDD XI0_I1442_s1 XI0_I1442_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1442_MP47 (XI0_I1442_bp3 I0_pp3_29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1442_MP49 (XI0_I1442_bsn XI0_I1442_bcon XI0_I1442_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1442_MP52 (XI0_I1442_bp5 I0_cm77_2 XI0_I1442_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1442_MP51 (XI0_I1442_bp4 I0_pp3_29 XI0_I1442_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1442_MP51_1 (XI0_I1442_bp5 I0_pp3_29 XI0_I1442_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1442_MP52_1 (XI0_I1442_bsn I0_cm77_2 XI0_I1442_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1442_MP54 (VDD XI0_I1442_bsn I0_cm81_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1442_MP41 (XI0_I1442_bp1 XI0_I1442_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1442_MP42 (XI0_I1442_bcon I0_pp3_29 XI0_I1442_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1442_MP45 (XI0_I1442_bp2 I0_cm77_2 XI0_I1442_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1442_MP43 (VDD XI0_I1442_s1 XI0_I1442_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1442_MP44 (XI0_I1442_bp2 I0_pp3_29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1442_MP56 (VDD XI0_I1442_bcon I0_cm81_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1442_MP46 (XI0_I1442_bp3 XI0_I1442_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1442_MP48 (VDD I0_cm77_2 XI0_I1442_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1442_MP50_1 (XI0_I1442_bp4 XI0_I1442_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1442_MP26 (VDD XI0_I1442_asn XI0_I1442_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1442_MP18 (XI0_I1442_ap3 I0_sn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1442_MP21 (XI0_I1442_asn XI0_I1442_acon XI0_I1442_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1442_MP24 (XI0_I1442_ap5 I0_pp2_31 XI0_I1442_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1442_MP23 (XI0_I1442_ap4 I0_sn1 XI0_I1442_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1442_MP22 (VDD I0_sn0 XI0_I1442_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1442_MP22_1 (XI0_I1442_ap4 I0_sn0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1442_MP23_1 (XI0_I1442_ap5 I0_sn1 XI0_I1442_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1442_MP24_1 (XI0_I1442_asn I0_pp2_31 XI0_I1442_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1442_MP17 (XI0_I1442_acon I0_pp2_31 XI0_I1442_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1442_MP14 (XI0_I1442_ap1 I0_sn1 XI0_I1442_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1442_MP13 (VDD I0_sn0 XI0_I1442_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1442_MP15 (XI0_I1442_ap2 I0_sn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1442_MP16 (VDD I0_sn1 XI0_I1442_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1442_MP28 (I0_cm81_2 XI0_I1442_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1442_MP19 (XI0_I1442_ap3 I0_sn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1442_MP20 (VDD I0_pp2_31 XI0_I1442_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1407_MP50 (VDD XI0_I1407_s1 XI0_I1407_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1407_MP47 (XI0_I1407_bp3 I0_pp3_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1407_MP49 (XI0_I1407_bsn XI0_I1407_bcon XI0_I1407_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1407_MP52 (XI0_I1407_bp5 I0_cm43_2 XI0_I1407_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1407_MP51 (XI0_I1407_bp4 I0_pp3_20 XI0_I1407_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1407_MP51_1 (XI0_I1407_bp5 I0_pp3_20 XI0_I1407_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1407_MP52_1 (XI0_I1407_bsn I0_cm43_2 XI0_I1407_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1407_MP54 (VDD XI0_I1407_bsn I0_cm46_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1407_MP41 (XI0_I1407_bp1 XI0_I1407_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1407_MP42 (XI0_I1407_bcon I0_pp3_20 XI0_I1407_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1407_MP45 (XI0_I1407_bp2 I0_cm43_2 XI0_I1407_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1407_MP43 (VDD XI0_I1407_s1 XI0_I1407_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1407_MP44 (XI0_I1407_bp2 I0_pp3_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1407_MP56 (VDD XI0_I1407_bcon I0_cm46_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1407_MP46 (XI0_I1407_bp3 XI0_I1407_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1407_MP48 (VDD I0_cm43_2 XI0_I1407_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1407_MP50_1 (XI0_I1407_bp4 XI0_I1407_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1407_MP26 (VDD XI0_I1407_asn XI0_I1407_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1407_MP18 (XI0_I1407_ap3 I0_pp0_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1407_MP21 (XI0_I1407_asn XI0_I1407_acon XI0_I1407_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1407_MP24 (XI0_I1407_ap5 I0_pp2_22 XI0_I1407_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1407_MP23 (XI0_I1407_ap4 I0_pp1_24 XI0_I1407_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1407_MP22 (VDD I0_pp0_26 XI0_I1407_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1407_MP22_1 (XI0_I1407_ap4 I0_pp0_26 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1407_MP23_1 (XI0_I1407_ap5 I0_pp1_24 XI0_I1407_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1407_MP24_1 (XI0_I1407_asn I0_pp2_22 XI0_I1407_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1407_MP17 (XI0_I1407_acon I0_pp2_22 XI0_I1407_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1407_MP14 (XI0_I1407_ap1 I0_pp1_24 XI0_I1407_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1407_MP13 (VDD I0_pp0_26 XI0_I1407_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1407_MP15 (XI0_I1407_ap2 I0_pp0_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1407_MP16 (VDD I0_pp1_24 XI0_I1407_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1407_MP28 (I0_cm46_2 XI0_I1407_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1407_MP19 (XI0_I1407_ap3 I0_pp1_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1407_MP20 (VDD I0_pp2_22 XI0_I1407_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1426_MP50 (VDD XI0_I1426_s1 XI0_I1426_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1426_MP47 (XI0_I1426_bp3 I0_pp3_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1426_MP49 (XI0_I1426_bsn XI0_I1426_bcon XI0_I1426_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1426_MP52 (XI0_I1426_bp5 I0_cm61_2 XI0_I1426_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1426_MP51 (XI0_I1426_bp4 I0_pp3_25 XI0_I1426_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1426_MP51_1 (XI0_I1426_bp5 I0_pp3_25 XI0_I1426_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1426_MP52_1 (XI0_I1426_bsn I0_cm61_2 XI0_I1426_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1426_MP54 (VDD XI0_I1426_bsn I0_cm65_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1426_MP41 (XI0_I1426_bp1 XI0_I1426_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1426_MP42 (XI0_I1426_bcon I0_pp3_25 XI0_I1426_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1426_MP45 (XI0_I1426_bp2 I0_cm61_2 XI0_I1426_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1426_MP43 (VDD XI0_I1426_s1 XI0_I1426_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1426_MP44 (XI0_I1426_bp2 I0_pp3_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1426_MP56 (VDD XI0_I1426_bcon I0_cm65_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1426_MP46 (XI0_I1426_bp3 XI0_I1426_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1426_MP48 (VDD I0_cm61_2 XI0_I1426_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1426_MP50_1 (XI0_I1426_bp4 XI0_I1426_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1426_MP26 (VDD XI0_I1426_asn XI0_I1426_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1426_MP18 (XI0_I1426_ap3 I0_pp0_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1426_MP21 (XI0_I1426_asn XI0_I1426_acon XI0_I1426_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1426_MP24 (XI0_I1426_ap5 I0_pp2_27 XI0_I1426_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1426_MP23 (XI0_I1426_ap4 I0_pp1_29 XI0_I1426_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1426_MP22 (VDD I0_pp0_31 XI0_I1426_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1426_MP22_1 (XI0_I1426_ap4 I0_pp0_31 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1426_MP23_1 (XI0_I1426_ap5 I0_pp1_29 XI0_I1426_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1426_MP24_1 (XI0_I1426_asn I0_pp2_27 XI0_I1426_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1426_MP17 (XI0_I1426_acon I0_pp2_27 XI0_I1426_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1426_MP14 (XI0_I1426_ap1 I0_pp1_29 XI0_I1426_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1426_MP13 (VDD I0_pp0_31 XI0_I1426_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1426_MP15 (XI0_I1426_ap2 I0_pp0_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1426_MP16 (VDD I0_pp1_29 XI0_I1426_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1426_MP28 (I0_cm65_2 XI0_I1426_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1426_MP19 (XI0_I1426_ap3 I0_pp1_29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1426_MP20 (VDD I0_pp2_27 XI0_I1426_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1430_MP50 (VDD XI0_I1430_s1 XI0_I1430_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1430_MP47 (XI0_I1430_bp3 I0_pp3_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1430_MP49 (XI0_I1430_bsn XI0_I1430_bcon XI0_I1430_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1430_MP52 (XI0_I1430_bp5 I0_cm65_2 XI0_I1430_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1430_MP51 (XI0_I1430_bp4 I0_pp3_26 XI0_I1430_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1430_MP51_1 (XI0_I1430_bp5 I0_pp3_26 XI0_I1430_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1430_MP52_1 (XI0_I1430_bsn I0_cm65_2 XI0_I1430_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1430_MP54 (VDD XI0_I1430_bsn I0_cm69_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1430_MP41 (XI0_I1430_bp1 XI0_I1430_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1430_MP42 (XI0_I1430_bcon I0_pp3_26 XI0_I1430_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1430_MP45 (XI0_I1430_bp2 I0_cm65_2 XI0_I1430_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1430_MP43 (VDD XI0_I1430_s1 XI0_I1430_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1430_MP44 (XI0_I1430_bp2 I0_pp3_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1430_MP56 (VDD XI0_I1430_bcon I0_cm69_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1430_MP46 (XI0_I1430_bp3 XI0_I1430_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1430_MP48 (VDD I0_cm65_2 XI0_I1430_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1430_MP50_1 (XI0_I1430_bp4 XI0_I1430_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1430_MP26 (VDD XI0_I1430_asn XI0_I1430_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1430_MP18 (XI0_I1430_ap3 I0_pp0_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1430_MP21 (XI0_I1430_asn XI0_I1430_acon XI0_I1430_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1430_MP24 (XI0_I1430_ap5 I0_pp2_28 XI0_I1430_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1430_MP23 (XI0_I1430_ap4 I0_pp1_30 XI0_I1430_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1430_MP22 (VDD I0_pp0_32 XI0_I1430_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1430_MP22_1 (XI0_I1430_ap4 I0_pp0_32 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1430_MP23_1 (XI0_I1430_ap5 I0_pp1_30 XI0_I1430_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1430_MP24_1 (XI0_I1430_asn I0_pp2_28 XI0_I1430_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1430_MP17 (XI0_I1430_acon I0_pp2_28 XI0_I1430_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1430_MP14 (XI0_I1430_ap1 I0_pp1_30 XI0_I1430_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1430_MP13 (VDD I0_pp0_32 XI0_I1430_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1430_MP15 (XI0_I1430_ap2 I0_pp0_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1430_MP16 (VDD I0_pp1_30 XI0_I1430_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1430_MP28 (I0_cm69_2 XI0_I1430_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1430_MP19 (XI0_I1430_ap3 I0_pp1_30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1430_MP20 (VDD I0_pp2_28 XI0_I1430_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1434_MP50 (VDD XI0_I1434_s1 XI0_I1434_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1434_MP47 (XI0_I1434_bp3 I0_pp3_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1434_MP49 (XI0_I1434_bsn XI0_I1434_bcon XI0_I1434_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1434_MP52 (XI0_I1434_bp5 I0_cm69_2 XI0_I1434_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1434_MP51 (XI0_I1434_bp4 I0_pp3_27 XI0_I1434_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1434_MP51_1 (XI0_I1434_bp5 I0_pp3_27 XI0_I1434_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1434_MP52_1 (XI0_I1434_bsn I0_cm69_2 XI0_I1434_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1434_MP54 (VDD XI0_I1434_bsn I0_cm73_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1434_MP41 (XI0_I1434_bp1 XI0_I1434_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1434_MP42 (XI0_I1434_bcon I0_pp3_27 XI0_I1434_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1434_MP45 (XI0_I1434_bp2 I0_cm69_2 XI0_I1434_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1434_MP43 (VDD XI0_I1434_s1 XI0_I1434_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1434_MP44 (XI0_I1434_bp2 I0_pp3_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1434_MP56 (VDD XI0_I1434_bcon I0_cm73_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1434_MP46 (XI0_I1434_bp3 XI0_I1434_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1434_MP48 (VDD I0_cm69_2 XI0_I1434_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1434_MP50_1 (XI0_I1434_bp4 XI0_I1434_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1434_MP26 (VDD XI0_I1434_asn XI0_I1434_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1434_MP18 (XI0_I1434_ap3 I0_pp0_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1434_MP21 (XI0_I1434_asn XI0_I1434_acon XI0_I1434_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1434_MP24 (XI0_I1434_ap5 I0_pp2_29 XI0_I1434_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1434_MP23 (XI0_I1434_ap4 I0_pp1_31 XI0_I1434_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1434_MP22 (VDD I0_pp0_32 XI0_I1434_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1434_MP22_1 (XI0_I1434_ap4 I0_pp0_32 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1434_MP23_1 (XI0_I1434_ap5 I0_pp1_31 XI0_I1434_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1434_MP24_1 (XI0_I1434_asn I0_pp2_29 XI0_I1434_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1434_MP17 (XI0_I1434_acon I0_pp2_29 XI0_I1434_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1434_MP14 (XI0_I1434_ap1 I0_pp1_31 XI0_I1434_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1434_MP13 (VDD I0_pp0_32 XI0_I1434_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1434_MP15 (XI0_I1434_ap2 I0_pp0_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1434_MP16 (VDD I0_pp1_31 XI0_I1434_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1434_MP28 (I0_cm73_2 XI0_I1434_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1434_MP19 (XI0_I1434_ap3 I0_pp1_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1434_MP20 (VDD I0_pp2_29 XI0_I1434_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1387_MP50 (VDD XI0_I1387_s1 XI0_I1387_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1387_MP47 (XI0_I1387_bp3 I0_pp3_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1387_MP49 (XI0_I1387_bsn XI0_I1387_bcon XI0_I1387_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1387_MP52 (XI0_I1387_bp5 I0_cm23_2 XI0_I1387_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1387_MP51 (XI0_I1387_bp4 I0_pp3_13 XI0_I1387_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1387_MP51_1 (XI0_I1387_bp5 I0_pp3_13 XI0_I1387_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1387_MP52_1 (XI0_I1387_bsn I0_cm23_2 XI0_I1387_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1387_MP54 (VDD XI0_I1387_bsn I0_cm26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1387_MP41 (XI0_I1387_bp1 XI0_I1387_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1387_MP42 (XI0_I1387_bcon I0_pp3_13 XI0_I1387_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1387_MP45 (XI0_I1387_bp2 I0_cm23_2 XI0_I1387_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1387_MP43 (VDD XI0_I1387_s1 XI0_I1387_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1387_MP44 (XI0_I1387_bp2 I0_pp3_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1387_MP56 (VDD XI0_I1387_bcon I0_cm26_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1387_MP46 (XI0_I1387_bp3 XI0_I1387_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1387_MP48 (VDD I0_cm23_2 XI0_I1387_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1387_MP50_1 (XI0_I1387_bp4 XI0_I1387_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1387_MP26 (VDD XI0_I1387_asn XI0_I1387_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1387_MP18 (XI0_I1387_ap3 I0_pp0_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1387_MP21 (XI0_I1387_asn XI0_I1387_acon XI0_I1387_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1387_MP24 (XI0_I1387_ap5 I0_pp2_15 XI0_I1387_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1387_MP23 (XI0_I1387_ap4 I0_pp1_17 XI0_I1387_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1387_MP22 (VDD I0_pp0_19 XI0_I1387_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1387_MP22_1 (XI0_I1387_ap4 I0_pp0_19 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1387_MP23_1 (XI0_I1387_ap5 I0_pp1_17 XI0_I1387_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1387_MP24_1 (XI0_I1387_asn I0_pp2_15 XI0_I1387_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1387_MP17 (XI0_I1387_acon I0_pp2_15 XI0_I1387_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1387_MP14 (XI0_I1387_ap1 I0_pp1_17 XI0_I1387_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1387_MP13 (VDD I0_pp0_19 XI0_I1387_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1387_MP15 (XI0_I1387_ap2 I0_pp0_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1387_MP16 (VDD I0_pp1_17 XI0_I1387_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1387_MP28 (I0_cm26_2 XI0_I1387_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1387_MP19 (XI0_I1387_ap3 I0_pp1_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1387_MP20 (VDD I0_pp2_15 XI0_I1387_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1389_MP50 (VDD XI0_I1389_s1 XI0_I1389_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1389_MP47 (XI0_I1389_bp3 I0_pp3_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1389_MP49 (XI0_I1389_bsn XI0_I1389_bcon XI0_I1389_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1389_MP52 (XI0_I1389_bp5 I0_cm26_2 XI0_I1389_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1389_MP51 (XI0_I1389_bp4 I0_pp3_14 XI0_I1389_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1389_MP51_1 (XI0_I1389_bp5 I0_pp3_14 XI0_I1389_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1389_MP52_1 (XI0_I1389_bsn I0_cm26_2 XI0_I1389_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1389_MP54 (VDD XI0_I1389_bsn I0_cm28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1389_MP41 (XI0_I1389_bp1 XI0_I1389_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1389_MP42 (XI0_I1389_bcon I0_pp3_14 XI0_I1389_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1389_MP45 (XI0_I1389_bp2 I0_cm26_2 XI0_I1389_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1389_MP43 (VDD XI0_I1389_s1 XI0_I1389_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1389_MP44 (XI0_I1389_bp2 I0_pp3_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1389_MP56 (VDD XI0_I1389_bcon I0_cm28_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1389_MP46 (XI0_I1389_bp3 XI0_I1389_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1389_MP48 (VDD I0_cm26_2 XI0_I1389_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1389_MP50_1 (XI0_I1389_bp4 XI0_I1389_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1389_MP26 (VDD XI0_I1389_asn XI0_I1389_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1389_MP18 (XI0_I1389_ap3 I0_pp0_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1389_MP21 (XI0_I1389_asn XI0_I1389_acon XI0_I1389_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1389_MP24 (XI0_I1389_ap5 I0_pp2_16 XI0_I1389_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1389_MP23 (XI0_I1389_ap4 I0_pp1_18 XI0_I1389_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1389_MP22 (VDD I0_pp0_20 XI0_I1389_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1389_MP22_1 (XI0_I1389_ap4 I0_pp0_20 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1389_MP23_1 (XI0_I1389_ap5 I0_pp1_18 XI0_I1389_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1389_MP24_1 (XI0_I1389_asn I0_pp2_16 XI0_I1389_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1389_MP17 (XI0_I1389_acon I0_pp2_16 XI0_I1389_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1389_MP14 (XI0_I1389_ap1 I0_pp1_18 XI0_I1389_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1389_MP13 (VDD I0_pp0_20 XI0_I1389_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1389_MP15 (XI0_I1389_ap2 I0_pp0_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1389_MP16 (VDD I0_pp1_18 XI0_I1389_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1389_MP28 (I0_cm28_2 XI0_I1389_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1389_MP19 (XI0_I1389_ap3 I0_pp1_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1389_MP20 (VDD I0_pp2_16 XI0_I1389_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1418_MP50 (VDD XI0_I1418_s1 XI0_I1418_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1418_MP47 (XI0_I1418_bp3 I0_pp3_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1418_MP49 (XI0_I1418_bsn XI0_I1418_bcon XI0_I1418_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1418_MP52 (XI0_I1418_bp5 I0_cm53_2 XI0_I1418_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1418_MP51 (XI0_I1418_bp4 I0_pp3_23 XI0_I1418_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1418_MP51_1 (XI0_I1418_bp5 I0_pp3_23 XI0_I1418_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1418_MP52_1 (XI0_I1418_bsn I0_cm53_2 XI0_I1418_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1418_MP54 (VDD XI0_I1418_bsn I0_cm57_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1418_MP41 (XI0_I1418_bp1 XI0_I1418_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1418_MP42 (XI0_I1418_bcon I0_pp3_23 XI0_I1418_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1418_MP45 (XI0_I1418_bp2 I0_cm53_2 XI0_I1418_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1418_MP43 (VDD XI0_I1418_s1 XI0_I1418_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1418_MP44 (XI0_I1418_bp2 I0_pp3_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1418_MP56 (VDD XI0_I1418_bcon I0_cm57_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1418_MP46 (XI0_I1418_bp3 XI0_I1418_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1418_MP48 (VDD I0_cm53_2 XI0_I1418_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1418_MP50_1 (XI0_I1418_bp4 XI0_I1418_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1418_MP26 (VDD XI0_I1418_asn XI0_I1418_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1418_MP18 (XI0_I1418_ap3 I0_pp0_29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1418_MP21 (XI0_I1418_asn XI0_I1418_acon XI0_I1418_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1418_MP24 (XI0_I1418_ap5 I0_pp2_25 XI0_I1418_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1418_MP23 (XI0_I1418_ap4 I0_pp1_27 XI0_I1418_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1418_MP22 (VDD I0_pp0_29 XI0_I1418_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1418_MP22_1 (XI0_I1418_ap4 I0_pp0_29 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1418_MP23_1 (XI0_I1418_ap5 I0_pp1_27 XI0_I1418_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1418_MP24_1 (XI0_I1418_asn I0_pp2_25 XI0_I1418_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1418_MP17 (XI0_I1418_acon I0_pp2_25 XI0_I1418_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1418_MP14 (XI0_I1418_ap1 I0_pp1_27 XI0_I1418_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1418_MP13 (VDD I0_pp0_29 XI0_I1418_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1418_MP15 (XI0_I1418_ap2 I0_pp0_29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1418_MP16 (VDD I0_pp1_27 XI0_I1418_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1418_MP28 (I0_cm57_2 XI0_I1418_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1418_MP19 (XI0_I1418_ap3 I0_pp1_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1418_MP20 (VDD I0_pp2_25 XI0_I1418_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1422_MP50 (VDD XI0_I1422_s1 XI0_I1422_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1422_MP47 (XI0_I1422_bp3 I0_pp3_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1422_MP49 (XI0_I1422_bsn XI0_I1422_bcon XI0_I1422_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1422_MP52 (XI0_I1422_bp5 I0_cm57_2 XI0_I1422_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1422_MP51 (XI0_I1422_bp4 I0_pp3_24 XI0_I1422_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1422_MP51_1 (XI0_I1422_bp5 I0_pp3_24 XI0_I1422_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1422_MP52_1 (XI0_I1422_bsn I0_cm57_2 XI0_I1422_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1422_MP54 (VDD XI0_I1422_bsn I0_cm61_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1422_MP41 (XI0_I1422_bp1 XI0_I1422_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1422_MP42 (XI0_I1422_bcon I0_pp3_24 XI0_I1422_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1422_MP45 (XI0_I1422_bp2 I0_cm57_2 XI0_I1422_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1422_MP43 (VDD XI0_I1422_s1 XI0_I1422_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1422_MP44 (XI0_I1422_bp2 I0_pp3_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1422_MP56 (VDD XI0_I1422_bcon I0_cm61_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1422_MP46 (XI0_I1422_bp3 XI0_I1422_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1422_MP48 (VDD I0_cm57_2 XI0_I1422_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1422_MP50_1 (XI0_I1422_bp4 XI0_I1422_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1422_MP26 (VDD XI0_I1422_asn XI0_I1422_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1422_MP18 (XI0_I1422_ap3 I0_pp0_30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1422_MP21 (XI0_I1422_asn XI0_I1422_acon XI0_I1422_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1422_MP24 (XI0_I1422_ap5 I0_pp2_26 XI0_I1422_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1422_MP23 (XI0_I1422_ap4 I0_pp1_28 XI0_I1422_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1422_MP22 (VDD I0_pp0_30 XI0_I1422_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1422_MP22_1 (XI0_I1422_ap4 I0_pp0_30 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1422_MP23_1 (XI0_I1422_ap5 I0_pp1_28 XI0_I1422_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1422_MP24_1 (XI0_I1422_asn I0_pp2_26 XI0_I1422_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1422_MP17 (XI0_I1422_acon I0_pp2_26 XI0_I1422_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1422_MP14 (XI0_I1422_ap1 I0_pp1_28 XI0_I1422_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1422_MP13 (VDD I0_pp0_30 XI0_I1422_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1422_MP15 (XI0_I1422_ap2 I0_pp0_30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1422_MP16 (VDD I0_pp1_28 XI0_I1422_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1422_MP28 (I0_cm61_2 XI0_I1422_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1422_MP19 (XI0_I1422_ap3 I0_pp1_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1422_MP20 (VDD I0_pp2_26 XI0_I1422_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1411_MP50 (VDD XI0_I1411_s1 XI0_I1411_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1411_MP47 (XI0_I1411_bp3 I0_pp3_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1411_MP49 (XI0_I1411_bsn XI0_I1411_bcon XI0_I1411_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1411_MP52 (XI0_I1411_bp5 I0_cm46_2 XI0_I1411_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1411_MP51 (XI0_I1411_bp4 I0_pp3_21 XI0_I1411_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1411_MP51_1 (XI0_I1411_bp5 I0_pp3_21 XI0_I1411_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1411_MP52_1 (XI0_I1411_bsn I0_cm46_2 XI0_I1411_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1411_MP54 (VDD XI0_I1411_bsn I0_cm50_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1411_MP41 (XI0_I1411_bp1 XI0_I1411_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1411_MP42 (XI0_I1411_bcon I0_pp3_21 XI0_I1411_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1411_MP45 (XI0_I1411_bp2 I0_cm46_2 XI0_I1411_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1411_MP43 (VDD XI0_I1411_s1 XI0_I1411_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1411_MP44 (XI0_I1411_bp2 I0_pp3_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1411_MP56 (VDD XI0_I1411_bcon I0_cm50_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1411_MP46 (XI0_I1411_bp3 XI0_I1411_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1411_MP48 (VDD I0_cm46_2 XI0_I1411_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1411_MP50_1 (XI0_I1411_bp4 XI0_I1411_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1411_MP26 (VDD XI0_I1411_asn XI0_I1411_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1411_MP18 (XI0_I1411_ap3 I0_pp0_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1411_MP21 (XI0_I1411_asn XI0_I1411_acon XI0_I1411_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1411_MP24 (XI0_I1411_ap5 I0_pp2_23 XI0_I1411_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1411_MP23 (XI0_I1411_ap4 I0_pp1_25 XI0_I1411_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1411_MP22 (VDD I0_pp0_27 XI0_I1411_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1411_MP22_1 (XI0_I1411_ap4 I0_pp0_27 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1411_MP23_1 (XI0_I1411_ap5 I0_pp1_25 XI0_I1411_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1411_MP24_1 (XI0_I1411_asn I0_pp2_23 XI0_I1411_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1411_MP17 (XI0_I1411_acon I0_pp2_23 XI0_I1411_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1411_MP14 (XI0_I1411_ap1 I0_pp1_25 XI0_I1411_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1411_MP13 (VDD I0_pp0_27 XI0_I1411_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1411_MP15 (XI0_I1411_ap2 I0_pp0_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1411_MP16 (VDD I0_pp1_25 XI0_I1411_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1411_MP28 (I0_cm50_2 XI0_I1411_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1411_MP19 (XI0_I1411_ap3 I0_pp1_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1411_MP20 (VDD I0_pp2_23 XI0_I1411_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1446_MP50 (VDD XI0_I1446_s1 XI0_I1446_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1446_MP47 (XI0_I1446_bp3 I0_pp4_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1446_MP49 (XI0_I1446_bsn XI0_I1446_bcon XI0_I1446_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1446_MP52 (XI0_I1446_bp5 I0_cm81_2 XI0_I1446_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1446_MP51 (XI0_I1446_bp4 I0_pp4_28 XI0_I1446_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1446_MP51_1 (XI0_I1446_bp5 I0_pp4_28 XI0_I1446_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1446_MP52_1 (XI0_I1446_bsn I0_cm81_2 XI0_I1446_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1446_MP54 (VDD XI0_I1446_bsn I0_cm85_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1446_MP41 (XI0_I1446_bp1 XI0_I1446_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1446_MP42 (XI0_I1446_bcon I0_pp4_28 XI0_I1446_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1446_MP45 (XI0_I1446_bp2 I0_cm81_2 XI0_I1446_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1446_MP43 (VDD XI0_I1446_s1 XI0_I1446_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1446_MP44 (XI0_I1446_bp2 I0_pp4_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1446_MP56 (VDD XI0_I1446_bcon I0_cm85_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1446_MP46 (XI0_I1446_bp3 XI0_I1446_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1446_MP48 (VDD I0_cm81_2 XI0_I1446_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1446_MP50_1 (XI0_I1446_bp4 XI0_I1446_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1446_MP26 (VDD XI0_I1446_asn XI0_I1446_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1446_MP18 (XI0_I1446_ap3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1446_MP21 (XI0_I1446_asn XI0_I1446_acon XI0_I1446_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1446_MP24 (XI0_I1446_ap5 I0_pp3_30 XI0_I1446_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1446_MP23 (XI0_I1446_ap4 I0_pp2_32 XI0_I1446_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1446_MP22 (VDD VDD XI0_I1446_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1446_MP22_1 (XI0_I1446_ap4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1446_MP23_1 (XI0_I1446_ap5 I0_pp2_32 XI0_I1446_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1446_MP24_1 (XI0_I1446_asn I0_pp3_30 XI0_I1446_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1446_MP17 (XI0_I1446_acon I0_pp3_30 XI0_I1446_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1446_MP14 (XI0_I1446_ap1 I0_pp2_32 XI0_I1446_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1446_MP13 (VDD VDD XI0_I1446_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1446_MP15 (XI0_I1446_ap2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1446_MP16 (VDD I0_pp2_32 XI0_I1446_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1446_MP28 (I0_cm85_2 XI0_I1446_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1446_MP19 (XI0_I1446_ap3 I0_pp2_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1446_MP20 (VDD I0_pp3_30 XI0_I1446_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1453_MP50 (VDD XI0_I1453_s1 XI0_I1453_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1453_MP47 (XI0_I1453_bp3 I0_pp5_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1453_MP49 (XI0_I1453_bsn XI0_I1453_bcon XI0_I1453_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1453_MP52 (XI0_I1453_bp5 I0_cm89_2 XI0_I1453_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1453_MP51 (XI0_I1453_bp4 I0_pp5_28 XI0_I1453_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1453_MP51_1 (XI0_I1453_bp5 I0_pp5_28 XI0_I1453_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1453_MP52_1 (XI0_I1453_bsn I0_cm89_2 XI0_I1453_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1453_MP54 (VDD XI0_I1453_bsn I0_cm92_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1453_MP41 (XI0_I1453_bp1 XI0_I1453_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1453_MP42 (XI0_I1453_bcon I0_pp5_28 XI0_I1453_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1453_MP45 (XI0_I1453_bp2 I0_cm89_2 XI0_I1453_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1453_MP43 (VDD XI0_I1453_s1 XI0_I1453_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1453_MP44 (XI0_I1453_bp2 I0_pp5_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1453_MP56 (VDD XI0_I1453_bcon I0_cm92_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1453_MP46 (XI0_I1453_bp3 XI0_I1453_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1453_MP48 (VDD I0_cm89_2 XI0_I1453_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1453_MP50_1 (XI0_I1453_bp4 XI0_I1453_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1453_MP26 (VDD XI0_I1453_asn XI0_I1453_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1453_MP18 (XI0_I1453_ap3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1453_MP21 (XI0_I1453_asn XI0_I1453_acon XI0_I1453_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1453_MP24 (XI0_I1453_ap5 I0_pp4_30 XI0_I1453_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1453_MP23 (XI0_I1453_ap4 I0_pp3_32 XI0_I1453_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1453_MP22 (VDD VDD XI0_I1453_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1453_MP22_1 (XI0_I1453_ap4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1453_MP23_1 (XI0_I1453_ap5 I0_pp3_32 XI0_I1453_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1453_MP24_1 (XI0_I1453_asn I0_pp4_30 XI0_I1453_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1453_MP17 (XI0_I1453_acon I0_pp4_30 XI0_I1453_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1453_MP14 (XI0_I1453_ap1 I0_pp3_32 XI0_I1453_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1453_MP13 (VDD VDD XI0_I1453_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1453_MP15 (XI0_I1453_ap2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1453_MP16 (VDD I0_pp3_32 XI0_I1453_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1453_MP28 (I0_cm92_2 XI0_I1453_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1453_MP19 (XI0_I1453_ap3 I0_pp3_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1453_MP20 (VDD I0_pp4_30 XI0_I1453_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1384_MP50 (VDD XI0_I1384_s1 XI0_I1384_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1384_MP47 (XI0_I1384_bp3 I0_pp3_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1384_MP49 (XI0_I1384_bsn XI0_I1384_bcon XI0_I1384_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1384_MP52 (XI0_I1384_bp5 I0_cm21_2 XI0_I1384_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1384_MP51 (XI0_I1384_bp4 I0_pp3_12 XI0_I1384_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1384_MP51_1 (XI0_I1384_bp5 I0_pp3_12 XI0_I1384_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1384_MP52_1 (XI0_I1384_bsn I0_cm21_2 XI0_I1384_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1384_MP54 (VDD XI0_I1384_bsn I0_cm23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1384_MP41 (XI0_I1384_bp1 XI0_I1384_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1384_MP42 (XI0_I1384_bcon I0_pp3_12 XI0_I1384_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1384_MP45 (XI0_I1384_bp2 I0_cm21_2 XI0_I1384_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1384_MP43 (VDD XI0_I1384_s1 XI0_I1384_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1384_MP44 (XI0_I1384_bp2 I0_pp3_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1384_MP56 (VDD XI0_I1384_bcon I0_cm23_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1384_MP46 (XI0_I1384_bp3 XI0_I1384_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1384_MP48 (VDD I0_cm21_2 XI0_I1384_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1384_MP50_1 (XI0_I1384_bp4 XI0_I1384_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1384_MP26 (VDD XI0_I1384_asn XI0_I1384_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1384_MP18 (XI0_I1384_ap3 I0_pp0_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1384_MP21 (XI0_I1384_asn XI0_I1384_acon XI0_I1384_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1384_MP24 (XI0_I1384_ap5 I0_pp2_14 XI0_I1384_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1384_MP23 (XI0_I1384_ap4 I0_pp1_16 XI0_I1384_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1384_MP22 (VDD I0_pp0_18 XI0_I1384_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1384_MP22_1 (XI0_I1384_ap4 I0_pp0_18 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1384_MP23_1 (XI0_I1384_ap5 I0_pp1_16 XI0_I1384_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1384_MP24_1 (XI0_I1384_asn I0_pp2_14 XI0_I1384_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1384_MP17 (XI0_I1384_acon I0_pp2_14 XI0_I1384_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1384_MP14 (XI0_I1384_ap1 I0_pp1_16 XI0_I1384_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1384_MP13 (VDD I0_pp0_18 XI0_I1384_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1384_MP15 (XI0_I1384_ap2 I0_pp0_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1384_MP16 (VDD I0_pp1_16 XI0_I1384_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1384_MP28 (I0_cm23_2 XI0_I1384_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1384_MP19 (XI0_I1384_ap3 I0_pp1_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1384_MP20 (VDD I0_pp2_14 XI0_I1384_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1404_MP50 (VDD XI0_I1404_s1 XI0_I1404_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1404_MP47 (XI0_I1404_bp3 I0_pp3_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1404_MP49 (XI0_I1404_bsn XI0_I1404_bcon XI0_I1404_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1404_MP52 (XI0_I1404_bp5 I0_cm40_2 XI0_I1404_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1404_MP51 (XI0_I1404_bp4 I0_pp3_19 XI0_I1404_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1404_MP51_1 (XI0_I1404_bp5 I0_pp3_19 XI0_I1404_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1404_MP52_1 (XI0_I1404_bsn I0_cm40_2 XI0_I1404_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1404_MP54 (VDD XI0_I1404_bsn I0_cm43_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1404_MP41 (XI0_I1404_bp1 XI0_I1404_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1404_MP42 (XI0_I1404_bcon I0_pp3_19 XI0_I1404_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1404_MP45 (XI0_I1404_bp2 I0_cm40_2 XI0_I1404_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1404_MP43 (VDD XI0_I1404_s1 XI0_I1404_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1404_MP44 (XI0_I1404_bp2 I0_pp3_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1404_MP56 (VDD XI0_I1404_bcon I0_cm43_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1404_MP46 (XI0_I1404_bp3 XI0_I1404_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1404_MP48 (VDD I0_cm40_2 XI0_I1404_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1404_MP50_1 (XI0_I1404_bp4 XI0_I1404_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1404_MP26 (VDD XI0_I1404_asn XI0_I1404_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1404_MP18 (XI0_I1404_ap3 I0_pp0_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1404_MP21 (XI0_I1404_asn XI0_I1404_acon XI0_I1404_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1404_MP24 (XI0_I1404_ap5 I0_pp2_21 XI0_I1404_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1404_MP23 (XI0_I1404_ap4 I0_pp1_23 XI0_I1404_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1404_MP22 (VDD I0_pp0_25 XI0_I1404_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1404_MP22_1 (XI0_I1404_ap4 I0_pp0_25 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1404_MP23_1 (XI0_I1404_ap5 I0_pp1_23 XI0_I1404_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1404_MP24_1 (XI0_I1404_asn I0_pp2_21 XI0_I1404_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1404_MP17 (XI0_I1404_acon I0_pp2_21 XI0_I1404_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1404_MP14 (XI0_I1404_ap1 I0_pp1_23 XI0_I1404_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1404_MP13 (VDD I0_pp0_25 XI0_I1404_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1404_MP15 (XI0_I1404_ap2 I0_pp0_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1404_MP16 (VDD I0_pp1_23 XI0_I1404_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1404_MP28 (I0_cm43_2 XI0_I1404_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1404_MP19 (XI0_I1404_ap3 I0_pp1_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1404_MP20 (VDD I0_pp2_21 XI0_I1404_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1392_MP50 (VDD XI0_I1392_s1 XI0_I1392_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1392_MP47 (XI0_I1392_bp3 I0_pp3_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1392_MP49 (XI0_I1392_bsn XI0_I1392_bcon XI0_I1392_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1392_MP52 (XI0_I1392_bp5 I0_cm28_2 XI0_I1392_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1392_MP51 (XI0_I1392_bp4 I0_pp3_15 XI0_I1392_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1392_MP51_1 (XI0_I1392_bp5 I0_pp3_15 XI0_I1392_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1392_MP52_1 (XI0_I1392_bsn I0_cm28_2 XI0_I1392_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1392_MP54 (VDD XI0_I1392_bsn I0_cm31_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1392_MP41 (XI0_I1392_bp1 XI0_I1392_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1392_MP42 (XI0_I1392_bcon I0_pp3_15 XI0_I1392_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1392_MP45 (XI0_I1392_bp2 I0_cm28_2 XI0_I1392_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1392_MP43 (VDD XI0_I1392_s1 XI0_I1392_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1392_MP44 (XI0_I1392_bp2 I0_pp3_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1392_MP56 (VDD XI0_I1392_bcon I0_cm31_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1392_MP46 (XI0_I1392_bp3 XI0_I1392_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1392_MP48 (VDD I0_cm28_2 XI0_I1392_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1392_MP50_1 (XI0_I1392_bp4 XI0_I1392_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1392_MP26 (VDD XI0_I1392_asn XI0_I1392_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1392_MP18 (XI0_I1392_ap3 I0_pp0_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1392_MP21 (XI0_I1392_asn XI0_I1392_acon XI0_I1392_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1392_MP24 (XI0_I1392_ap5 I0_pp2_17 XI0_I1392_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1392_MP23 (XI0_I1392_ap4 I0_pp1_19 XI0_I1392_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1392_MP22 (VDD I0_pp0_21 XI0_I1392_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1392_MP22_1 (XI0_I1392_ap4 I0_pp0_21 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1392_MP23_1 (XI0_I1392_ap5 I0_pp1_19 XI0_I1392_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1392_MP24_1 (XI0_I1392_asn I0_pp2_17 XI0_I1392_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1392_MP17 (XI0_I1392_acon I0_pp2_17 XI0_I1392_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1392_MP14 (XI0_I1392_ap1 I0_pp1_19 XI0_I1392_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1392_MP13 (VDD I0_pp0_21 XI0_I1392_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1392_MP15 (XI0_I1392_ap2 I0_pp0_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1392_MP16 (VDD I0_pp1_19 XI0_I1392_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1392_MP28 (I0_cm31_2 XI0_I1392_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
