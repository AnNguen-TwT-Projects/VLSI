// ALU32 sau layout: Assura RCX
simulator lang=spectre
subckt ALU32 A_0 A_1 A_2 A_3 A_4 A_5 A_6 A_7 A_8 A_9 A_10 A_11 A_12 A_13 A_14 A_15 A_16 A_17 A_18 A_19 A_20 A_21 A_22 A_23 A_24 A_25 A_26 A_27 A_28 A_29 A_30 A_31 B_0 B_1 B_2 B_3 B_4 B_5 B_6 B_7 B_8 B_9 B_10 B_11 B_12 B_13 B_14 B_15 B_16 B_17 B_18 B_19 B_20 B_21 B_22 B_23 B_24 B_25 B_26 B_27 B_28 B_29 B_30 B_31 OP_0 OP_1 OP_2 OP_3 Y_0 Y_1 Y_2 Y_3 Y_4 Y_5 Y_6 Y_7 Y_8 Y_9 Y_10 Y_11 Y_12 Y_13 Y_14 Y_15 Y_16 Y_17 Y_18 Y_19 Y_20 Y_21 Y_22 Y_23 Y_24 Y_25 Y_26 Y_27 Y_28 Y_29 Y_30 Y_31 Y_32 Y_33 Y_34 Y_35 Y_36 Y_37 Y_38 Y_39 Y_40 Y_41 Y_42 Y_43 Y_44 Y_45 Y_46 Y_47 Y_48 Y_49 Y_50 Y_51 Y_52 Y_53 Y_54 Y_55 Y_56 Y_57 Y_58 Y_59 Y_60 Y_61 Y_62 Y_63 Z C V DZ VDD VSS
    I_MXI1_I1160_I142_XG_MN2 (XI1_I1160_I142_XG_n1 I1_I1160_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I142_XG_MN0 (I1_I1160_G17_10 I1_I1160_P17_14n XI1_I1160_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I142_XG_MN1 (XI1_I1160_I142_XG_n1 I1_I1160_G13_10n I1_I1160_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I138_XG_MN2 (XI1_I1160_I138_XG_n1 I1_I1160_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I138_XG_MN0 (I1_I1160_G13_6 I1_I1160_P13_10n XI1_I1160_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I138_XG_MN1 (XI1_I1160_I138_XG_n1 I1_I1160_G9_6n I1_I1160_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I151_XG_MN2 (XI1_I930_I151_XG_n1 I1_I930_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I151_XG_MN0 (I1_I930_G26_19 I1_I930_P26_23n XI1_I930_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I151_XG_MN1 (XI1_I930_I151_XG_n1 I1_I930_G22_19n I1_I930_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I147_XG_MN2 (XI1_I930_I147_XG_n1 I1_I930_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I147_XG_MN0 (I1_I930_G22_15 I1_I930_P22_19n XI1_I930_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I147_XG_MN1 (XI1_I930_I147_XG_n1 I1_I930_G18_15n I1_I930_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I83_XG_MN2 (XI1_I1436_I83_XG_n1 I1_I1436_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I83_XG_MN0 (I1_I1436_G17_16 I1_I1436_pn17 XI1_I1436_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I83_XG_MN1 (XI1_I1436_I83_XG_n1 I1_I1436_gn16 I1_I1436_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I82_XG_MN2 (XI1_I1436_I82_XG_n1 I1_I1436_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I82_XG_MN0 (I1_I1436_G16_15 I1_I1436_pn16 XI1_I1436_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I82_XG_MN1 (XI1_I1436_I82_XG_n1 I1_I1436_gn15 I1_I1436_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I148_XG_MN2 (XI1_I1758_I148_XG_n1 I1_I1758_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I148_XG_MN0 (I1_I1758_G23_16 I1_I1758_P23_20n XI1_I1758_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I148_XG_MN1 (XI1_I1758_I148_XG_n1 I1_I1758_G19_16n I1_I1758_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I150_XG_MN2 (XI1_I1758_I150_XG_n1 I1_I1758_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I150_XG_MN0 (I1_I1758_G25_18 I1_I1758_P25_22n XI1_I1758_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I150_XG_MN1 (XI1_I1758_I150_XG_n1 I1_I1758_G21_18n I1_I1758_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I146_XG_MN2 (XI1_I1758_I146_XG_n1 I1_I1758_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I146_XG_MN0 (I1_I1758_G21_14 I1_I1758_P21_18n XI1_I1758_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I146_XG_MN1 (XI1_I1758_I146_XG_n1 I1_I1758_G17_14n I1_I1758_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I89_XG_MN2 (XI1_I1666_I89_XG_n1 I1_I1666_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I89_XG_MN0 (I1_I1666_G23_22 I1_I1666_pn23 XI1_I1666_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I89_XG_MN1 (XI1_I1666_I89_XG_n1 I1_I1666_gn22 I1_I1666_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I88_XG_MN2 (XI1_I1666_I88_XG_n1 I1_I1666_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I88_XG_MN0 (I1_I1666_G22_21 I1_I1666_pn22 XI1_I1666_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I88_XG_MN1 (XI1_I1666_I88_XG_n1 I1_I1666_gn21 I1_I1666_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I71_XG_MN2 (XI1_I1804_I71_XG_n1 I1_I1804_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I71_XG_MN0 (I1_I1804_G5_4 I1_I1804_pn5 XI1_I1804_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I71_XG_MN1 (XI1_I1804_I71_XG_n1 I1_I1804_gn4 I1_I1804_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I70_XG_MN2 (XI1_I1804_I70_XG_n1 I1_I1804_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I70_XG_MN0 (I1_I1804_G4_3 I1_I1804_pn4 XI1_I1804_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I70_XG_MN1 (XI1_I1804_I70_XG_n1 I1_I1804_gn3 I1_I1804_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I151_XG_MN2 (XI1_I1804_I151_XG_n1 I1_I1804_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I151_XG_MN0 (I1_I1804_G26_19 I1_I1804_P26_23n XI1_I1804_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I151_XG_MN1 (XI1_I1804_I151_XG_n1 I1_I1804_G22_19n I1_I1804_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I147_XG_MN2 (XI1_I1804_I147_XG_n1 I1_I1804_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I147_XG_MN0 (I1_I1804_G22_15 I1_I1804_P22_19n XI1_I1804_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I147_XG_MN1 (XI1_I1804_I147_XG_n1 I1_I1804_G18_15n I1_I1804_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I137_XG_MN2 (XI1_I1850_I137_XG_n1 I1_I1850_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I137_XG_MN0 (I1_I1850_G12_5 I1_I1850_P12_9n XI1_I1850_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I137_XG_MN1 (XI1_I1850_I137_XG_n1 I1_I1850_G8_5n I1_I1850_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I135_XG_MN2 (XI1_I1850_I135_XG_n1 I1_I1850_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I135_XG_MN0 (I1_I1850_G10_3 I1_I1850_P10_7n XI1_I1850_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I135_XG_MN1 (XI1_I1850_I135_XG_n1 I1_I1850_G6_3n I1_I1850_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I151_XG_MN2 (XI1_I1896_I151_XG_n1 I1_I1896_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I151_XG_MN0 (I1_I1896_G26_19 I1_I1896_P26_23n XI1_I1896_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I151_XG_MN1 (XI1_I1896_I151_XG_n1 I1_I1896_G22_19n I1_I1896_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I147_XG_MN2 (XI1_I1896_I147_XG_n1 I1_I1896_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I147_XG_MN0 (I1_I1896_G22_15 I1_I1896_P22_19n XI1_I1896_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I147_XG_MN1 (XI1_I1896_I147_XG_n1 I1_I1896_G18_15n I1_I1896_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I97_XG_MN2 (XI1_I1988_I97_XG_n1 I1_I1988_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I97_XG_MN0 (I1_I1988_G31_30 I1_I1988_pn31 XI1_I1988_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I97_XG_MN1 (XI1_I1988_I97_XG_n1 I1_I1988_gn30 I1_I1988_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I96_XG_MN2 (XI1_I1988_I96_XG_n1 I1_I1988_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I96_XG_MN0 (I1_I1988_G30_29 I1_I1988_pn30 XI1_I1988_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I96_XG_MN1 (XI1_I1988_I96_XG_n1 I1_I1988_gn29 I1_I1988_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I117_XG_MN2 (I1_I838_G21_18n I1_I838_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I117_XG_MN0 (XI1_I838_I117_XG_n1 I1_I838_P21_20 I1_I838_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I117_XG_MN1 (VSS I1_I838_G19_18 XI1_I838_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I115_XG_MN2 (I1_I838_G19_16n I1_I838_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I115_XG_MN0 (XI1_I838_I115_XG_n1 I1_I838_P19_18 I1_I838_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I115_XG_MN1 (VSS I1_I838_G17_16 XI1_I838_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I177_XG_MN2 (I1_I838_G26_11n I1_I838_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I177_XG_MN0 (XI1_I838_I177_XG_n1 I1_I838_P26_19 I1_I838_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I177_XG_MN1 (VSS I1_I838_G18_11 XI1_I838_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I173_XG_MN2 (I1_I838_G22_7n I1_I838_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I173_XG_MN0 (XI1_I838_I173_XG_n1 I1_I838_P22_15 I1_I838_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I173_XG_MN1 (VSS I1_I838_G14_7 XI1_I838_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I101_XG_MN2 (I1_I1298_G5_2n I1_I1298_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I101_XG_MN0 (XI1_I1298_I101_XG_n1 I1_I1298_P5_4 I1_I1298_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I101_XG_MN1 (VSS I1_I1298_G3_2 XI1_I1298_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I99_XG_MN2 (I1_I1298_G3_0n I1_I1298_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I99_XG_MN0 (XI1_I1298_I99_XG_n1 I1_I1298_P3_2 I1_I1298_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I99_XG_MN1 (VSS I1_I1298_G1_0 XI1_I1298_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I120_XG_MN2 (I1_I884_G24_21n I1_I884_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I120_XG_MN0 (XI1_I884_I120_XG_n1 I1_I884_P24_23 I1_I884_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I120_XG_MN1 (VSS I1_I884_G22_21 XI1_I884_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I118_XG_MN2 (I1_I884_G22_19n I1_I884_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I118_XG_MN0 (XI1_I884_I118_XG_n1 I1_I884_P22_21 I1_I884_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I118_XG_MN1 (VSS I1_I884_G20_19 XI1_I884_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I176_XG_MN2 (I1_I1390_G25_10n I1_I1390_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I176_XG_MN0 (XI1_I1390_I176_XG_n1 I1_I1390_P25_18 I1_I1390_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I176_XG_MN1 (VSS I1_I1390_G17_10 XI1_I1390_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I172_XG_MN2 (I1_I1390_G21_6n I1_I1390_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I172_XG_MN0 (XI1_I1390_I172_XG_n1 I1_I1390_P21_14 I1_I1390_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I172_XG_MN1 (VSS I1_I1390_G13_6 XI1_I1390_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I121_XG_MN2 (I1_I1160_G25_22n I1_I1160_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I121_XG_MN0 (XI1_I1160_I121_XG_n1 I1_I1160_P25_24 I1_I1160_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I121_XG_MN1 (VSS I1_I1160_G23_22 XI1_I1160_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I119_XG_MN2 (I1_I1160_G23_20n I1_I1160_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I119_XG_MN0 (XI1_I1160_I119_XG_n1 I1_I1160_P23_22 I1_I1160_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I119_XG_MN1 (VSS I1_I1160_G21_20 XI1_I1160_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I176_XG_MN2 (I1_I1436_G25_10n I1_I1436_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1436_I176_XG_MN0 (XI1_I1436_I176_XG_n1 I1_I1436_P25_18 I1_I1436_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1436_I176_XG_MN1 (VSS I1_I1436_G17_10 XI1_I1436_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I172_XG_MN2 (I1_I1436_G21_6n I1_I1436_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1436_I172_XG_MN0 (XI1_I1436_I172_XG_n1 I1_I1436_P21_14 I1_I1436_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1436_I172_XG_MN1 (VSS I1_I1436_G13_6 XI1_I1436_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I179_XG_MN2 (I1_I1022_G28_13n I1_I1022_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1022_I179_XG_MN0 (XI1_I1022_I179_XG_n1 I1_I1022_P28_21 I1_I1022_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1022_I179_XG_MN1 (VSS I1_I1022_G20_13 XI1_I1022_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I116_XG_MN2 (I1_I1022_G20_17n I1_I1022_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1022_I116_XG_MN0 (XI1_I1022_I116_XG_n1 I1_I1022_P20_19 I1_I1022_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1022_I116_XG_MN1 (VSS I1_I1022_G18_17 XI1_I1022_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I125_XG_MN2 (I1_I1712_G29_26n I1_I1712_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1712_I125_XG_MN0 (XI1_I1712_I125_XG_n1 I1_I1712_P29_28 I1_I1712_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1712_I125_XG_MN1 (VSS I1_I1712_G27_26 XI1_I1712_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I123_XG_MN2 (I1_I1712_G27_24n I1_I1712_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1712_I123_XG_MN0 (XI1_I1712_I123_XG_n1 I1_I1712_P27_26 I1_I1712_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1712_I123_XG_MN1 (VSS I1_I1712_G25_24 XI1_I1712_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I114_XG_MN2 (I1_I1712_G18_15n I1_I1712_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1712_I114_XG_MN0 (XI1_I1712_I114_XG_n1 I1_I1712_P18_17 I1_I1712_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1712_I114_XG_MN1 (VSS I1_I1712_G16_15 XI1_I1712_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I112_XG_MN2 (I1_I1712_G16_13n I1_I1712_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1712_I112_XG_MN0 (XI1_I1712_I112_XG_n1 I1_I1712_P16_15 I1_I1712_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1712_I112_XG_MN1 (VSS I1_I1712_G14_13 XI1_I1712_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I110_XG_MN2 (I1_I1712_G14_11n I1_I1712_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1712_I110_XG_MN0 (XI1_I1712_I110_XG_n1 I1_I1712_P14_13 I1_I1712_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1712_I110_XG_MN1 (VSS I1_I1712_G12_11 XI1_I1712_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I128_MN2 (I2_I3_q3_2 I2_I3_o3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2_I3_I128_MN0 (XI2_I3_I128_n1 I2_I3_SEL_AS_b3_0 I2_I3_q3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2_I3_I128_MN1 (VSS I2_S_3 XI2_I3_I128_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I116_MN2 (I2_I3_q2_2 I2_I3_o2_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2_I3_I116_MN0 (XI2_I3_I116_n1 I2_I3_SEL_AS_b3_0 I2_I3_q2_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2_I3_I116_MN1 (VSS I2_S_2 XI2_I3_I116_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I123_XG_MN2 (I1_I1850_G27_24n I1_I1850_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1850_I123_XG_MN0 (XI1_I1850_I123_XG_n1 I1_I1850_P27_26 I1_I1850_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1850_I123_XG_MN1 (VSS I1_I1850_G25_24 XI1_I1850_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I125_XG_MN2 (I1_I1850_G29_26n I1_I1850_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1850_I125_XG_MN0 (XI1_I1850_I125_XG_n1 I1_I1850_P29_28 I1_I1850_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1850_I125_XG_MN1 (VSS I1_I1850_G27_26 XI1_I1850_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I198_XG_MN2 (XI1_I838_I198_XG_n1 I1_I838_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I198_XG_MN0 (I1_I838_G27_0 I1_I838_P27_12n XI1_I838_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I198_XG_MN1 (XI1_I838_I198_XG_n1 I1_I838_G11_0n I1_I838_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I148_XG_MN2 (XI1_I838_I148_XG_n1 I1_I838_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I148_XG_MN0 (I1_I838_G23_16 I1_I838_P23_20n XI1_I838_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I148_XG_MN1 (XI1_I838_I148_XG_n1 I1_I838_G19_16n I1_I838_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I148_XG_MN2 (XI1_I1160_I148_XG_n1 I1_I1160_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I148_XG_MN0 (I1_I1160_G23_16 I1_I1160_P23_20n XI1_I1160_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I148_XG_MN1 (XI1_I1160_I148_XG_n1 I1_I1160_G19_16n I1_I1160_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I150_XG_MN2 (XI1_I1160_I150_XG_n1 I1_I1160_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I150_XG_MN0 (I1_I1160_G25_18 I1_I1160_P25_22n XI1_I1160_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I150_XG_MN1 (XI1_I1160_I150_XG_n1 I1_I1160_G21_18n I1_I1160_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I87_XG_MN2 (XI1_I930_I87_XG_n1 I1_I930_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I87_XG_MN0 (I1_I930_G21_20 I1_I930_pn21 XI1_I930_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I87_XG_MN1 (XI1_I930_I87_XG_n1 I1_I930_gn20 I1_I930_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I86_XG_MN2 (XI1_I930_I86_XG_n1 I1_I930_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I86_XG_MN0 (I1_I930_G20_19 I1_I930_pn20 XI1_I930_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I86_XG_MN1 (XI1_I930_I86_XG_n1 I1_I930_gn19 I1_I930_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I151_XG_MN2 (XI1_I1160_I151_XG_n1 I1_I1160_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I151_XG_MN0 (I1_I1160_G26_19 I1_I1160_P26_23n XI1_I1160_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I151_XG_MN1 (XI1_I1160_I151_XG_n1 I1_I1160_G22_19n I1_I1160_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I147_XG_MN2 (XI1_I1160_I147_XG_n1 I1_I1160_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I147_XG_MN0 (I1_I1160_G22_15 I1_I1160_P22_19n XI1_I1160_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I147_XG_MN1 (XI1_I1160_I147_XG_n1 I1_I1160_G18_15n I1_I1160_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I197_XG_MN2 (XI1_I930_I197_XG_n1 I1_I930_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I197_XG_MN0 (I1_I930_G26_0 I1_I930_P26_11n XI1_I930_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I197_XG_MN1 (XI1_I930_I197_XG_n1 I1_I930_G10_0n I1_I930_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I149_XG_MN2 (XI1_I930_I149_XG_n1 I1_I930_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I149_XG_MN0 (I1_I930_G24_17 I1_I930_P24_21n XI1_I930_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I149_XG_MN1 (XI1_I930_I149_XG_n1 I1_I930_G20_17n I1_I930_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I145_XG_MN2 (XI1_I930_I145_XG_n1 I1_I930_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I145_XG_MN0 (I1_I930_G20_13 I1_I930_P20_17n XI1_I930_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I145_XG_MN1 (XI1_I930_I145_XG_n1 I1_I930_G16_13n I1_I930_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I200_XG_MN2 (XI1_I1482_I200_XG_n1 I1_I1482_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I200_XG_MN0 (I1_I1482_G29_0 I1_I1482_P29_14n XI1_I1482_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I200_XG_MN1 (XI1_I1482_I200_XG_n1 I1_I1482_G13_0n I1_I1482_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I198_XG_MN2 (XI1_I1482_I198_XG_n1 I1_I1482_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I198_XG_MN0 (I1_I1482_G27_0 I1_I1482_P27_12n XI1_I1482_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I198_XG_MN1 (XI1_I1482_I198_XG_n1 I1_I1482_G11_0n I1_I1482_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I151_XG_MN2 (XI1_I1482_I151_XG_n1 I1_I1482_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I151_XG_MN0 (I1_I1482_G26_19 I1_I1482_P26_23n XI1_I1482_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I151_XG_MN1 (XI1_I1482_I151_XG_n1 I1_I1482_G22_19n I1_I1482_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I147_XG_MN2 (XI1_I1482_I147_XG_n1 I1_I1482_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I147_XG_MN0 (I1_I1482_G22_15 I1_I1482_P22_19n XI1_I1482_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I147_XG_MN1 (XI1_I1482_I147_XG_n1 I1_I1482_G18_15n I1_I1482_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I85_XG_MN2 (XI1_I1574_I85_XG_n1 I1_I1574_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I85_XG_MN0 (I1_I1574_G19_18 I1_I1574_pn19 XI1_I1574_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I85_XG_MN1 (XI1_I1574_I85_XG_n1 I1_I1574_gn18 I1_I1574_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I84_XG_MN2 (XI1_I1574_I84_XG_n1 I1_I1574_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I84_XG_MN0 (I1_I1574_G18_17 I1_I1574_pn18 XI1_I1574_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I84_XG_MN1 (XI1_I1574_I84_XG_n1 I1_I1574_gn17 I1_I1574_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I88_XG_MN2 (XI1_I1804_I88_XG_n1 I1_I1804_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I88_XG_MN0 (I1_I1804_G22_21 I1_I1804_pn22 XI1_I1804_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I88_XG_MN1 (XI1_I1804_I88_XG_n1 I1_I1804_gn21 I1_I1804_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I87_XG_MN2 (XI1_I1804_I87_XG_n1 I1_I1804_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I87_XG_MN0 (I1_I1804_G21_20 I1_I1804_pn21 XI1_I1804_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I87_XG_MN1 (XI1_I1804_I87_XG_n1 I1_I1804_gn20 I1_I1804_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I135_XG_MN2 (XI1_I1804_I135_XG_n1 I1_I1804_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I135_XG_MN0 (I1_I1804_G10_3 I1_I1804_P10_7n XI1_I1804_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I135_XG_MN1 (XI1_I1804_I135_XG_n1 I1_I1804_G6_3n I1_I1804_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I183_XG_MN2 (XI1_I1804_I183_XG_n1 I1_I1804_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I183_XG_MN0 (I1_I1804_G16_0 I1_I1804_P16_1n XI1_I1804_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I183_XG_MN1 (XI1_I1804_I183_XG_n1 I1_I1804_G0_0n I1_I1804_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I94_XG_MN2 (XI1_I1298_I94_XG_n1 I1_I1298_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I94_XG_MN0 (I1_I1298_G28_27 I1_I1298_pn28 XI1_I1298_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I94_XG_MN1 (XI1_I1298_I94_XG_n1 I1_I1298_gn27 I1_I1298_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I93_XG_MN2 (XI1_I1298_I93_XG_n1 I1_I1298_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I93_XG_MN0 (I1_I1298_G27_26 I1_I1298_pn27 XI1_I1298_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I93_XG_MN1 (XI1_I1298_I93_XG_n1 I1_I1298_gn26 I1_I1298_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I151_XG_MN2 (XI1_I1344_I151_XG_n1 I1_I1344_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I151_XG_MN0 (I1_I1344_G26_19 I1_I1344_P26_23n XI1_I1344_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I151_XG_MN1 (XI1_I1344_I151_XG_n1 I1_I1344_G22_19n I1_I1344_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I153_XG_MN2 (XI1_I1344_I153_XG_n1 I1_I1344_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I153_XG_MN0 (I1_I1344_G28_21 I1_I1344_P28_25n XI1_I1344_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I153_XG_MN1 (XI1_I1344_I153_XG_n1 I1_I1344_G24_21n I1_I1344_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I144_XG_MN2 (XI1_I1160_I144_XG_n1 I1_I1160_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I144_XG_MN0 (I1_I1160_G19_12 I1_I1160_P19_16n XI1_I1160_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I144_XG_MN1 (XI1_I1160_I144_XG_n1 I1_I1160_G15_12n I1_I1160_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I140_XG_MN2 (XI1_I1160_I140_XG_n1 I1_I1160_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I140_XG_MN0 (I1_I1160_G15_8 I1_I1160_P15_12n XI1_I1160_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I140_XG_MN1 (XI1_I1160_I140_XG_n1 I1_I1160_G11_8n I1_I1160_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I72_XG_MN2 (XI1_I1390_I72_XG_n1 I1_I1390_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I72_XG_MN0 (I1_I1390_G6_5 I1_I1390_pn6 XI1_I1390_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I72_XG_MN1 (XI1_I1390_I72_XG_n1 I1_I1390_gn5 I1_I1390_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I71_XG_MN2 (XI1_I1390_I71_XG_n1 I1_I1390_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I71_XG_MN0 (I1_I1390_G5_4 I1_I1390_pn5 XI1_I1390_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I71_XG_MN1 (XI1_I1390_I71_XG_n1 I1_I1390_gn4 I1_I1390_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I135_XG_MN2 (XI1_I1160_I135_XG_n1 I1_I1160_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I135_XG_MN0 (I1_I1160_G10_3 I1_I1160_P10_7n XI1_I1160_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I135_XG_MN1 (XI1_I1160_I135_XG_n1 I1_I1160_G6_3n I1_I1160_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I141_XG_MN2 (XI1_I1160_I141_XG_n1 I1_I1160_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I141_XG_MN0 (I1_I1160_G16_9 I1_I1160_P16_13n XI1_I1160_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I141_XG_MN1 (XI1_I1160_I141_XG_n1 I1_I1160_G12_9n I1_I1160_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I137_XG_MN2 (XI1_I1160_I137_XG_n1 I1_I1160_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I137_XG_MN0 (I1_I1160_G12_5 I1_I1160_P12_9n XI1_I1160_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I137_XG_MN1 (XI1_I1160_I137_XG_n1 I1_I1160_G8_5n I1_I1160_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I85_XG_MN2 (XI1_I1160_I85_XG_n1 I1_I1160_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I85_XG_MN0 (I1_I1160_G19_18 I1_I1160_pn19 XI1_I1160_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I85_XG_MN1 (XI1_I1160_I85_XG_n1 I1_I1160_gn18 I1_I1160_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I84_XG_MN2 (XI1_I1160_I84_XG_n1 I1_I1160_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I84_XG_MN0 (I1_I1160_G18_17 I1_I1160_pn18 XI1_I1160_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I84_XG_MN1 (XI1_I1160_I84_XG_n1 I1_I1160_gn17 I1_I1160_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I97_XG_MN2 (XI1_I976_I97_XG_n1 I1_I976_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I97_XG_MN0 (I1_I976_G31_30 I1_I976_pn31 XI1_I976_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I97_XG_MN1 (XI1_I976_I97_XG_n1 I1_I976_gn30 I1_I976_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I95_XG_MN2 (XI1_I976_I95_XG_n1 I1_I976_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I95_XG_MN0 (I1_I976_G29_28 I1_I976_pn29 XI1_I976_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I95_XG_MN1 (XI1_I976_I95_XG_n1 I1_I976_gn28 I1_I976_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I149_XG_MN2 (XI1_I976_I149_XG_n1 I1_I976_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I149_XG_MN0 (I1_I976_G24_17 I1_I976_P24_21n XI1_I976_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I149_XG_MN1 (XI1_I976_I149_XG_n1 I1_I976_G20_17n I1_I976_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I145_XG_MN2 (XI1_I976_I145_XG_n1 I1_I976_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I145_XG_MN0 (I1_I976_G20_13 I1_I976_P20_17n XI1_I976_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I145_XG_MN1 (XI1_I976_I145_XG_n1 I1_I976_G16_13n I1_I976_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I135_XG_MN2 (XI1_I1114_I135_XG_n1 I1_I1114_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I135_XG_MN0 (I1_I1114_G10_3 I1_I1114_P10_7n XI1_I1114_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I135_XG_MN1 (XI1_I1114_I135_XG_n1 I1_I1114_G6_3n I1_I1114_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I131_XG_MN2 (XI1_I1114_I131_XG_n1 I1_I1114_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I131_XG_MN0 (I1_I1114_G6_0 I1_I1114_P6_3n XI1_I1114_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I131_XG_MN1 (XI1_I1114_I131_XG_n1 I1_I1114_G2_0n I1_I1114_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I145_XG_MN2 (XI1_I1528_I145_XG_n1 I1_I1528_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I145_XG_MN0 (I1_I1528_G20_13 I1_I1528_P20_17n XI1_I1528_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I145_XG_MN1 (XI1_I1528_I145_XG_n1 I1_I1528_G16_13n I1_I1528_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I143_XG_MN2 (XI1_I1528_I143_XG_n1 I1_I1528_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I143_XG_MN0 (I1_I1528_G18_11 I1_I1528_P18_15n XI1_I1528_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I143_XG_MN1 (XI1_I1528_I143_XG_n1 I1_I1528_G14_11n I1_I1528_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I84_XG_MN2 (XI1_I1712_I84_XG_n1 I1_I1712_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I84_XG_MN0 (I1_I1712_G18_17 I1_I1712_pn18 XI1_I1712_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I84_XG_MN1 (XI1_I1712_I84_XG_n1 I1_I1712_gn17 I1_I1712_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I83_XG_MN2 (XI1_I1712_I83_XG_n1 I1_I1712_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I83_XG_MN0 (I1_I1712_G17_16 I1_I1712_pn17 XI1_I1712_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I83_XG_MN1 (XI1_I1712_I83_XG_n1 I1_I1712_gn16 I1_I1712_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I82_XG_MN2 (XI1_I1712_I82_XG_n1 I1_I1712_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I82_XG_MN0 (I1_I1712_G16_15 I1_I1712_pn16 XI1_I1712_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I82_XG_MN1 (XI1_I1712_I82_XG_n1 I1_I1712_gn15 I1_I1712_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I152_XG_MN2 (XI1_I1666_I152_XG_n1 I1_I1666_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I152_XG_MN0 (I1_I1666_G27_20 I1_I1666_P27_24n XI1_I1666_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I152_XG_MN1 (XI1_I1666_I152_XG_n1 I1_I1666_G23_20n I1_I1666_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I148_XG_MN2 (XI1_I1666_I148_XG_n1 I1_I1666_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I148_XG_MN0 (I1_I1666_G23_16 I1_I1666_P23_20n XI1_I1666_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I148_XG_MN1 (XI1_I1666_I148_XG_n1 I1_I1666_G19_16n I1_I1666_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I83_XG_MN2 (XI1_I1850_I83_XG_n1 I1_I1850_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I83_XG_MN0 (I1_I1850_G17_16 I1_I1850_pn17 XI1_I1850_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I83_XG_MN1 (XI1_I1850_I83_XG_n1 I1_I1850_gn16 I1_I1850_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I82_XG_MN2 (XI1_I1850_I82_XG_n1 I1_I1850_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I82_XG_MN0 (I1_I1850_G16_15 I1_I1850_pn16 XI1_I1850_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I82_XG_MN1 (XI1_I1850_I82_XG_n1 I1_I1850_gn15 I1_I1850_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I82_XG_MN2 (XI1_I838_I82_XG_n1 I1_I838_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I82_XG_MN0 (I1_I838_G16_15 I1_I838_pn16 XI1_I838_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I82_XG_MN1 (XI1_I838_I82_XG_n1 I1_I838_gn15 I1_I838_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I81_XG_MN2 (XI1_I838_I81_XG_n1 I1_I838_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I81_XG_MN0 (I1_I838_G15_14 I1_I838_pn15 XI1_I838_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I81_XG_MN1 (XI1_I838_I81_XG_n1 I1_I838_gn14 I1_I838_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I88_XG_MN2 (XI1_I884_I88_XG_n1 I1_I884_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I88_XG_MN0 (I1_I884_G22_21 I1_I884_pn22 XI1_I884_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I88_XG_MN1 (XI1_I884_I88_XG_n1 I1_I884_gn21 I1_I884_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I87_XG_MN2 (XI1_I884_I87_XG_n1 I1_I884_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I87_XG_MN0 (I1_I884_G21_20 I1_I884_pn21 XI1_I884_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I87_XG_MN1 (XI1_I884_I87_XG_n1 I1_I884_gn20 I1_I884_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I91_XG_MN2 (XI1_I1436_I91_XG_n1 I1_I1436_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I91_XG_MN0 (I1_I1436_G25_24 I1_I1436_pn25 XI1_I1436_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I91_XG_MN1 (XI1_I1436_I91_XG_n1 I1_I1436_gn24 I1_I1436_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I90_XG_MN2 (XI1_I1436_I90_XG_n1 I1_I1436_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I90_XG_MN0 (I1_I1436_G24_23 I1_I1436_pn24 XI1_I1436_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I90_XG_MN1 (XI1_I1436_I90_XG_n1 I1_I1436_gn23 I1_I1436_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I89_XG_MN2 (XI1_I1436_I89_XG_n1 I1_I1436_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I89_XG_MN0 (I1_I1436_G23_22 I1_I1436_pn23 XI1_I1436_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I89_XG_MN1 (XI1_I1436_I89_XG_n1 I1_I1436_gn22 I1_I1436_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I88_XG_MN2 (XI1_I1436_I88_XG_n1 I1_I1436_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I88_XG_MN0 (I1_I1436_G22_21 I1_I1436_pn22 XI1_I1436_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I88_XG_MN1 (XI1_I1436_I88_XG_n1 I1_I1436_gn21 I1_I1436_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I76_XG_MN2 (XI1_I1436_I76_XG_n1 I1_I1436_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I76_XG_MN0 (I1_I1436_G10_9 I1_I1436_pn10 XI1_I1436_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I76_XG_MN1 (XI1_I1436_I76_XG_n1 I1_I1436_gn9 I1_I1436_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I75_XG_MN2 (XI1_I1436_I75_XG_n1 I1_I1436_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I75_XG_MN0 (I1_I1436_G9_8 I1_I1436_pn9 XI1_I1436_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I75_XG_MN1 (XI1_I1436_I75_XG_n1 I1_I1436_gn8 I1_I1436_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I145_XG_MN2 (XI1_I1436_I145_XG_n1 I1_I1436_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I145_XG_MN0 (I1_I1436_G20_13 I1_I1436_P20_17n XI1_I1436_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I145_XG_MN1 (XI1_I1436_I145_XG_n1 I1_I1436_G16_13n I1_I1436_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I143_XG_MN2 (XI1_I1436_I143_XG_n1 I1_I1436_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I143_XG_MN0 (I1_I1436_G18_11 I1_I1436_P18_15n XI1_I1436_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I143_XG_MN1 (XI1_I1436_I143_XG_n1 I1_I1436_G14_11n I1_I1436_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I91_XG_MN2 (XI1_I976_I91_XG_n1 I1_I976_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I91_XG_MN0 (I1_I976_G25_24 I1_I976_pn25 XI1_I976_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I91_XG_MN1 (XI1_I976_I91_XG_n1 I1_I976_gn24 I1_I976_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I90_XG_MN2 (XI1_I976_I90_XG_n1 I1_I976_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I90_XG_MN0 (I1_I976_G24_23 I1_I976_pn24 XI1_I976_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I90_XG_MN1 (XI1_I976_I90_XG_n1 I1_I976_gn23 I1_I976_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I82_XG_MN2 (XI1_I1482_I82_XG_n1 I1_I1482_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I82_XG_MN0 (I1_I1482_G16_15 I1_I1482_pn16 XI1_I1482_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I82_XG_MN1 (XI1_I1482_I82_XG_n1 I1_I1482_gn15 I1_I1482_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I81_XG_MN2 (XI1_I1482_I81_XG_n1 I1_I1482_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I81_XG_MN0 (I1_I1482_G15_14 I1_I1482_pn15 XI1_I1482_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I81_XG_MN1 (XI1_I1482_I81_XG_n1 I1_I1482_gn14 I1_I1482_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I80_XG_MN2 (XI1_I1482_I80_XG_n1 I1_I1482_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I80_XG_MN0 (I1_I1482_G14_13 I1_I1482_pn14 XI1_I1482_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I80_XG_MN1 (XI1_I1482_I80_XG_n1 I1_I1482_gn13 I1_I1482_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I72_XG_MN2 (XI1_I1528_I72_XG_n1 I1_I1528_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I72_XG_MN0 (I1_I1528_G6_5 I1_I1528_pn6 XI1_I1528_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I72_XG_MN1 (XI1_I1528_I72_XG_n1 I1_I1528_gn5 I1_I1528_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I71_XG_MN2 (XI1_I1528_I71_XG_n1 I1_I1528_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I71_XG_MN0 (I1_I1528_G5_4 I1_I1528_pn5 XI1_I1528_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I71_XG_MN1 (XI1_I1528_I71_XG_n1 I1_I1528_gn4 I1_I1528_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I139_XG_MN2 (XI1_I1574_I139_XG_n1 I1_I1574_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I139_XG_MN0 (I1_I1574_G14_7 I1_I1574_P14_11n XI1_I1574_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I139_XG_MN1 (XI1_I1574_I139_XG_n1 I1_I1574_G10_7n I1_I1574_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I195_XG_MN2 (XI1_I1574_I195_XG_n1 I1_I1574_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I195_XG_MN0 (I1_I1574_G24_0 I1_I1574_P24_9n XI1_I1574_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I195_XG_MN1 (XI1_I1574_I195_XG_n1 I1_I1574_G8_0n I1_I1574_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I68_XG_MN2 (XI2_I1_I42_I68_XG_n1 I2_I1_I42_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I68_XG_MN0 (I2_I1_I42_G2_1 I2_I1_I42_pn2 XI2_I1_I42_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I68_XG_MN1 (XI2_I1_I42_I68_XG_n1 I2_I1_I42_gn1 I2_I1_I42_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I67_XG_MN2 (XI2_I1_I42_I67_XG_n1 I2_I1_I42_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I67_XG_MN0 (I2_I1_I42_G1_0 I2_I1_I42_pn1 XI2_I1_I42_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I67_XG_MN1 (XI2_I1_I42_I67_XG_n1 I2_I1_I42_G0_0n I2_I1_I42_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I87_XG_MN2 (XI1_I1758_I87_XG_n1 I1_I1758_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I87_XG_MN0 (I1_I1758_G21_20 I1_I1758_pn21 XI1_I1758_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I87_XG_MN1 (XI1_I1758_I87_XG_n1 I1_I1758_gn20 I1_I1758_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I86_XG_MN2 (XI1_I1758_I86_XG_n1 I1_I1758_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I86_XG_MN0 (I1_I1758_G20_19 I1_I1758_pn20 XI1_I1758_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I86_XG_MN1 (XI1_I1758_I86_XG_n1 I1_I1758_gn19 I1_I1758_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I93_XG_MN2 (XI1_I838_I93_XG_n1 I1_I838_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I93_XG_MN0 (I1_I838_G27_26 I1_I838_pn27 XI1_I838_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I93_XG_MN1 (XI1_I838_I93_XG_n1 I1_I838_gn26 I1_I838_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I92_XG_MN2 (XI1_I838_I92_XG_n1 I1_I838_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I92_XG_MN0 (I1_I838_G26_25 I1_I838_pn26 XI1_I838_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I92_XG_MN1 (XI1_I838_I92_XG_n1 I1_I838_gn25 I1_I838_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I202_XG_MN2 (XI1_I1114_I202_XG_n1 I1_I1114_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I202_XG_MN0 (I1_c12_o I1_I1114_P31_16n XI1_I1114_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I202_XG_MN1 (XI1_I1114_I202_XG_n1 I1_I1114_G15_0n I1_c12_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I154_XG_MN2 (XI1_I1114_I154_XG_n1 I1_I1114_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I154_XG_MN0 (I1_I1114_G29_22 I1_I1114_P29_26n XI1_I1114_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I154_XG_MN1 (XI1_I1114_I154_XG_n1 I1_I1114_G25_22n I1_I1114_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I82_XG_MN2 (XI1_I976_I82_XG_n1 I1_I976_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I82_XG_MN0 (I1_I976_G16_15 I1_I976_pn16 XI1_I976_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I82_XG_MN1 (XI1_I976_I82_XG_n1 I1_I976_gn15 I1_I976_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I81_XG_MN2 (XI1_I976_I81_XG_n1 I1_I976_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I81_XG_MN0 (I1_I976_G15_14 I1_I976_pn15 XI1_I976_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I81_XG_MN1 (XI1_I976_I81_XG_n1 I1_I976_gn14 I1_I976_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I80_XG_MN2 (XI1_I976_I80_XG_n1 I1_I976_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I80_XG_MN0 (I1_I976_G14_13 I1_I976_pn14 XI1_I976_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I80_XG_MN1 (XI1_I976_I80_XG_n1 I1_I976_gn13 I1_I976_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I140_XG_MN2 (XI1_I1482_I140_XG_n1 I1_I1482_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I140_XG_MN0 (I1_I1482_G15_8 I1_I1482_P15_12n XI1_I1482_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I140_XG_MN1 (XI1_I1482_I140_XG_n1 I1_I1482_G11_8n I1_I1482_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I142_XG_MN2 (XI1_I1482_I142_XG_n1 I1_I1482_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I142_XG_MN0 (I1_I1482_G17_10 I1_I1482_P17_14n XI1_I1482_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I142_XG_MN1 (XI1_I1482_I142_XG_n1 I1_I1482_G13_10n I1_I1482_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I82_XG_MN2 (XI1_I1528_I82_XG_n1 I1_I1528_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I82_XG_MN0 (I1_I1528_G16_15 I1_I1528_pn16 XI1_I1528_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I82_XG_MN1 (XI1_I1528_I82_XG_n1 I1_I1528_gn15 I1_I1528_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I81_XG_MN2 (XI1_I1528_I81_XG_n1 I1_I1528_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I81_XG_MN0 (I1_I1528_G15_14 I1_I1528_pn15 XI1_I1528_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I81_XG_MN1 (XI1_I1528_I81_XG_n1 I1_I1528_gn14 I1_I1528_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I82_XG_MN2 (XI1_I1758_I82_XG_n1 I1_I1758_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I82_XG_MN0 (I1_I1758_G16_15 I1_I1758_pn16 XI1_I1758_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I82_XG_MN1 (XI1_I1758_I82_XG_n1 I1_I1758_gn15 I1_I1758_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I80_XG_MN2 (XI1_I1758_I80_XG_n1 I1_I1758_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I80_XG_MN0 (I1_I1758_G14_13 I1_I1758_pn14 XI1_I1758_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I80_XG_MN1 (XI1_I1758_I80_XG_n1 I1_I1758_gn13 I1_I1758_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I78_XG_MN2 (XI1_I1758_I78_XG_n1 I1_I1758_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I78_XG_MN0 (I1_I1758_G12_11 I1_I1758_pn12 XI1_I1758_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I78_XG_MN1 (XI1_I1758_I78_XG_n1 I1_I1758_gn11 I1_I1758_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I139_XG_MN2 (XI1_I1758_I139_XG_n1 I1_I1758_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I139_XG_MN0 (I1_I1758_G14_7 I1_I1758_P14_11n XI1_I1758_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I139_XG_MN1 (XI1_I1758_I139_XG_n1 I1_I1758_G10_7n I1_I1758_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I141_XG_MN2 (XI1_I1758_I141_XG_n1 I1_I1758_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I141_XG_MN0 (I1_I1758_G16_9 I1_I1758_P16_13n XI1_I1758_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I141_XG_MN1 (XI1_I1758_I141_XG_n1 I1_I1758_G12_9n I1_I1758_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I198_XG_MN2 (XI1_I1344_I198_XG_n1 I1_I1344_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I198_XG_MN0 (I1_I1344_G27_0 I1_I1344_P27_12n XI1_I1344_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I198_XG_MN1 (XI1_I1344_I198_XG_n1 I1_I1344_G11_0n I1_I1344_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I144_XG_MN2 (XI1_I1344_I144_XG_n1 I1_I1344_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I144_XG_MN0 (I1_I1344_G19_12 I1_I1344_P19_16n XI1_I1344_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I144_XG_MN1 (XI1_I1344_I144_XG_n1 I1_I1344_G15_12n I1_I1344_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I136_XG_MN2 (XI1_I1206_I136_XG_n1 I1_I1206_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I136_XG_MN0 (I1_I1206_G11_4 I1_I1206_P11_8n XI1_I1206_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I136_XG_MN1 (XI1_I1206_I136_XG_n1 I1_I1206_G7_4n I1_I1206_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I138_XG_MN2 (XI1_I1206_I138_XG_n1 I1_I1206_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I138_XG_MN0 (I1_I1206_G13_6 I1_I1206_P13_10n XI1_I1206_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I138_XG_MN1 (XI1_I1206_I138_XG_n1 I1_I1206_G9_6n I1_I1206_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I146_XG_MN2 (XI1_I884_I146_XG_n1 I1_I884_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I146_XG_MN0 (I1_I884_G21_14 I1_I884_P21_18n XI1_I884_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I146_XG_MN1 (XI1_I884_I146_XG_n1 I1_I884_G17_14n I1_I884_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I144_XG_MN2 (XI1_I884_I144_XG_n1 I1_I884_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I144_XG_MN0 (I1_I884_G19_12 I1_I884_P19_16n XI1_I884_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I144_XG_MN1 (XI1_I884_I144_XG_n1 I1_I884_G15_12n I1_I884_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I85_XG_MN2 (XI1_I930_I85_XG_n1 I1_I930_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I85_XG_MN0 (I1_I930_G19_18 I1_I930_pn19 XI1_I930_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I85_XG_MN1 (XI1_I930_I85_XG_n1 I1_I930_gn18 I1_I930_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I83_XG_MN2 (XI1_I930_I83_XG_n1 I1_I930_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I83_XG_MN0 (I1_I930_G17_16 I1_I930_pn17 XI1_I930_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I83_XG_MN1 (XI1_I930_I83_XG_n1 I1_I930_gn16 I1_I930_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I82_XG_MN2 (XI1_I930_I82_XG_n1 I1_I930_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I82_XG_MN0 (I1_I930_G16_15 I1_I930_pn16 XI1_I930_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I82_XG_MN1 (XI1_I930_I82_XG_n1 I1_I930_gn15 I1_I930_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I75_XG_MN2 (XI1_I930_I75_XG_n1 I1_I930_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I75_XG_MN0 (I1_I930_G9_8 I1_I930_pn9 XI1_I930_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I75_XG_MN1 (XI1_I930_I75_XG_n1 I1_I930_gn8 I1_I930_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I74_XG_MN2 (XI1_I930_I74_XG_n1 I1_I930_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I74_XG_MN0 (I1_I930_G8_7 I1_I930_pn8 XI1_I930_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I74_XG_MN1 (XI1_I930_I74_XG_n1 I1_I930_gn7 I1_I930_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I79_XG_MN2 (XI1_I1160_I79_XG_n1 I1_I1160_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I79_XG_MN0 (I1_I1160_G13_12 I1_I1160_pn13 XI1_I1160_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I79_XG_MN1 (XI1_I1160_I79_XG_n1 I1_I1160_gn12 I1_I1160_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I77_XG_MN2 (XI1_I1160_I77_XG_n1 I1_I1160_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I77_XG_MN0 (I1_I1160_G11_10 I1_I1160_pn11 XI1_I1160_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I77_XG_MN1 (XI1_I1160_I77_XG_n1 I1_I1160_gn10 I1_I1160_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I75_XG_MN2 (XI1_I1160_I75_XG_n1 I1_I1160_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I75_XG_MN0 (I1_I1160_G9_8 I1_I1160_pn9 XI1_I1160_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I75_XG_MN1 (XI1_I1160_I75_XG_n1 I1_I1160_gn8 I1_I1160_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I74_XG_MN2 (XI1_I1160_I74_XG_n1 I1_I1160_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I74_XG_MN0 (I1_I1160_G8_7 I1_I1160_pn8 XI1_I1160_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I74_XG_MN1 (XI1_I1160_I74_XG_n1 I1_I1160_gn7 I1_I1160_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I76_XG_MN2 (XI1_I1482_I76_XG_n1 I1_I1482_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I76_XG_MN0 (I1_I1482_G10_9 I1_I1482_pn10 XI1_I1482_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I76_XG_MN1 (XI1_I1482_I76_XG_n1 I1_I1482_gn9 I1_I1482_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I75_XG_MN2 (XI1_I1482_I75_XG_n1 I1_I1482_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I75_XG_MN0 (I1_I1482_G9_8 I1_I1482_pn9 XI1_I1482_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I75_XG_MN1 (XI1_I1482_I75_XG_n1 I1_I1482_gn8 I1_I1482_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I71_XG_MN2 (XI1_I1482_I71_XG_n1 I1_I1482_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I71_XG_MN0 (I1_I1482_G5_4 I1_I1482_pn5 XI1_I1482_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I71_XG_MN1 (XI1_I1482_I71_XG_n1 I1_I1482_gn4 I1_I1482_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I70_XG_MN2 (XI1_I1482_I70_XG_n1 I1_I1482_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I70_XG_MN0 (I1_I1482_G4_3 I1_I1482_pn4 XI1_I1482_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I70_XG_MN1 (XI1_I1482_I70_XG_n1 I1_I1482_gn3 I1_I1482_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I79_XG_MN2 (XI1_I1022_I79_XG_n1 I1_I1022_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I79_XG_MN0 (I1_I1022_G13_12 I1_I1022_pn13 XI1_I1022_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I79_XG_MN1 (XI1_I1022_I79_XG_n1 I1_I1022_gn12 I1_I1022_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I78_XG_MN2 (XI1_I1022_I78_XG_n1 I1_I1022_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I78_XG_MN0 (I1_I1022_G12_11 I1_I1022_pn12 XI1_I1022_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I78_XG_MN1 (XI1_I1022_I78_XG_n1 I1_I1022_gn11 I1_I1022_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I72_XG_MN2 (XI1_I1114_I72_XG_n1 I1_I1114_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I72_XG_MN0 (I1_I1114_G6_5 I1_I1114_pn6 XI1_I1114_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I72_XG_MN1 (XI1_I1114_I72_XG_n1 I1_I1114_gn5 I1_I1114_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I71_XG_MN2 (XI1_I1114_I71_XG_n1 I1_I1114_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I71_XG_MN0 (I1_I1114_G5_4 I1_I1114_pn5 XI1_I1114_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I71_XG_MN1 (XI1_I1114_I71_XG_n1 I1_I1114_gn4 I1_I1114_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I70_XG_MN2 (XI1_I1114_I70_XG_n1 I1_I1114_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I70_XG_MN0 (I1_I1114_G4_3 I1_I1114_pn4 XI1_I1114_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I70_XG_MN1 (XI1_I1114_I70_XG_n1 I1_I1114_gn3 I1_I1114_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1114_I69_XG_MN2 (XI1_I1114_I69_XG_n1 I1_I1114_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1114_I69_XG_MN0 (I1_I1114_G3_2 I1_I1114_pn3 XI1_I1114_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1114_I69_XG_MN1 (XI1_I1114_I69_XG_n1 I1_I1114_gn2 I1_I1114_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I139_XG_MN2 (XI1_I1482_I139_XG_n1 I1_I1482_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I139_XG_MN0 (I1_I1482_G14_7 I1_I1482_P14_11n XI1_I1482_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I139_XG_MN1 (XI1_I1482_I139_XG_n1 I1_I1482_G10_7n I1_I1482_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I188_XG_MN2 (XI1_I1482_I188_XG_n1 I1_I1482_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I188_XG_MN0 (I1_I1482_G20_0 I1_I1482_P20_5n XI1_I1482_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I188_XG_MN1 (XI1_I1482_I188_XG_n1 I1_I1482_G4_0n I1_I1482_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I197_XG_MN2 (XI1_I1528_I197_XG_n1 I1_I1528_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I197_XG_MN0 (I1_I1528_G26_0 I1_I1528_P26_11n XI1_I1528_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I197_XG_MN1 (XI1_I1528_I197_XG_n1 I1_I1528_G10_0n I1_I1528_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I188_XG_MN2 (XI1_I1528_I188_XG_n1 I1_I1528_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I188_XG_MN0 (I1_I1528_G20_0 I1_I1528_P20_5n XI1_I1528_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I188_XG_MN1 (XI1_I1528_I188_XG_n1 I1_I1528_G4_0n I1_I1528_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I94_XG_MN2 (XI1_I1528_I94_XG_n1 I1_I1528_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I94_XG_MN0 (I1_I1528_G28_27 I1_I1528_pn28 XI1_I1528_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I94_XG_MN1 (XI1_I1528_I94_XG_n1 I1_I1528_gn27 I1_I1528_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I93_XG_MN2 (XI1_I1528_I93_XG_n1 I1_I1528_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I93_XG_MN0 (I1_I1528_G27_26 I1_I1528_pn27 XI1_I1528_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I93_XG_MN1 (XI1_I1528_I93_XG_n1 I1_I1528_gn26 I1_I1528_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I71_XG_MN2 (XI1_I1620_I71_XG_n1 I1_I1620_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I71_XG_MN0 (I1_I1620_G5_4 I1_I1620_pn5 XI1_I1620_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I71_XG_MN1 (XI1_I1620_I71_XG_n1 I1_I1620_gn4 I1_I1620_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I70_XG_MN2 (XI1_I1620_I70_XG_n1 I1_I1620_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I70_XG_MN0 (I1_I1620_G4_3 I1_I1620_pn4 XI1_I1620_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I70_XG_MN1 (XI1_I1620_I70_XG_n1 I1_I1620_gn3 I1_I1620_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I152_XG_MN2 (XI1_I1804_I152_XG_n1 I1_I1804_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I152_XG_MN0 (I1_I1804_G27_20 I1_I1804_P27_24n XI1_I1804_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I152_XG_MN1 (XI1_I1804_I152_XG_n1 I1_I1804_G23_20n I1_I1804_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I200_XG_MN2 (XI1_I1804_I200_XG_n1 I1_I1804_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I200_XG_MN0 (I1_I1804_G29_0 I1_I1804_P29_14n XI1_I1804_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I200_XG_MN1 (XI1_I1804_I200_XG_n1 I1_I1804_G13_0n I1_I1804_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I148_XG_MN2 (XI1_I1804_I148_XG_n1 I1_I1804_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I148_XG_MN0 (I1_I1804_G23_16 I1_I1804_P23_20n XI1_I1804_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I148_XG_MN1 (XI1_I1804_I148_XG_n1 I1_I1804_G19_16n I1_I1804_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I80_XG_MN2 (XI1_I1942_I80_XG_n1 I1_I1942_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I80_XG_MN0 (I1_I1942_G14_13 I1_I1942_pn14 XI1_I1942_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I80_XG_MN1 (XI1_I1942_I80_XG_n1 I1_I1942_gn13 I1_I1942_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I142_XG_MN2 (XI1_I1942_I142_XG_n1 I1_I1942_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I142_XG_MN0 (I1_I1942_G17_10 I1_I1942_P17_14n XI1_I1942_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I142_XG_MN1 (XI1_I1942_I142_XG_n1 I1_I1942_G13_10n I1_I1942_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I146_XG_MN2 (XI1_I1206_I146_XG_n1 I1_I1206_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I146_XG_MN0 (I1_I1206_G21_14 I1_I1206_P21_18n XI1_I1206_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I146_XG_MN1 (XI1_I1206_I146_XG_n1 I1_I1206_G17_14n I1_I1206_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I190_XG_MN2 (XI1_I1206_I190_XG_n1 I1_I1206_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I190_XG_MN0 (I1_I1206_G21_0 I1_I1206_P21_6n XI1_I1206_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I190_XG_MN1 (XI1_I1206_I190_XG_n1 I1_I1206_G5_0n I1_I1206_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I92_XG_MN2 (XI1_I1390_I92_XG_n1 I1_I1390_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I92_XG_MN0 (I1_I1390_G26_25 I1_I1390_pn26 XI1_I1390_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I92_XG_MN1 (XI1_I1390_I92_XG_n1 I1_I1390_gn25 I1_I1390_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I90_XG_MN2 (XI1_I1390_I90_XG_n1 I1_I1390_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I90_XG_MN0 (I1_I1390_G24_23 I1_I1390_pn24 XI1_I1390_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I90_XG_MN1 (XI1_I1390_I90_XG_n1 I1_I1390_gn23 I1_I1390_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I72_XG_MN2 (XI1_I884_I72_XG_n1 I1_I884_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I72_XG_MN0 (I1_I884_G6_5 I1_I884_pn6 XI1_I884_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I72_XG_MN1 (XI1_I884_I72_XG_n1 I1_I884_gn5 I1_I884_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I71_XG_MN2 (XI1_I884_I71_XG_n1 I1_I884_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I71_XG_MN0 (I1_I884_G5_4 I1_I884_pn5 XI1_I884_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I71_XG_MN1 (XI1_I884_I71_XG_n1 I1_I884_gn4 I1_I884_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I140_XG_MN2 (XI1_I1390_I140_XG_n1 I1_I1390_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I140_XG_MN0 (I1_I1390_G15_8 I1_I1390_P15_12n XI1_I1390_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I140_XG_MN1 (XI1_I1390_I140_XG_n1 I1_I1390_G11_8n I1_I1390_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I142_XG_MN2 (XI1_I1390_I142_XG_n1 I1_I1390_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I142_XG_MN0 (I1_I1390_G17_10 I1_I1390_P17_14n XI1_I1390_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I142_XG_MN1 (XI1_I1390_I142_XG_n1 I1_I1390_G13_10n I1_I1390_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I156_XG_MN2 (XI1_I1160_I156_XG_n1 I1_I1160_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I156_XG_MN0 (I1_I1160_G31_24 I1_I1160_P31_28n XI1_I1160_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I156_XG_MN1 (XI1_I1160_I156_XG_n1 I1_I1160_G27_24n I1_I1160_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I154_XG_MN2 (XI1_I1160_I154_XG_n1 I1_I1160_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I154_XG_MN0 (I1_I1160_G29_22 I1_I1160_P29_26n XI1_I1160_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I154_XG_MN1 (XI1_I1160_I154_XG_n1 I1_I1160_G25_22n I1_I1160_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I69_XG_MN2 (XI1_I1160_I69_XG_n1 I1_I1160_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I69_XG_MN0 (I1_I1160_G3_2 I1_I1160_pn3 XI1_I1160_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I69_XG_MN1 (XI1_I1160_I69_XG_n1 I1_I1160_gn2 I1_I1160_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I68_XG_MN2 (XI1_I1160_I68_XG_n1 I1_I1160_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I68_XG_MN0 (I1_I1160_G2_1 I1_I1160_pn2 XI1_I1160_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1160_I68_XG_MN1 (XI1_I1160_I68_XG_n1 I1_I1160_gn1 I1_I1160_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I86_XG_MN2 (XI1_I1528_I86_XG_n1 I1_I1528_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I86_XG_MN0 (I1_I1528_G20_19 I1_I1528_pn20 XI1_I1528_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I86_XG_MN1 (XI1_I1528_I86_XG_n1 I1_I1528_gn19 I1_I1528_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I85_XG_MN2 (XI1_I1528_I85_XG_n1 I1_I1528_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I85_XG_MN0 (I1_I1528_G19_18 I1_I1528_pn19 XI1_I1528_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I85_XG_MN1 (XI1_I1528_I85_XG_n1 I1_I1528_gn18 I1_I1528_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I132_XG_MN2 (XI1_I1620_I132_XG_n1 I1_I1620_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I132_XG_MN0 (I1_I1620_G7_0 I1_I1620_P7_4n XI1_I1620_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I132_XG_MN1 (XI1_I1620_I132_XG_n1 I1_I1620_G3_0n I1_I1620_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I134_XG_MN2 (XI1_I1620_I134_XG_n1 I1_I1620_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I134_XG_MN0 (I1_I1620_G9_2 I1_I1620_P9_6n XI1_I1620_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I134_XG_MN1 (XI1_I1620_I134_XG_n1 I1_I1620_G5_2n I1_I1620_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1356_MN1 (I1_qu14_b3_4 I1_qu14_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1356_MN1_1 (VSS I1_qu14_b2_1 I1_qu14_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1351_MN1 (I1_qu14_b2_1 I1_qu14_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1351_MN1_1 (VSS I1_qu14_b1_0 I1_qu14_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I499_MN1 (I1_dd29_b3_1 I1_dd29_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I499_MN1_1 (VSS I1_dd29_b2_0 I1_dd29_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I486_MN1 (I1_dd28_b3_1 I1_dd28_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I486_MN1_1 (VSS I1_dd28_b2_0 I1_dd28_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I512_MN1 (I1_dd30_b3_1 I1_dd30_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I512_MN1_1 (VSS I1_dd30_b2_0 I1_dd30_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I525_MN1 (I1_dd31_b3_1 I1_dd31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I525_MN1_1 (VSS I1_dd31_b2_0 I1_dd31_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I383_MN1 (I1_dd20_b3_2 I1_dd20_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I383_MN1_1 (VSS I1_dd20_b2_0 I1_dd20_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I418_MN1 (I1_dd23_b2_0 I1_dd23_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I418_MN1_1 (VSS I1_dd23_b1_0 I1_dd23_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I458_MN1 (I1_dd26_b2_1 I1_dd26_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I458_MN1_1 (VSS I1_dd26_b1_0 I1_dd26_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I445_MN1 (I1_dd25_b2_1 I1_dd25_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I445_MN1_1 (VSS I1_dd25_b1_0 I1_dd25_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I523_MN1 (I1_dd31_b2_1 I1_dd31_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I523_MN1_1 (VSS I1_dd31_b1_0 I1_dd31_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I432_MN1 (I1_dd24_b2_1 I1_dd24_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I432_MN1_1 (VSS I1_dd24_b1_0 I1_dd24_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I37_MN1 (I2_I3_SEL_NOT_b3_3 I2_I3_SEL_NOT_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I37_MN1_1 (VSS I2_I3_SEL_NOT_b2_1 I2_I3_SEL_NOT_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I27_MN1 (I2_I3_SEL_XOR_b3_3 I2_I3_SEL_XOR_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I27_MN1_1 (VSS I2_I3_SEL_XOR_b2_1 I2_I3_SEL_XOR_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I36_MN1 (I2_I3_SEL_NOT_b3_2 I2_I3_SEL_NOT_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I36_MN1_1 (VSS I2_I3_SEL_NOT_b2_0 I2_I3_SEL_NOT_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I26_MN1 (I2_I3_SEL_XOR_b3_2 I2_I3_SEL_XOR_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I26_MN1_1 (VSS I2_I3_SEL_XOR_b2_0 I2_I3_SEL_XOR_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I242_MN1 (I1_dd9_b3_4 I1_dd9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I242_MN1_1 (VSS I1_dd9_b2_1 I1_dd9_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I229_MN1 (I1_dd8_b3_4 I1_dd8_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I229_MN1_1 (VSS I1_dd8_b2_1 I1_dd8_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I655_MN1 (I0_one3_b3_3 I0_one3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I655_MN1_1 (VSS I0_one3_b2_1 I0_one3_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I665_MN1 (I0_two3_b3_3 I0_two3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I665_MN1_1 (VSS I0_two3_b2_1 I0_two3_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I35_MN1 (I2_I3_SEL_NOT_b3_1 I2_I3_SEL_NOT_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I35_MN1_1 (VSS I2_I3_SEL_NOT_b2_0 I2_I3_SEL_NOT_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I25_MN1 (I2_I3_SEL_XOR_b3_1 I2_I3_SEL_XOR_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I25_MN1_1 (VSS I2_I3_SEL_XOR_b2_0 I2_I3_SEL_XOR_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I25_MN1 (XI1_I1160_I25_n1 I1_b13_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I25_MN0 (I1_I1160_gn25 I1_p12_24 XI1_I1160_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I28_MN1 (XI1_I1160_I28_n1 I1_b13_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I28_MN0 (I1_I1160_gn28 I1_p12_27 XI1_I1160_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I310_MN1 (XI2_I3_I310_n1 I2_AND_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I310_MN0 (I2_I3_n19_0 I2_I3_SEL_AND_b3_3 XI2_I3_I310_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I316_MN1 (XI2_I3_I316_n1 I2_I3_n19_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I316_MN0 (I2_I3_o19_0 I2_I3_n19_0 XI2_I3_I316_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I351_MN1 (XI2_I3_I351_n1 DIVQ_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I351_MN0 (I2_I3_n22_5 I2_I3_SEL_DIV_b3_3 XI2_I3_I351_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I366_MN1 (XI2_I3_I366_n1 I2_I3_n23_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I366_MN0 (I2_I3_o23_2 I2_I3_n23_4 XI2_I3_I366_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I382_MN1 (XI2_I3_I382_n1 I2_AND_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I382_MN0 (I2_I3_n25_0 I2_I3_SEL_AND_b3_4 XI2_I3_I382_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I388_MN1 (XI2_I3_I388_n1 I2_I3_n25_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I388_MN0 (I2_I3_o25_0 I2_I3_n25_0 XI2_I3_I388_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I371_MN1 (XI2_I3_I371_n1 I2_OR_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I371_MN0 (I2_I3_n24_1 I2_I3_SEL_OR_b3_4 XI2_I3_I371_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I381_MN1 (XI2_I3_I381_n1 I2_I3_q24_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I381_MN0 (Y_24 I2_I3_q24_1 XI2_I3_I381_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I394_MN1 (XI2_I3_I394_n1 I2_AND_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I394_MN0 (I2_I3_n26_0 I2_I3_SEL_AND_b3_4 XI2_I3_I394_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I400_MN1 (XI2_I3_I400_n1 I2_I3_n26_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I400_MN0 (I2_I3_o26_0 I2_I3_n26_0 XI2_I3_I400_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I207_MN1 (XI2_I3_I207_n1 DIVQ_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I207_MN0 (I2_I3_n10_5 I2_I3_SEL_DIV_b3_1 XI2_I3_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I192_MN1 (XI2_I3_I192_n1 I2_XOR_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I192_MN0 (I2_I3_n9_2 I2_I3_SEL_XOR_b3_1 XI2_I3_I192_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I145_MN1 (XI2_I3_I145_n1 I2_NOT_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I145_MN0 (I2_I3_n5_3 I2_I3_SEL_NOT_b3_0 XI2_I3_I145_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I149_MN1 (XI2_I3_I149_n1 I2_I3_n5_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I149_MN0 (I2_I3_o5_1 I2_I3_n5_2 XI2_I3_I149_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I8_MN1 (XI1_I1988_I8_n1 I1_b31_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I8_MN0 (I1_I1988_gn8 I1_p30_7 XI1_I1988_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2016_MN1 (XI1_I2016_n1 I1_p31_32_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2016_MN0 (I1_dmn7 I1_dd7_b3_5 XI1_I2016_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I509_MN1 (XI2_I3_I509_n1 DIVR_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I509_MN0 (I2_I3_hd46 I2_I3_SEL_DIV_b3_7 XI2_I3_I509_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I501_MN1 (XI2_I3_I501_n1 I2_I3_hd43 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I501_MN0 (Y_43 I2_I3_hm43 XI2_I3_I501_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I527_MN1 (XI2_I3_I527_n1 DIVR_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I527_MN0 (I2_I3_hd52 I2_I3_SEL_DIV_b3_8 XI2_I3_I527_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I525_MN1 (XI2_I3_I525_n1 I2_I3_hd51 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I525_MN0 (Y_51 I2_I3_hm51 XI2_I3_I525_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I28_MN1 (XI1_I976_I28_n1 I1_b9_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I28_MN0 (I1_I976_gn28 I1_p8_27 XI1_I976_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I27_MN1 (XI1_I976_I27_n1 I1_b9_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I27_MN0 (I1_I976_gn27 I1_p8_26 XI1_I976_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I369_MN1 (XI2_I3_I369_n1 I2_I3_q23_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I369_MN0 (Y_23 I2_I3_q23_1 XI2_I3_I369_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I346_MN1 (XI2_I3_I346_n1 I2_AND_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I346_MN0 (I2_I3_n22_0 I2_I3_SEL_AND_b3_4 XI2_I3_I346_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I352_MN1 (XI2_I3_I352_n1 I2_I3_n22_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I352_MN0 (I2_I3_o22_0 I2_I3_n22_0 XI2_I3_I352_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I409_MN1 (XI2_I3_I409_n1 I2_NOT_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I409_MN0 (I2_I3_n27_3 I2_I3_SEL_NOT_b3_5 XI2_I3_I409_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I413_MN1 (XI2_I3_I413_n1 I2_I3_n27_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I413_MN0 (I2_I3_o27_1 I2_I3_n27_2 XI2_I3_I413_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I253_MN1 (XI2_I3_I253_n1 I2_NOT_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I253_MN0 (I2_I3_n14_3 I2_I3_SEL_NOT_b3_2 XI2_I3_I253_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I257_MN1 (XI2_I3_I257_n1 I2_I3_n14_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I257_MN0 (I2_I3_o14_1 I2_I3_n14_2 XI2_I3_I257_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I251_MN1 (XI2_I3_I251_n1 I2_OR_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I251_MN0 (I2_I3_n14_1 I2_I3_SEL_OR_b3_2 XI2_I3_I251_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I256_MN1 (XI2_I3_I256_n1 I2_I3_n14_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I256_MN0 (I2_I3_o14_0 I2_I3_n14_0 XI2_I3_I256_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I118_MN1 (XI2_I3_I118_n1 I2_AND_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I118_MN0 (I2_I3_n3_0 I2_I3_SEL_AND_b3_0 XI2_I3_I118_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I124_MN1 (XI2_I3_I124_n1 I2_I3_n3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I124_MN0 (I2_I3_o3_0 I2_I3_n3_0 XI2_I3_I124_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2030_MN1 (XI1_I2030_n1 I1_p31_32_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2030_MN0 (I1_dmn14 I1_dd14_b3_5 XI1_I2030_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2032_MN1 (XI1_I2032_n1 I1_p31_32_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2032_MN0 (I1_dmn15 I1_dd15_b3_5 XI1_I2032_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I519_MN1 (XI2_I3_I519_n1 I2_I3_hd49 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I519_MN0 (Y_49 I2_I3_hm49 XI2_I3_I519_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I517_MN1 (XI2_I3_I517_n1 MULP_49 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I517_MN0 (I2_I3_hm49 I2_I3_SEL_MUL_b3_8 XI2_I3_I517_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I4_I41_MN1 (XI2_I4_I41_n1 I2_I4_z0_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I4_I41_MN0 (I2_I4_z1_9 I2_I4_z0_18 XI2_I4_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I551_MN1 (XI2_I3_I551_n1 DIVR_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I551_MN0 (I2_I3_hd60 I2_I3_SEL_DIV_b3_10 XI2_I3_I551_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I548_MN1 (XI2_I3_I548_n1 DIVR_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I548_MN0 (I2_I3_hd59 I2_I3_SEL_DIV_b3_10 XI2_I3_I548_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I75_XG_MN2 (XI1_I1206_I75_XG_n1 I1_I1206_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I75_XG_MN0 (I1_I1206_G9_8 I1_I1206_pn9 XI1_I1206_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I75_XG_MN1 (XI1_I1206_I75_XG_n1 I1_I1206_gn8 I1_I1206_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I74_XG_MN2 (XI1_I1206_I74_XG_n1 I1_I1206_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I74_XG_MN0 (I1_I1206_G8_7 I1_I1206_pn8 XI1_I1206_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I74_XG_MN1 (XI1_I1206_I74_XG_n1 I1_I1206_gn7 I1_I1206_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I74_XG_MN2 (XI1_I884_I74_XG_n1 I1_I884_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I74_XG_MN0 (I1_I884_G8_7 I1_I884_pn8 XI1_I884_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I74_XG_MN1 (XI1_I884_I74_XG_n1 I1_I884_gn7 I1_I884_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I73_XG_MN2 (XI1_I884_I73_XG_n1 I1_I884_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I73_XG_MN0 (I1_I884_G7_6 I1_I884_pn7 XI1_I884_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I73_XG_MN1 (XI1_I884_I73_XG_n1 I1_I884_gn6 I1_I884_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I94_XG_MN2 (XI1_I930_I94_XG_n1 I1_I930_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I94_XG_MN0 (I1_I930_G28_27 I1_I930_pn28 XI1_I930_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I94_XG_MN1 (XI1_I930_I94_XG_n1 I1_I930_gn27 I1_I930_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I93_XG_MN2 (XI1_I930_I93_XG_n1 I1_I930_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I93_XG_MN0 (I1_I930_G27_26 I1_I930_pn27 XI1_I930_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I93_XG_MN1 (XI1_I930_I93_XG_n1 I1_I930_gn26 I1_I930_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I92_XG_MN2 (XI1_I930_I92_XG_n1 I1_I930_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I92_XG_MN0 (I1_I930_G26_25 I1_I930_pn26 XI1_I930_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I92_XG_MN1 (XI1_I930_I92_XG_n1 I1_I930_gn25 I1_I930_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I91_XG_MN2 (XI1_I930_I91_XG_n1 I1_I930_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I930_I91_XG_MN0 (I1_I930_G25_24 I1_I930_pn25 XI1_I930_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I930_I91_XG_MN1 (XI1_I930_I91_XG_n1 I1_I930_gn24 I1_I930_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I149_XG_MN2 (XI1_I1390_I149_XG_n1 I1_I1390_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I149_XG_MN0 (I1_I1390_G24_17 I1_I1390_P24_21n XI1_I1390_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I149_XG_MN1 (XI1_I1390_I149_XG_n1 I1_I1390_G20_17n I1_I1390_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I145_XG_MN2 (XI1_I1390_I145_XG_n1 I1_I1390_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I145_XG_MN0 (I1_I1390_G20_13 I1_I1390_P20_17n XI1_I1390_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I145_XG_MN1 (XI1_I1390_I145_XG_n1 I1_I1390_G16_13n I1_I1390_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I74_XG_MN2 (XI1_I1436_I74_XG_n1 I1_I1436_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I74_XG_MN0 (I1_I1436_G8_7 I1_I1436_pn8 XI1_I1436_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I74_XG_MN1 (XI1_I1436_I74_XG_n1 I1_I1436_gn7 I1_I1436_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I73_XG_MN2 (XI1_I1436_I73_XG_n1 I1_I1436_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I73_XG_MN0 (I1_I1436_G7_6 I1_I1436_pn7 XI1_I1436_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1436_I73_XG_MN1 (XI1_I1436_I73_XG_n1 I1_I1436_gn6 I1_I1436_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I148_XG_MN2 (XI1_I976_I148_XG_n1 I1_I976_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I148_XG_MN0 (I1_I976_G23_16 I1_I976_P23_20n XI1_I976_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I148_XG_MN1 (XI1_I976_I148_XG_n1 I1_I976_G19_16n I1_I976_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I200_XG_MN2 (XI1_I976_I200_XG_n1 I1_I976_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I200_XG_MN0 (I1_I976_G29_0 I1_I976_P29_14n XI1_I976_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I976_I200_XG_MN1 (XI1_I976_I200_XG_n1 I1_I976_G13_0n I1_I976_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I69_XG_MN2 (XI1_I1482_I69_XG_n1 I1_I1482_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I69_XG_MN0 (I1_I1482_G3_2 I1_I1482_pn3 XI1_I1482_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I69_XG_MN1 (XI1_I1482_I69_XG_n1 I1_I1482_gn2 I1_I1482_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1482_I68_XG_MN2 (XI1_I1482_I68_XG_n1 I1_I1482_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1482_I68_XG_MN0 (I1_I1482_G2_1 I1_I1482_pn2 XI1_I1482_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1482_I68_XG_MN1 (XI1_I1482_I68_XG_n1 I1_I1482_gn1 I1_I1482_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I128_XG_MN2 (XI1_I562_I128_XG_n1 I1_I562_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I128_XG_MN0 (I1_I562_G4_0 I1_I562_P4_1n XI1_I562_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I128_XG_MN1 (XI1_I562_I128_XG_n1 I1_I562_G0_0n I1_I562_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I131_XG_MN2 (XI1_I562_I131_XG_n1 I1_I562_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I131_XG_MN0 (I1_I562_G6_0 I1_I562_P6_3n XI1_I562_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I131_XG_MN1 (XI1_I562_I131_XG_n1 I1_I562_G2_0n I1_I562_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I198_XG_MN2 (XI1_I1528_I198_XG_n1 I1_I1528_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I198_XG_MN0 (I1_I1528_G27_0 I1_I1528_P27_12n XI1_I1528_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I198_XG_MN1 (XI1_I1528_I198_XG_n1 I1_I1528_G11_0n I1_I1528_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I200_XG_MN2 (XI1_I1528_I200_XG_n1 I1_I1528_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I200_XG_MN0 (I1_I1528_G29_0 I1_I1528_P29_14n XI1_I1528_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I200_XG_MN1 (XI1_I1528_I200_XG_n1 I1_I1528_G13_0n I1_I1528_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I149_XG_MN2 (XI1_I1712_I149_XG_n1 I1_I1712_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I149_XG_MN0 (I1_I1712_G24_17 I1_I1712_P24_21n XI1_I1712_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I149_XG_MN1 (XI1_I1712_I149_XG_n1 I1_I1712_G20_17n I1_I1712_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I145_XG_MN2 (XI1_I1712_I145_XG_n1 I1_I1712_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I145_XG_MN0 (I1_I1712_G20_13 I1_I1712_P20_17n XI1_I1712_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I145_XG_MN1 (XI1_I1712_I145_XG_n1 I1_I1712_G16_13n I1_I1712_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I77_XG_MN2 (XI1_I1620_I77_XG_n1 I1_I1620_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I77_XG_MN0 (I1_I1620_G11_10 I1_I1620_pn11 XI1_I1620_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I77_XG_MN1 (XI1_I1620_I77_XG_n1 I1_I1620_gn10 I1_I1620_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I76_XG_MN2 (XI1_I1620_I76_XG_n1 I1_I1620_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I76_XG_MN0 (I1_I1620_G10_9 I1_I1620_pn10 XI1_I1620_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I76_XG_MN1 (XI1_I1620_I76_XG_n1 I1_I1620_gn9 I1_I1620_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I94_XG_MN2 (XI1_I1666_I94_XG_n1 I1_I1666_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I94_XG_MN0 (I1_I1666_G28_27 I1_I1666_pn28 XI1_I1666_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I94_XG_MN1 (XI1_I1666_I94_XG_n1 I1_I1666_gn27 I1_I1666_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I93_XG_MN2 (XI1_I1666_I93_XG_n1 I1_I1666_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I93_XG_MN0 (I1_I1666_G27_26 I1_I1666_pn27 XI1_I1666_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I93_XG_MN1 (XI1_I1666_I93_XG_n1 I1_I1666_gn26 I1_I1666_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I69_XG_MN2 (XI1_I1804_I69_XG_n1 I1_I1804_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I69_XG_MN0 (I1_I1804_G3_2 I1_I1804_pn3 XI1_I1804_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I69_XG_MN1 (XI1_I1804_I69_XG_n1 I1_I1804_gn2 I1_I1804_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I68_XG_MN2 (XI1_I1804_I68_XG_n1 I1_I1804_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I68_XG_MN0 (I1_I1804_G2_1 I1_I1804_pn2 XI1_I1804_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I68_XG_MN1 (XI1_I1804_I68_XG_n1 I1_I1804_gn1 I1_I1804_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I74_XG_MN2 (XI1_I1850_I74_XG_n1 I1_I1850_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I74_XG_MN0 (I1_I1850_G8_7 I1_I1850_pn8 XI1_I1850_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I74_XG_MN1 (XI1_I1850_I74_XG_n1 I1_I1850_gn7 I1_I1850_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I73_XG_MN2 (XI1_I1850_I73_XG_n1 I1_I1850_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I73_XG_MN0 (I1_I1850_G7_6 I1_I1850_pn7 XI1_I1850_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I73_XG_MN1 (XI1_I1850_I73_XG_n1 I1_I1850_gn6 I1_I1850_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I301_MN1 (XI2_I3_I301_n1 I2_NOT_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I301_MN0 (I2_I3_n18_3 I2_I3_SEL_NOT_b3_3 XI2_I3_I301_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I2_I108_MN1 (XI2_I2_I108_n1 B_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I2_I108_MN0 (I2_I2_nand18 A_18 XI2_I2_I108_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I335_MN1 (XI2_I3_I335_n1 I2_OR_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I335_MN0 (I2_I3_n21_1 I2_I3_SEL_OR_b3_3 XI2_I3_I335_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I345_MN1 (XI2_I3_I345_n1 I2_I3_q21_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I345_MN0 (Y_21 I2_I3_q21_1 XI2_I3_I345_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I349_MN1 (XI2_I3_I349_n1 I2_NOT_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I349_MN0 (I2_I3_n22_3 I2_I3_SEL_NOT_b3_4 XI2_I3_I349_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I353_MN1 (XI2_I3_I353_n1 I2_I3_n22_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I353_MN0 (I2_I3_o22_1 I2_I3_n22_2 XI2_I3_I353_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I279_MN1 (XI2_I3_I279_n1 DIVQ_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I279_MN0 (I2_I3_n16_5 I2_I3_SEL_DIV_b3_2 XI2_I3_I279_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I291_MN1 (XI2_I3_I291_n1 DIVQ_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I291_MN0 (I2_I3_n17_5 I2_I3_SEL_DIV_b3_2 XI2_I3_I291_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I454_MN1 (XI2_I3_I454_n1 I2_AND_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I454_MN0 (I2_I3_n31_0 I2_I3_SEL_AND_b3_5 XI2_I3_I454_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I460_MN1 (XI2_I3_I460_n1 I2_I3_n31_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I460_MN0 (I2_I3_o31_0 I2_I3_n31_0 XI2_I3_I460_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I4_MN1 (XI2_I1_I42_I4_n1 I2_I1_bx4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I4_MN0 (I2_I1_I42_gn4 A_4 XI2_I1_I42_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I3_MN1 (XI2_I1_I42_I3_n1 I2_I1_bx3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I3_MN0 (I2_I1_I42_gn3 A_3 XI2_I1_I42_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I120_MN1 (XI2_I3_I120_n1 I2_XOR_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I120_MN0 (I2_I3_n3_2 I2_I3_SEL_XOR_b3_0 XI2_I3_I120_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I125_MN1 (XI2_I3_I125_n1 I2_I3_n3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I125_MN0 (I2_I3_o3_1 I2_I3_n3_2 XI2_I3_I125_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2042_MN1 (XI1_I2042_n1 I1_p31_32_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2042_MN0 (I1_dmn20 I1_dd20_b3_5 XI1_I2042_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I22_MN1 (XI1_I1988_I22_n1 I1_b31_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I22_MN0 (I1_I1988_gn22 I1_p30_21 XI1_I1988_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I125_XP_MN1 (XI1_I1942_I125_XP_n1 I1_I1942_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I125_XP_MN0 (I1_I1942_P29_26n I1_I1942_P29_28 XI1_I1942_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I127_XP_MN1 (XI1_I1942_I127_XP_n1 I1_I1942_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I127_XP_MN0 (I1_I1942_P31_28n I1_I1942_P31_30 XI1_I1942_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2062_MN1 (XI1_I2062_n1 I1_p31_32_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2062_MN0 (I1_dmn30 I1_dd30_b3_5 XI1_I2062_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I30_MN1 (XI1_I1988_I30_n1 I1_b31_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I30_MN0 (I1_I1988_gn30 I1_p30_29 XI1_I1988_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I557_MN1 (XI2_I3_I557_n1 DIVR_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I557_MN0 (I2_I3_hd62 I2_I3_SEL_DIV_b3_10 XI2_I3_I557_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I560_MN1 (XI2_I3_I560_n1 DIVR_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I560_MN0 (I2_I3_hd63 I2_I3_SEL_DIV_b3_10 XI2_I3_I560_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I104_XP_MN1 (XI1_I838_I104_XP_n1 I1_I838_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I104_XP_MN0 (I1_I838_P8_5n I1_I838_P8_7 XI1_I838_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I102_XP_MN1 (XI1_I838_I102_XP_n1 I1_I838_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I102_XP_MN0 (I1_I838_P6_3n I1_I838_P6_5 XI1_I838_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I113_XP_MN1 (XI1_I1436_I113_XP_n1 I1_I1436_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I113_XP_MN0 (I1_I1436_P17_14n I1_I1436_P17_16 XI1_I1436_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I111_XP_MN1 (XI1_I1436_I111_XP_n1 I1_I1436_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I111_XP_MN0 (I1_I1436_P15_12n I1_I1436_P15_14 XI1_I1436_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I389_MN1 (XI2_I3_I389_n1 I2_I3_n25_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I389_MN0 (I2_I3_o25_1 I2_I3_n25_2 XI2_I3_I389_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I384_MN1 (XI2_I3_I384_n1 I2_XOR_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I384_MN0 (I2_I3_n25_2 I2_I3_SEL_XOR_b3_4 XI2_I3_I384_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I435_MN1 (XI2_I3_I435_n1 DIVQ_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I435_MN0 (I2_I3_n29_5 I2_I3_SEL_DIV_b3_4 XI2_I3_I435_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2294_MN1 (XI1_I2294_n1 I1_sqn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2294_MN0 (I1_vn DIVQ_31 XI1_I2294_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I377_MN1 (XI2_I3_I377_n1 I2_I3_n24_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I377_MN0 (I2_I3_o24_1 I2_I3_n24_2 XI2_I3_I377_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I372_MN1 (XI2_I3_I372_n1 I2_XOR_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I372_MN0 (I2_I3_n24_2 I2_I3_SEL_XOR_b3_4 XI2_I3_I372_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I426_MN1 (XI2_I3_I426_n1 I2_I3_n28_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I426_MN0 (I2_I3_o28_2 I2_I3_n28_4 XI2_I3_I426_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I4_I68_MN1 (XI2_I4_I68_n1 DIVV VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I4_I68_MN0 (I2_I4_v2 I2_SEL_DIV XI2_I4_I68_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I4_I57_MN1 (XI2_I4_I57_n1 I2_I4_z2_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I4_I57_MN0 (I2_I4_z3_1 I2_I4_z2_2 XI2_I4_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I449_MN1 (XI2_I3_I449_n1 I2_I3_n30_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I449_MN0 (I2_I3_o30_1 I2_I3_n30_2 XI2_I3_I449_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I444_MN1 (XI2_I3_I444_n1 I2_XOR_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I444_MN0 (I2_I3_n30_2 I2_I3_SEL_XOR_b3_5 XI2_I3_I444_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I4_I38_MN1 (XI2_I4_I38_n1 I2_I4_z0_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I4_I38_MN0 (I2_I4_z1_6 I2_I4_z0_12 XI2_I4_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I4_I39_MN1 (XI2_I4_I39_n1 I2_I4_z0_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I4_I39_MN0 (I2_I4_z1_7 I2_I4_z0_14 XI2_I4_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I0_I4_MN1 (XI2_I0_I4_n1 I2_I0_opn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I0_I4_MN0 (I2_I0_h00 I2_I0_opn3 XI2_I0_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I0_I5_MN1 (XI2_I0_I5_n1 OP_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I0_I5_MN0 (I2_I0_h01 I2_I0_opn3 XI2_I0_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I102_MN1 (XI2_I3_I102_n1 I2_I3_n1_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I102_MN0 (I2_I3_o1_2 I2_I3_n1_4 XI2_I3_I102_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I138_MN1 (XI2_I3_I138_n1 I2_I3_n4_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I138_MN0 (I2_I3_o4_2 I2_I3_n4_4 XI2_I3_I138_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I98_MN1 (XI2_I3_I98_n1 MULP_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I98_MN0 (I2_I3_n1_4 I2_I3_SEL_MUL_b3_0 XI2_I3_I98_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I146_MN1 (XI2_I3_I146_n1 MULP_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I146_MN0 (I2_I3_n5_4 I2_I3_SEL_MUL_b3_0 XI2_I3_I146_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I490_MN1 (XI2_I3_I490_n1 MULP_40 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I490_MN0 (I2_I3_hm40 I2_I3_SEL_MUL_b3_6 XI2_I3_I490_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I478_MN1 (XI2_I3_I478_n1 MULP_36 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I478_MN0 (I2_I3_hm36 I2_I3_SEL_MUL_b3_6 XI2_I3_I478_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I511_MN1 (XI2_I3_I511_n1 MULP_47 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I511_MN0 (I2_I3_hm47 I2_I3_SEL_MUL_b3_8 XI2_I3_I511_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I514_MN1 (XI2_I3_I514_n1 MULP_48 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I514_MN0 (I2_I3_hm48 I2_I3_SEL_MUL_b3_8 XI2_I3_I514_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I541_MN1 (XI2_I3_I541_n1 MULP_57 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I541_MN0 (I2_I3_hm57 I2_I3_SEL_MUL_b3_9 XI2_I3_I541_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I538_MN1 (XI2_I3_I538_n1 MULP_56 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I538_MN0 (I2_I3_hm56 I2_I3_SEL_MUL_b3_9 XI2_I3_I538_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I532_MN1 (XI2_I3_I532_n1 MULP_54 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I532_MN0 (I2_I3_hm54 I2_I3_SEL_MUL_b3_9 XI2_I3_I532_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I544_MN1 (XI2_I3_I544_n1 MULP_58 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I544_MN0 (I2_I3_hm58 I2_I3_SEL_MUL_b3_9 XI2_I3_I544_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1212_MN1 (I1_qu17_b2_0 I1_qu17_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1212_MN1_1 (VSS I1_qu17_b1_0 I1_qu17_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1211_MN1 (I1_qu17_b1_0 I1_qu17_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1211_MN1_1 (VSS I1_qu17_b0 I1_qu17_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I896_MN1 (I1_qu24_b3_4 I1_qu24_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I896_MN1_1 (VSS I1_qu24_b2_1 I1_qu24_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I891_MN1 (I1_qu24_b2_1 I1_qu24_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I891_MN1_1 (VSS I1_qu24_b1_0 I1_qu24_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I487_MN1 (I1_dd28_b3_2 I1_dd28_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I487_MN1_1 (VSS I1_dd28_b2_0 I1_dd28_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I470_MN1 (I1_dd27_b2_0 I1_dd27_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I470_MN1_1 (VSS I1_dd27_b1_0 I1_dd27_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I483_MN1 (I1_dd28_b2_0 I1_dd28_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I483_MN1_1 (VSS I1_dd28_b1_0 I1_dd28_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I150_MN1 (I1_dd2_b3_3 I1_dd2_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I150_MN1_1 (VSS I1_dd2_b2_1 I1_dd2_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I189_MN1 (I1_dd5_b3_3 I1_dd5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I189_MN1_1 (VSS I1_dd5_b2_1 I1_dd5_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I159_MN1 (I1_dd3_b2_1 I1_dd3_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I159_MN1_1 (VSS I1_dd3_b1_0 I1_dd3_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I261_MN1 (I1_dd11_b1_0 I1_dd11_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I261_MN1_1 (VSS I1_dd11_b0 I1_dd11_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I222_MN1 (I1_dd8_b1_0 I1_dd8_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I222_MN1_1 (VSS I1_dd8_b0 I1_dd8_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I196_MN1 (I1_dd6_b1_0 I1_dd6_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I196_MN1_1 (VSS I1_dd6_b0 I1_dd6_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I170_MN1 (I1_dd4_b1_0 I1_dd4_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I170_MN1_1 (VSS I1_dd4_b0 I1_dd4_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I236_MN1 (I0_A_22_b3_2 I0_A_22_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I236_MN1_1 (VSS I0_A_22_b2_0 I0_A_22_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I265_MN1 (I0_A_25_b3_1 I0_A_25_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I265_MN1_1 (VSS I0_A_25_b2_0 I0_A_25_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I498_MN1 (I0_two0_b3_1 I0_two0_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I498_MN1_1 (VSS I0_two0_b2_0 I0_two0_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I488_MN1 (I0_one0_b3_1 I0_one0_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I488_MN1_1 (VSS I0_one0_b2_0 I0_one0_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I471_MN1 (I0_B_29_b3_5 I0_B_29_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I471_MN1_1 (VSS I0_B_29_b2_1 I0_B_29_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1156_MN1 (I0_two12_b2_1 I0_two12_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1156_MN1_1 (VSS I0_two12_b1_0 I0_two12_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I451_MN1 (I0_B_25_b3_5 I0_B_25_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I451_MN1_1 (VSS I0_B_25_b2_1 I0_B_25_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I481_MN1 (I0_B_31_b3_5 I0_B_31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I481_MN1_1 (VSS I0_B_31_b2_1 I0_B_31_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I460_MN1 (I0_B_27_b3_4 I0_B_27_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I460_MN1_1 (VSS I0_B_27_b2_1 I0_B_27_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1317_MN1 (I0_one15_b3_5 I0_one15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1317_MN1_1 (VSS I0_one15_b2_1 I0_one15_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1327_MN1 (I0_two15_b3_5 I0_two15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1327_MN1_1 (VSS I0_two15_b2_1 I0_two15_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I805_MN1 (I1_qu26_b3_5 I1_qu26_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I805_MN1_1 (VSS I1_qu26_b2_1 I1_qu26_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I799_MN1 (I1_qu26_b2_1 I1_qu26_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I799_MN1_1 (VSS I1_qu26_b1_0 I1_qu26_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I444_MN1 (I1_dd25_b2_0 I1_dd25_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I444_MN1_1 (VSS I1_dd25_b1_0 I1_dd25_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I457_MN1 (I1_dd26_b2_0 I1_dd26_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I457_MN1_1 (VSS I1_dd26_b1_0 I1_dd26_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I409_MN1 (I1_dd22_b3_2 I1_dd22_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I409_MN1_1 (VSS I1_dd22_b2_0 I1_dd22_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I422_MN1 (I1_dd23_b3_2 I1_dd23_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I422_MN1_1 (VSS I1_dd23_b2_0 I1_dd23_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I370_MN1 (I1_dd19_b3_2 I1_dd19_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I370_MN1_1 (VSS I1_dd19_b2_0 I1_dd19_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I357_MN1 (I1_dd18_b3_2 I1_dd18_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I357_MN1_1 (VSS I1_dd18_b2_0 I1_dd18_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I318_MN1 (I1_dd15_b3_2 I1_dd15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I318_MN1_1 (VSS I1_dd15_b2_0 I1_dd15_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I331_MN1 (I1_dd16_b3_2 I1_dd16_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I331_MN1_1 (VSS I1_dd16_b2_0 I1_dd16_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I380_MN1 (I1_dd20_b2_1 I1_dd20_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I380_MN1_1 (VSS I1_dd20_b1_0 I1_dd20_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I289_MN1 (I1_dd13_b2_1 I1_dd13_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I289_MN1_1 (VSS I1_dd13_b1_0 I1_dd13_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I354_MN1 (I1_dd18_b2_1 I1_dd18_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I354_MN1_1 (VSS I1_dd18_b1_0 I1_dd18_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I254_MN1 (I1_dd10_b3_3 I1_dd10_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I254_MN1_1 (VSS I1_dd10_b2_1 I1_dd10_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I16_MN1 (I2_I3_SEL_OR_b3_2 I2_I3_SEL_OR_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I16_MN1_1 (VSS I2_I3_SEL_OR_b2_0 I2_I3_SEL_OR_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I6_MN1 (I2_I3_SEL_AND_b3_2 I2_I3_SEL_AND_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I6_MN1_1 (VSS I2_I3_SEL_AND_b2_0 I2_I3_SEL_AND_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I202_MN1 (I0_A_19_b2_0 I0_A_19_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I202_MN1_1 (VSS I0_A_19_b1_0 I0_A_19_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I721_MN1 (I0_two4_b3_4 I0_two4_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I721_MN1_1 (VSS I0_two4_b2_1 I0_two4_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I132_MN1 (I0_A_12_b2_0 I0_A_12_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I132_MN1_1 (VSS I0_A_12_b1_0 I0_A_12_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I135_MN1 (I0_A_12_b3_1 I0_A_12_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I135_MN1_1 (VSS I0_A_12_b2_0 I0_A_12_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I5_MN1 (I0_B_1_b3_1 I0_B_1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I5_MN1_1 (VSS I0_B_1_b2_0 I0_B_1_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I542_MN1 (I0_one1_b3_0 I0_one1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I542_MN1_1 (VSS I0_one1_b2_0 I0_one1_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I884_MN1 (I0_two7_b3_2 I0_two7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I884_MN1_1 (VSS I0_two7_b2_0 I0_two7_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I880_MN1 (I0_two7_b2_0 I0_two7_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I880_MN1_1 (VSS I0_two7_b1_0 I0_two7_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I411_MN1 (I1_dd22_b3_4 I1_dd22_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I411_MN1_1 (VSS I1_dd22_b2_1 I1_dd22_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I528_MN1 (I1_dd31_b3_4 I1_dd31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I528_MN1_1 (VSS I1_dd31_b2_1 I1_dd31_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I177_MN1 (I0_A_16_b3_3 I0_A_16_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I177_MN1_1 (VSS I0_A_16_b2_1 I0_A_16_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I428_MN1 (I0_B_21_b3_2 I0_B_21_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I428_MN1_1 (VSS I0_B_21_b2_0 I0_B_21_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I424_MN1 (I0_B_21_b2_0 I0_B_21_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I424_MN1_1 (VSS I0_B_21_b1_0 I0_B_21_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1105_MN1 (I0_two11_b3_3 I0_two11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1105_MN1_1 (VSS I0_two11_b2_1 I0_two11_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1095_MN1 (I0_one11_b3_3 I0_one11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1095_MN1_1 (VSS I0_one11_b2_1 I0_one11_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I146_XP_MN0 (I1_I746_P21_14 I1_I746_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I146_XP_MN1 (VSS I1_I746_P17_14n I1_I746_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.16u ps=0.68u
    I_MXI1_I746_I150_XP_MN0 (I1_I746_P25_18 I1_I746_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I150_XP_MN1 (VSS I1_I746_P21_18n I1_I746_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.16u ps=0.68u
    I_MXI1_I700_I143_XP_MN0 (I1_I700_P18_11 I1_I700_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I143_XP_MN1 (VSS I1_I700_P14_11n I1_I700_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.16u ps=0.68u
    I_MXI1_I700_I145_XP_MN0 (I1_I700_P20_13 I1_I700_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I145_XP_MN1 (VSS I1_I700_P16_13n I1_I700_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I85_XP_MN0 (I2_I1_I42_P19_18 I2_I1_I42_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I85_XP_MN1 (VSS I2_I1_I42_pn18 I2_I1_I42_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I86_XP_MN0 (I2_I1_I42_P20_19 I2_I1_I42_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I86_XP_MN1 (VSS I2_I1_I42_pn19 I2_I1_I42_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I87_XP_MN0 (I2_I1_I42_P21_20 I2_I1_I42_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I87_XP_MN1 (VSS I2_I1_I42_pn20 I2_I1_I42_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I88_XP_MN0 (I2_I1_I42_P22_21 I2_I1_I42_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I88_XP_MN1 (VSS I2_I1_I42_pn21 I2_I1_I42_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.16u ps=0.68u
    I_MXI2_I4_I12_MN0 (I2_I4_z0_12 Y_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2_I4_I12_MN1 (VSS Y_25 I2_I4_z0_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.16u ps=0.68u
    I_MXI2_I4_I14_MN0 (I2_I4_z0_14 Y_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2_I4_I14_MN1 (VSS Y_29 I2_I4_z0_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.16u ps=0.68u
    I_MXI1_I1666_I144_XP_MN0 (I1_I1666_P19_12 I1_I1666_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1666_I144_XP_MN1 (VSS I1_I1666_P15_12n I1_I1666_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.16u ps=0.68u
    I_MXI1_I1666_I146_XP_MN0 (I1_I1666_P21_14 I1_I1666_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1666_I146_XP_MN1 (VSS I1_I1666_P17_14n I1_I1666_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.16u ps=0.68u
    I_MXI0_I1660_I290_XP_MN0 (I0_I1660_P37_30 I0_I1660_P37_34n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1660_I290_XP_MN1 (VSS I0_I1660_P33_30n I0_I1660_P37_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.16u ps=0.68u
    I_MXI0_I1660_I292_XP_MN0 (I0_I1660_P39_32 I0_I1660_P39_36n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1660_I292_XP_MN1 (VSS I0_I1660_P35_32n I0_I1660_P39_32 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.16u ps=0.68u
    I_MXI0_I1660_I283_XP_MN0 (I0_I1660_P30_23 I0_I1660_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1660_I283_XP_MN1 (VSS I0_I1660_P26_23n I0_I1660_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.16u ps=0.68u
    I_MXI0_I1660_I407_XP_MN0 (I0_I1660_P44_13 I0_I1660_P44_29n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1660_I407_XP_MN1 (VSS I0_I1660_P28_13n I0_I1660_P44_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.16u ps=0.68u
    I_MXI1_I1298_I96_XG_MN2 (XI1_I1298_I96_XG_n1 I1_I1298_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I96_XG_MN0 (I1_I1298_G30_29 I1_I1298_pn30 XI1_I1298_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I96_XG_MN1 (XI1_I1298_I96_XG_n1 I1_I1298_gn29 I1_I1298_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I97_XG_MN2 (XI1_I1298_I97_XG_n1 I1_I1298_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I97_XG_MN0 (I1_I1298_G31_30 I1_I1298_pn31 XI1_I1298_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I97_XG_MN1 (XI1_I1298_I97_XG_n1 I1_I1298_gn30 I1_I1298_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I150_XG_MN2 (XI1_I792_I150_XG_n1 I1_I792_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I150_XG_MN0 (I1_I792_G25_18 I1_I792_P25_22n XI1_I792_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I150_XG_MN1 (XI1_I792_I150_XG_n1 I1_I792_G21_18n I1_I792_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I148_XG_MN2 (XI1_I792_I148_XG_n1 I1_I792_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I148_XG_MN0 (I1_I792_G23_16 I1_I792_P23_20n XI1_I792_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I148_XG_MN1 (XI1_I792_I148_XG_n1 I1_I792_G19_16n I1_I792_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I76_XG_MN2 (XI1_I792_I76_XG_n1 I1_I792_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I76_XG_MN0 (I1_I792_G10_9 I1_I792_pn10 XI1_I792_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I76_XG_MN1 (XI1_I792_I76_XG_n1 I1_I792_gn9 I1_I792_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I77_XG_MN2 (XI1_I792_I77_XG_n1 I1_I792_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I77_XG_MN0 (I1_I792_G11_10 I1_I792_pn11 XI1_I792_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I77_XG_MN1 (XI1_I792_I77_XG_n1 I1_I792_gn10 I1_I792_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I72_XG_MN2 (XI1_I792_I72_XG_n1 I1_I792_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I72_XG_MN0 (I1_I792_G6_5 I1_I792_pn6 XI1_I792_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I72_XG_MN1 (XI1_I792_I72_XG_n1 I1_I792_gn5 I1_I792_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I73_XG_MN2 (XI1_I792_I73_XG_n1 I1_I792_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I73_XG_MN0 (I1_I792_G7_6 I1_I792_pn7 XI1_I792_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I73_XG_MN1 (XI1_I792_I73_XG_n1 I1_I792_gn6 I1_I792_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I86_XG_MN2 (XI1_I746_I86_XG_n1 I1_I746_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I86_XG_MN0 (I1_I746_G20_19 I1_I746_pn20 XI1_I746_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I86_XG_MN1 (XI1_I746_I86_XG_n1 I1_I746_gn19 I1_I746_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I87_XG_MN2 (XI1_I746_I87_XG_n1 I1_I746_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I87_XG_MN0 (I1_I746_G21_20 I1_I746_pn21 XI1_I746_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I87_XG_MN1 (XI1_I746_I87_XG_n1 I1_I746_gn20 I1_I746_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I148_XG_MN2 (XI1_I700_I148_XG_n1 I1_I700_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I148_XG_MN0 (I1_I700_G23_16 I1_I700_P23_20n XI1_I700_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I148_XG_MN1 (XI1_I700_I148_XG_n1 I1_I700_G19_16n I1_I700_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I152_XG_MN2 (XI1_I700_I152_XG_n1 I1_I700_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I152_XG_MN0 (I1_I700_G27_20 I1_I700_P27_24n XI1_I700_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I152_XG_MN1 (XI1_I700_I152_XG_n1 I1_I700_G23_20n I1_I700_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I199_XG_MN2 (XI1_I700_I199_XG_n1 I1_I700_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I199_XG_MN0 (I1_I700_G28_0 I1_I700_P28_13n XI1_I700_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I199_XG_MN1 (XI1_I700_I199_XG_n1 I1_I700_G12_0n I1_I700_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I201_XG_MN2 (XI1_I700_I201_XG_n1 I1_I700_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I201_XG_MN0 (I1_c3_m I1_I700_P30_15n XI1_I700_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I201_XG_MN1 (XI1_I700_I201_XG_n1 I1_I700_G14_0n I1_c3_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I75_XG_MN2 (XI1_I700_I75_XG_n1 I1_I700_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I75_XG_MN0 (I1_I700_G9_8 I1_I700_pn9 XI1_I700_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I75_XG_MN1 (XI1_I700_I75_XG_n1 I1_I700_gn8 I1_I700_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I76_XG_MN2 (XI1_I700_I76_XG_n1 I1_I700_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I76_XG_MN0 (I1_I700_G10_9 I1_I700_pn10 XI1_I700_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I76_XG_MN1 (XI1_I700_I76_XG_n1 I1_I700_gn9 I1_I700_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I77_XG_MN2 (XI1_I700_I77_XG_n1 I1_I700_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I77_XG_MN0 (I1_I700_G11_10 I1_I700_pn11 XI1_I700_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I77_XG_MN1 (XI1_I700_I77_XG_n1 I1_I700_gn10 I1_I700_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I87_XG_MN2 (XI1_I700_I87_XG_n1 I1_I700_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I87_XG_MN0 (I1_I700_G21_20 I1_I700_pn21 XI1_I700_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I87_XG_MN1 (XI1_I700_I87_XG_n1 I1_I700_gn20 I1_I700_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I88_XG_MN2 (XI1_I700_I88_XG_n1 I1_I700_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I88_XG_MN0 (I1_I700_G22_21 I1_I700_pn22 XI1_I700_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I88_XG_MN1 (XI1_I700_I88_XG_n1 I1_I700_gn21 I1_I700_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I89_XG_MN2 (XI1_I700_I89_XG_n1 I1_I700_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I700_I89_XG_MN0 (I1_I700_G23_22 I1_I700_pn23 XI1_I700_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I700_I89_XG_MN1 (XI1_I700_I89_XG_n1 I1_I700_gn22 I1_I700_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I78_XG_MN2 (XI1_I608_I78_XG_n1 I1_I608_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I78_XG_MN0 (I1_I608_G12_11 I1_I608_pn12 XI1_I608_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I78_XG_MN1 (XI1_I608_I78_XG_n1 I1_I608_gn11 I1_I608_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I79_XG_MN2 (XI1_I608_I79_XG_n1 I1_I608_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I79_XG_MN0 (I1_I608_G13_12 I1_I608_pn13 XI1_I608_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I79_XG_MN1 (XI1_I608_I79_XG_n1 I1_I608_gn12 I1_I608_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I83_XG_MN2 (XI1_I562_I83_XG_n1 I1_I562_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I83_XG_MN0 (I1_I562_G17_16 I1_I562_pn17 XI1_I562_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I83_XG_MN1 (XI1_I562_I83_XG_n1 I1_I562_gn16 I1_I562_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I84_XG_MN2 (XI1_I562_I84_XG_n1 I1_I562_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I84_XG_MN0 (I1_I562_G18_17 I1_I562_pn18 XI1_I562_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I84_XG_MN1 (XI1_I562_I84_XG_n1 I1_I562_gn17 I1_I562_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I142_XG_MN2 (XI0_I1660_I142_XG_n1 I0_I1660_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I142_XG_MN0 (I0_I1660_G12_11 I0_I1660_pn12 XI0_I1660_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I142_XG_MN1 (XI0_I1660_I142_XG_n1 I0_I1660_gn11 I0_I1660_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I143_XG_MN2 (XI0_I1660_I143_XG_n1 I0_I1660_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I143_XG_MN0 (I0_I1660_G13_12 I0_I1660_pn13 XI0_I1660_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I143_XG_MN1 (XI0_I1660_I143_XG_n1 I0_I1660_gn12 I0_I1660_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I144_XG_MN2 (XI0_I1660_I144_XG_n1 I0_I1660_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I144_XG_MN0 (I0_I1660_G14_13 I0_I1660_pn14 XI0_I1660_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I144_XG_MN1 (XI0_I1660_I144_XG_n1 I0_I1660_gn13 I0_I1660_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I396_XG_MN2 (XI0_I1660_I396_XG_n1 I0_I1660_G33_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I396_XG_MN0 (I0_I1660_G33_2 I0_I1660_P33_18n XI0_I1660_I396_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I396_XG_MN1 (XI0_I1660_I396_XG_n1 I0_I1660_G17_2n I0_I1660_G33_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I273_XG_MN2 (XI0_I1660_I273_XG_n1 I0_I1660_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I273_XG_MN0 (I0_I1660_G20_13 I0_I1660_P20_17n XI0_I1660_I273_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I273_XG_MN1 (XI0_I1660_I273_XG_n1 I0_I1660_G16_13n I0_I1660_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1265_MN1 (I1_qu16_b3_5 I1_qu16_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1265_MN1_1 (VSS I1_qu16_b2_1 I1_qu16_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1264_MN1 (I1_qu16_b3_4 I1_qu16_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1264_MN1_1 (VSS I1_qu16_b2_1 I1_qu16_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1259_MN1 (I1_qu16_b2_1 I1_qu16_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1259_MN1_1 (VSS I1_qu16_b1_0 I1_qu16_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1258_MN1 (I1_qu16_b2_0 I1_qu16_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1258_MN1_1 (VSS I1_qu16_b1_0 I1_qu16_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1263_MN1 (I1_qu16_b3_3 I1_qu16_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1263_MN1_1 (VSS I1_qu16_b2_1 I1_qu16_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I711_MN1 (I1_qu28_b3_3 I1_qu28_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I711_MN1_1 (VSS I1_qu28_b2_1 I1_qu28_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I706_MN1 (I1_qu28_b2_0 I1_qu28_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I706_MN1_1 (VSS I1_qu28_b1_0 I1_qu28_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I163_MN1 (I1_dd3_b3_3 I1_dd3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I163_MN1_1 (VSS I1_dd3_b2_1 I1_dd3_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I211_MN1 (I1_dd7_b2_1 I1_dd7_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I211_MN1_1 (VSS I1_dd7_b1_0 I1_dd7_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I176_MN1 (I1_dd4_b3_3 I1_dd4_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I176_MN1_1 (VSS I1_dd4_b2_1 I1_dd4_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I386_MN1 (I0_B_13_b3_0 I0_B_13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I386_MN1_1 (VSS I0_B_13_b2_0 I0_B_13_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I770_MN1 (I0_two5_b2_0 I0_two5_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I770_MN1_1 (VSS I0_two5_b1_0 I0_two5_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I815_MN1 (I0_one6_b2_0 I0_one6_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I815_MN1_1 (VSS I0_one6_b1_0 I0_one6_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I384_MN1 (I0_B_13_b2_0 I0_B_13_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I384_MN1_1 (VSS I0_B_13_b1_0 I0_B_13_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I142_MN1 (I0_A_13_b2_0 I0_A_13_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I142_MN1_1 (VSS I0_A_13_b1_0 I0_A_13_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I85_MN1 (I0_A_7_b3_1 I0_A_7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I85_MN1_1 (VSS I0_A_7_b2_0 I0_A_7_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I708_MN1 (I0_one4_b3_1 I0_one4_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I708_MN1_1 (VSS I0_one4_b2_0 I0_one4_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I407_MN1 (I0_B_17_b3_1 I0_B_17_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I407_MN1_1 (VSS I0_B_17_b2_0 I0_B_17_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I406_MN1 (I0_B_17_b3_0 I0_B_17_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I406_MN1_1 (VSS I0_B_17_b2_0 I0_B_17_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I477_MN1 (I1_dd27_b3_5 I1_dd27_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I477_MN1_1 (VSS I1_dd27_b2_1 I1_dd27_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I490_MN1 (I1_dd28_b3_5 I1_dd28_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I490_MN1_1 (VSS I1_dd28_b2_1 I1_dd28_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I230_MN1 (I1_dd8_b3_5 I1_dd8_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I230_MN1_1 (VSS I1_dd8_b2_1 I1_dd8_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I269_MN1 (I1_dd11_b3_5 I1_dd11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I269_MN1_1 (VSS I1_dd11_b2_1 I1_dd11_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I707_MN1 (I1_qu28_b2_1 I1_qu28_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I707_MN1_1 (VSS I1_qu28_b1_0 I1_qu28_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I705_MN1 (I1_qu28_b1_0 I1_qu28_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I705_MN1_1 (VSS I1_qu28_b0 I1_qu28_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I474_MN1 (I1_dd27_b3_2 I1_dd27_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I474_MN1_1 (VSS I1_dd27_b2_0 I1_dd27_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I500_MN1 (I1_dd29_b3_2 I1_dd29_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I500_MN1_1 (VSS I1_dd29_b2_0 I1_dd29_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I496_MN1 (I1_dd29_b2_0 I1_dd29_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I496_MN1_1 (VSS I1_dd29_b1_0 I1_dd29_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I473_MN1 (I1_dd27_b3_1 I1_dd27_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I473_MN1_1 (VSS I1_dd27_b2_0 I1_dd27_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I213_MN1 (I1_dd7_b3_1 I1_dd7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I213_MN1_1 (VSS I1_dd7_b2_0 I1_dd7_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I200_MN1 (I1_dd6_b3_1 I1_dd6_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I200_MN1_1 (VSS I1_dd6_b2_0 I1_dd6_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I341_MN1 (I1_dd17_b2_1 I1_dd17_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I341_MN1_1 (VSS I1_dd17_b1_0 I1_dd17_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I202_MN1 (I1_dd6_b3_3 I1_dd6_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I202_MN1_1 (VSS I1_dd6_b2_1 I1_dd6_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I389_MN1 (I0_B_13_b3_3 I0_B_13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I389_MN1_1 (VSS I0_B_13_b2_1 I0_B_13_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I391_MN1 (I0_B_13_b3_5 I0_B_13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I391_MN1_1 (VSS I0_B_13_b2_1 I0_B_13_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I529_MN1 (I1_dd31_b3_5 I1_dd31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I529_MN1_1 (VSS I1_dd31_b2_1 I1_dd31_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I334_MN1 (I1_dd16_b3_5 I1_dd16_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I334_MN1_1 (VSS I1_dd16_b2_1 I1_dd16_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1158_MN1 (I0_two12_b3_1 I0_two12_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1158_MN1_1 (VSS I0_two12_b2_0 I0_two12_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I446_MN1 (I0_B_25_b3_0 I0_B_25_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I446_MN1_1 (VSS I0_B_25_b2_0 I0_B_25_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I50_MN1 (I2_I3_SEL_MUL_b3_5 I2_I3_SEL_MUL_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I50_MN1_1 (VSS I2_I3_SEL_MUL_b2_1 I2_I3_SEL_MUL_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I43_MN1 (I2_I3_SEL_MUL_b2_1 I2_I3_SEL_MUL_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I43_MN1_1 (VSS I2_I3_SEL_MUL_b1_0 I2_I3_SEL_MUL_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I67_XG_MN2 (XI1_I792_I67_XG_n1 I1_I792_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I67_XG_MN0 (I1_I792_G1_0 I1_I792_pn1 XI1_I792_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I67_XG_MN1 (XI1_I792_I67_XG_n1 I1_I792_G0_0n I1_I792_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I69_XG_MN2 (XI1_I792_I69_XG_n1 I1_I792_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I69_XG_MN0 (I1_I792_G3_2 I1_I792_pn3 XI1_I792_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I69_XG_MN1 (XI1_I792_I69_XG_n1 I1_I792_gn2 I1_I792_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I78_XG_MN2 (XI1_I746_I78_XG_n1 I1_I746_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I78_XG_MN0 (I1_I746_G12_11 I1_I746_pn12 XI1_I746_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I78_XG_MN1 (XI1_I746_I78_XG_n1 I1_I746_gn11 I1_I746_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I79_XG_MN2 (XI1_I746_I79_XG_n1 I1_I746_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I79_XG_MN0 (I1_I746_G13_12 I1_I746_pn13 XI1_I746_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I79_XG_MN1 (XI1_I746_I79_XG_n1 I1_I746_gn12 I1_I746_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I72_XG_MN2 (XI1_I746_I72_XG_n1 I1_I746_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I72_XG_MN0 (I1_I746_G6_5 I1_I746_pn6 XI1_I746_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I72_XG_MN1 (XI1_I746_I72_XG_n1 I1_I746_gn5 I1_I746_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I73_XG_MN2 (XI1_I746_I73_XG_n1 I1_I746_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I73_XG_MN0 (I1_I746_G7_6 I1_I746_pn7 XI1_I746_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I73_XG_MN1 (XI1_I746_I73_XG_n1 I1_I746_gn6 I1_I746_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I94_XG_MN2 (XI1_I654_I94_XG_n1 I1_I654_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I94_XG_MN0 (I1_I654_G28_27 I1_I654_pn28 XI1_I654_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I94_XG_MN1 (XI1_I654_I94_XG_n1 I1_I654_gn27 I1_I654_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I654_I95_XG_MN2 (XI1_I654_I95_XG_n1 I1_I654_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I654_I95_XG_MN0 (I1_I654_G29_28 I1_I654_pn29 XI1_I654_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I654_I95_XG_MN1 (XI1_I654_I95_XG_n1 I1_I654_gn28 I1_I654_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I92_XG_MN2 (XI1_I608_I92_XG_n1 I1_I608_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I92_XG_MN0 (I1_I608_G26_25 I1_I608_pn26 XI1_I608_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I92_XG_MN1 (XI1_I608_I92_XG_n1 I1_I608_gn25 I1_I608_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I608_I93_XG_MN2 (XI1_I608_I93_XG_n1 I1_I608_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I608_I93_XG_MN0 (I1_I608_G27_26 I1_I608_pn27 XI1_I608_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I608_I93_XG_MN1 (XI1_I608_I93_XG_n1 I1_I608_gn26 I1_I608_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I69_XG_MN2 (XI1_I1022_I69_XG_n1 I1_I1022_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I69_XG_MN0 (I1_I1022_G3_2 I1_I1022_pn3 XI1_I1022_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I69_XG_MN1 (XI1_I1022_I69_XG_n1 I1_I1022_gn2 I1_I1022_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1022_I70_XG_MN2 (XI1_I1022_I70_XG_n1 I1_I1022_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1022_I70_XG_MN0 (I1_I1022_G4_3 I1_I1022_pn4 XI1_I1022_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1022_I70_XG_MN1 (XI1_I1022_I70_XG_n1 I1_I1022_gn3 I1_I1022_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I85_XG_MN2 (XI2_I1_I42_I85_XG_n1 I2_I1_I42_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I85_XG_MN0 (I2_I1_I42_G19_18 I2_I1_I42_pn19 XI2_I1_I42_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I85_XG_MN1 (XI2_I1_I42_I85_XG_n1 I2_I1_I42_gn18 I2_I1_I42_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I86_XG_MN2 (XI2_I1_I42_I86_XG_n1 I2_I1_I42_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I86_XG_MN0 (I2_I1_I42_G20_19 I2_I1_I42_pn20 XI2_I1_I42_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I86_XG_MN1 (XI2_I1_I42_I86_XG_n1 I2_I1_I42_gn19 I2_I1_I42_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I148_XG_MN2 (XI2_I1_I42_I148_XG_n1 I2_I1_I42_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I148_XG_MN0 (I2_I1_I42_G23_16 I2_I1_I42_P23_20n XI2_I1_I42_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I148_XG_MN1 (XI2_I1_I42_I148_XG_n1 I2_I1_I42_G19_16n I2_I1_I42_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I152_XG_MN2 (XI2_I1_I42_I152_XG_n1 I2_I1_I42_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I152_XG_MN0 (I2_I1_I42_G27_20 I2_I1_I42_P27_24n XI2_I1_I42_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I152_XG_MN1 (XI2_I1_I42_I152_XG_n1 I2_I1_I42_G23_20n I2_I1_I42_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I150_XG_MN2 (XI0_I1660_I150_XG_n1 I0_I1660_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I150_XG_MN0 (I0_I1660_G20_19 I0_I1660_pn20 XI0_I1660_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I150_XG_MN1 (XI0_I1660_I150_XG_n1 I0_I1660_gn19 I0_I1660_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I151_XG_MN2 (XI0_I1660_I151_XG_n1 I0_I1660_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I151_XG_MN0 (I0_I1660_G21_20 I0_I1660_pn21 XI0_I1660_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I151_XG_MN1 (XI0_I1660_I151_XG_n1 I0_I1660_gn20 I0_I1660_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I157_XG_MN2 (XI0_I1660_I157_XG_n1 I0_I1660_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I157_XG_MN0 (I0_I1660_G27_26 I0_I1660_pn27 XI0_I1660_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I157_XG_MN1 (XI0_I1660_I157_XG_n1 I0_I1660_gn26 I0_I1660_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I158_XG_MN2 (XI0_I1660_I158_XG_n1 I0_I1660_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I158_XG_MN0 (I0_I1660_G28_27 I0_I1660_pn28 XI0_I1660_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I158_XG_MN1 (XI0_I1660_I158_XG_n1 I0_I1660_gn27 I0_I1660_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I162_XG_MN2 (XI0_I1660_I162_XG_n1 I0_I1660_gn32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I162_XG_MN0 (I0_I1660_G32_31 I0_I1660_pn32 XI0_I1660_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I162_XG_MN1 (XI0_I1660_I162_XG_n1 I0_I1660_gn31 I0_I1660_G32_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I163_XG_MN2 (XI0_I1660_I163_XG_n1 I0_I1660_gn33 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I163_XG_MN0 (I0_I1660_G33_32 I0_I1660_pn33 XI0_I1660_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I163_XG_MN1 (XI0_I1660_I163_XG_n1 I0_I1660_gn32 I0_I1660_G33_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I168_XG_MN2 (XI0_I1660_I168_XG_n1 I0_I1660_gn38 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I168_XG_MN0 (I0_I1660_G38_37 I0_I1660_pn38 XI0_I1660_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I168_XG_MN1 (XI0_I1660_I168_XG_n1 I0_I1660_gn37 I0_I1660_G38_37 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I169_XG_MN2 (XI0_I1660_I169_XG_n1 I0_I1660_gn39 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I169_XG_MN0 (I0_I1660_G39_38 I0_I1660_pn39 XI0_I1660_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I169_XG_MN1 (XI0_I1660_I169_XG_n1 I0_I1660_gn38 I0_I1660_G39_38 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I62_MN1 (XI1_I1344_I62_Bn I1_b17_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I62_MN5 (XI1_I1344_I62_n2 I1_b17_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I62_MN4 (I1_I1344_pn30 XI1_I1344_I62_An XI1_I1344_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I62_MN2 (XI1_I1344_I62_n1 I1_p16_29 I1_I1344_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I62_MN3 (VSS XI1_I1344_I62_Bn XI1_I1344_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I62_MN0 (XI1_I1344_I62_An I1_p16_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I63_MN1 (XI1_I1344_I63_Bn I1_b17_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I63_MN5 (XI1_I1344_I63_n2 I1_b17_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I63_MN4 (I1_I1344_pn31 XI1_I1344_I63_An XI1_I1344_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I63_MN2 (XI1_I1344_I63_n1 I1_p16_30 I1_I1344_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I63_MN3 (VSS XI1_I1344_I63_Bn XI1_I1344_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I63_MN0 (XI1_I1344_I63_An I1_p16_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I233_MN1 (XI1_I1298_I233_Bn I1_I1298_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I233_MN5 (XI1_I1298_I233_n2 I1_I1298_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I233_MN4 (I1_p16_30 XI1_I1298_I233_An XI1_I1298_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I233_MN2 (XI1_I1298_I233_n1 I1_I1298_pn30 I1_p16_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I233_MN3 (VSS XI1_I1298_I233_Bn XI1_I1298_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I233_MN0 (XI1_I1298_I233_An I1_I1298_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I234_MN1 (XI1_I1298_I234_Bn I1_c16_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I234_MN5 (XI1_I1298_I234_n2 I1_c16_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I234_MN4 (I1_p16_31 XI1_I1298_I234_An XI1_I1298_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I234_MN2 (XI1_I1298_I234_n1 I1_I1298_pn31 I1_p16_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I234_MN3 (VSS XI1_I1298_I234_Bn XI1_I1298_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I234_MN0 (XI1_I1298_I234_An I1_I1298_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I232_MN1 (XI1_I1298_I232_Bn I1_I1298_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I232_MN5 (XI1_I1298_I232_n2 I1_I1298_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I232_MN4 (I1_p16_29 XI1_I1298_I232_An XI1_I1298_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I232_MN2 (XI1_I1298_I232_n1 I1_I1298_pn29 I1_p16_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I232_MN3 (VSS XI1_I1298_I232_Bn XI1_I1298_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I232_MN0 (XI1_I1298_I232_An I1_I1298_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I61_MN1 (XI1_I1298_I61_Bn I1_b16_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I61_MN5 (XI1_I1298_I61_n2 I1_b16_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I61_MN4 (I1_I1298_pn29 XI1_I1298_I61_An XI1_I1298_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I61_MN2 (XI1_I1298_I61_n1 I1_p15_28 I1_I1298_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I61_MN3 (VSS XI1_I1298_I61_Bn XI1_I1298_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I61_MN0 (XI1_I1298_I61_An I1_p15_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I62_MN1 (XI1_I1298_I62_Bn I1_b16_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I62_MN5 (XI1_I1298_I62_n2 I1_b16_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I62_MN4 (I1_I1298_pn30 XI1_I1298_I62_An XI1_I1298_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I62_MN2 (XI1_I1298_I62_n1 I1_p15_29 I1_I1298_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I62_MN3 (VSS XI1_I1298_I62_Bn XI1_I1298_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I62_MN0 (XI1_I1298_I62_An I1_p15_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I63_MN1 (XI1_I1298_I63_Bn I1_b16_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I63_MN5 (XI1_I1298_I63_n2 I1_b16_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I63_MN4 (I1_I1298_pn31 XI1_I1298_I63_An XI1_I1298_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I63_MN2 (XI1_I1298_I63_n1 I1_p15_30 I1_I1298_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I63_MN3 (VSS XI1_I1298_I63_Bn XI1_I1298_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I63_MN0 (XI1_I1298_I63_An I1_p15_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I232_MN1 (XI1_I1252_I232_Bn I1_I1252_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I232_MN5 (XI1_I1252_I232_n2 I1_I1252_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I232_MN4 (I1_p15_29 XI1_I1252_I232_An XI1_I1252_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I232_MN2 (XI1_I1252_I232_n1 I1_I1252_pn29 I1_p15_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I232_MN3 (VSS XI1_I1252_I232_Bn XI1_I1252_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I232_MN0 (XI1_I1252_I232_An I1_I1252_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I234_MN1 (XI1_I1252_I234_Bn I1_c15_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I234_MN5 (XI1_I1252_I234_n2 I1_c15_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I234_MN4 (I1_p15_31 XI1_I1252_I234_An XI1_I1252_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I234_MN2 (XI1_I1252_I234_n1 I1_I1252_pn31 I1_p15_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I234_MN3 (VSS XI1_I1252_I234_Bn XI1_I1252_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I234_MN0 (XI1_I1252_I234_An I1_I1252_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I231_MN1 (XI1_I1252_I231_Bn I1_I1252_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I231_MN5 (XI1_I1252_I231_n2 I1_I1252_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I231_MN4 (I1_p15_28 XI1_I1252_I231_An XI1_I1252_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I231_MN2 (XI1_I1252_I231_n1 I1_I1252_pn28 I1_p15_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I231_MN3 (VSS XI1_I1252_I231_Bn XI1_I1252_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I231_MN0 (XI1_I1252_I231_An I1_I1252_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I233_MN1 (XI1_I1252_I233_Bn I1_I1252_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I233_MN5 (XI1_I1252_I233_n2 I1_I1252_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I233_MN4 (I1_p15_30 XI1_I1252_I233_An XI1_I1252_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I233_MN2 (XI1_I1252_I233_n1 I1_I1252_pn30 I1_p15_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I233_MN3 (VSS XI1_I1252_I233_Bn XI1_I1252_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I233_MN0 (XI1_I1252_I233_An I1_I1252_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I60_MN1 (XI1_I1252_I60_Bn I1_b15_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I60_MN5 (XI1_I1252_I60_n2 I1_b15_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I60_MN4 (I1_I1252_pn28 XI1_I1252_I60_An XI1_I1252_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I60_MN2 (XI1_I1252_I60_n1 I1_p14_27 I1_I1252_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I60_MN3 (VSS XI1_I1252_I60_Bn XI1_I1252_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I60_MN0 (XI1_I1252_I60_An I1_p14_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I61_MN1 (XI1_I1252_I61_Bn I1_b15_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I61_MN5 (XI1_I1252_I61_n2 I1_b15_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I61_MN4 (I1_I1252_pn29 XI1_I1252_I61_An XI1_I1252_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I61_MN2 (XI1_I1252_I61_n1 I1_p14_28 I1_I1252_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I61_MN3 (VSS XI1_I1252_I61_Bn XI1_I1252_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I61_MN0 (XI1_I1252_I61_An I1_p14_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I63_MN1 (XI1_I1252_I63_Bn I1_b15_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I63_MN5 (XI1_I1252_I63_n2 I1_b15_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I63_MN4 (I1_I1252_pn31 XI1_I1252_I63_An XI1_I1252_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I63_MN2 (XI1_I1252_I63_n1 I1_p14_30 I1_I1252_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I63_MN3 (VSS XI1_I1252_I63_Bn XI1_I1252_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I63_MN0 (XI1_I1252_I63_An I1_p14_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I62_MN1 (XI1_I1252_I62_Bn I1_b15_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I62_MN5 (XI1_I1252_I62_n2 I1_b15_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I62_MN4 (I1_I1252_pn30 XI1_I1252_I62_An XI1_I1252_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I62_MN2 (XI1_I1252_I62_n1 I1_p14_29 I1_I1252_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I62_MN3 (VSS XI1_I1252_I62_Bn XI1_I1252_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I62_MN0 (XI1_I1252_I62_An I1_p14_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I231_MN1 (XI1_I1206_I231_Bn I1_I1206_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I231_MN5 (XI1_I1206_I231_n2 I1_I1206_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I231_MN4 (I1_p14_28 XI1_I1206_I231_An XI1_I1206_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I231_MN2 (XI1_I1206_I231_n1 I1_I1206_pn28 I1_p14_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I231_MN3 (VSS XI1_I1206_I231_Bn XI1_I1206_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I231_MN0 (XI1_I1206_I231_An I1_I1206_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I61_MN1 (XI1_I1206_I61_Bn I1_b14_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I61_MN5 (XI1_I1206_I61_n2 I1_b14_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I61_MN4 (I1_I1206_pn29 XI1_I1206_I61_An XI1_I1206_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I61_MN2 (XI1_I1206_I61_n1 I1_p13_28 I1_I1206_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I61_MN3 (VSS XI1_I1206_I61_Bn XI1_I1206_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I61_MN0 (XI1_I1206_I61_An I1_p13_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I232_MN1 (XI1_I1206_I232_Bn I1_I1206_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I232_MN5 (XI1_I1206_I232_n2 I1_I1206_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I232_MN4 (I1_p14_29 XI1_I1206_I232_An XI1_I1206_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I232_MN2 (XI1_I1206_I232_n1 I1_I1206_pn29 I1_p14_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I232_MN3 (VSS XI1_I1206_I232_Bn XI1_I1206_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I232_MN0 (XI1_I1206_I232_An I1_I1206_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I60_MN1 (XI1_I1206_I60_Bn I1_b14_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I60_MN5 (XI1_I1206_I60_n2 I1_b14_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I60_MN4 (I1_I1206_pn28 XI1_I1206_I60_An XI1_I1206_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I60_MN2 (XI1_I1206_I60_n1 I1_p13_27 I1_I1206_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I60_MN3 (VSS XI1_I1206_I60_Bn XI1_I1206_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I60_MN0 (XI1_I1206_I60_An I1_p13_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I59_MN1 (XI1_I1206_I59_Bn I1_b14_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I59_MN5 (XI1_I1206_I59_n2 I1_b14_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I59_MN4 (I1_I1206_pn27 XI1_I1206_I59_An XI1_I1206_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I59_MN2 (XI1_I1206_I59_n1 I1_p13_26 I1_I1206_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I59_MN3 (VSS XI1_I1206_I59_Bn XI1_I1206_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I59_MN0 (XI1_I1206_I59_An I1_p13_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I230_MN1 (XI1_I1206_I230_Bn I1_I1206_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I230_MN5 (XI1_I1206_I230_n2 I1_I1206_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I230_MN4 (I1_p14_27 XI1_I1206_I230_An XI1_I1206_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I230_MN2 (XI1_I1206_I230_n1 I1_I1206_pn27 I1_p14_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I230_MN3 (VSS XI1_I1206_I230_Bn XI1_I1206_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I230_MN0 (XI1_I1206_I230_An I1_I1206_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I62_MN1 (XI1_I838_I62_Bn I1_b6_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I62_MN5 (XI1_I838_I62_n2 I1_b6_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I62_MN4 (I1_I838_pn30 XI1_I838_I62_An XI1_I838_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I62_MN2 (XI1_I838_I62_n1 I1_p5_29 I1_I838_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I62_MN3 (VSS XI1_I838_I62_Bn XI1_I838_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I62_MN0 (XI1_I838_I62_An I1_p5_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I233_MN1 (XI1_I792_I233_Bn I1_I792_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I233_MN5 (XI1_I792_I233_n2 I1_I792_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I233_MN4 (I1_p5_30 XI1_I792_I233_An XI1_I792_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I233_MN2 (XI1_I792_I233_n1 I1_I792_pn30 I1_p5_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I233_MN3 (VSS XI1_I792_I233_Bn XI1_I792_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I233_MN0 (XI1_I792_I233_An I1_I792_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I231_MN1 (XI1_I792_I231_Bn I1_I792_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I231_MN5 (XI1_I792_I231_n2 I1_I792_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I231_MN4 (I1_p5_28 XI1_I792_I231_An XI1_I792_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I231_MN2 (XI1_I792_I231_n1 I1_I792_pn28 I1_p5_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I231_MN3 (VSS XI1_I792_I231_Bn XI1_I792_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I231_MN0 (XI1_I792_I231_An I1_I792_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I232_MN1 (XI1_I792_I232_Bn I1_I792_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I232_MN5 (XI1_I792_I232_n2 I1_I792_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I232_MN4 (I1_p5_29 XI1_I792_I232_An XI1_I792_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I232_MN2 (XI1_I792_I232_n1 I1_I792_pn29 I1_p5_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I232_MN3 (VSS XI1_I792_I232_Bn XI1_I792_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I232_MN0 (XI1_I792_I232_An I1_I792_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I234_MN1 (XI1_I792_I234_Bn I1_c5_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I234_MN5 (XI1_I792_I234_n2 I1_c5_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I234_MN4 (I1_p5_31 XI1_I792_I234_An XI1_I792_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I234_MN2 (XI1_I792_I234_n1 I1_I792_pn31 I1_p5_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I234_MN3 (VSS XI1_I792_I234_Bn XI1_I792_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I234_MN0 (XI1_I792_I234_An I1_I792_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I62_MN1 (XI1_I792_I62_Bn I1_b5_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I62_MN5 (XI1_I792_I62_n2 I1_b5_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I62_MN4 (I1_I792_pn30 XI1_I792_I62_An XI1_I792_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I62_MN2 (XI1_I792_I62_n1 I1_p4_29 I1_I792_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I62_MN3 (VSS XI1_I792_I62_Bn XI1_I792_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I62_MN0 (XI1_I792_I62_An I1_p4_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I63_MN1 (XI1_I792_I63_Bn I1_b5_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I63_MN5 (XI1_I792_I63_n2 I1_b5_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I63_MN4 (I1_I792_pn31 XI1_I792_I63_An XI1_I792_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I63_MN2 (XI1_I792_I63_n1 I1_p4_30 I1_I792_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I63_MN3 (VSS XI1_I792_I63_Bn XI1_I792_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I63_MN0 (XI1_I792_I63_An I1_p4_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I60_MN1 (XI1_I792_I60_Bn I1_b5_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I60_MN5 (XI1_I792_I60_n2 I1_b5_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I60_MN4 (I1_I792_pn28 XI1_I792_I60_An XI1_I792_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I60_MN2 (XI1_I792_I60_n1 I1_p4_27 I1_I792_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I60_MN3 (VSS XI1_I792_I60_Bn XI1_I792_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I60_MN0 (XI1_I792_I60_An I1_p4_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I61_MN1 (XI1_I792_I61_Bn I1_b5_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I61_MN5 (XI1_I792_I61_n2 I1_b5_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I61_MN4 (I1_I792_pn29 XI1_I792_I61_An XI1_I792_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I61_MN2 (XI1_I792_I61_n1 I1_p4_28 I1_I792_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I61_MN3 (VSS XI1_I792_I61_Bn XI1_I792_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I61_MN0 (XI1_I792_I61_An I1_p4_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I61_MN1 (XI1_I1344_I61_Bn I1_b17_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I61_MN5 (XI1_I1344_I61_n2 I1_b17_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I61_MN4 (I1_I1344_pn29 XI1_I1344_I61_An XI1_I1344_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I61_MN2 (XI1_I1344_I61_n1 I1_p16_28 I1_I1344_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I61_MN3 (VSS XI1_I1344_I61_Bn XI1_I1344_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I61_MN0 (XI1_I1344_I61_An I1_p16_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I231_MN1 (XI1_I1298_I231_Bn I1_I1298_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I231_MN5 (XI1_I1298_I231_n2 I1_I1298_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I231_MN4 (I1_p16_28 XI1_I1298_I231_An XI1_I1298_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I231_MN2 (XI1_I1298_I231_n1 I1_I1298_pn28 I1_p16_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I231_MN3 (VSS XI1_I1298_I231_Bn XI1_I1298_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I231_MN0 (XI1_I1298_I231_An I1_I1298_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I230_MN1 (XI1_I1298_I230_Bn I1_I1298_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I230_MN5 (XI1_I1298_I230_n2 I1_I1298_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I230_MN4 (I1_p16_27 XI1_I1298_I230_An XI1_I1298_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I230_MN2 (XI1_I1298_I230_n1 I1_I1298_pn27 I1_p16_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I230_MN3 (VSS XI1_I1298_I230_Bn XI1_I1298_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I230_MN0 (XI1_I1298_I230_An I1_I1298_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I60_MN1 (XI1_I1298_I60_Bn I1_b16_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I60_MN5 (XI1_I1298_I60_n2 I1_b16_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I60_MN4 (I1_I1298_pn28 XI1_I1298_I60_An XI1_I1298_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I60_MN2 (XI1_I1298_I60_n1 I1_p15_27 I1_I1298_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I60_MN3 (VSS XI1_I1298_I60_Bn XI1_I1298_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I60_MN0 (XI1_I1298_I60_An I1_p15_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I59_MN1 (XI1_I1298_I59_Bn I1_b16_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I59_MN5 (XI1_I1298_I59_n2 I1_b16_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I59_MN4 (I1_I1298_pn27 XI1_I1298_I59_An XI1_I1298_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I59_MN2 (XI1_I1298_I59_n1 I1_p15_26 I1_I1298_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I59_MN3 (VSS XI1_I1298_I59_Bn XI1_I1298_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I59_MN0 (XI1_I1298_I59_An I1_p15_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I230_MN1 (XI1_I1252_I230_Bn I1_I1252_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I230_MN5 (XI1_I1252_I230_n2 I1_I1252_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I230_MN4 (I1_p15_27 XI1_I1252_I230_An XI1_I1252_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I230_MN2 (XI1_I1252_I230_n1 I1_I1252_pn27 I1_p15_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I230_MN3 (VSS XI1_I1252_I230_Bn XI1_I1252_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I230_MN0 (XI1_I1252_I230_An I1_I1252_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I229_MN1 (XI1_I1252_I229_Bn I1_I1252_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I229_MN5 (XI1_I1252_I229_n2 I1_I1252_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I229_MN4 (I1_p15_26 XI1_I1252_I229_An XI1_I1252_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I229_MN2 (XI1_I1252_I229_n1 I1_I1252_pn26 I1_p15_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I229_MN3 (VSS XI1_I1252_I229_Bn XI1_I1252_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I229_MN0 (XI1_I1252_I229_An I1_I1252_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I59_MN1 (XI1_I1252_I59_Bn I1_b15_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I59_MN5 (XI1_I1252_I59_n2 I1_b15_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I59_MN4 (I1_I1252_pn27 XI1_I1252_I59_An XI1_I1252_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I59_MN2 (XI1_I1252_I59_n1 I1_p14_26 I1_I1252_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I59_MN3 (VSS XI1_I1252_I59_Bn XI1_I1252_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I59_MN0 (XI1_I1252_I59_An I1_p14_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I63_MN1 (XI1_I1206_I63_Bn I1_b14_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I63_MN5 (XI1_I1206_I63_n2 I1_b14_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I63_MN4 (I1_I1206_pn31 XI1_I1206_I63_An XI1_I1206_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I63_MN2 (XI1_I1206_I63_n1 I1_p13_30 I1_I1206_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I63_MN3 (VSS XI1_I1206_I63_Bn XI1_I1206_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I63_MN0 (XI1_I1206_I63_An I1_p13_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I62_MN1 (XI1_I1206_I62_Bn I1_b14_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I62_MN5 (XI1_I1206_I62_n2 I1_b14_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I62_MN4 (I1_I1206_pn30 XI1_I1206_I62_An XI1_I1206_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I62_MN2 (XI1_I1206_I62_n1 I1_p13_29 I1_I1206_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I62_MN3 (VSS XI1_I1206_I62_Bn XI1_I1206_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I62_MN0 (XI1_I1206_I62_An I1_p13_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I234_MN1 (XI1_I1206_I234_Bn I1_c14_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I234_MN5 (XI1_I1206_I234_n2 I1_c14_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I234_MN4 (I1_p14_31 XI1_I1206_I234_An XI1_I1206_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I234_MN2 (XI1_I1206_I234_n1 I1_I1206_pn31 I1_p14_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I234_MN3 (VSS XI1_I1206_I234_Bn XI1_I1206_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I234_MN0 (XI1_I1206_I234_An I1_I1206_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I233_MN1 (XI1_I1206_I233_Bn I1_I1206_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I233_MN5 (XI1_I1206_I233_n2 I1_I1206_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I233_MN4 (I1_p14_30 XI1_I1206_I233_An XI1_I1206_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I233_MN2 (XI1_I1206_I233_n1 I1_I1206_pn30 I1_p14_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I233_MN3 (VSS XI1_I1206_I233_Bn XI1_I1206_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I233_MN0 (XI1_I1206_I233_An I1_I1206_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I229_MN1 (XI1_I1206_I229_Bn I1_I1206_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I229_MN5 (XI1_I1206_I229_n2 I1_I1206_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I229_MN4 (I1_p14_26 XI1_I1206_I229_An XI1_I1206_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I229_MN2 (XI1_I1206_I229_n1 I1_I1206_pn26 I1_p14_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I229_MN3 (VSS XI1_I1206_I229_Bn XI1_I1206_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I229_MN0 (XI1_I1206_I229_An I1_I1206_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I61_MN1 (XI1_I838_I61_Bn I1_b6_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I61_MN5 (XI1_I838_I61_n2 I1_b6_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I61_MN4 (I1_I838_pn29 XI1_I838_I61_An XI1_I838_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I61_MN2 (XI1_I838_I61_n1 I1_p5_28 I1_I838_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I61_MN3 (VSS XI1_I838_I61_Bn XI1_I838_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I61_MN0 (XI1_I838_I61_An I1_p5_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I59_MN1 (XI1_I838_I59_Bn I1_b6_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I59_MN5 (XI1_I838_I59_n2 I1_b6_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I59_MN4 (I1_I838_pn27 XI1_I838_I59_An XI1_I838_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I59_MN2 (XI1_I838_I59_n1 I1_p5_26 I1_I838_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I59_MN3 (VSS XI1_I838_I59_Bn XI1_I838_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I59_MN0 (XI1_I838_I59_An I1_p5_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I63_MN1 (XI1_I838_I63_Bn I1_b6_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I63_MN5 (XI1_I838_I63_n2 I1_b6_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I63_MN4 (I1_I838_pn31 XI1_I838_I63_An XI1_I838_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I63_MN2 (XI1_I838_I63_n1 I1_p5_30 I1_I838_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I63_MN3 (VSS XI1_I838_I63_Bn XI1_I838_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I63_MN0 (XI1_I838_I63_An I1_p5_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I57_MN1 (XI1_I838_I57_Bn I1_b6_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I57_MN5 (XI1_I838_I57_n2 I1_b6_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I57_MN4 (I1_I838_pn25 XI1_I838_I57_An XI1_I838_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I57_MN2 (XI1_I838_I57_n1 I1_p5_24 I1_I838_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I57_MN3 (VSS XI1_I838_I57_Bn XI1_I838_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I57_MN0 (XI1_I838_I57_An I1_p5_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I227_MN1 (XI1_I838_I227_Bn I1_I838_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I227_MN5 (XI1_I838_I227_n2 I1_I838_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I227_MN4 (I1_p6_24 XI1_I838_I227_An XI1_I838_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I227_MN2 (XI1_I838_I227_n1 I1_I838_pn24 I1_p6_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I227_MN3 (VSS XI1_I838_I227_Bn XI1_I838_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I227_MN0 (XI1_I838_I227_An I1_I838_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I225_MN1 (XI1_I838_I225_Bn I1_I838_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I225_MN5 (XI1_I838_I225_n2 I1_I838_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I225_MN4 (I1_p6_22 XI1_I838_I225_An XI1_I838_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I225_MN2 (XI1_I838_I225_n1 I1_I838_pn22 I1_p6_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I225_MN3 (VSS XI1_I838_I225_Bn XI1_I838_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I225_MN0 (XI1_I838_I225_An I1_I838_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I225_MN1 (XI1_I792_I225_Bn I1_I792_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I225_MN5 (XI1_I792_I225_n2 I1_I792_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I225_MN4 (I1_p5_22 XI1_I792_I225_An XI1_I792_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I225_MN2 (XI1_I792_I225_n1 I1_I792_pn22 I1_p5_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I225_MN3 (VSS XI1_I792_I225_Bn XI1_I792_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I225_MN0 (XI1_I792_I225_An I1_I792_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I229_MN1 (XI1_I792_I229_Bn I1_I792_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I229_MN5 (XI1_I792_I229_n2 I1_I792_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I229_MN4 (I1_p5_26 XI1_I792_I229_An XI1_I792_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I229_MN2 (XI1_I792_I229_n1 I1_I792_pn26 I1_p5_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I229_MN3 (VSS XI1_I792_I229_Bn XI1_I792_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I229_MN0 (XI1_I792_I229_An I1_I792_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I227_MN1 (XI1_I792_I227_Bn I1_I792_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I227_MN5 (XI1_I792_I227_n2 I1_I792_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I227_MN4 (I1_p5_24 XI1_I792_I227_An XI1_I792_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I227_MN2 (XI1_I792_I227_n1 I1_I792_pn24 I1_p5_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I227_MN3 (VSS XI1_I792_I227_Bn XI1_I792_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I227_MN0 (XI1_I792_I227_An I1_I792_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I230_MN1 (XI1_I792_I230_Bn I1_I792_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I230_MN5 (XI1_I792_I230_n2 I1_I792_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I230_MN4 (I1_p5_27 XI1_I792_I230_An XI1_I792_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I230_MN2 (XI1_I792_I230_n1 I1_I792_pn27 I1_p5_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I230_MN3 (VSS XI1_I792_I230_Bn XI1_I792_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I230_MN0 (XI1_I792_I230_An I1_I792_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I58_MN1 (XI1_I792_I58_Bn I1_b5_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I58_MN5 (XI1_I792_I58_n2 I1_b5_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I58_MN4 (I1_I792_pn26 XI1_I792_I58_An XI1_I792_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I58_MN2 (XI1_I792_I58_n1 I1_p4_25 I1_I792_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I58_MN3 (VSS XI1_I792_I58_Bn XI1_I792_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I58_MN0 (XI1_I792_I58_An I1_p4_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I57_MN1 (XI1_I792_I57_Bn I1_b5_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I57_MN5 (XI1_I792_I57_n2 I1_b5_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I57_MN4 (I1_I792_pn25 XI1_I792_I57_An XI1_I792_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I57_MN2 (XI1_I792_I57_n1 I1_p4_24 I1_I792_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I57_MN3 (VSS XI1_I792_I57_Bn XI1_I792_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I57_MN0 (XI1_I792_I57_An I1_p4_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I59_MN1 (XI1_I792_I59_Bn I1_b5_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I59_MN5 (XI1_I792_I59_n2 I1_b5_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I59_MN4 (I1_I792_pn27 XI1_I792_I59_An XI1_I792_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I59_MN2 (XI1_I792_I59_n1 I1_p4_26 I1_I792_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I59_MN3 (VSS XI1_I792_I59_Bn XI1_I792_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I59_MN0 (XI1_I792_I59_An I1_p4_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I231_MN1 (XI1_I746_I231_Bn I1_I746_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I231_MN5 (XI1_I746_I231_n2 I1_I746_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I231_MN4 (I1_p4_28 XI1_I746_I231_An XI1_I746_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I231_MN2 (XI1_I746_I231_n1 I1_I746_pn28 I1_p4_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I231_MN3 (VSS XI1_I746_I231_Bn XI1_I746_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I231_MN0 (XI1_I746_I231_An I1_I746_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I60_MN1 (XI1_I1344_I60_Bn I1_b17_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I60_MN5 (XI1_I1344_I60_n2 I1_b17_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I60_MN4 (I1_I1344_pn28 XI1_I1344_I60_An XI1_I1344_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I60_MN2 (XI1_I1344_I60_n1 I1_p16_27 I1_I1344_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I60_MN3 (VSS XI1_I1344_I60_Bn XI1_I1344_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I60_MN0 (XI1_I1344_I60_An I1_p16_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I231_MN1 (XI1_I1344_I231_Bn I1_I1344_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I231_MN5 (XI1_I1344_I231_n2 I1_I1344_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I231_MN4 (I1_p17_28 XI1_I1344_I231_An XI1_I1344_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I231_MN2 (XI1_I1344_I231_n1 I1_I1344_pn28 I1_p17_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I231_MN3 (VSS XI1_I1344_I231_Bn XI1_I1344_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I231_MN0 (XI1_I1344_I231_An I1_I1344_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I233_MN1 (XI1_I1344_I233_Bn I1_I1344_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I233_MN5 (XI1_I1344_I233_n2 I1_I1344_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I233_MN4 (I1_p17_30 XI1_I1344_I233_An XI1_I1344_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I233_MN2 (XI1_I1344_I233_n1 I1_I1344_pn30 I1_p17_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I233_MN3 (VSS XI1_I1344_I233_Bn XI1_I1344_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I233_MN0 (XI1_I1344_I233_An I1_I1344_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I227_MN1 (XI1_I1344_I227_Bn I1_I1344_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I227_MN5 (XI1_I1344_I227_n2 I1_I1344_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I227_MN4 (I1_p17_24 XI1_I1344_I227_An XI1_I1344_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I227_MN2 (XI1_I1344_I227_n1 I1_I1344_pn24 I1_p17_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I227_MN3 (VSS XI1_I1344_I227_Bn XI1_I1344_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I227_MN0 (XI1_I1344_I227_An I1_I1344_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I229_MN1 (XI1_I1298_I229_Bn I1_I1298_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I229_MN5 (XI1_I1298_I229_n2 I1_I1298_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I229_MN4 (I1_p16_26 XI1_I1298_I229_An XI1_I1298_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I229_MN2 (XI1_I1298_I229_n1 I1_I1298_pn26 I1_p16_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I229_MN3 (VSS XI1_I1298_I229_Bn XI1_I1298_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I229_MN0 (XI1_I1298_I229_An I1_I1298_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I57_MN1 (XI1_I1298_I57_Bn I1_b16_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I57_MN5 (XI1_I1298_I57_n2 I1_b16_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I57_MN4 (I1_I1298_pn25 XI1_I1298_I57_An XI1_I1298_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I57_MN2 (XI1_I1298_I57_n1 I1_p15_24 I1_I1298_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I57_MN3 (VSS XI1_I1298_I57_Bn XI1_I1298_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I57_MN0 (XI1_I1298_I57_An I1_p15_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I58_MN1 (XI1_I1298_I58_Bn I1_b16_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I58_MN5 (XI1_I1298_I58_n2 I1_b16_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I58_MN4 (I1_I1298_pn26 XI1_I1298_I58_An XI1_I1298_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I58_MN2 (XI1_I1298_I58_n1 I1_p15_25 I1_I1298_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I58_MN3 (VSS XI1_I1298_I58_Bn XI1_I1298_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I58_MN0 (XI1_I1298_I58_An I1_p15_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I56_MN1 (XI1_I1298_I56_Bn I1_b16_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I56_MN5 (XI1_I1298_I56_n2 I1_b16_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I56_MN4 (I1_I1298_pn24 XI1_I1298_I56_An XI1_I1298_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I56_MN2 (XI1_I1298_I56_n1 I1_p15_23 I1_I1298_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I56_MN3 (VSS XI1_I1298_I56_Bn XI1_I1298_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I56_MN0 (XI1_I1298_I56_An I1_p15_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I228_MN1 (XI1_I1252_I228_Bn I1_I1252_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I228_MN5 (XI1_I1252_I228_n2 I1_I1252_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I228_MN4 (I1_p15_25 XI1_I1252_I228_An XI1_I1252_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I228_MN2 (XI1_I1252_I228_n1 I1_I1252_pn25 I1_p15_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I228_MN3 (VSS XI1_I1252_I228_Bn XI1_I1252_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I228_MN0 (XI1_I1252_I228_An I1_I1252_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I227_MN1 (XI1_I1252_I227_Bn I1_I1252_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I227_MN5 (XI1_I1252_I227_n2 I1_I1252_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I227_MN4 (I1_p15_24 XI1_I1252_I227_An XI1_I1252_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I227_MN2 (XI1_I1252_I227_n1 I1_I1252_pn24 I1_p15_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I227_MN3 (VSS XI1_I1252_I227_Bn XI1_I1252_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I227_MN0 (XI1_I1252_I227_An I1_I1252_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I56_MN1 (XI1_I1252_I56_Bn I1_b15_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I56_MN5 (XI1_I1252_I56_n2 I1_b15_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I56_MN4 (I1_I1252_pn24 XI1_I1252_I56_An XI1_I1252_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I56_MN2 (XI1_I1252_I56_n1 I1_p14_23 I1_I1252_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I56_MN3 (VSS XI1_I1252_I56_Bn XI1_I1252_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I56_MN0 (XI1_I1252_I56_An I1_p14_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I58_MN1 (XI1_I1252_I58_Bn I1_b15_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I58_MN5 (XI1_I1252_I58_n2 I1_b15_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I58_MN4 (I1_I1252_pn26 XI1_I1252_I58_An XI1_I1252_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I58_MN2 (XI1_I1252_I58_n1 I1_p14_25 I1_I1252_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I58_MN3 (VSS XI1_I1252_I58_Bn XI1_I1252_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I58_MN0 (XI1_I1252_I58_An I1_p14_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I57_MN1 (XI1_I1252_I57_Bn I1_b15_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I57_MN5 (XI1_I1252_I57_n2 I1_b15_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I57_MN4 (I1_I1252_pn25 XI1_I1252_I57_An XI1_I1252_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I57_MN2 (XI1_I1252_I57_n1 I1_p14_24 I1_I1252_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I57_MN3 (VSS XI1_I1252_I57_Bn XI1_I1252_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I57_MN0 (XI1_I1252_I57_An I1_p14_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I227_MN1 (XI1_I1206_I227_Bn I1_I1206_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I227_MN5 (XI1_I1206_I227_n2 I1_I1206_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I227_MN4 (I1_p14_24 XI1_I1206_I227_An XI1_I1206_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I227_MN2 (XI1_I1206_I227_n1 I1_I1206_pn24 I1_p14_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I227_MN3 (VSS XI1_I1206_I227_Bn XI1_I1206_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I227_MN0 (XI1_I1206_I227_An I1_I1206_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I58_MN1 (XI1_I1206_I58_Bn I1_b14_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I58_MN5 (XI1_I1206_I58_n2 I1_b14_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I58_MN4 (I1_I1206_pn26 XI1_I1206_I58_An XI1_I1206_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I58_MN2 (XI1_I1206_I58_n1 I1_p13_25 I1_I1206_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I58_MN3 (VSS XI1_I1206_I58_Bn XI1_I1206_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I58_MN0 (XI1_I1206_I58_An I1_p13_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I228_MN1 (XI1_I1206_I228_Bn I1_I1206_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I228_MN5 (XI1_I1206_I228_n2 I1_I1206_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I228_MN4 (I1_p14_25 XI1_I1206_I228_An XI1_I1206_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I228_MN2 (XI1_I1206_I228_n1 I1_I1206_pn25 I1_p14_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I228_MN3 (VSS XI1_I1206_I228_Bn XI1_I1206_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I228_MN0 (XI1_I1206_I228_An I1_I1206_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I60_MN1 (XI1_I838_I60_Bn I1_b6_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I60_MN5 (XI1_I838_I60_n2 I1_b6_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I60_MN4 (I1_I838_pn28 XI1_I838_I60_An XI1_I838_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I60_MN2 (XI1_I838_I60_n1 I1_p5_27 I1_I838_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I60_MN3 (VSS XI1_I838_I60_Bn XI1_I838_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I60_MN0 (XI1_I838_I60_An I1_p5_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I233_MN1 (XI1_I838_I233_Bn I1_I838_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I233_MN5 (XI1_I838_I233_n2 I1_I838_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I233_MN4 (I1_p6_30 XI1_I838_I233_An XI1_I838_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I233_MN2 (XI1_I838_I233_n1 I1_I838_pn30 I1_p6_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I233_MN3 (VSS XI1_I838_I233_Bn XI1_I838_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I233_MN0 (XI1_I838_I233_An I1_I838_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I56_MN1 (XI1_I838_I56_Bn I1_b6_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I56_MN5 (XI1_I838_I56_n2 I1_b6_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I56_MN4 (I1_I838_pn24 XI1_I838_I56_An XI1_I838_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I56_MN2 (XI1_I838_I56_n1 I1_p5_23 I1_I838_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I56_MN3 (VSS XI1_I838_I56_Bn XI1_I838_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I56_MN0 (XI1_I838_I56_An I1_p5_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I55_MN1 (XI1_I838_I55_Bn I1_b6_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I55_MN5 (XI1_I838_I55_n2 I1_b6_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I55_MN4 (I1_I838_pn23 XI1_I838_I55_An XI1_I838_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I55_MN2 (XI1_I838_I55_n1 I1_p5_22 I1_I838_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I55_MN3 (VSS XI1_I838_I55_Bn XI1_I838_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I55_MN0 (XI1_I838_I55_An I1_p5_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I53_MN1 (XI1_I838_I53_Bn I1_b6_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I53_MN5 (XI1_I838_I53_n2 I1_b6_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I53_MN4 (I1_I838_pn21 XI1_I838_I53_An XI1_I838_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I53_MN2 (XI1_I838_I53_n1 I1_p5_20 I1_I838_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I53_MN3 (VSS XI1_I838_I53_Bn XI1_I838_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I53_MN0 (XI1_I838_I53_An I1_p5_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I223_MN1 (XI1_I838_I223_Bn I1_I838_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I223_MN5 (XI1_I838_I223_n2 I1_I838_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I223_MN4 (I1_p6_20 XI1_I838_I223_An XI1_I838_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I223_MN2 (XI1_I838_I223_n1 I1_I838_pn20 I1_p6_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I223_MN3 (VSS XI1_I838_I223_Bn XI1_I838_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I223_MN0 (XI1_I838_I223_An I1_I838_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I221_MN1 (XI1_I838_I221_Bn I1_I838_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I221_MN5 (XI1_I838_I221_n2 I1_I838_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I221_MN4 (I1_p6_18 XI1_I838_I221_An XI1_I838_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I221_MN2 (XI1_I838_I221_n1 I1_I838_pn18 I1_p6_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I221_MN3 (VSS XI1_I838_I221_Bn XI1_I838_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I221_MN0 (XI1_I838_I221_An I1_I838_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I223_MN1 (XI1_I792_I223_Bn I1_I792_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I223_MN5 (XI1_I792_I223_n2 I1_I792_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I223_MN4 (I1_p5_20 XI1_I792_I223_An XI1_I792_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I223_MN2 (XI1_I792_I223_n1 I1_I792_pn20 I1_p5_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I223_MN3 (VSS XI1_I792_I223_Bn XI1_I792_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I223_MN0 (XI1_I792_I223_An I1_I792_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I228_MN1 (XI1_I792_I228_Bn I1_I792_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I228_MN5 (XI1_I792_I228_n2 I1_I792_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I228_MN4 (I1_p5_25 XI1_I792_I228_An XI1_I792_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I228_MN2 (XI1_I792_I228_n1 I1_I792_pn25 I1_p5_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I228_MN3 (VSS XI1_I792_I228_Bn XI1_I792_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I228_MN0 (XI1_I792_I228_An I1_I792_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I226_MN1 (XI1_I792_I226_Bn I1_I792_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I226_MN5 (XI1_I792_I226_n2 I1_I792_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I226_MN4 (I1_p5_23 XI1_I792_I226_An XI1_I792_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I226_MN2 (XI1_I792_I226_n1 I1_I792_pn23 I1_p5_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I226_MN3 (VSS XI1_I792_I226_Bn XI1_I792_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I226_MN0 (XI1_I792_I226_An I1_I792_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I55_MN1 (XI1_I792_I55_Bn I1_b5_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I55_MN5 (XI1_I792_I55_n2 I1_b5_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I55_MN4 (I1_I792_pn23 XI1_I792_I55_An XI1_I792_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I55_MN2 (XI1_I792_I55_n1 I1_p4_22 I1_I792_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I55_MN3 (VSS XI1_I792_I55_Bn XI1_I792_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I55_MN0 (XI1_I792_I55_An I1_p4_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I56_MN1 (XI1_I792_I56_Bn I1_b5_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I56_MN5 (XI1_I792_I56_n2 I1_b5_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I56_MN4 (I1_I792_pn24 XI1_I792_I56_An XI1_I792_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I56_MN2 (XI1_I792_I56_n1 I1_p4_23 I1_I792_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I56_MN3 (VSS XI1_I792_I56_Bn XI1_I792_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I56_MN0 (XI1_I792_I56_An I1_p4_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I226_MN1 (XI1_I746_I226_Bn I1_I746_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I226_MN5 (XI1_I746_I226_n2 I1_I746_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I226_MN4 (I1_p4_23 XI1_I746_I226_An XI1_I746_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I226_MN2 (XI1_I746_I226_n1 I1_I746_pn23 I1_p4_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I226_MN3 (VSS XI1_I746_I226_Bn XI1_I746_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I226_MN0 (XI1_I746_I226_An I1_I746_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I230_MN1 (XI1_I746_I230_Bn I1_I746_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I230_MN5 (XI1_I746_I230_n2 I1_I746_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I230_MN4 (I1_p4_27 XI1_I746_I230_An XI1_I746_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I230_MN2 (XI1_I746_I230_n1 I1_I746_pn27 I1_p4_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I230_MN3 (VSS XI1_I746_I230_Bn XI1_I746_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I230_MN0 (XI1_I746_I230_An I1_I746_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I229_MN1 (XI1_I746_I229_Bn I1_I746_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I229_MN5 (XI1_I746_I229_n2 I1_I746_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I229_MN4 (I1_p4_26 XI1_I746_I229_An XI1_I746_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I229_MN2 (XI1_I746_I229_n1 I1_I746_pn26 I1_p4_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I229_MN3 (VSS XI1_I746_I229_Bn XI1_I746_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I229_MN0 (XI1_I746_I229_An I1_I746_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I234_MN1 (XI1_I746_I234_Bn I1_c4_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I234_MN5 (XI1_I746_I234_n2 I1_c4_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I234_MN4 (I1_p4_31 XI1_I746_I234_An XI1_I746_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I234_MN2 (XI1_I746_I234_n1 I1_I746_pn31 I1_p4_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I234_MN3 (VSS XI1_I746_I234_Bn XI1_I746_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I234_MN0 (XI1_I746_I234_An I1_I746_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I233_MN1 (XI1_I746_I233_Bn I1_I746_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I233_MN5 (XI1_I746_I233_n2 I1_I746_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I233_MN4 (I1_p4_30 XI1_I746_I233_An XI1_I746_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I233_MN2 (XI1_I746_I233_n1 I1_I746_pn30 I1_p4_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I233_MN3 (VSS XI1_I746_I233_Bn XI1_I746_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I233_MN0 (XI1_I746_I233_An I1_I746_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I58_MN1 (XI1_I746_I58_Bn I1_b4_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I58_MN5 (XI1_I746_I58_n2 I1_b4_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I58_MN4 (I1_I746_pn26 XI1_I746_I58_An XI1_I746_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I58_MN2 (XI1_I746_I58_n1 I1_p3_25 I1_I746_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I58_MN3 (VSS XI1_I746_I58_Bn XI1_I746_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I58_MN0 (XI1_I746_I58_An I1_p3_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I59_MN1 (XI1_I746_I59_Bn I1_b4_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I59_MN5 (XI1_I746_I59_n2 I1_b4_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I59_MN4 (I1_I746_pn27 XI1_I746_I59_An XI1_I746_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I59_MN2 (XI1_I746_I59_n1 I1_p3_26 I1_I746_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I59_MN3 (VSS XI1_I746_I59_Bn XI1_I746_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I59_MN0 (XI1_I746_I59_An I1_p3_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I59_MN1 (XI1_I1344_I59_Bn I1_b17_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I59_MN5 (XI1_I1344_I59_n2 I1_b17_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I59_MN4 (I1_I1344_pn27 XI1_I1344_I59_An XI1_I1344_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I59_MN2 (XI1_I1344_I59_n1 I1_p16_26 I1_I1344_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I59_MN3 (VSS XI1_I1344_I59_Bn XI1_I1344_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I59_MN0 (XI1_I1344_I59_An I1_p16_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I223_MN1 (XI1_I1344_I223_Bn I1_I1344_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I223_MN5 (XI1_I1344_I223_n2 I1_I1344_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I223_MN4 (I1_p17_20 XI1_I1344_I223_An XI1_I1344_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I223_MN2 (XI1_I1344_I223_n1 I1_I1344_pn20 I1_p17_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I223_MN3 (VSS XI1_I1344_I223_Bn XI1_I1344_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I223_MN0 (XI1_I1344_I223_An I1_I1344_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I227_MN1 (XI1_I1298_I227_Bn I1_I1298_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I227_MN5 (XI1_I1298_I227_n2 I1_I1298_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I227_MN4 (I1_p16_24 XI1_I1298_I227_An XI1_I1298_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I227_MN2 (XI1_I1298_I227_n1 I1_I1298_pn24 I1_p16_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I227_MN3 (VSS XI1_I1298_I227_Bn XI1_I1298_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I227_MN0 (XI1_I1298_I227_An I1_I1298_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I226_MN1 (XI1_I1298_I226_Bn I1_I1298_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I226_MN5 (XI1_I1298_I226_n2 I1_I1298_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I226_MN4 (I1_p16_23 XI1_I1298_I226_An XI1_I1298_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I226_MN2 (XI1_I1298_I226_n1 I1_I1298_pn23 I1_p16_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I226_MN3 (VSS XI1_I1298_I226_Bn XI1_I1298_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I226_MN0 (XI1_I1298_I226_An I1_I1298_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I228_MN1 (XI1_I1298_I228_Bn I1_I1298_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I228_MN5 (XI1_I1298_I228_n2 I1_I1298_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I228_MN4 (I1_p16_25 XI1_I1298_I228_An XI1_I1298_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I228_MN2 (XI1_I1298_I228_n1 I1_I1298_pn25 I1_p16_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I228_MN3 (VSS XI1_I1298_I228_Bn XI1_I1298_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I228_MN0 (XI1_I1298_I228_An I1_I1298_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I54_MN1 (XI1_I1298_I54_Bn I1_b16_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I54_MN5 (XI1_I1298_I54_n2 I1_b16_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I54_MN4 (I1_I1298_pn22 XI1_I1298_I54_An XI1_I1298_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I54_MN2 (XI1_I1298_I54_n1 I1_p15_21 I1_I1298_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I54_MN3 (VSS XI1_I1298_I54_Bn XI1_I1298_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I54_MN0 (XI1_I1298_I54_An I1_p15_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I55_MN1 (XI1_I1298_I55_Bn I1_b16_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I55_MN5 (XI1_I1298_I55_n2 I1_b16_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I55_MN4 (I1_I1298_pn23 XI1_I1298_I55_An XI1_I1298_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I55_MN2 (XI1_I1298_I55_n1 I1_p15_22 I1_I1298_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I55_MN3 (VSS XI1_I1298_I55_Bn XI1_I1298_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I55_MN0 (XI1_I1298_I55_An I1_p15_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I224_MN1 (XI1_I1252_I224_Bn I1_I1252_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I224_MN5 (XI1_I1252_I224_n2 I1_I1252_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I224_MN4 (I1_p15_21 XI1_I1252_I224_An XI1_I1252_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I224_MN2 (XI1_I1252_I224_n1 I1_I1252_pn21 I1_p15_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I224_MN3 (VSS XI1_I1252_I224_Bn XI1_I1252_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I224_MN0 (XI1_I1252_I224_An I1_I1252_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I226_MN1 (XI1_I1252_I226_Bn I1_I1252_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I226_MN5 (XI1_I1252_I226_n2 I1_I1252_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I226_MN4 (I1_p15_23 XI1_I1252_I226_An XI1_I1252_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I226_MN2 (XI1_I1252_I226_n1 I1_I1252_pn23 I1_p15_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I226_MN3 (VSS XI1_I1252_I226_Bn XI1_I1252_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I226_MN0 (XI1_I1252_I226_An I1_I1252_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I225_MN1 (XI1_I1252_I225_Bn I1_I1252_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I225_MN5 (XI1_I1252_I225_n2 I1_I1252_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I225_MN4 (I1_p15_22 XI1_I1252_I225_An XI1_I1252_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I225_MN2 (XI1_I1252_I225_n1 I1_I1252_pn22 I1_p15_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I225_MN3 (VSS XI1_I1252_I225_Bn XI1_I1252_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I225_MN0 (XI1_I1252_I225_An I1_I1252_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I55_MN1 (XI1_I1252_I55_Bn I1_b15_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I55_MN5 (XI1_I1252_I55_n2 I1_b15_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I55_MN4 (I1_I1252_pn23 XI1_I1252_I55_An XI1_I1252_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I55_MN2 (XI1_I1252_I55_n1 I1_p14_22 I1_I1252_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I55_MN3 (VSS XI1_I1252_I55_Bn XI1_I1252_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I55_MN0 (XI1_I1252_I55_An I1_p14_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I55_MN1 (XI1_I1206_I55_Bn I1_b14_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I55_MN5 (XI1_I1206_I55_n2 I1_b14_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I55_MN4 (I1_I1206_pn23 XI1_I1206_I55_An XI1_I1206_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I55_MN2 (XI1_I1206_I55_n1 I1_p13_22 I1_I1206_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I55_MN3 (VSS XI1_I1206_I55_Bn XI1_I1206_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I55_MN0 (XI1_I1206_I55_An I1_p13_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I226_MN1 (XI1_I1206_I226_Bn I1_I1206_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I226_MN5 (XI1_I1206_I226_n2 I1_I1206_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I226_MN4 (I1_p14_23 XI1_I1206_I226_An XI1_I1206_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I226_MN2 (XI1_I1206_I226_n1 I1_I1206_pn23 I1_p14_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I226_MN3 (VSS XI1_I1206_I226_Bn XI1_I1206_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I226_MN0 (XI1_I1206_I226_An I1_I1206_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I56_MN1 (XI1_I1206_I56_Bn I1_b14_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I56_MN5 (XI1_I1206_I56_n2 I1_b14_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I56_MN4 (I1_I1206_pn24 XI1_I1206_I56_An XI1_I1206_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I56_MN2 (XI1_I1206_I56_n1 I1_p13_23 I1_I1206_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I56_MN3 (VSS XI1_I1206_I56_Bn XI1_I1206_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I56_MN0 (XI1_I1206_I56_An I1_p13_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I225_MN1 (XI1_I1206_I225_Bn I1_I1206_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I225_MN5 (XI1_I1206_I225_n2 I1_I1206_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I225_MN4 (I1_p14_22 XI1_I1206_I225_An XI1_I1206_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I225_MN2 (XI1_I1206_I225_n1 I1_I1206_pn22 I1_p14_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I225_MN3 (VSS XI1_I1206_I225_Bn XI1_I1206_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I225_MN0 (XI1_I1206_I225_An I1_I1206_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I57_MN1 (XI1_I1206_I57_Bn I1_b14_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I57_MN5 (XI1_I1206_I57_n2 I1_b14_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I57_MN4 (I1_I1206_pn25 XI1_I1206_I57_An XI1_I1206_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I57_MN2 (XI1_I1206_I57_n1 I1_p13_24 I1_I1206_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I57_MN3 (VSS XI1_I1206_I57_Bn XI1_I1206_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I57_MN0 (XI1_I1206_I57_An I1_p13_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I231_MN1 (XI1_I838_I231_Bn I1_I838_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I231_MN5 (XI1_I838_I231_n2 I1_I838_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I231_MN4 (I1_p6_28 XI1_I838_I231_An XI1_I838_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I231_MN2 (XI1_I838_I231_n1 I1_I838_pn28 I1_p6_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I231_MN3 (VSS XI1_I838_I231_Bn XI1_I838_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I231_MN0 (XI1_I838_I231_An I1_I838_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I58_MN1 (XI1_I838_I58_Bn I1_b6_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I58_MN5 (XI1_I838_I58_n2 I1_b6_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I58_MN4 (I1_I838_pn26 XI1_I838_I58_An XI1_I838_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I58_MN2 (XI1_I838_I58_n1 I1_p5_25 I1_I838_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I58_MN3 (VSS XI1_I838_I58_Bn XI1_I838_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I58_MN0 (XI1_I838_I58_An I1_p5_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I54_MN1 (XI1_I838_I54_Bn I1_b6_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I54_MN5 (XI1_I838_I54_n2 I1_b6_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I54_MN4 (I1_I838_pn22 XI1_I838_I54_An XI1_I838_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I54_MN2 (XI1_I838_I54_n1 I1_p5_21 I1_I838_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I54_MN3 (VSS XI1_I838_I54_Bn XI1_I838_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I54_MN0 (XI1_I838_I54_An I1_p5_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I52_MN1 (XI1_I838_I52_Bn I1_b6_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I52_MN5 (XI1_I838_I52_n2 I1_b6_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I52_MN4 (I1_I838_pn20 XI1_I838_I52_An XI1_I838_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I52_MN2 (XI1_I838_I52_n1 I1_p5_19 I1_I838_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I52_MN3 (VSS XI1_I838_I52_Bn XI1_I838_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I52_MN0 (XI1_I838_I52_An I1_p5_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I50_MN1 (XI1_I838_I50_Bn I1_b6_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I50_MN5 (XI1_I838_I50_n2 I1_b6_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I50_MN4 (I1_I838_pn18 XI1_I838_I50_An XI1_I838_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I50_MN2 (XI1_I838_I50_n1 I1_p5_17 I1_I838_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I50_MN3 (VSS XI1_I838_I50_Bn XI1_I838_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I50_MN0 (XI1_I838_I50_An I1_p5_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I48_MN1 (XI1_I838_I48_Bn I1_b6_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I48_MN5 (XI1_I838_I48_n2 I1_b6_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I48_MN4 (I1_I838_pn16 XI1_I838_I48_An XI1_I838_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I48_MN2 (XI1_I838_I48_n1 I1_p5_15 I1_I838_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I48_MN3 (VSS XI1_I838_I48_Bn XI1_I838_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I48_MN0 (XI1_I838_I48_An I1_p5_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I49_MN1 (XI1_I838_I49_Bn I1_b6_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I49_MN5 (XI1_I838_I49_n2 I1_b6_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I49_MN4 (I1_I838_pn17 XI1_I838_I49_An XI1_I838_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I49_MN2 (XI1_I838_I49_n1 I1_p5_16 I1_I838_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I49_MN3 (VSS XI1_I838_I49_Bn XI1_I838_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I49_MN0 (XI1_I838_I49_An I1_p5_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I47_MN1 (XI1_I838_I47_Bn I1_b6_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I47_MN5 (XI1_I838_I47_n2 I1_b6_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I47_MN4 (I1_I838_pn15 XI1_I838_I47_An XI1_I838_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I47_MN2 (XI1_I838_I47_n1 I1_p5_14 I1_I838_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I47_MN3 (VSS XI1_I838_I47_Bn XI1_I838_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I47_MN0 (XI1_I838_I47_An I1_p5_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I45_MN1 (XI1_I838_I45_Bn I1_b6_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I45_MN5 (XI1_I838_I45_n2 I1_b6_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I45_MN4 (I1_I838_pn13 XI1_I838_I45_An XI1_I838_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I45_MN2 (XI1_I838_I45_n1 I1_p5_12 I1_I838_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I45_MN3 (VSS XI1_I838_I45_Bn XI1_I838_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I45_MN0 (XI1_I838_I45_An I1_p5_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I43_MN1 (XI1_I838_I43_Bn I1_b6_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I43_MN5 (XI1_I838_I43_n2 I1_b6_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I43_MN4 (I1_I838_pn11 XI1_I838_I43_An XI1_I838_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I43_MN2 (XI1_I838_I43_n1 I1_p5_10 I1_I838_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I43_MN3 (VSS XI1_I838_I43_Bn XI1_I838_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I43_MN0 (XI1_I838_I43_An I1_p5_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I222_MN1 (XI1_I792_I222_Bn I1_I792_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I222_MN5 (XI1_I792_I222_n2 I1_I792_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I222_MN4 (I1_p5_19 XI1_I792_I222_An XI1_I792_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I222_MN2 (XI1_I792_I222_n1 I1_I792_pn19 I1_p5_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I222_MN3 (VSS XI1_I792_I222_Bn XI1_I792_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I222_MN0 (XI1_I792_I222_An I1_I792_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I224_MN1 (XI1_I792_I224_Bn I1_I792_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I224_MN5 (XI1_I792_I224_n2 I1_I792_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I224_MN4 (I1_p5_21 XI1_I792_I224_An XI1_I792_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I224_MN2 (XI1_I792_I224_n1 I1_I792_pn21 I1_p5_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I224_MN3 (VSS XI1_I792_I224_Bn XI1_I792_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I224_MN0 (XI1_I792_I224_An I1_I792_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I52_MN1 (XI1_I792_I52_Bn I1_b5_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I52_MN5 (XI1_I792_I52_n2 I1_b5_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I52_MN4 (I1_I792_pn20 XI1_I792_I52_An XI1_I792_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I52_MN2 (XI1_I792_I52_n1 I1_p4_19 I1_I792_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I52_MN3 (VSS XI1_I792_I52_Bn XI1_I792_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I52_MN0 (XI1_I792_I52_An I1_p4_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I53_MN1 (XI1_I792_I53_Bn I1_b5_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I53_MN5 (XI1_I792_I53_n2 I1_b5_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I53_MN4 (I1_I792_pn21 XI1_I792_I53_An XI1_I792_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I53_MN2 (XI1_I792_I53_n1 I1_p4_20 I1_I792_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I53_MN3 (VSS XI1_I792_I53_Bn XI1_I792_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I53_MN0 (XI1_I792_I53_An I1_p4_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I54_MN1 (XI1_I792_I54_Bn I1_b5_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I54_MN5 (XI1_I792_I54_n2 I1_b5_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I54_MN4 (I1_I792_pn22 XI1_I792_I54_An XI1_I792_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I54_MN2 (XI1_I792_I54_n1 I1_p4_21 I1_I792_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I54_MN3 (VSS XI1_I792_I54_Bn XI1_I792_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I54_MN0 (XI1_I792_I54_An I1_p4_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I228_MN1 (XI1_I746_I228_Bn I1_I746_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I228_MN5 (XI1_I746_I228_n2 I1_I746_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I228_MN4 (I1_p4_25 XI1_I746_I228_An XI1_I746_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I228_MN2 (XI1_I746_I228_n1 I1_I746_pn25 I1_p4_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I228_MN3 (VSS XI1_I746_I228_Bn XI1_I746_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I228_MN0 (XI1_I746_I228_An I1_I746_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I232_MN1 (XI1_I746_I232_Bn I1_I746_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I232_MN5 (XI1_I746_I232_n2 I1_I746_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I232_MN4 (I1_p4_29 XI1_I746_I232_An XI1_I746_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I232_MN2 (XI1_I746_I232_n1 I1_I746_pn29 I1_p4_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I232_MN3 (VSS XI1_I746_I232_Bn XI1_I746_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I232_MN0 (XI1_I746_I232_An I1_I746_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I60_MN1 (XI1_I746_I60_Bn I1_b4_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I60_MN5 (XI1_I746_I60_n2 I1_b4_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I60_MN4 (I1_I746_pn28 XI1_I746_I60_An XI1_I746_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I60_MN2 (XI1_I746_I60_n1 I1_p3_27 I1_I746_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I60_MN3 (VSS XI1_I746_I60_Bn XI1_I746_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I60_MN0 (XI1_I746_I60_An I1_p3_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I58_MN1 (XI1_I1344_I58_Bn I1_b17_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I58_MN5 (XI1_I1344_I58_n2 I1_b17_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I58_MN4 (I1_I1344_pn26 XI1_I1344_I58_An XI1_I1344_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I58_MN2 (XI1_I1344_I58_n1 I1_p16_25 I1_I1344_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I58_MN3 (VSS XI1_I1344_I58_Bn XI1_I1344_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I58_MN0 (XI1_I1344_I58_An I1_p16_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I57_MN1 (XI1_I1344_I57_Bn I1_b17_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I57_MN5 (XI1_I1344_I57_n2 I1_b17_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I57_MN4 (I1_I1344_pn25 XI1_I1344_I57_An XI1_I1344_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I57_MN2 (XI1_I1344_I57_n1 I1_p16_24 I1_I1344_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I57_MN3 (VSS XI1_I1344_I57_Bn XI1_I1344_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I57_MN0 (XI1_I1344_I57_An I1_p16_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I56_MN1 (XI1_I1344_I56_Bn I1_b17_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I56_MN5 (XI1_I1344_I56_n2 I1_b17_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I56_MN4 (I1_I1344_pn24 XI1_I1344_I56_An XI1_I1344_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I56_MN2 (XI1_I1344_I56_n1 I1_p16_23 I1_I1344_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I56_MN3 (VSS XI1_I1344_I56_Bn XI1_I1344_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I56_MN0 (XI1_I1344_I56_An I1_p16_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I225_MN1 (XI1_I1344_I225_Bn I1_I1344_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I225_MN5 (XI1_I1344_I225_n2 I1_I1344_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I225_MN4 (I1_p17_22 XI1_I1344_I225_An XI1_I1344_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I225_MN2 (XI1_I1344_I225_n1 I1_I1344_pn22 I1_p17_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I225_MN3 (VSS XI1_I1344_I225_Bn XI1_I1344_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I225_MN0 (XI1_I1344_I225_An I1_I1344_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I55_MN1 (XI1_I1344_I55_Bn I1_b17_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I55_MN5 (XI1_I1344_I55_n2 I1_b17_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I55_MN4 (I1_I1344_pn23 XI1_I1344_I55_An XI1_I1344_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I55_MN2 (XI1_I1344_I55_n1 I1_p16_22 I1_I1344_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I55_MN3 (VSS XI1_I1344_I55_Bn XI1_I1344_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I55_MN0 (XI1_I1344_I55_An I1_p16_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I225_MN1 (XI1_I1298_I225_Bn I1_I1298_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I225_MN5 (XI1_I1298_I225_n2 I1_I1298_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I225_MN4 (I1_p16_22 XI1_I1298_I225_An XI1_I1298_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I225_MN2 (XI1_I1298_I225_n1 I1_I1298_pn22 I1_p16_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I225_MN3 (VSS XI1_I1298_I225_Bn XI1_I1298_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I225_MN0 (XI1_I1298_I225_An I1_I1298_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I53_MN1 (XI1_I1298_I53_Bn I1_b16_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I53_MN5 (XI1_I1298_I53_n2 I1_b16_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I53_MN4 (I1_I1298_pn21 XI1_I1298_I53_An XI1_I1298_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I53_MN2 (XI1_I1298_I53_n1 I1_p15_20 I1_I1298_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I53_MN3 (VSS XI1_I1298_I53_Bn XI1_I1298_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I53_MN0 (XI1_I1298_I53_An I1_p15_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I223_MN1 (XI1_I1252_I223_Bn I1_I1252_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I223_MN5 (XI1_I1252_I223_n2 I1_I1252_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I223_MN4 (I1_p15_20 XI1_I1252_I223_An XI1_I1252_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I223_MN2 (XI1_I1252_I223_n1 I1_I1252_pn20 I1_p15_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I223_MN3 (VSS XI1_I1252_I223_Bn XI1_I1252_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I223_MN0 (XI1_I1252_I223_An I1_I1252_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I54_MN1 (XI1_I1252_I54_Bn I1_b15_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I54_MN5 (XI1_I1252_I54_n2 I1_b15_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I54_MN4 (I1_I1252_pn22 XI1_I1252_I54_An XI1_I1252_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I54_MN2 (XI1_I1252_I54_n1 I1_p14_21 I1_I1252_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I54_MN3 (VSS XI1_I1252_I54_Bn XI1_I1252_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I54_MN0 (XI1_I1252_I54_An I1_p14_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I53_MN1 (XI1_I1252_I53_Bn I1_b15_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I53_MN5 (XI1_I1252_I53_n2 I1_b15_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I53_MN4 (I1_I1252_pn21 XI1_I1252_I53_An XI1_I1252_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I53_MN2 (XI1_I1252_I53_n1 I1_p14_20 I1_I1252_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I53_MN3 (VSS XI1_I1252_I53_Bn XI1_I1252_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I53_MN0 (XI1_I1252_I53_An I1_p14_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I53_MN1 (XI1_I1206_I53_Bn I1_b14_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I53_MN5 (XI1_I1206_I53_n2 I1_b14_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I53_MN4 (I1_I1206_pn21 XI1_I1206_I53_An XI1_I1206_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I53_MN2 (XI1_I1206_I53_n1 I1_p13_20 I1_I1206_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I53_MN3 (VSS XI1_I1206_I53_Bn XI1_I1206_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I53_MN0 (XI1_I1206_I53_An I1_p13_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I224_MN1 (XI1_I1206_I224_Bn I1_I1206_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I224_MN5 (XI1_I1206_I224_n2 I1_I1206_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I224_MN4 (I1_p14_21 XI1_I1206_I224_An XI1_I1206_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I224_MN2 (XI1_I1206_I224_n1 I1_I1206_pn21 I1_p14_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I224_MN3 (VSS XI1_I1206_I224_Bn XI1_I1206_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I224_MN0 (XI1_I1206_I224_An I1_I1206_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I54_MN1 (XI1_I1206_I54_Bn I1_b14_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I54_MN5 (XI1_I1206_I54_n2 I1_b14_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I54_MN4 (I1_I1206_pn22 XI1_I1206_I54_An XI1_I1206_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I54_MN2 (XI1_I1206_I54_n1 I1_p13_21 I1_I1206_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I54_MN3 (VSS XI1_I1206_I54_Bn XI1_I1206_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I54_MN0 (XI1_I1206_I54_An I1_p13_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I223_MN1 (XI1_I1206_I223_Bn I1_I1206_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I223_MN5 (XI1_I1206_I223_n2 I1_I1206_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I223_MN4 (I1_p14_20 XI1_I1206_I223_An XI1_I1206_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I223_MN2 (XI1_I1206_I223_n1 I1_I1206_pn20 I1_p14_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I223_MN3 (VSS XI1_I1206_I223_Bn XI1_I1206_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I223_MN0 (XI1_I1206_I223_An I1_I1206_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I229_MN1 (XI1_I838_I229_Bn I1_I838_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I229_MN5 (XI1_I838_I229_n2 I1_I838_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I229_MN4 (I1_p6_26 XI1_I838_I229_An XI1_I838_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I229_MN2 (XI1_I838_I229_n1 I1_I838_pn26 I1_p6_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I229_MN3 (VSS XI1_I838_I229_Bn XI1_I838_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I229_MN0 (XI1_I838_I229_An I1_I838_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I51_MN1 (XI1_I838_I51_Bn I1_b6_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I51_MN5 (XI1_I838_I51_n2 I1_b6_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I51_MN4 (I1_I838_pn19 XI1_I838_I51_An XI1_I838_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I51_MN2 (XI1_I838_I51_n1 I1_p5_18 I1_I838_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I51_MN3 (VSS XI1_I838_I51_Bn XI1_I838_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I51_MN0 (XI1_I838_I51_An I1_p5_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I46_MN1 (XI1_I838_I46_Bn I1_b6_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I46_MN5 (XI1_I838_I46_n2 I1_b6_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I46_MN4 (I1_I838_pn14 XI1_I838_I46_An XI1_I838_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I46_MN2 (XI1_I838_I46_n1 I1_p5_13 I1_I838_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I46_MN3 (VSS XI1_I838_I46_Bn XI1_I838_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I46_MN0 (XI1_I838_I46_An I1_p5_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I44_MN1 (XI1_I838_I44_Bn I1_b6_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I44_MN5 (XI1_I838_I44_n2 I1_b6_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I44_MN4 (I1_I838_pn12 XI1_I838_I44_An XI1_I838_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I44_MN2 (XI1_I838_I44_n1 I1_p5_11 I1_I838_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I44_MN3 (VSS XI1_I838_I44_Bn XI1_I838_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I44_MN0 (XI1_I838_I44_An I1_p5_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I211_MN1 (XI1_I838_I211_Bn I1_I838_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I211_MN5 (XI1_I838_I211_n2 I1_I838_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I211_MN4 (I1_p6_8 XI1_I838_I211_An XI1_I838_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I211_MN2 (XI1_I838_I211_n1 I1_I838_pn8 I1_p6_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I211_MN3 (VSS XI1_I838_I211_Bn XI1_I838_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I211_MN0 (XI1_I838_I211_An I1_I838_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I221_MN1 (XI1_I792_I221_Bn I1_I792_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I221_MN5 (XI1_I792_I221_n2 I1_I792_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I221_MN4 (I1_p5_18 XI1_I792_I221_An XI1_I792_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I221_MN2 (XI1_I792_I221_n1 I1_I792_pn18 I1_p5_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I221_MN3 (VSS XI1_I792_I221_Bn XI1_I792_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I221_MN0 (XI1_I792_I221_An I1_I792_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I51_MN1 (XI1_I792_I51_Bn I1_b5_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I51_MN5 (XI1_I792_I51_n2 I1_b5_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I51_MN4 (I1_I792_pn19 XI1_I792_I51_An XI1_I792_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I51_MN2 (XI1_I792_I51_n1 I1_p4_18 I1_I792_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I51_MN3 (VSS XI1_I792_I51_Bn XI1_I792_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I51_MN0 (XI1_I792_I51_An I1_p4_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I222_MN1 (XI1_I746_I222_Bn I1_I746_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I222_MN5 (XI1_I746_I222_n2 I1_I746_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I222_MN4 (I1_p4_19 XI1_I746_I222_An XI1_I746_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I222_MN2 (XI1_I746_I222_n1 I1_I746_pn19 I1_p4_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I222_MN3 (VSS XI1_I746_I222_Bn XI1_I746_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I222_MN0 (XI1_I746_I222_An I1_I746_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I224_MN1 (XI1_I746_I224_Bn I1_I746_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I224_MN5 (XI1_I746_I224_n2 I1_I746_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I224_MN4 (I1_p4_21 XI1_I746_I224_An XI1_I746_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I224_MN2 (XI1_I746_I224_n1 I1_I746_pn21 I1_p4_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I224_MN3 (VSS XI1_I746_I224_Bn XI1_I746_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I224_MN0 (XI1_I746_I224_An I1_I746_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I227_MN1 (XI1_I746_I227_Bn I1_I746_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I227_MN5 (XI1_I746_I227_n2 I1_I746_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I227_MN4 (I1_p4_24 XI1_I746_I227_An XI1_I746_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I227_MN2 (XI1_I746_I227_n1 I1_I746_pn24 I1_p4_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I227_MN3 (VSS XI1_I746_I227_Bn XI1_I746_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I227_MN0 (XI1_I746_I227_An I1_I746_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I57_MN1 (XI1_I746_I57_Bn I1_b4_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I57_MN5 (XI1_I746_I57_n2 I1_b4_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I57_MN4 (I1_I746_pn25 XI1_I746_I57_An XI1_I746_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I57_MN2 (XI1_I746_I57_n1 I1_p3_24 I1_I746_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I57_MN3 (VSS XI1_I746_I57_Bn XI1_I746_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I57_MN0 (XI1_I746_I57_An I1_p3_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I61_MN1 (XI1_I746_I61_Bn I1_b4_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I61_MN5 (XI1_I746_I61_n2 I1_b4_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I61_MN4 (I1_I746_pn29 XI1_I746_I61_An XI1_I746_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I61_MN2 (XI1_I746_I61_n1 I1_p3_28 I1_I746_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I61_MN3 (VSS XI1_I746_I61_Bn XI1_I746_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I61_MN0 (XI1_I746_I61_An I1_p3_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I229_MN1 (XI1_I1344_I229_Bn I1_I1344_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I229_MN5 (XI1_I1344_I229_n2 I1_I1344_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I229_MN4 (I1_p17_26 XI1_I1344_I229_An XI1_I1344_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I229_MN2 (XI1_I1344_I229_n1 I1_I1344_pn26 I1_p17_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I229_MN3 (VSS XI1_I1344_I229_Bn XI1_I1344_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I229_MN0 (XI1_I1344_I229_An I1_I1344_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I54_MN1 (XI1_I1344_I54_Bn I1_b17_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I54_MN5 (XI1_I1344_I54_n2 I1_b17_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I54_MN4 (I1_I1344_pn22 XI1_I1344_I54_An XI1_I1344_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I54_MN2 (XI1_I1344_I54_n1 I1_p16_21 I1_I1344_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I54_MN3 (VSS XI1_I1344_I54_Bn XI1_I1344_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I54_MN0 (XI1_I1344_I54_An I1_p16_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I53_MN1 (XI1_I1344_I53_Bn I1_b17_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I53_MN5 (XI1_I1344_I53_n2 I1_b17_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I53_MN4 (I1_I1344_pn21 XI1_I1344_I53_An XI1_I1344_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I53_MN2 (XI1_I1344_I53_n1 I1_p16_20 I1_I1344_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I53_MN3 (VSS XI1_I1344_I53_Bn XI1_I1344_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I53_MN0 (XI1_I1344_I53_An I1_p16_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I49_MN1 (XI1_I1344_I49_Bn I1_b17_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I49_MN5 (XI1_I1344_I49_n2 I1_b17_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I49_MN4 (I1_I1344_pn17 XI1_I1344_I49_An XI1_I1344_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I49_MN2 (XI1_I1344_I49_n1 I1_p16_16 I1_I1344_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I49_MN3 (VSS XI1_I1344_I49_Bn XI1_I1344_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I49_MN0 (XI1_I1344_I49_An I1_p16_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I48_MN1 (XI1_I1344_I48_Bn I1_b17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I48_MN5 (XI1_I1344_I48_n2 I1_b17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I48_MN4 (I1_I1344_pn16 XI1_I1344_I48_An XI1_I1344_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I48_MN2 (XI1_I1344_I48_n1 I1_p16_15 I1_I1344_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I48_MN3 (VSS XI1_I1344_I48_Bn XI1_I1344_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I48_MN0 (XI1_I1344_I48_An I1_p16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I223_MN1 (XI1_I1298_I223_Bn I1_I1298_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I223_MN5 (XI1_I1298_I223_n2 I1_I1298_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I223_MN4 (I1_p16_20 XI1_I1298_I223_An XI1_I1298_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I223_MN2 (XI1_I1298_I223_n1 I1_I1298_pn20 I1_p16_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I223_MN3 (VSS XI1_I1298_I223_Bn XI1_I1298_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I223_MN0 (XI1_I1298_I223_An I1_I1298_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I224_MN1 (XI1_I1298_I224_Bn I1_I1298_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I224_MN5 (XI1_I1298_I224_n2 I1_I1298_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I224_MN4 (I1_p16_21 XI1_I1298_I224_An XI1_I1298_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I224_MN2 (XI1_I1298_I224_n1 I1_I1298_pn21 I1_p16_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I224_MN3 (VSS XI1_I1298_I224_Bn XI1_I1298_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I224_MN0 (XI1_I1298_I224_An I1_I1298_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I52_MN1 (XI1_I1298_I52_Bn I1_b16_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I52_MN5 (XI1_I1298_I52_n2 I1_b16_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I52_MN4 (I1_I1298_pn20 XI1_I1298_I52_An XI1_I1298_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I52_MN2 (XI1_I1298_I52_n1 I1_p15_19 I1_I1298_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I52_MN3 (VSS XI1_I1298_I52_Bn XI1_I1298_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I52_MN0 (XI1_I1298_I52_An I1_p15_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I51_MN1 (XI1_I1298_I51_Bn I1_b16_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I51_MN5 (XI1_I1298_I51_n2 I1_b16_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I51_MN4 (I1_I1298_pn19 XI1_I1298_I51_An XI1_I1298_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I51_MN2 (XI1_I1298_I51_n1 I1_p15_18 I1_I1298_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I51_MN3 (VSS XI1_I1298_I51_Bn XI1_I1298_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I51_MN0 (XI1_I1298_I51_An I1_p15_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I222_MN1 (XI1_I1252_I222_Bn I1_I1252_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I222_MN5 (XI1_I1252_I222_n2 I1_I1252_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I222_MN4 (I1_p15_19 XI1_I1252_I222_An XI1_I1252_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I222_MN2 (XI1_I1252_I222_n1 I1_I1252_pn19 I1_p15_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I222_MN3 (VSS XI1_I1252_I222_Bn XI1_I1252_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I222_MN0 (XI1_I1252_I222_An I1_I1252_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I52_MN1 (XI1_I1252_I52_Bn I1_b15_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I52_MN5 (XI1_I1252_I52_n2 I1_b15_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I52_MN4 (I1_I1252_pn20 XI1_I1252_I52_An XI1_I1252_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I52_MN2 (XI1_I1252_I52_n1 I1_p14_19 I1_I1252_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I52_MN3 (VSS XI1_I1252_I52_Bn XI1_I1252_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I52_MN0 (XI1_I1252_I52_An I1_p14_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I52_MN1 (XI1_I1206_I52_Bn I1_b14_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I52_MN5 (XI1_I1206_I52_n2 I1_b14_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I52_MN4 (I1_I1206_pn20 XI1_I1206_I52_An XI1_I1206_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I52_MN2 (XI1_I1206_I52_n1 I1_p13_19 I1_I1206_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I52_MN3 (VSS XI1_I1206_I52_Bn XI1_I1206_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I52_MN0 (XI1_I1206_I52_An I1_p13_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I232_MN1 (XI1_I838_I232_Bn I1_I838_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I232_MN5 (XI1_I838_I232_n2 I1_I838_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I232_MN4 (I1_p6_29 XI1_I838_I232_An XI1_I838_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I232_MN2 (XI1_I838_I232_n1 I1_I838_pn29 I1_p6_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I232_MN3 (VSS XI1_I838_I232_Bn XI1_I838_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I232_MN0 (XI1_I838_I232_An I1_I838_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I59_MN1 (XI1_I884_I59_Bn I1_b7_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I59_MN5 (XI1_I884_I59_n2 I1_b7_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I59_MN4 (I1_I884_pn27 XI1_I884_I59_An XI1_I884_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I59_MN2 (XI1_I884_I59_n1 I1_p6_26 I1_I884_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I59_MN3 (VSS XI1_I884_I59_Bn XI1_I884_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I59_MN0 (XI1_I884_I59_An I1_p6_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I230_MN1 (XI1_I838_I230_Bn I1_I838_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I230_MN5 (XI1_I838_I230_n2 I1_I838_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I230_MN4 (I1_p6_27 XI1_I838_I230_An XI1_I838_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I230_MN2 (XI1_I838_I230_n1 I1_I838_pn27 I1_p6_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I230_MN3 (VSS XI1_I838_I230_Bn XI1_I838_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I230_MN0 (XI1_I838_I230_An I1_I838_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I57_MN1 (XI1_I884_I57_Bn I1_b7_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I57_MN5 (XI1_I884_I57_n2 I1_b7_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I57_MN4 (I1_I884_pn25 XI1_I884_I57_An XI1_I884_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I57_MN2 (XI1_I884_I57_n1 I1_p6_24 I1_I884_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I57_MN3 (VSS XI1_I884_I57_Bn XI1_I884_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I57_MN0 (XI1_I884_I57_An I1_p6_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I234_MN1 (XI1_I838_I234_Bn I1_c6_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I234_MN5 (XI1_I838_I234_n2 I1_c6_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I234_MN4 (I1_p6_31 XI1_I838_I234_An XI1_I838_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I234_MN2 (XI1_I838_I234_n1 I1_I838_pn31 I1_p6_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I234_MN3 (VSS XI1_I838_I234_Bn XI1_I838_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I234_MN0 (XI1_I838_I234_An I1_I838_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I228_MN1 (XI1_I838_I228_Bn I1_I838_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I228_MN5 (XI1_I838_I228_n2 I1_I838_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I228_MN4 (I1_p6_25 XI1_I838_I228_An XI1_I838_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I228_MN2 (XI1_I838_I228_n1 I1_I838_pn25 I1_p6_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I228_MN3 (VSS XI1_I838_I228_Bn XI1_I838_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I228_MN0 (XI1_I838_I228_An I1_I838_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I226_MN1 (XI1_I838_I226_Bn I1_I838_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I226_MN5 (XI1_I838_I226_n2 I1_I838_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I226_MN4 (I1_p6_23 XI1_I838_I226_An XI1_I838_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I226_MN2 (XI1_I838_I226_n1 I1_I838_pn23 I1_p6_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I226_MN3 (VSS XI1_I838_I226_Bn XI1_I838_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I226_MN0 (XI1_I838_I226_An I1_I838_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I42_MN1 (XI1_I838_I42_Bn I1_b6_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I42_MN5 (XI1_I838_I42_n2 I1_b6_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I42_MN4 (I1_I838_pn10 XI1_I838_I42_An XI1_I838_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I42_MN2 (XI1_I838_I42_n1 I1_p5_9 I1_I838_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I42_MN3 (VSS XI1_I838_I42_Bn XI1_I838_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I42_MN0 (XI1_I838_I42_An I1_p5_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I41_MN1 (XI1_I838_I41_Bn I1_b6_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I41_MN5 (XI1_I838_I41_n2 I1_b6_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I41_MN4 (I1_I838_pn9 XI1_I838_I41_An XI1_I838_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I41_MN2 (XI1_I838_I41_n1 I1_p5_8 I1_I838_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I41_MN3 (VSS XI1_I838_I41_Bn XI1_I838_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I41_MN0 (XI1_I838_I41_An I1_p5_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I40_MN1 (XI1_I838_I40_Bn I1_b6_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I40_MN5 (XI1_I838_I40_n2 I1_b6_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I40_MN4 (I1_I838_pn8 XI1_I838_I40_An XI1_I838_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I40_MN2 (XI1_I838_I40_n1 I1_p5_7 I1_I838_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I40_MN3 (VSS XI1_I838_I40_Bn XI1_I838_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I40_MN0 (XI1_I838_I40_An I1_p5_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I211_MN1 (XI1_I792_I211_Bn I1_I792_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I211_MN5 (XI1_I792_I211_n2 I1_I792_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I211_MN4 (I1_p5_8 XI1_I792_I211_An XI1_I792_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I211_MN2 (XI1_I792_I211_n1 I1_I792_pn8 I1_p5_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I211_MN3 (VSS XI1_I792_I211_Bn XI1_I792_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I211_MN0 (XI1_I792_I211_An I1_I792_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I220_MN1 (XI1_I792_I220_Bn I1_I792_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I220_MN5 (XI1_I792_I220_n2 I1_I792_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I220_MN4 (I1_p5_17 XI1_I792_I220_An XI1_I792_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I220_MN2 (XI1_I792_I220_n1 I1_I792_pn17 I1_p5_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I220_MN3 (VSS XI1_I792_I220_Bn XI1_I792_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I220_MN0 (XI1_I792_I220_An I1_I792_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I47_MN1 (XI1_I792_I47_Bn I1_b5_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I47_MN5 (XI1_I792_I47_n2 I1_b5_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I47_MN4 (I1_I792_pn15 XI1_I792_I47_An XI1_I792_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I47_MN2 (XI1_I792_I47_n1 I1_p4_14 I1_I792_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I47_MN3 (VSS XI1_I792_I47_Bn XI1_I792_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I47_MN0 (XI1_I792_I47_An I1_p4_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I48_MN1 (XI1_I792_I48_Bn I1_b5_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I48_MN5 (XI1_I792_I48_n2 I1_b5_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I48_MN4 (I1_I792_pn16 XI1_I792_I48_An XI1_I792_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I48_MN2 (XI1_I792_I48_n1 I1_p4_15 I1_I792_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I48_MN3 (VSS XI1_I792_I48_Bn XI1_I792_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I48_MN0 (XI1_I792_I48_An I1_p4_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I49_MN1 (XI1_I792_I49_Bn I1_b5_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I49_MN5 (XI1_I792_I49_n2 I1_b5_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I49_MN4 (I1_I792_pn17 XI1_I792_I49_An XI1_I792_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I49_MN2 (XI1_I792_I49_n1 I1_p4_16 I1_I792_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I49_MN3 (VSS XI1_I792_I49_Bn XI1_I792_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I49_MN0 (XI1_I792_I49_An I1_p4_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I50_MN1 (XI1_I792_I50_Bn I1_b5_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I50_MN5 (XI1_I792_I50_n2 I1_b5_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I50_MN4 (I1_I792_pn18 XI1_I792_I50_An XI1_I792_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I50_MN2 (XI1_I792_I50_n1 I1_p4_17 I1_I792_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I50_MN3 (VSS XI1_I792_I50_Bn XI1_I792_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I50_MN0 (XI1_I792_I50_An I1_p4_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I234_MN1 (XI1_I1344_I234_Bn I1_c17_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I234_MN5 (XI1_I1344_I234_n2 I1_c17_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I234_MN4 (I1_p17_31 XI1_I1344_I234_An XI1_I1344_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I234_MN2 (XI1_I1344_I234_n1 I1_I1344_pn31 I1_p17_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I234_MN3 (VSS XI1_I1344_I234_Bn XI1_I1344_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I234_MN0 (XI1_I1344_I234_An I1_I1344_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I52_MN1 (XI1_I1344_I52_Bn I1_b17_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I52_MN5 (XI1_I1344_I52_n2 I1_b17_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I52_MN4 (I1_I1344_pn20 XI1_I1344_I52_An XI1_I1344_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I52_MN2 (XI1_I1344_I52_n1 I1_p16_19 I1_I1344_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I52_MN3 (VSS XI1_I1344_I52_Bn XI1_I1344_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I52_MN0 (XI1_I1344_I52_An I1_p16_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I50_MN1 (XI1_I1344_I50_Bn I1_b17_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I50_MN5 (XI1_I1344_I50_n2 I1_b17_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I50_MN4 (I1_I1344_pn18 XI1_I1344_I50_An XI1_I1344_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I50_MN2 (XI1_I1344_I50_n1 I1_p16_17 I1_I1344_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I50_MN3 (VSS XI1_I1344_I50_Bn XI1_I1344_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I50_MN0 (XI1_I1344_I50_An I1_p16_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I221_MN1 (XI1_I1344_I221_Bn I1_I1344_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I221_MN5 (XI1_I1344_I221_n2 I1_I1344_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I221_MN4 (I1_p17_18 XI1_I1344_I221_An XI1_I1344_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I221_MN2 (XI1_I1344_I221_n1 I1_I1344_pn18 I1_p17_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I221_MN3 (VSS XI1_I1344_I221_Bn XI1_I1344_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I221_MN0 (XI1_I1344_I221_An I1_I1344_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I47_MN1 (XI1_I1344_I47_Bn I1_b17_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I47_MN5 (XI1_I1344_I47_n2 I1_b17_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I47_MN4 (I1_I1344_pn15 XI1_I1344_I47_An XI1_I1344_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I47_MN2 (XI1_I1344_I47_n1 I1_p16_14 I1_I1344_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I47_MN3 (VSS XI1_I1344_I47_Bn XI1_I1344_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I47_MN0 (XI1_I1344_I47_An I1_p16_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I222_MN1 (XI1_I1298_I222_Bn I1_I1298_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I222_MN5 (XI1_I1298_I222_n2 I1_I1298_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I222_MN4 (I1_p16_19 XI1_I1298_I222_An XI1_I1298_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I222_MN2 (XI1_I1298_I222_n1 I1_I1298_pn19 I1_p16_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I222_MN3 (VSS XI1_I1298_I222_Bn XI1_I1298_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I222_MN0 (XI1_I1298_I222_An I1_I1298_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I220_MN1 (XI1_I1298_I220_Bn I1_I1298_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I220_MN5 (XI1_I1298_I220_n2 I1_I1298_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I220_MN4 (I1_p16_17 XI1_I1298_I220_An XI1_I1298_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I220_MN2 (XI1_I1298_I220_n1 I1_I1298_pn17 I1_p16_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I220_MN3 (VSS XI1_I1298_I220_Bn XI1_I1298_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I220_MN0 (XI1_I1298_I220_An I1_I1298_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I49_MN1 (XI1_I1298_I49_Bn I1_b16_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I49_MN5 (XI1_I1298_I49_n2 I1_b16_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I49_MN4 (I1_I1298_pn17 XI1_I1298_I49_An XI1_I1298_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I49_MN2 (XI1_I1298_I49_n1 I1_p15_16 I1_I1298_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I49_MN3 (VSS XI1_I1298_I49_Bn XI1_I1298_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I49_MN0 (XI1_I1298_I49_An I1_p15_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I48_MN1 (XI1_I1298_I48_Bn I1_b16_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I48_MN5 (XI1_I1298_I48_n2 I1_b16_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I48_MN4 (I1_I1298_pn16 XI1_I1298_I48_An XI1_I1298_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I48_MN2 (XI1_I1298_I48_n1 I1_p15_15 I1_I1298_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I48_MN3 (VSS XI1_I1298_I48_Bn XI1_I1298_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I48_MN0 (XI1_I1298_I48_An I1_p15_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I50_MN1 (XI1_I1298_I50_Bn I1_b16_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I50_MN5 (XI1_I1298_I50_n2 I1_b16_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I50_MN4 (I1_I1298_pn18 XI1_I1298_I50_An XI1_I1298_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I50_MN2 (XI1_I1298_I50_n1 I1_p15_17 I1_I1298_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I50_MN3 (VSS XI1_I1298_I50_Bn XI1_I1298_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I50_MN0 (XI1_I1298_I50_An I1_p15_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I220_MN1 (XI1_I1252_I220_Bn I1_I1252_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I220_MN5 (XI1_I1252_I220_n2 I1_I1252_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I220_MN4 (I1_p15_17 XI1_I1252_I220_An XI1_I1252_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I220_MN2 (XI1_I1252_I220_n1 I1_I1252_pn17 I1_p15_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I220_MN3 (VSS XI1_I1252_I220_Bn XI1_I1252_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I220_MN0 (XI1_I1252_I220_An I1_I1252_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I221_MN1 (XI1_I1252_I221_Bn I1_I1252_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I221_MN5 (XI1_I1252_I221_n2 I1_I1252_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I221_MN4 (I1_p15_18 XI1_I1252_I221_An XI1_I1252_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I221_MN2 (XI1_I1252_I221_n1 I1_I1252_pn18 I1_p15_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I221_MN3 (VSS XI1_I1252_I221_Bn XI1_I1252_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I221_MN0 (XI1_I1252_I221_An I1_I1252_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I51_MN1 (XI1_I1252_I51_Bn I1_b15_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I51_MN5 (XI1_I1252_I51_n2 I1_b15_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I51_MN4 (I1_I1252_pn19 XI1_I1252_I51_An XI1_I1252_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I51_MN2 (XI1_I1252_I51_n1 I1_p14_18 I1_I1252_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I51_MN3 (VSS XI1_I1252_I51_Bn XI1_I1252_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I51_MN0 (XI1_I1252_I51_An I1_p14_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I50_MN1 (XI1_I1252_I50_Bn I1_b15_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I50_MN5 (XI1_I1252_I50_n2 I1_b15_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I50_MN4 (I1_I1252_pn18 XI1_I1252_I50_An XI1_I1252_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I50_MN2 (XI1_I1252_I50_n1 I1_p14_17 I1_I1252_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I50_MN3 (VSS XI1_I1252_I50_Bn XI1_I1252_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I50_MN0 (XI1_I1252_I50_An I1_p14_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I50_MN1 (XI1_I1206_I50_Bn I1_b14_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I50_MN5 (XI1_I1206_I50_n2 I1_b14_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I50_MN4 (I1_I1206_pn18 XI1_I1206_I50_An XI1_I1206_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I50_MN2 (XI1_I1206_I50_n1 I1_p13_17 I1_I1206_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I50_MN3 (VSS XI1_I1206_I50_Bn XI1_I1206_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I50_MN0 (XI1_I1206_I50_An I1_p13_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I51_MN1 (XI1_I1206_I51_Bn I1_b14_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I51_MN5 (XI1_I1206_I51_n2 I1_b14_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I51_MN4 (I1_I1206_pn19 XI1_I1206_I51_An XI1_I1206_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I51_MN2 (XI1_I1206_I51_n1 I1_p13_18 I1_I1206_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I51_MN3 (VSS XI1_I1206_I51_Bn XI1_I1206_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I51_MN0 (XI1_I1206_I51_An I1_p13_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I222_MN1 (XI1_I1206_I222_Bn I1_I1206_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I222_MN5 (XI1_I1206_I222_n2 I1_I1206_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I222_MN4 (I1_p14_19 XI1_I1206_I222_An XI1_I1206_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I222_MN2 (XI1_I1206_I222_n1 I1_I1206_pn19 I1_p14_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I222_MN3 (VSS XI1_I1206_I222_Bn XI1_I1206_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I222_MN0 (XI1_I1206_I222_An I1_I1206_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I61_MN1 (XI1_I884_I61_Bn I1_b7_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I61_MN5 (XI1_I884_I61_n2 I1_b7_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I61_MN4 (I1_I884_pn29 XI1_I884_I61_An XI1_I884_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I61_MN2 (XI1_I884_I61_n1 I1_p6_28 I1_I884_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I61_MN3 (VSS XI1_I884_I61_Bn XI1_I884_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I61_MN0 (XI1_I884_I61_An I1_p6_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I55_MN1 (XI1_I884_I55_Bn I1_b7_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I55_MN5 (XI1_I884_I55_n2 I1_b7_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I55_MN4 (I1_I884_pn23 XI1_I884_I55_An XI1_I884_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I55_MN2 (XI1_I884_I55_n1 I1_p6_22 I1_I884_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I55_MN3 (VSS XI1_I884_I55_Bn XI1_I884_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I55_MN0 (XI1_I884_I55_An I1_p6_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I224_MN1 (XI1_I838_I224_Bn I1_I838_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I224_MN5 (XI1_I838_I224_n2 I1_I838_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I224_MN4 (I1_p6_21 XI1_I838_I224_An XI1_I838_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I224_MN2 (XI1_I838_I224_n1 I1_I838_pn21 I1_p6_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I224_MN3 (VSS XI1_I838_I224_Bn XI1_I838_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I224_MN0 (XI1_I838_I224_An I1_I838_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I222_MN1 (XI1_I838_I222_Bn I1_I838_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I222_MN5 (XI1_I838_I222_n2 I1_I838_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I222_MN4 (I1_p6_19 XI1_I838_I222_An XI1_I838_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I222_MN2 (XI1_I838_I222_n1 I1_I838_pn19 I1_p6_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I222_MN3 (VSS XI1_I838_I222_Bn XI1_I838_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I222_MN0 (XI1_I838_I222_An I1_I838_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I210_MN1 (XI1_I838_I210_Bn I1_I838_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I210_MN5 (XI1_I838_I210_n2 I1_I838_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I210_MN4 (I1_p6_7 XI1_I838_I210_An XI1_I838_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I210_MN2 (XI1_I838_I210_n1 I1_I838_pn7 I1_p6_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I210_MN3 (VSS XI1_I838_I210_Bn XI1_I838_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I210_MN0 (XI1_I838_I210_An I1_I838_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I209_MN1 (XI1_I838_I209_Bn I1_I838_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I209_MN5 (XI1_I838_I209_n2 I1_I838_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I209_MN4 (I1_p6_6 XI1_I838_I209_An XI1_I838_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I209_MN2 (XI1_I838_I209_n1 I1_I838_pn6 I1_p6_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I209_MN3 (VSS XI1_I838_I209_Bn XI1_I838_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I209_MN0 (XI1_I838_I209_An I1_I838_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I39_MN1 (XI1_I838_I39_Bn I1_b6_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I39_MN5 (XI1_I838_I39_n2 I1_b6_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I39_MN4 (I1_I838_pn7 XI1_I838_I39_An XI1_I838_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I39_MN2 (XI1_I838_I39_n1 I1_p5_6 I1_I838_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I39_MN3 (VSS XI1_I838_I39_Bn XI1_I838_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I39_MN0 (XI1_I838_I39_An I1_p5_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I209_MN1 (XI1_I792_I209_Bn I1_I792_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I209_MN5 (XI1_I792_I209_n2 I1_I792_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I209_MN4 (I1_p5_6 XI1_I792_I209_An XI1_I792_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I209_MN2 (XI1_I792_I209_n1 I1_I792_pn6 I1_p5_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I209_MN3 (VSS XI1_I792_I209_Bn XI1_I792_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I209_MN0 (XI1_I792_I209_An I1_I792_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I210_MN1 (XI1_I792_I210_Bn I1_I792_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I210_MN5 (XI1_I792_I210_n2 I1_I792_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I210_MN4 (I1_p5_7 XI1_I792_I210_An XI1_I792_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I210_MN2 (XI1_I792_I210_n1 I1_I792_pn7 I1_p5_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I210_MN3 (VSS XI1_I792_I210_Bn XI1_I792_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I210_MN0 (XI1_I792_I210_An I1_I792_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I220_MN1 (XI1_I746_I220_Bn I1_I746_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I220_MN5 (XI1_I746_I220_n2 I1_I746_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I220_MN4 (I1_p4_17 XI1_I746_I220_An XI1_I746_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I220_MN2 (XI1_I746_I220_n1 I1_I746_pn17 I1_p4_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I220_MN3 (VSS XI1_I746_I220_Bn XI1_I746_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I220_MN0 (XI1_I746_I220_An I1_I746_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I221_MN1 (XI1_I746_I221_Bn I1_I746_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I221_MN5 (XI1_I746_I221_n2 I1_I746_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I221_MN4 (I1_p4_18 XI1_I746_I221_An XI1_I746_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I221_MN2 (XI1_I746_I221_n1 I1_I746_pn18 I1_p4_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I221_MN3 (VSS XI1_I746_I221_Bn XI1_I746_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I221_MN0 (XI1_I746_I221_An I1_I746_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I225_MN1 (XI1_I746_I225_Bn I1_I746_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I225_MN5 (XI1_I746_I225_n2 I1_I746_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I225_MN4 (I1_p4_22 XI1_I746_I225_An XI1_I746_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I225_MN2 (XI1_I746_I225_n1 I1_I746_pn22 I1_p4_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I225_MN3 (VSS XI1_I746_I225_Bn XI1_I746_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I225_MN0 (XI1_I746_I225_An I1_I746_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I56_MN1 (XI1_I746_I56_Bn I1_b4_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I56_MN5 (XI1_I746_I56_n2 I1_b4_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I56_MN4 (I1_I746_pn24 XI1_I746_I56_An XI1_I746_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I56_MN2 (XI1_I746_I56_n1 I1_p3_23 I1_I746_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I56_MN3 (VSS XI1_I746_I56_Bn XI1_I746_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I56_MN0 (XI1_I746_I56_An I1_p3_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I62_MN1 (XI1_I746_I62_Bn I1_b4_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I62_MN5 (XI1_I746_I62_n2 I1_b4_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I62_MN4 (I1_I746_pn30 XI1_I746_I62_An XI1_I746_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I62_MN2 (XI1_I746_I62_n1 I1_p3_29 I1_I746_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I62_MN3 (VSS XI1_I746_I62_Bn XI1_I746_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I62_MN0 (XI1_I746_I62_An I1_p3_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I61_MN1 (XI1_I1390_I61_Bn I1_b18_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I61_MN5 (XI1_I1390_I61_n2 I1_b18_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I61_MN4 (I1_I1390_pn29 XI1_I1390_I61_An XI1_I1390_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I61_MN2 (XI1_I1390_I61_n1 I1_p17_28 I1_I1390_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I61_MN3 (VSS XI1_I1390_I61_Bn XI1_I1390_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I61_MN0 (XI1_I1390_I61_An I1_p17_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I230_MN1 (XI1_I1344_I230_Bn I1_I1344_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I230_MN5 (XI1_I1344_I230_n2 I1_I1344_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I230_MN4 (I1_p17_27 XI1_I1344_I230_An XI1_I1344_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I230_MN2 (XI1_I1344_I230_n1 I1_I1344_pn27 I1_p17_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I230_MN3 (VSS XI1_I1344_I230_Bn XI1_I1344_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I230_MN0 (XI1_I1344_I230_An I1_I1344_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I232_MN1 (XI1_I1344_I232_Bn I1_I1344_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I232_MN5 (XI1_I1344_I232_n2 I1_I1344_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I232_MN4 (I1_p17_29 XI1_I1344_I232_An XI1_I1344_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I232_MN2 (XI1_I1344_I232_n1 I1_I1344_pn29 I1_p17_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I232_MN3 (VSS XI1_I1344_I232_Bn XI1_I1344_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I232_MN0 (XI1_I1344_I232_An I1_I1344_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I51_MN1 (XI1_I1344_I51_Bn I1_b17_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I51_MN5 (XI1_I1344_I51_n2 I1_b17_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I51_MN4 (I1_I1344_pn19 XI1_I1344_I51_An XI1_I1344_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I51_MN2 (XI1_I1344_I51_n1 I1_p16_18 I1_I1344_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I51_MN3 (VSS XI1_I1344_I51_Bn XI1_I1344_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I51_MN0 (XI1_I1344_I51_An I1_p16_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I46_MN1 (XI1_I1344_I46_Bn I1_b17_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I46_MN5 (XI1_I1344_I46_n2 I1_b17_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I46_MN4 (I1_I1344_pn14 XI1_I1344_I46_An XI1_I1344_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I46_MN2 (XI1_I1344_I46_n1 I1_p16_13 I1_I1344_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I46_MN3 (VSS XI1_I1344_I46_Bn XI1_I1344_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I46_MN0 (XI1_I1344_I46_An I1_p16_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I221_MN1 (XI1_I1298_I221_Bn I1_I1298_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I221_MN5 (XI1_I1298_I221_n2 I1_I1298_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I221_MN4 (I1_p16_18 XI1_I1298_I221_An XI1_I1298_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I221_MN2 (XI1_I1298_I221_n1 I1_I1298_pn18 I1_p16_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I221_MN3 (VSS XI1_I1298_I221_Bn XI1_I1298_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I221_MN0 (XI1_I1298_I221_An I1_I1298_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I47_MN1 (XI1_I1298_I47_Bn I1_b16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I47_MN5 (XI1_I1298_I47_n2 I1_b16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I47_MN4 (I1_I1298_pn15 XI1_I1298_I47_An XI1_I1298_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I47_MN2 (XI1_I1298_I47_n1 I1_p15_14 I1_I1298_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I47_MN3 (VSS XI1_I1298_I47_Bn XI1_I1298_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I47_MN0 (XI1_I1298_I47_An I1_p15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I48_MN1 (XI1_I1252_I48_Bn I1_b15_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I48_MN5 (XI1_I1252_I48_n2 I1_b15_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I48_MN4 (I1_I1252_pn16 XI1_I1252_I48_An XI1_I1252_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I48_MN2 (XI1_I1252_I48_n1 I1_p14_15 I1_I1252_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I48_MN3 (VSS XI1_I1252_I48_Bn XI1_I1252_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I48_MN0 (XI1_I1252_I48_An I1_p14_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I49_MN1 (XI1_I1252_I49_Bn I1_b15_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I49_MN5 (XI1_I1252_I49_n2 I1_b15_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I49_MN4 (I1_I1252_pn17 XI1_I1252_I49_An XI1_I1252_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I49_MN2 (XI1_I1252_I49_n1 I1_p14_16 I1_I1252_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I49_MN3 (VSS XI1_I1252_I49_Bn XI1_I1252_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I49_MN0 (XI1_I1252_I49_An I1_p14_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I47_MN1 (XI1_I1252_I47_Bn I1_b15_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I47_MN5 (XI1_I1252_I47_n2 I1_b15_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I47_MN4 (I1_I1252_pn15 XI1_I1252_I47_An XI1_I1252_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I47_MN2 (XI1_I1252_I47_n1 I1_p14_14 I1_I1252_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I47_MN3 (VSS XI1_I1252_I47_Bn XI1_I1252_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I47_MN0 (XI1_I1252_I47_An I1_p14_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I220_MN1 (XI1_I1206_I220_Bn I1_I1206_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I220_MN5 (XI1_I1206_I220_n2 I1_I1206_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I220_MN4 (I1_p14_17 XI1_I1206_I220_An XI1_I1206_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I220_MN2 (XI1_I1206_I220_n1 I1_I1206_pn17 I1_p14_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I220_MN3 (VSS XI1_I1206_I220_Bn XI1_I1206_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I220_MN0 (XI1_I1206_I220_An I1_I1206_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I221_MN1 (XI1_I1206_I221_Bn I1_I1206_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I221_MN5 (XI1_I1206_I221_n2 I1_I1206_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I221_MN4 (I1_p14_18 XI1_I1206_I221_An XI1_I1206_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I221_MN2 (XI1_I1206_I221_n1 I1_I1206_pn18 I1_p14_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I221_MN3 (VSS XI1_I1206_I221_Bn XI1_I1206_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I221_MN0 (XI1_I1206_I221_An I1_I1206_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I60_MN1 (XI1_I884_I60_Bn I1_b7_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I60_MN5 (XI1_I884_I60_n2 I1_b7_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I60_MN4 (I1_I884_pn28 XI1_I884_I60_An XI1_I884_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I60_MN2 (XI1_I884_I60_n1 I1_p6_27 I1_I884_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I60_MN3 (VSS XI1_I884_I60_Bn XI1_I884_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I60_MN0 (XI1_I884_I60_An I1_p6_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I58_MN1 (XI1_I884_I58_Bn I1_b7_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I58_MN5 (XI1_I884_I58_n2 I1_b7_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I58_MN4 (I1_I884_pn26 XI1_I884_I58_An XI1_I884_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I58_MN2 (XI1_I884_I58_n1 I1_p6_25 I1_I884_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I58_MN3 (VSS XI1_I884_I58_Bn XI1_I884_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I58_MN0 (XI1_I884_I58_An I1_p6_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I56_MN1 (XI1_I884_I56_Bn I1_b7_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I56_MN5 (XI1_I884_I56_n2 I1_b7_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I56_MN4 (I1_I884_pn24 XI1_I884_I56_An XI1_I884_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I56_MN2 (XI1_I884_I56_n1 I1_p6_23 I1_I884_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I56_MN3 (VSS XI1_I884_I56_Bn XI1_I884_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I56_MN0 (XI1_I884_I56_An I1_p6_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I54_MN1 (XI1_I884_I54_Bn I1_b7_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I54_MN5 (XI1_I884_I54_n2 I1_b7_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I54_MN4 (I1_I884_pn22 XI1_I884_I54_An XI1_I884_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I54_MN2 (XI1_I884_I54_n1 I1_p6_21 I1_I884_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I54_MN3 (VSS XI1_I884_I54_Bn XI1_I884_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I54_MN0 (XI1_I884_I54_An I1_p6_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I52_MN1 (XI1_I884_I52_Bn I1_b7_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I52_MN5 (XI1_I884_I52_n2 I1_b7_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I52_MN4 (I1_I884_pn20 XI1_I884_I52_An XI1_I884_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I52_MN2 (XI1_I884_I52_n1 I1_p6_19 I1_I884_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I52_MN3 (VSS XI1_I884_I52_Bn XI1_I884_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I52_MN0 (XI1_I884_I52_An I1_p6_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I50_MN1 (XI1_I884_I50_Bn I1_b7_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I50_MN5 (XI1_I884_I50_n2 I1_b7_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I50_MN4 (I1_I884_pn18 XI1_I884_I50_An XI1_I884_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I50_MN2 (XI1_I884_I50_n1 I1_p6_17 I1_I884_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I50_MN3 (VSS XI1_I884_I50_Bn XI1_I884_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I50_MN0 (XI1_I884_I50_An I1_p6_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I49_MN1 (XI1_I884_I49_Bn I1_b7_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I49_MN5 (XI1_I884_I49_n2 I1_b7_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I49_MN4 (I1_I884_pn17 XI1_I884_I49_An XI1_I884_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I49_MN2 (XI1_I884_I49_n1 I1_p6_16 I1_I884_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I49_MN3 (VSS XI1_I884_I49_Bn XI1_I884_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I49_MN0 (XI1_I884_I49_An I1_p6_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I220_MN1 (XI1_I838_I220_Bn I1_I838_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I220_MN5 (XI1_I838_I220_n2 I1_I838_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I220_MN4 (I1_p6_17 XI1_I838_I220_An XI1_I838_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I220_MN2 (XI1_I838_I220_n1 I1_I838_pn17 I1_p6_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I220_MN3 (VSS XI1_I838_I220_Bn XI1_I838_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I220_MN0 (XI1_I838_I220_An I1_I838_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I208_MN1 (XI1_I838_I208_Bn I1_I838_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I208_MN5 (XI1_I838_I208_n2 I1_I838_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I208_MN4 (I1_p6_5 XI1_I838_I208_An XI1_I838_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I208_MN2 (XI1_I838_I208_n1 I1_I838_pn5 I1_p6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I208_MN3 (VSS XI1_I838_I208_Bn XI1_I838_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I208_MN0 (XI1_I838_I208_An I1_I838_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I38_MN1 (XI1_I838_I38_Bn I1_b6_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I38_MN5 (XI1_I838_I38_n2 I1_b6_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I38_MN4 (I1_I838_pn6 XI1_I838_I38_An XI1_I838_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I38_MN2 (XI1_I838_I38_n1 I1_p5_5 I1_I838_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I38_MN3 (VSS XI1_I838_I38_Bn XI1_I838_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I38_MN0 (XI1_I838_I38_An I1_p5_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I37_MN1 (XI1_I838_I37_Bn I1_b6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I838_I37_MN5 (XI1_I838_I37_n2 I1_b6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I37_MN4 (I1_I838_pn5 XI1_I838_I37_An XI1_I838_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I37_MN2 (XI1_I838_I37_n1 I1_p5_4 I1_I838_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I838_I37_MN3 (VSS XI1_I838_I37_Bn XI1_I838_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I37_MN0 (XI1_I838_I37_An I1_p5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I208_MN1 (XI1_I792_I208_Bn I1_I792_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I208_MN5 (XI1_I792_I208_n2 I1_I792_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I208_MN4 (I1_p5_5 XI1_I792_I208_An XI1_I792_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I208_MN2 (XI1_I792_I208_n1 I1_I792_pn5 I1_p5_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I208_MN3 (VSS XI1_I792_I208_Bn XI1_I792_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I208_MN0 (XI1_I792_I208_An I1_I792_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I42_MN1 (XI1_I792_I42_Bn I1_b5_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I42_MN5 (XI1_I792_I42_n2 I1_b5_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I42_MN4 (I1_I792_pn10 XI1_I792_I42_An XI1_I792_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I42_MN2 (XI1_I792_I42_n1 I1_p4_9 I1_I792_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I42_MN3 (VSS XI1_I792_I42_Bn XI1_I792_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I42_MN0 (XI1_I792_I42_An I1_p4_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I44_MN1 (XI1_I792_I44_Bn I1_b5_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I44_MN5 (XI1_I792_I44_n2 I1_b5_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I44_MN4 (I1_I792_pn12 XI1_I792_I44_An XI1_I792_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I44_MN2 (XI1_I792_I44_n1 I1_p4_11 I1_I792_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I44_MN3 (VSS XI1_I792_I44_Bn XI1_I792_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I44_MN0 (XI1_I792_I44_An I1_p4_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I45_MN1 (XI1_I792_I45_Bn I1_b5_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I45_MN5 (XI1_I792_I45_n2 I1_b5_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I45_MN4 (I1_I792_pn13 XI1_I792_I45_An XI1_I792_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I45_MN2 (XI1_I792_I45_n1 I1_p4_12 I1_I792_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I45_MN3 (VSS XI1_I792_I45_Bn XI1_I792_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I45_MN0 (XI1_I792_I45_An I1_p4_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I46_MN1 (XI1_I792_I46_Bn I1_b5_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I792_I46_MN5 (XI1_I792_I46_n2 I1_b5_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I792_I46_MN4 (I1_I792_pn14 XI1_I792_I46_An XI1_I792_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I46_MN2 (XI1_I792_I46_n1 I1_p4_13 I1_I792_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I792_I46_MN3 (VSS XI1_I792_I46_Bn XI1_I792_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I46_MN0 (XI1_I792_I46_An I1_p4_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I223_MN1 (XI1_I746_I223_Bn I1_I746_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I223_MN5 (XI1_I746_I223_n2 I1_I746_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I223_MN4 (I1_p4_20 XI1_I746_I223_An XI1_I746_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I223_MN2 (XI1_I746_I223_n1 I1_I746_pn20 I1_p4_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I223_MN3 (VSS XI1_I746_I223_Bn XI1_I746_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I223_MN0 (XI1_I746_I223_An I1_I746_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I63_MN1 (XI1_I746_I63_Bn I1_b4_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I746_I63_MN5 (XI1_I746_I63_n2 I1_b4_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I746_I63_MN4 (I1_I746_pn31 XI1_I746_I63_An XI1_I746_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I63_MN2 (XI1_I746_I63_n1 I1_p3_30 I1_I746_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I746_I63_MN3 (VSS XI1_I746_I63_Bn XI1_I746_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I63_MN0 (XI1_I746_I63_An I1_p3_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I59_MN1 (XI1_I1390_I59_Bn I1_b18_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I59_MN5 (XI1_I1390_I59_n2 I1_b18_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I59_MN4 (I1_I1390_pn27 XI1_I1390_I59_An XI1_I1390_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I59_MN2 (XI1_I1390_I59_n1 I1_p17_26 I1_I1390_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I59_MN3 (VSS XI1_I1390_I59_Bn XI1_I1390_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I59_MN0 (XI1_I1390_I59_An I1_p17_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I57_MN1 (XI1_I1390_I57_Bn I1_b18_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1390_I57_MN5 (XI1_I1390_I57_n2 I1_b18_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1390_I57_MN4 (I1_I1390_pn25 XI1_I1390_I57_An XI1_I1390_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I57_MN2 (XI1_I1390_I57_n1 I1_p17_24 I1_I1390_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1390_I57_MN3 (VSS XI1_I1390_I57_Bn XI1_I1390_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I57_MN0 (XI1_I1390_I57_An I1_p17_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I228_MN1 (XI1_I1344_I228_Bn I1_I1344_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I228_MN5 (XI1_I1344_I228_n2 I1_I1344_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I228_MN4 (I1_p17_25 XI1_I1344_I228_An XI1_I1344_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I228_MN2 (XI1_I1344_I228_n1 I1_I1344_pn25 I1_p17_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I228_MN3 (VSS XI1_I1344_I228_Bn XI1_I1344_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I228_MN0 (XI1_I1344_I228_An I1_I1344_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I224_MN1 (XI1_I1344_I224_Bn I1_I1344_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I224_MN5 (XI1_I1344_I224_n2 I1_I1344_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I224_MN4 (I1_p17_21 XI1_I1344_I224_An XI1_I1344_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I224_MN2 (XI1_I1344_I224_n1 I1_I1344_pn21 I1_p17_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I224_MN3 (VSS XI1_I1344_I224_Bn XI1_I1344_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I224_MN0 (XI1_I1344_I224_An I1_I1344_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I44_MN1 (XI1_I1344_I44_Bn I1_b17_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I44_MN5 (XI1_I1344_I44_n2 I1_b17_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I44_MN4 (I1_I1344_pn12 XI1_I1344_I44_An XI1_I1344_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I44_MN2 (XI1_I1344_I44_n1 I1_p16_11 I1_I1344_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I44_MN3 (VSS XI1_I1344_I44_Bn XI1_I1344_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I44_MN0 (XI1_I1344_I44_An I1_p16_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I45_MN1 (XI1_I1344_I45_Bn I1_b17_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I45_MN5 (XI1_I1344_I45_n2 I1_b17_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1344_I45_MN4 (I1_I1344_pn13 XI1_I1344_I45_An XI1_I1344_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I45_MN2 (XI1_I1344_I45_n1 I1_p16_12 I1_I1344_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1344_I45_MN3 (VSS XI1_I1344_I45_Bn XI1_I1344_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I45_MN0 (XI1_I1344_I45_An I1_p16_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I45_MN1 (XI1_I1298_I45_Bn I1_b16_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I45_MN5 (XI1_I1298_I45_n2 I1_b16_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I45_MN4 (I1_I1298_pn13 XI1_I1298_I45_An XI1_I1298_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I45_MN2 (XI1_I1298_I45_n1 I1_p15_12 I1_I1298_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I45_MN3 (VSS XI1_I1298_I45_Bn XI1_I1298_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I45_MN0 (XI1_I1298_I45_An I1_p15_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I46_MN1 (XI1_I1298_I46_Bn I1_b16_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1298_I46_MN5 (XI1_I1298_I46_n2 I1_b16_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1298_I46_MN4 (I1_I1298_pn14 XI1_I1298_I46_An XI1_I1298_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I46_MN2 (XI1_I1298_I46_n1 I1_p15_13 I1_I1298_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1298_I46_MN3 (VSS XI1_I1298_I46_Bn XI1_I1298_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I46_MN0 (XI1_I1298_I46_An I1_p15_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I45_MN1 (XI1_I1252_I45_Bn I1_b15_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I45_MN5 (XI1_I1252_I45_n2 I1_b15_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I45_MN4 (I1_I1252_pn13 XI1_I1252_I45_An XI1_I1252_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I45_MN2 (XI1_I1252_I45_n1 I1_p14_12 I1_I1252_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I45_MN3 (VSS XI1_I1252_I45_Bn XI1_I1252_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I45_MN0 (XI1_I1252_I45_An I1_p14_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I46_MN1 (XI1_I1252_I46_Bn I1_b15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1252_I46_MN5 (XI1_I1252_I46_n2 I1_b15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1252_I46_MN4 (I1_I1252_pn14 XI1_I1252_I46_An XI1_I1252_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I46_MN2 (XI1_I1252_I46_n1 I1_p14_13 I1_I1252_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1252_I46_MN3 (VSS XI1_I1252_I46_Bn XI1_I1252_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I46_MN0 (XI1_I1252_I46_An I1_p14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I48_MN1 (XI1_I1206_I48_Bn I1_b14_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I48_MN5 (XI1_I1206_I48_n2 I1_b14_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I48_MN4 (I1_I1206_pn16 XI1_I1206_I48_An XI1_I1206_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I48_MN2 (XI1_I1206_I48_n1 I1_p13_15 I1_I1206_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I48_MN3 (VSS XI1_I1206_I48_Bn XI1_I1206_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I48_MN0 (XI1_I1206_I48_An I1_p13_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I49_MN1 (XI1_I1206_I49_Bn I1_b14_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I49_MN5 (XI1_I1206_I49_n2 I1_b14_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I49_MN4 (I1_I1206_pn17 XI1_I1206_I49_An XI1_I1206_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I49_MN2 (XI1_I1206_I49_n1 I1_p13_16 I1_I1206_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I49_MN3 (VSS XI1_I1206_I49_Bn XI1_I1206_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I49_MN0 (XI1_I1206_I49_An I1_p13_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I47_MN1 (XI1_I1206_I47_Bn I1_b14_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1206_I47_MN5 (XI1_I1206_I47_n2 I1_b14_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1206_I47_MN4 (I1_I1206_pn15 XI1_I1206_I47_An XI1_I1206_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I47_MN2 (XI1_I1206_I47_n1 I1_p13_14 I1_I1206_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1206_I47_MN3 (VSS XI1_I1206_I47_Bn XI1_I1206_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I47_MN0 (XI1_I1206_I47_An I1_p13_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I63_MN1 (XI1_I884_I63_Bn I1_b7_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I63_MN5 (XI1_I884_I63_n2 I1_b7_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I63_MN4 (I1_I884_pn31 XI1_I884_I63_An XI1_I884_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I63_MN2 (XI1_I884_I63_n1 I1_p6_30 I1_I884_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I63_MN3 (VSS XI1_I884_I63_Bn XI1_I884_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I63_MN0 (XI1_I884_I63_An I1_p6_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I53_MN1 (XI1_I884_I53_Bn I1_b7_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I53_MN5 (XI1_I884_I53_n2 I1_b7_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I53_MN4 (I1_I884_pn21 XI1_I884_I53_An XI1_I884_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I53_MN2 (XI1_I884_I53_n1 I1_p6_20 I1_I884_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I53_MN3 (VSS XI1_I884_I53_Bn XI1_I884_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I53_MN0 (XI1_I884_I53_An I1_p6_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I51_MN1 (XI1_I884_I51_Bn I1_b7_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I51_MN5 (XI1_I884_I51_n2 I1_b7_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I51_MN4 (I1_I884_pn19 XI1_I884_I51_An XI1_I884_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I51_MN2 (XI1_I884_I51_n1 I1_p6_18 I1_I884_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I51_MN3 (VSS XI1_I884_I51_Bn XI1_I884_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I51_MN0 (XI1_I884_I51_An I1_p6_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I48_MN1 (XI1_I884_I48_Bn I1_b7_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I48_MN5 (XI1_I884_I48_n2 I1_b7_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I48_MN4 (I1_I884_pn16 XI1_I884_I48_An XI1_I884_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I48_MN2 (XI1_I884_I48_n1 I1_p6_15 I1_I884_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I48_MN3 (VSS XI1_I884_I48_Bn XI1_I884_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I48_MN0 (XI1_I884_I48_An I1_p6_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I47_MN1 (XI1_I884_I47_Bn I1_b7_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I47_MN5 (XI1_I884_I47_n2 I1_b7_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I47_MN4 (I1_I884_pn15 XI1_I884_I47_An XI1_I884_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I47_MN2 (XI1_I884_I47_n1 I1_p6_14 I1_I884_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I47_MN3 (VSS XI1_I884_I47_Bn XI1_I884_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I47_MN0 (XI1_I884_I47_An I1_p6_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I46_MN1 (XI1_I884_I46_Bn I1_b7_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I46_MN5 (XI1_I884_I46_n2 I1_b7_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I46_MN4 (I1_I884_pn14 XI1_I884_I46_An XI1_I884_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I46_MN2 (XI1_I884_I46_n1 I1_p6_13 I1_I884_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I884_I46_MN3 (VSS XI1_I884_I46_Bn XI1_I884_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I46_MN0 (XI1_I884_I46_An I1_p6_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I45_MN1 (XI1_I884_I45_Bn I1_b7_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I884_I45_MN5 (XI1_I884_I45_n2 I1_b7_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I884_I45_MN4 (I1_I884_pn13 XI1_I884_I45_An XI1_I884_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
